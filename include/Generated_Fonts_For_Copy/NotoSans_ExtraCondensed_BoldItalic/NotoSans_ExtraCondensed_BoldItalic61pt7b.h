#ifndef _NOTOSANS_EXTRACONDENSED_BOLDITALIC61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLDITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F,
  0xCF, 0xF1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC7, 0xF9, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF1,
  0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xED, 0xF8, 0x03, 0xFC,
  0xC7, 0x00, 0x3F, 0x9C, 0x10, 0x03, 0xF9, 0xC0, 0x00, 0x3F, 0x98, 0x00,
  0x07, 0xF9, 0x80, 0x00, 0x3F, 0xD8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xDF,
  0xF0, 0x00, 0x0C, 0xFF, 0x00, 0x00, 0xCF, 0xF0, 0x00, 0x1C, 0xFF, 0x06,
  0x01, 0xCF, 0xF0, 0x70, 0x18, 0xFE, 0x07, 0xC1, 0x9F, 0xE0, 0x7F, 0x9F,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x3F,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x03, 0xE0,
  0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x87, 0xE0,
  0x01, 0xF0, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0xFC, 0x00, 0x3F, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x1F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x7E, 0x0F,
  0x0F, 0xC3, 0xF3, 0xF0, 0xFF, 0x3F, 0x1F, 0x8F, 0xC7, 0xFE, 0xFC, 0x7E,
  0x7E, 0x3F, 0xFB, 0xF3, 0xF1, 0xF1, 0xFF, 0xF7, 0xFF, 0xCF, 0xC7, 0xFF,
  0xDF, 0xFE, 0x3E, 0x3F, 0x1F, 0x7F, 0xF1, 0xF9, 0xF8, 0x7C, 0xFF, 0x8F,
  0xC7, 0xE1, 0xF1, 0xF8, 0x3F, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0xFC, 0x1F,
  0x00, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0x7E, 0x1F, 0x80, 0x1F, 0x81,
  0xF0, 0x7C, 0x00, 0xFC, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x7E, 0x00, 0x7E, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF,
  0xF8, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x3F, 0xDF,
  0xE7, 0xF8, 0x7F, 0x3F, 0xCF, 0xE1, 0xFE, 0x3F, 0xFF, 0xC7, 0xF8, 0x7F,
  0xFF, 0x0F, 0xF0, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xF8, 0x7F, 0x81, 0xFF,
  0xF0, 0xFF, 0x03, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0x83, 0xFC, 0x07, 0xFE,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF1, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x7F, 0xC0, 0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x04, 0x0F, 0xC0, 0x0E, 0x1F, 0x80, 0x3F, 0x3F, 0x02,
  0x7F, 0xFE, 0x7C, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x83, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xE1, 0xFE, 0x03, 0x83, 0xF8, 0x03, 0x03, 0xC0, 0x04, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0x3F, 0x83,
  0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07,
  0xFB, 0xFC, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xDF, 0xCF, 0xF7, 0xF8, 0xFC,
  0xFF, 0x0F, 0x1F, 0xC1, 0xC3, 0xF8, 0x10, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC3, 0xFF, 0x00, 0x7C, 0x0F, 0xF8, 0x03, 0x80,
  0x7F, 0xC0, 0x18, 0x03, 0xFE, 0x00, 0x40, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0x81, 0xFF, 0x00, 0x60, 0x1F,
  0xF0, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x3F, 0xE0, 0xE0,
  0x07, 0xFE, 0x0F, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFB, 0xF8, 0x00, 0x1F, 0x3F, 0x80,
  0x03, 0xF7, 0xF8, 0x00, 0x3E, 0x7F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0x87, 0xF0, 0x01, 0xF8, 0xFF, 0x00, 0x3F, 0x0F, 0xF0,
  0x03, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0xF8,
  0x1F, 0xE0, 0x1F, 0x81, 0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF1, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3C,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x40, 0x03, 0xFE, 0x0E, 0x00, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x03, 0xFD,
  0xFF, 0x00, 0x7F, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07,
  0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x83, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xF0,
  0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0xFF, 0x87,
  0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xDF, 0xC0, 0x7F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x00, 0x60,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x38, 0x3F, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x40, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xC0, 0xFF, 0x04, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0xF8, 0x7C, 0x1F,
  0x81, 0xFF, 0xF1, 0xF0, 0x7C, 0x0F, 0xFF, 0x87, 0xC3, 0xF0, 0x7F, 0xFE,
  0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x87, 0xE1, 0xF1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC7, 0xC3, 0xF0, 0x7C, 0x1F, 0x3F, 0x0F, 0x81, 0xF0,
  0x7C, 0xF8, 0x3E, 0x0F, 0xC1, 0xF3, 0xE1, 0xF8, 0x3F, 0x0F, 0x8F, 0x87,
  0xC0, 0xF8, 0x3E, 0x7E, 0x1F, 0x03, 0xE0, 0xF9, 0xF0, 0xFC, 0x1F, 0x83,
  0xE7, 0xC3, 0xF0, 0x7E, 0x1F, 0x1F, 0x0F, 0xC1, 0xF0, 0x7C, 0x7C, 0x3E,
  0x0F, 0xC1, 0xE1, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xFC, 0x3E,
  0x3F, 0x0F, 0xC7, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xF0, 0xFF,
  0xEF, 0xFE, 0x0F, 0xC1, 0xFF, 0x3F, 0xF0, 0x3F, 0x03, 0xF8, 0xFF, 0x80,
  0x7C, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x01,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x83, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF3, 0xFF, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x78, 0x03, 0xFF, 0x00, 0x80,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x20, 0x07, 0xFC, 0x07, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x03, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x80, 0x18,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8,
  0x7F, 0xC0, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF0,
  0x7F, 0x81, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFD, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x10, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x7F,
  0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xBF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x7F, 0x80,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x00, 0x7F,
  0x7F, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF0, 0xFC, 0xFF, 0x00, 0xFE, 0x7F,
  0x1F, 0xCF, 0xF0, 0x0F, 0xE3, 0xF1, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x1F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF3, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0x3F, 0x1F,
  0xE0, 0x1F, 0xC3, 0xF7, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x7E, 0x1F, 0xC0,
  0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFF, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xF8, 0x3F, 0x80, 0x3F, 0x83,
  0xFF, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFF,
  0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFE,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x01, 0xFC, 0x01,
  0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0x80, 0x3F, 0xBF, 0x03, 0xF8, 0x03, 0xFB, 0xF0, 0x3F, 0x80, 0x7F, 0x3F,
  0x87, 0xF8, 0x07, 0xF3, 0xF8, 0x7F, 0x00, 0x7F, 0x3F, 0x87, 0xF0, 0x07,
  0xF3, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFC, 0xFF,
  0x00, 0xFE, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0xFE, 0x00, 0xFE, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0xFE, 0x01, 0xFE, 0x0F, 0xDF, 0xC0, 0x1F,
  0xC0, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFC,
  0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xF8, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF0,
  0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F,
  0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xF9,
  0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFE,
  0x7F, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC3, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xFC, 0x01, 0xFF, 0x01, 0xC0, 0x1F, 0xF0,
  0x02, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x10, 0x00, 0xFF, 0x80, 0xE0, 0x07, 0xFC, 0x07,
  0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x7F, 0x9F, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x83,
  0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF7, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xFC,
  0x07, 0xF0, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xFC, 0x0F,
  0xF0, 0x7F, 0x01, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x7F,
  0x07, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xFF, 0x87, 0xF8, 0x07, 0xF0, 0xFD, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xDF,
  0x87, 0xF0, 0x07, 0xF1, 0xFD, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0x9F, 0x8F,
  0xE0, 0x07, 0xF3, 0xF9, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x1F, 0x9F, 0xE0,
  0x07, 0xF3, 0xF1, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x1F, 0xBF, 0xC0, 0x07,
  0xF7, 0xE1, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x1F, 0xBF, 0x80, 0x07, 0xFF,
  0xC1, 0xFF, 0xF8, 0x00, 0x7E, 0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0xFF,
  0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xF1,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0xFF,
  0xCF, 0xE0, 0x1F, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFB, 0xF8, 0x03, 0xFF, 0xBF, 0x80, 0x3F, 0xF3, 0xF8, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC3, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x1F, 0xDF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87,
  0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x7F, 0xF8, 0x0F, 0xCF,
  0xFE, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0x0C, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x83,
  0xFE, 0x02, 0x03, 0xFE, 0x3C, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0x0F, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xFC, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xDF, 0x80, 0x0F, 0xFF, 0x7E, 0x00, 0x3F,
  0xF1, 0xF8, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFE, 0x3F, 0x83, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x7F, 0x80, 0x60, 0x7F,
  0xE7, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0x84, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x23, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x02, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x7F, 0xE7, 0xF0, 0x01, 0xFF, 0xEF,
  0xE0, 0x07, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC1,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x07, 0xFC, 0x01,
  0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC3, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x1F, 0xDF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x04, 0x7F, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xF9, 0xFF, 0x07, 0xFC, 0x03, 0xF3, 0xFF, 0x8F, 0xFC,
  0x03, 0xF7, 0xFF, 0x9F, 0xFE, 0x03, 0xF7, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xF1,
  0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x3E, 0x1F, 0xE0, 0x0F, 0xC7, 0xFE, 0x01, 0xF9, 0xFF,
  0xE0, 0x3F, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8,
  0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFC,
  0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE,
  0x7F, 0x81, 0xFE, 0x1F, 0xC1, 0xFF, 0x0F, 0xF9, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x07, 0xC0,
  0x01, 0xF8, 0x7F, 0x80, 0x07, 0xE3, 0xFF, 0x00, 0x1F, 0x9F, 0xFE, 0x00,
  0x7E, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xCF, 0xFC, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x18, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x10,
  0x07, 0xFC, 0x7E, 0x00, 0xFF, 0xEF, 0xE0, 0x1F, 0xFE, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F,
  0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0x80,
  0x3F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x06, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x07, 0xF1, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xE0,
  0x3F, 0x7F, 0xC0, 0x7E, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xB0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x7E, 0x07, 0xF8,
  0x18, 0x1F, 0xE0, 0x10, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE1, 0x00, 0x7F, 0xC3, 0x00, 0xFF, 0x87, 0xC7, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x83, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC2, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x06, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC,
  0x01, 0xFF, 0x9F, 0x80, 0x1F, 0xE3, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE,
  0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xF8, 0x0F, 0xE7,
  0xF0, 0x3F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x7F, 0x07, 0xFE,
  0x0F, 0xF1, 0xFC, 0x1F, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0xE0, 0xFE, 0x1F,
  0xC3, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0xF8,
  0x7F, 0x07, 0xF1, 0xFF, 0xE3, 0xF8, 0x1F, 0xCF, 0xDF, 0x8F, 0xE0, 0x7F,
  0x3F, 0x7E, 0x7F, 0x01, 0xFC, 0xFD, 0xF9, 0xFC, 0x07, 0xE7, 0xE7, 0xE7,
  0xF0, 0x1F, 0x9F, 0x9F, 0xBF, 0x80, 0x7E, 0x7E, 0x7E, 0xFE, 0x01, 0xFB,
  0xF1, 0xF3, 0xF0, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBE, 0x3F, 0x7F,
  0x00, 0xFF, 0xF8, 0xFD, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC,
  0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x7F,
  0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x43, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x47, 0xFC, 0x00, 0x17, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0xC0, 0x0F, 0xFF, 0x20, 0x00, 0xFF, 0x88,
  0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 18, 45, 15, 0, -44 },
  { 103, 21, 16, 24, 6, -44 },
  { 145, 31, 44, 29, 0, -44 },
  { 316, 28, 50, 26, 0, -46 },
  { 491, 38, 45, 43, 3, -44 },
  { 705, 31, 45, 31, 0, -44 },
  { 880, 10, 16, 15, 6, -44 },
  { 900, 20, 54, 16, 1, -44 },
  { 1035, 21, 54, 17, -5, -44 },
  { 1177, 23, 26, 25, 5, -47 },
  { 1252, 25, 29, 28, 2, -36 },
  { 1343, 13, 16, 14, -3, -8 },
  { 1369, 16, 7, 18, 1, -20 },
  { 1383, 10, 10, 14, 0, -9 },
  { 1396, 31, 44, 23, -3, -44 },
  { 1567, 25, 45, 26, 1, -44 },
  { 1708, 19, 44, 26, 6, -44 },
  { 1813, 29, 44, 26, -2, -44 },
  { 1973, 28, 45, 26, -1, -44 },
  { 2131, 28, 44, 26, -1, -44 },
  { 2285, 27, 45, 26, 0, -44 },
  { 2437, 27, 45, 26, 1, -44 },
  { 2589, 28, 44, 26, 2, -44 },
  { 2743, 27, 45, 26, 0, -44 },
  { 2895, 26, 45, 26, 0, -44 },
  { 3042, 15, 35, 15, 0, -34 },
  { 3108, 18, 42, 15, -3, -34 },
  { 3203, 25, 29, 28, 2, -36 },
  { 3294, 25, 19, 28, 2, -31 },
  { 3354, 26, 29, 28, 2, -36 },
  { 3449, 22, 45, 20, 1, -44 },
  { 3573, 38, 49, 40, 1, -44 },
  { 3806, 29, 44, 29, -4, -44 },
  { 3966, 30, 44, 29, 0, -44 },
  { 4131, 29, 45, 27, 2, -44 },
  { 4295, 31, 44, 31, 0, -44 },
  { 4466, 27, 44, 24, 0, -44 },
  { 4615, 27, 44, 23, 0, -44 },
  { 4764, 32, 45, 32, 2, -44 },
  { 4944, 34, 44, 32, 0, -44 },
  { 5131, 27, 44, 19, -3, -44 },
  { 5280, 26, 57, 15, -9, -44 },
  { 5466, 34, 44, 28, 0, -44 },
  { 5653, 20, 44, 24, 0, -44 },
  { 5763, 44, 44, 42, 0, -44 },
  { 6005, 36, 44, 34, 0, -44 },
  { 6203, 31, 45, 33, 2, -44 },
  { 6378, 30, 44, 28, 0, -44 },
  { 6543, 31, 54, 33, 2, -44 },
  { 6753, 29, 44, 28, 0, -44 },
  { 6913, 29, 45, 25, -1, -44 },
  { 7077, 25, 44, 24, 4, -44 },
  { 7215, 32, 45, 31, 2, -44 },
  { 7395, 29, 44, 28, 5, -44 },
  { 7555, 44, 44, 43, 4, -44 },
  { 7797, 35, 44, 27, -4, -44 },
  { 7990, 26, 44, 26, 5, -44 },
  { 8133, 30, 44, 24, -2, -44 },
  { 8298, 24, 54, 17, -2, -44 },
  { 8460, 13, 44, 23, 6, -44 },
  { 8532, 24, 54, 17, -4, -44 },
  { 8694, 27, 27, 26, 0, -44 },
  { 8786, 21, 4, 20, -6, 5 },
  { 8797, 11, 10, 18, 9, -47 },
  { 8811, 28, 35, 28, 1, -34 },
  { 8934, 27, 47, 28, 0, -46 },
  { 9093, 23, 35, 22, 1, -34 },
  { 9194, 30, 47, 28, 1, -46 },
  { 9371, 24, 35, 26, 1, -34 },
  { 9476, 31, 62, 17, -7, -47 },
  { 9717, 31, 49, 28, -2, -34 },
  { 9907, 27, 46, 28, 0, -46 },
  { 10063, 17, 46, 14, 0, -46 },
  { 10161, 25, 61, 14, -8, -46 },
  { 10352, 29, 46, 26, 0, -46 },
  { 10519, 17, 46, 14, 0, -46 },
  { 10617, 40, 34, 41, 0, -34 },
  { 10787, 27, 34, 28, 0, -34 },
  { 10902, 25, 35, 27, 1, -34 },
  { 11012, 30, 48, 28, -3, -34 },
  { 11192, 28, 49, 28, 1, -34 },
  { 11364, 23, 34, 20, 0, -34 },
  { 11462, 23, 35, 22, 0, -34 },
  { 11563, 18, 41, 18, 2, -40 },
  { 11656, 27, 34, 28, 1, -33 },
  { 11771, 24, 33, 24, 4, -33 },
  { 11870, 38, 33, 37, 3, -33 },
  { 12027, 30, 33, 25, -3, -33 },
  { 12151, 33, 48, 25, -5, -33 },
  { 12349, 25, 33, 21, -2, -33 },
  { 12453, 24, 54, 21, 1, -44 },
  { 12615, 7, 61, 23, 7, -47 },
  { 12669, 24, 54, 21, -4, -44 },
  { 12831, 26, 11, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_BoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLDITALIC61PT7B_H_
