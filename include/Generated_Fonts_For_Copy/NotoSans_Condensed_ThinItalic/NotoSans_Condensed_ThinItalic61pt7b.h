#ifndef _NOTOSANS_CONDENSED_THINITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x11, 0x83, 0x10, 0x31,
  0x03, 0x30, 0x23, 0x02, 0x20, 0x62, 0x06, 0x20, 0x46, 0x04, 0x60, 0x44,
  0x0C, 0x40, 0xC4, 0x08, 0xC0, 0x88, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x40, 0x30, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08,
  0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00,
  0x01, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x01, 0x00,
  0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x18,
  0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x80, 0x40, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x40, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x20, 0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x30, 0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08,
  0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF3, 0x3E, 0x00, 0xC1,
  0x02, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0x60,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x18, 0x08, 0x00, 0x0C,
  0x04, 0x00, 0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x81, 0x80, 0x00, 0xC1, 0x80, 0x80, 0x41, 0x80, 0x78, 0x23, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x30, 0x3D, 0xC0, 0x03, 0x01, 0x82, 0x00, 0x18,
  0x18, 0x18, 0x01, 0x81, 0x80, 0xC0, 0x08, 0x08, 0x06, 0x00, 0xC0, 0xC0,
  0x30, 0x04, 0x06, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x18, 0x03, 0x03, 0x00, 0x80, 0x10, 0x10, 0x0C, 0x00, 0x81, 0x80,
  0x60, 0x0C, 0x08, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x03, 0x04, 0x00, 0x80,
  0x10, 0x60, 0x04, 0x01, 0x86, 0x04, 0x20, 0x0C, 0x30, 0xFD, 0x00, 0x43,
  0x0C, 0x38, 0x06, 0x10, 0xC1, 0xC0, 0x31, 0x8C, 0x06, 0x03, 0x08, 0x40,
  0x38, 0x18, 0xC6, 0x01, 0xC1, 0x8C, 0x20, 0x0B, 0xB8, 0x63, 0x00, 0x4F,
  0x86, 0x18, 0x02, 0x00, 0x20, 0x80, 0x10, 0x03, 0x0C, 0x01, 0x80, 0x10,
  0x60, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x18, 0x10, 0x03, 0x00, 0xC0, 0x80,
  0x10, 0x0C, 0x0C, 0x01, 0x80, 0x40, 0x60, 0x0C, 0x06, 0x03, 0x00, 0x60,
  0x20, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x01, 0x01, 0x80,
  0x30, 0x18, 0x18, 0x01, 0x80, 0x80, 0xC0, 0x04, 0x0C, 0x0C, 0x00, 0x30,
  0xC0, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x00, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x40,
  0x0C, 0x00, 0x20, 0x04, 0x00, 0x10, 0x06, 0x00, 0x08, 0x03, 0x00, 0x04,
  0x03, 0x00, 0x02, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x11, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0xC3, 0x01, 0x80, 0x43, 0x00, 0x40,
  0x63, 0x00, 0x30, 0x31, 0x80, 0x18, 0x11, 0x80, 0x06, 0x18, 0xC0, 0x03,
  0x08, 0x60, 0x00, 0x8C, 0x20, 0x00, 0x64, 0x30, 0x00, 0x36, 0x18, 0x00,
  0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0xC0, 0xC0,
  0x03, 0x60, 0x60, 0x03, 0x10, 0x18, 0x03, 0x0C, 0x0E, 0x07, 0x02, 0x01,
  0xFF, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x23,
  0x18, 0x84, 0x23, 0x10, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x40, 0x60, 0x38, 0x10, 0x03, 0x84, 0x00, 0x31,
  0x01, 0x03, 0x47, 0xC0, 0x3F, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x06, 0x20,
  0x03, 0x0C, 0x01, 0x81, 0x01, 0x80, 0x60, 0x40, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7B, 0xC0, 0x03, 0x03, 0x80, 0x18,
  0x06, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x20, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x11, 0x00,
  0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x60, 0x10, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x83, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x1C, 0x06, 0x81, 0xB0,
  0xE6, 0x30, 0x8C, 0x17, 0x06, 0xC0, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x9E, 0x00, 0x1C, 0x01, 0x80, 0x08, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x1C, 0x01, 0xC0, 0x18,
  0x00, 0x60, 0x08, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x90, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x61, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x03,
  0x00, 0x04, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x01, 0x80,
  0x04, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0x80, 0x7F, 0xFF, 0xFF, 0x40, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x40, 0x03, 0x80, 0x38, 0x07, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x86, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x30, 0xFF, 0x00, 0x33, 0x81,
  0xC0, 0x26, 0x00, 0xC0, 0x2C, 0x00, 0x60, 0x78, 0x00, 0x20, 0x70, 0x00,
  0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x40, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x60, 0x01,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x04, 0x00, 0x08, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x20, 0x00,
  0x20, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xCC, 0x00, 0x03,
  0x83, 0x00, 0x03, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x81,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x79, 0xE0, 0x01, 0x80, 0x60, 0x06, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x60,
  0x00, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC1, 0x00, 0x03, 0x83,
  0x00, 0x0B, 0x06, 0x00, 0x34, 0x06, 0x01, 0xD8, 0x07, 0xFE, 0x30, 0x03,
  0xF0, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x02, 0x03, 0x80, 0x07,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x07, 0x03, 0x01, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xE7, 0x80, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1,
  0x00, 0x0F, 0xE0, 0x30, 0xC0, 0x0F, 0x38, 0x0C, 0x20, 0x06, 0x06, 0x03,
  0x18, 0x03, 0x01, 0x80, 0xC6, 0x01, 0x80, 0x40, 0x31, 0x00, 0xC0, 0x30,
  0x0C, 0xC0, 0x30, 0x0C, 0x02, 0x30, 0x18, 0x03, 0x00, 0x88, 0x06, 0x00,
  0x80, 0x66, 0x03, 0x00, 0x60, 0x19, 0x80, 0xC0, 0x18, 0x06, 0x60, 0x20,
  0x06, 0x01, 0x90, 0x18, 0x01, 0x00, 0x44, 0x06, 0x00, 0xC0, 0x33, 0x01,
  0x80, 0x30, 0x0C, 0xC0, 0x60, 0x0C, 0x02, 0x30, 0x10, 0x06, 0x01, 0x8C,
  0x04, 0x01, 0x80, 0x43, 0x01, 0x00, 0xE0, 0x30, 0xC0, 0x60, 0x28, 0x08,
  0x30, 0x18, 0x1A, 0x06, 0x0C, 0x06, 0x0C, 0xC3, 0x03, 0x00, 0xE6, 0x3B,
  0x80, 0xC0, 0x1F, 0x07, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x26, 0x00, 0x00, 0x66, 0x00, 0x00, 0x46,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x86, 0x00, 0x01, 0x86, 0x00, 0x01, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x02,
  0x00, 0x10, 0x02, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x02,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x02,
  0x01, 0x80, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x04, 0x00, 0xE0, 0x01, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x18,
  0x00, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x40, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC0, 0x20, 0x00, 0x10, 0x18, 0x00, 0x04, 0x06, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x18, 0x00, 0x04,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x10, 0x00,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0xE0, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x78, 0x00, 0x20, 0x03,
  0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x04,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0E,
  0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x0E, 0x00, 0x40, 0x03, 0x80, 0x08, 0x01, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x10, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60,
  0x01, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x10,
  0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x00, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x08, 0x30,
  0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x60, 0x04, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x80, 0x18, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x4D, 0x80, 0x00,
  0x05, 0x98, 0x00, 0x00, 0xD0, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x10, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0x40, 0x1E, 0x00,
  0x00, 0x06, 0x80, 0x34, 0x00, 0x00, 0x0B, 0x00, 0x48, 0x00, 0x00, 0x36,
  0x00, 0x90, 0x00, 0x00, 0x4C, 0x03, 0x20, 0x00, 0x01, 0x90, 0x06, 0x40,
  0x00, 0x02, 0x20, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x11, 0x80, 0x00, 0x11,
  0x80, 0x63, 0x00, 0x00, 0x63, 0x00, 0xC6, 0x00, 0x00, 0x84, 0x01, 0x8C,
  0x00, 0x03, 0x08, 0x02, 0x18, 0x00, 0x0C, 0x30, 0x04, 0x10, 0x00, 0x18,
  0x60, 0x18, 0x20, 0x00, 0x60, 0x80, 0x30, 0x40, 0x00, 0xC1, 0x00, 0x60,
  0x80, 0x03, 0x06, 0x00, 0x81, 0x00, 0x06, 0x0C, 0x01, 0x03, 0x00, 0x18,
  0x18, 0x06, 0x06, 0x00, 0x30, 0x20, 0x0C, 0x0C, 0x00, 0xC0, 0x40, 0x18,
  0x18, 0x01, 0x81, 0x80, 0x20, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x0C,
  0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x03, 0x00, 0x80, 0x60, 0x10, 0x06,
  0x01, 0x01, 0x80, 0x60, 0x08, 0x02, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x60, 0x0C, 0x01,
  0x00, 0x30, 0x80, 0x18, 0x02, 0x00, 0x63, 0x00, 0x30, 0x0C, 0x00, 0xC4,
  0x00, 0x40, 0x18, 0x01, 0x98, 0x00, 0x80, 0x30, 0x01, 0x20, 0x03, 0x00,
  0x40, 0x02, 0xC0, 0x06, 0x01, 0x80, 0x05, 0x00, 0x0C, 0x03, 0x00, 0x0E,
  0x00, 0x10, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x06,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0xD0, 0x00, 0x04, 0x00, 0xD8, 0x00, 0x04,
  0x00, 0x98, 0x00, 0x0C, 0x00, 0x98, 0x00, 0x0C, 0x01, 0x88, 0x00, 0x0C,
  0x01, 0x8C, 0x00, 0x08, 0x01, 0x8C, 0x00, 0x18, 0x01, 0x0C, 0x00, 0x18,
  0x03, 0x04, 0x00, 0x18, 0x03, 0x06, 0x00, 0x18, 0x03, 0x06, 0x00, 0x10,
  0x02, 0x02, 0x00, 0x30, 0x02, 0x02, 0x00, 0x30, 0x06, 0x03, 0x00, 0x30,
  0x06, 0x03, 0x00, 0x20, 0x06, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x80, 0x40,
  0x0C, 0x00, 0x80, 0x40, 0x08, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0xC0, 0xC0,
  0x18, 0x00, 0x40, 0xC0, 0x18, 0x00, 0x60, 0x80, 0x10, 0x00, 0x61, 0x80,
  0x10, 0x00, 0x61, 0x80, 0x30, 0x00, 0x21, 0x80, 0x30, 0x00, 0x31, 0x00,
  0x30, 0x00, 0x31, 0x00, 0x20, 0x00, 0x33, 0x00, 0x20, 0x00, 0x13, 0x00,
  0x60, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x1A, 0x00, 0x60, 0x00, 0x1A, 0x00,
  0x40, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x10, 0x0F, 0x00, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x01,
  0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0x20, 0x01, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x0F, 0x80, 0x0F, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x10, 0x0F, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10,
  0x00, 0x18, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x20, 0x03, 0x80, 0x10, 0x07, 0x80, 0x1F, 0xFF, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0x40,
  0x01, 0x80, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00,
  0x30, 0x02, 0x00, 0x08, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x01, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x90, 0x00, 0x03, 0x20, 0x00, 0x04, 0x40, 0x00, 0x18, 0x80, 0x00, 0x31,
  0x00, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80,
  0x04, 0x03, 0x00, 0x18, 0x06, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x60,
  0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00, 0x08, 0x18, 0x00,
  0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01,
  0x0C, 0x00, 0x02, 0x30, 0x00, 0x04, 0x60, 0x00, 0x09, 0x80, 0x00, 0x13,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x58, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0A, 0x00, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x80, 0x00,
  0x68, 0x00, 0x07, 0x00, 0x01, 0x90, 0x00, 0x0A, 0x00, 0x03, 0x20, 0x00,
  0x34, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x18, 0x80, 0x01, 0x90, 0x00,
  0x31, 0x00, 0x03, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00,
  0x18, 0x80, 0x02, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x10, 0x00, 0xC2, 0x00,
  0x10, 0x20, 0x01, 0x04, 0x00, 0x60, 0x40, 0x06, 0x08, 0x00, 0xC0, 0x80,
  0x0C, 0x10, 0x03, 0x01, 0x00, 0x10, 0x20, 0x06, 0x02, 0x00, 0x60, 0x40,
  0x08, 0x04, 0x00, 0x80, 0x80, 0x30, 0x08, 0x03, 0x01, 0x00, 0x60, 0x10,
  0x06, 0x02, 0x01, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0x40, 0x30, 0x08,
  0x04, 0x00, 0x80, 0x40, 0x10, 0x18, 0x01, 0x01, 0x80, 0x20, 0x20, 0x02,
  0x02, 0x00, 0x40, 0xC0, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x08, 0x18, 0x01,
  0x06, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x00,
  0x41, 0x00, 0x08, 0x60, 0x00, 0x86, 0x00, 0x10, 0x80, 0x01, 0x0C, 0x00,
  0x23, 0x00, 0x02, 0x30, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x88, 0x00,
  0x0C, 0x80, 0x01, 0x30, 0x00, 0x1B, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00,
  0x05, 0x80, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x00, 0xB0, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x30, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x10, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x64,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x20, 0x01,
  0x81, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x20, 0x02, 0x03, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80,
  0x06, 0x18, 0x00, 0x30, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x26,
  0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0xC0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C,
  0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x40, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x21, 0x80, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0x40, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x08, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x83, 0x04, 0x18, 0x20, 0xC1,
  0x06, 0x08, 0x10, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x84, 0x03, 0x81, 0x98,
  0x0C, 0x01, 0x30, 0x30, 0x03, 0x40, 0xC0, 0x02, 0x81, 0x80, 0x05, 0x06,
  0x00, 0x0E, 0x08, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x61, 0x00, 0x00, 0x86, 0x00, 0x01,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x02, 0x00, 0x1C, 0x04,
  0x00, 0x68, 0x0C, 0x01, 0x90, 0x0C, 0x06, 0x60, 0x1C, 0x18, 0xC0, 0x1F,
  0xE1, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x78, 0x00, 0xC3, 0xFC,
  0x01, 0x9C, 0x0C, 0x03, 0x70, 0x0C, 0x04, 0xC0, 0x18, 0x0B, 0x00, 0x18,
  0x3C, 0x00, 0x30, 0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40,
  0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0x50, 0x00, 0x40, 0xA0, 0x01, 0x81, 0x60, 0x06, 0x06, 0x60, 0x18, 0x0C,
  0xE0, 0xE0, 0x10, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xFC, 0x03, 0x80, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x60, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0xC0, 0x03, 0xFC, 0x20, 0x03, 0x81, 0x88, 0x01, 0x80,
  0x36, 0x00, 0xC0, 0x05, 0x80, 0x60, 0x01, 0x60, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x03, 0x00, 0x05, 0x00, 0x40, 0x03, 0xC0, 0x10, 0x01, 0xB0, 0x06, 0x00,
  0xC8, 0x00, 0xC0, 0x72, 0x00, 0x38, 0x38, 0x80, 0x07, 0xF8, 0x60, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0xE0, 0x18,
  0x06, 0x03, 0x00, 0x20, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x02, 0x08,
  0x00, 0x21, 0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x01, 0x82,
  0x00, 0x30, 0x60, 0x0E, 0x06, 0x07, 0x80, 0x7F, 0xE0, 0x07, 0x80, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x02, 0x01, 0xC0, 0xE0, 0x0F,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x40, 0x03, 0xFC, 0x20,
  0x03, 0x81, 0x88, 0x01, 0x80, 0x32, 0x00, 0xC0, 0x05, 0x80, 0x60, 0x01,
  0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x10, 0x18, 0x00, 0x0C,
  0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x0F, 0x00, 0x40, 0x03, 0xC0,
  0x10, 0x01, 0xB0, 0x06, 0x00, 0xE8, 0x00, 0xC0, 0x72, 0x00, 0x38, 0x39,
  0x80, 0x07, 0xF8, 0x60, 0x00, 0x38, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x0F, 0x00, 0x10, 0xFF, 0x00, 0xCE,
  0x06, 0x03, 0x60, 0x0C, 0x0B, 0x00, 0x30, 0x28, 0x00, 0xC1, 0xE0, 0x03,
  0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x0C,
  0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00,
  0x10, 0x60, 0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x60, 0x80,
  0x01, 0x86, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03,
  0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x01, 0xC0, 0xC0,
  0x04, 0x03, 0x00, 0x30, 0x08, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x40, 0x60, 0x01, 0x03, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x02, 0x38, 0x00, 0x09, 0xA0,
  0x00, 0x64, 0xC0, 0x01, 0xB3, 0x00, 0x05, 0x8C, 0x00, 0x1C, 0x10, 0x00,
  0xE0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x20, 0x08, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x00, 0x18,
  0x04, 0x00, 0x60, 0x30, 0x00, 0x80, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x63, 0xFC, 0x0F,
  0xF0, 0x0C, 0xC0, 0xC3, 0x03, 0x01, 0x30, 0x08, 0xC0, 0x30, 0x2C, 0x01,
  0xB0, 0x06, 0x07, 0x00, 0x3C, 0x00, 0x41, 0xC0, 0x07, 0x00, 0x08, 0x38,
  0x00, 0xE0, 0x01, 0x06, 0x00, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x08, 0x00, 0x30, 0xC0, 0x03, 0x00,
  0x04, 0x18, 0x00, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x00, 0x30, 0x40, 0x01,
  0x00, 0x06, 0x18, 0x00, 0x20, 0x00, 0x83, 0x00, 0x0C, 0x00, 0x10, 0x60,
  0x01, 0x80, 0x06, 0x08, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x00, 0x18,
  0x60, 0x00, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x00, 0x41, 0x00, 0x06, 0x00,
  0x18, 0x20, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0x00, 0x61, 0x80, 0x06,
  0x00, 0x08, 0x30, 0x00, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x00, 0x60, 0x80,
  0x02, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x01, 0x06, 0x00, 0x18, 0x00, 0x20,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x0C, 0x7F, 0xC0, 0x33,
  0x81, 0x80, 0x98, 0x03, 0x02, 0xC0, 0x0C, 0x0A, 0x00, 0x30, 0x70, 0x00,
  0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x83,
  0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C,
  0x30, 0x00, 0x20, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20,
  0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00,
  0xC1, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x38, 0x18, 0x03, 0x00, 0x60, 0x30,
  0x01, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x01, 0x08, 0x00, 0x08,
  0xC0, 0x00, 0x46, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00,
  0x05, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xD0,
  0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x30, 0x80,
  0x03, 0x06, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x03, 0x80,
  0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x08, 0x7F,
  0x80, 0x06, 0x70, 0x30, 0x01, 0x38, 0x06, 0x00, 0x4C, 0x01, 0x80, 0x16,
  0x00, 0x30, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0,
  0x38, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x07, 0x00, 0x01, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x18, 0x08, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x38, 0x00,
  0x30, 0x0A, 0x00, 0x18, 0x02, 0xC0, 0x0C, 0x01, 0x90, 0x06, 0x00, 0x67,
  0x07, 0x00, 0x18, 0xFF, 0x80, 0x04, 0x06, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0x00, 0x7F, 0xC2, 0x00, 0xE0, 0x62,
  0x01, 0x80, 0x32, 0x03, 0x00, 0x16, 0x06, 0x00, 0x16, 0x06, 0x00, 0x1C,
  0x0C, 0x00, 0x1C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x10, 0x60, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0,
  0x40, 0x03, 0xC0, 0x40, 0x06, 0xC0, 0x60, 0x0E, 0x80, 0x30, 0x1C, 0x80,
  0x38, 0x39, 0x80, 0x1F, 0xE1, 0x80, 0x03, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0xC7, 0xF0, 0x33, 0x80, 0x09, 0x80, 0x02, 0xC0, 0x00,
  0xA0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0E, 0x03, 0x83, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x20, 0x07, 0x07, 0x01, 0xC0, 0x7F, 0xE0, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x3F, 0xF8, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x04, 0x18, 0x00,
  0x30, 0x40, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x00, 0x83, 0x00, 0x02,
  0x0C, 0x00, 0x18, 0x20, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x04, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x01, 0x40,
  0xC0, 0x0D, 0x01, 0x00, 0x64, 0x07, 0x07, 0x30, 0x0F, 0xF0, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x06, 0x08,
  0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x26,
  0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x28, 0x00, 0x70, 0x01, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x0D, 0x00,
  0x32, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x90, 0x02, 0x20, 0x06, 0x40, 0x18,
  0x80, 0x11, 0x00, 0x42, 0x00, 0xC4, 0x03, 0x08, 0x02, 0x10, 0x0C, 0x20,
  0x18, 0x40, 0x20, 0x80, 0x41, 0x01, 0x82, 0x03, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x02, 0x04, 0x04,
  0x18, 0x08, 0x30, 0x10, 0x40, 0x20, 0x80, 0x43, 0x00, 0x86, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x23, 0x00, 0x44, 0x00,
  0x98, 0x01, 0x30, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00, 0x16, 0x00, 0x2C,
  0x00, 0x58, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01, 0x80, 0x03, 0x01, 0x80, 0x06,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x20, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x80,
  0x00, 0x21, 0x80, 0x00, 0x33, 0x00, 0x00, 0x32, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x84, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x02, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x18, 0x01, 0x00, 0x18, 0x01, 0x00, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x40, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x80, 0x00, 0x80, 0x06, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x20, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x02, 0xF3, 0xC0,
  0x0F, 0x00, 0xE0, 0x34, 0x00, 0x7F, 0xC8, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 44, 12, 1, -44 },
  { 67, 12, 16, 17, 6, -44 },
  { 91, 27, 44, 27, 1, -44 },
  { 240, 25, 50, 25, 0, -46 },
  { 397, 29, 45, 36, 4, -44 },
  { 561, 25, 45, 26, 0, -44 },
  { 702, 5, 16, 9, 6, -44 },
  { 712, 16, 53, 15, 2, -43 },
  { 818, 17, 53, 15, -4, -43 },
  { 931, 18, 19, 23, 7, -46 },
  { 974, 23, 29, 27, 3, -36 },
  { 1058, 8, 14, 10, -3, -6 },
  { 1072, 13, 1, 17, 2, -17 },
  { 1074, 3, 4, 10, 1, -4 },
  { 1076, 25, 44, 18, -3, -44 },
  { 1214, 22, 45, 25, 2, -44 },
  { 1338, 11, 44, 25, 8, -44 },
  { 1399, 25, 44, 25, -1, -44 },
  { 1537, 25, 45, 25, -1, -44 },
  { 1678, 25, 44, 25, -1, -44 },
  { 1816, 25, 45, 25, 0, -44 },
  { 1957, 24, 45, 25, 2, -44 },
  { 2092, 23, 44, 25, 4, -44 },
  { 2219, 25, 45, 25, 0, -44 },
  { 2360, 23, 45, 25, 1, -44 },
  { 2490, 9, 32, 10, 1, -32 },
  { 2526, 13, 40, 10, -3, -32 },
  { 2591, 23, 26, 27, 3, -35 },
  { 2666, 23, 15, 27, 3, -29 },
  { 2710, 23, 26, 27, 3, -35 },
  { 2785, 18, 44, 18, 2, -44 },
  { 2884, 34, 49, 37, 2, -44 },
  { 3093, 24, 44, 24, -4, -44 },
  { 3225, 26, 44, 27, 1, -44 },
  { 3368, 26, 45, 25, 3, -44 },
  { 3515, 27, 44, 30, 1, -44 },
  { 3664, 25, 44, 24, 1, -44 },
  { 3802, 25, 44, 22, 1, -44 },
  { 3940, 29, 45, 32, 3, -44 },
  { 4104, 31, 44, 31, 1, -44 },
  { 4275, 18, 44, 12, -2, -44 },
  { 4374, 21, 55, 11, -9, -44 },
  { 4519, 28, 44, 25, 1, -44 },
  { 4673, 16, 44, 22, 1, -44 },
  { 4761, 39, 44, 40, 1, -44 },
  { 4976, 32, 44, 32, 1, -44 },
  { 5152, 28, 45, 32, 3, -44 },
  { 5310, 25, 44, 25, 1, -44 },
  { 5448, 28, 54, 32, 3, -44 },
  { 5637, 25, 44, 26, 1, -44 },
  { 5775, 26, 45, 24, -1, -44 },
  { 5922, 21, 44, 21, 5, -44 },
  { 6038, 29, 45, 31, 3, -44 },
  { 6202, 23, 44, 24, 6, -44 },
  { 6329, 39, 44, 41, 6, -44 },
  { 6544, 30, 44, 22, -4, -44 },
  { 6709, 21, 44, 21, 5, -44 },
  { 6825, 28, 44, 23, -2, -44 },
  { 6979, 22, 54, 17, -1, -44 },
  { 7128, 9, 44, 19, 6, -44 },
  { 7178, 22, 54, 17, -4, -44 },
  { 7327, 24, 23, 27, 2, -44 },
  { 7396, 18, 1, 18, -5, 6 },
  { 7399, 6, 10, 13, 9, -47 },
  { 7407, 23, 34, 26, 2, -33 },
  { 7505, 23, 47, 26, 1, -46 },
  { 7641, 19, 34, 20, 2, -33 },
  { 7722, 26, 47, 27, 2, -46 },
  { 7875, 20, 34, 23, 2, -33 },
  { 7960, 28, 62, 13, -8, -47 },
  { 8177, 26, 48, 26, 0, -33 },
  { 8333, 22, 46, 25, 1, -46 },
  { 8460, 11, 44, 10, 1, -44 },
  { 8521, 20, 59, 11, -8, -44 },
  { 8669, 22, 46, 21, 1, -46 },
  { 8796, 11, 46, 10, 1, -46 },
  { 8860, 35, 33, 39, 1, -33 },
  { 9005, 22, 33, 25, 1, -33 },
  { 9096, 21, 34, 26, 2, -33 },
  { 9186, 26, 47, 26, -2, -33 },
  { 9339, 24, 47, 27, 2, -33 },
  { 9480, 18, 33, 17, 1, -33 },
  { 9555, 19, 34, 19, 0, -33 },
  { 9636, 13, 41, 13, 2, -40 },
  { 9703, 22, 33, 25, 2, -32 },
  { 9794, 19, 32, 19, 3, -32 },
  { 9870, 30, 32, 32, 4, -32 },
  { 9990, 24, 32, 20, -2, -32 },
  { 10086, 30, 47, 20, -7, -32 },
  { 10263, 21, 32, 18, -2, -32 },
  { 10347, 21, 54, 19, 2, -44 },
  { 10489, 1, 61, 24, 12, -46 },
  { 10497, 21, 54, 19, -4, -44 },
  { 10639, 23, 5, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_THINITALIC61PT7B_H_
