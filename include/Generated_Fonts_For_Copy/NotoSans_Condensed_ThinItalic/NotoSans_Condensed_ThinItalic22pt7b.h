#ifndef _NOTOSANS_CONDENSED_THINITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x00, 0x18, 0x4A,
  0x55, 0x29, 0x48, 0x04, 0x41, 0x20, 0x48, 0x22, 0x09, 0x0F, 0xF1, 0x10,
  0x44, 0x12, 0x08, 0x8F, 0xF0, 0x90, 0x24, 0x11, 0x04, 0x81, 0x20, 0x02,
  0x01, 0x03, 0xE2, 0x82, 0x41, 0x20, 0x90, 0x28, 0x08, 0x06, 0x02, 0x81,
  0x41, 0x10, 0x90, 0x49, 0xF8, 0x10, 0x10, 0x00, 0x18, 0x24, 0x89, 0x12,
  0x22, 0x48, 0x91, 0x12, 0x22, 0xB4, 0x59, 0x95, 0x2D, 0x44, 0x28, 0x89,
  0x11, 0x22, 0x44, 0x88, 0x92, 0x1C, 0x06, 0x04, 0x84, 0x42, 0x21, 0x20,
  0x90, 0x50, 0x10, 0x38, 0x22, 0x51, 0x30, 0xA8, 0x34, 0x12, 0x18, 0xF2,
  0x56, 0xA0, 0x04, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x0C, 0x00, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x08, 0x00, 0x10, 0x49, 0x1F, 0x23,
  0x40, 0x80, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08,
  0x29, 0x28, 0xF0, 0xC0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0E, 0x11,
  0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84,
  0x88, 0x70, 0x13, 0xD1, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x0E, 0x08,
  0x80, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x01, 0xF8, 0x0F, 0x18, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x3C, 0x04, 0x01, 0x00, 0x40, 0x20, 0x20, 0x10, 0x11, 0xF0, 0x00, 0x80,
  0x80, 0xC0, 0xA0, 0x50, 0x48, 0x44, 0x24, 0x22, 0x21, 0x10, 0x9F, 0xE0,
  0x40, 0x20, 0x10, 0x08, 0x0F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0xA0,
  0x68, 0x02, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x11, 0xF0, 0x0F, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x98, 0xE4, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84,
  0x84, 0x78, 0x7F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0F, 0x08, 0x48, 0x24,
  0x12, 0x09, 0x08, 0x48, 0x18, 0x34, 0x21, 0x20, 0x90, 0x28, 0x14, 0x0A,
  0x08, 0xF8, 0x0E, 0x08, 0x88, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x82, 0x23,
  0x0E, 0x80, 0x40, 0x40, 0x20, 0x20, 0x11, 0xF0, 0x12, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x08, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84, 0x42, 0x00,
  0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30, 0x08, 0x06, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0x0C, 0x10, 0x60, 0x80, 0x78,
  0x10, 0x41, 0x04, 0x20, 0x84, 0x21, 0x04, 0x20, 0x00, 0x00, 0x20, 0x03,
  0xC0, 0xC2, 0x10, 0x12, 0x01, 0x40, 0x14, 0x79, 0x48, 0x98, 0x91, 0x91,
  0x19, 0x12, 0x91, 0x29, 0x22, 0x95, 0x48, 0x88, 0x80, 0x08, 0x00, 0x40,
  0x03, 0xE0, 0x01, 0x03, 0x03, 0x05, 0x05, 0x09, 0x09, 0x11, 0x11, 0x1F,
  0x21, 0x21, 0x41, 0x41, 0x81, 0x81, 0x0F, 0x04, 0x21, 0x04, 0x41, 0x10,
  0x48, 0x22, 0x08, 0xFC, 0x21, 0x08, 0x44, 0x09, 0x02, 0x41, 0x10, 0x48,
  0x23, 0xF0, 0x07, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0xF0, 0x0F, 0x04,
  0x21, 0x04, 0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x09,
  0x02, 0x40, 0x90, 0x48, 0x23, 0xF0, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0xFC, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x03, 0xF0, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x3F, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x07, 0xC1,
  0x04, 0x40, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x83, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x09, 0x02, 0x10, 0x41, 0xF8, 0x10, 0x22, 0x04, 0x40,
  0x88, 0x11, 0x02, 0x40, 0x48, 0x11, 0xFE, 0x20, 0x44, 0x09, 0x02, 0x20,
  0x44, 0x08, 0x81, 0x20, 0x24, 0x08, 0x1E, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x70, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x86, 0x00, 0x10, 0x22, 0x08, 0x42, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x01,
  0x40, 0x38, 0x04, 0x81, 0x10, 0x22, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x3F,
  0x08, 0x02, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x45, 0x02, 0x8A,
  0x0A, 0x14, 0x14, 0x28, 0x48, 0x48, 0x91, 0x12, 0x22, 0x24, 0x84, 0x51,
  0x08, 0xA2, 0x21, 0x84, 0x42, 0x08, 0x08, 0x11, 0x81, 0x18, 0x21, 0x82,
  0x14, 0x22, 0x42, 0x24, 0x22, 0x44, 0x22, 0x42, 0x24, 0x42, 0x44, 0x24,
  0x41, 0x84, 0x18, 0x81, 0x88, 0x08, 0x0F, 0x04, 0x22, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x44,
  0x21, 0xF0, 0x0F, 0x08, 0x44, 0x22, 0x11, 0x09, 0x04, 0x82, 0x42, 0x3E,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x0F, 0x04, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81,
  0x20, 0x44, 0x21, 0xD0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x0F, 0x08, 0x44,
  0x22, 0x11, 0x09, 0x04, 0x82, 0x42, 0x3E, 0x12, 0x11, 0x08, 0x84, 0x22,
  0x12, 0x09, 0x04, 0x0F, 0x88, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x11, 0xF0, 0xFF, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x20, 0x48, 0x12, 0x04, 0x81, 0x40, 0x50, 0x24, 0x09, 0x02, 0x40,
  0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x88, 0x21, 0xF0, 0x80, 0xC0, 0xA0,
  0x50, 0x48, 0x24, 0x22, 0x11, 0x10, 0x88, 0x48, 0x24, 0x12, 0x0A, 0x05,
  0x01, 0x00, 0x80, 0x81, 0x06, 0x08, 0x18, 0x20, 0xA1, 0x42, 0x85, 0x0A,
  0x14, 0x48, 0x91, 0x22, 0x48, 0x91, 0x22, 0x44, 0x8A, 0x14, 0x28, 0x50,
  0xA1, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x10, 0x42, 0x10, 0x88, 0x22,
  0x09, 0x02, 0x80, 0x60, 0x10, 0x04, 0x03, 0x01, 0x40, 0x88, 0x22, 0x10,
  0x88, 0x22, 0x08, 0x81, 0x82, 0x84, 0x84, 0x88, 0x88, 0x50, 0x50, 0x60,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x0F, 0xC0, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x04, 0x03, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xF0, 0x92, 0x24,
  0x92, 0x48, 0x92, 0x49, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x23, 0xC0, 0x08, 0x08, 0x14,
  0x24, 0x22, 0x42, 0x41, 0x81, 0xFE, 0x95, 0x1D, 0x23, 0x41, 0x41, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0x74, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xB0, 0xE4, 0x61, 0x20, 0x90, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08,
  0x84, 0xBC, 0x00, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x03, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xE8, 0x8C, 0x82, 0x41,
  0x41, 0x20, 0x90, 0x48, 0x24, 0x12, 0x11, 0x18, 0x74, 0x00, 0x1C, 0x45,
  0x0A, 0x18, 0x53, 0x38, 0x40, 0x81, 0x02, 0x03, 0xC0, 0x00, 0xC0, 0x40,
  0x20, 0x08, 0x02, 0x03, 0xC0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x38,
  0x00, 0x0E, 0x88, 0xC8, 0x24, 0x14, 0x12, 0x09, 0x04, 0x82, 0x41, 0x21,
  0x11, 0x87, 0x40, 0x20, 0x10, 0x10, 0x08, 0xF8, 0x00, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x1E, 0x31, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42,
  0x82, 0x82, 0x11, 0x00, 0x12, 0x22, 0x24, 0x44, 0x44, 0x88, 0x02, 0x04,
  0x00, 0x00, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x0E, 0x00, 0x08, 0x10, 0x10, 0x10, 0x10, 0x11, 0x22,
  0x22, 0x24, 0x28, 0x50, 0x68, 0x48, 0x48, 0x44, 0x84, 0x84, 0x11, 0x11,
  0x11, 0x22, 0x22, 0x44, 0x44, 0x48, 0x80, 0x2E, 0x70, 0x8C, 0x48, 0x42,
  0x42, 0x12, 0x10, 0xA0, 0x85, 0x08, 0x28, 0x42, 0x42, 0x12, 0x10, 0xA0,
  0x85, 0x08, 0x40, 0x2E, 0x31, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42,
  0x42, 0x82, 0x82, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A,
  0x13, 0xC0, 0x13, 0x05, 0x21, 0x84, 0x41, 0x10, 0x44, 0x12, 0x04, 0x82,
  0x20, 0x88, 0x22, 0x11, 0x78, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00,
  0x1D, 0x23, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C, 0x74,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x2E, 0x60, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x00, 0x1E, 0x41, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x27, 0xC0, 0x22, 0xF4, 0x44, 0x48, 0x88, 0x88, 0x8E, 0x41, 0x41,
  0x41, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x83, 0x06,
  0x14, 0x28, 0x91, 0x24, 0x48, 0xA1, 0x43, 0x02, 0x00, 0x84, 0x30, 0x86,
  0x30, 0xC6, 0x28, 0xC5, 0x29, 0x24, 0xA5, 0x14, 0xA3, 0x18, 0x43, 0x08,
  0x41, 0x00, 0x10, 0x88, 0x84, 0x42, 0x40, 0xC0, 0x40, 0x20, 0x28, 0x24,
  0x12, 0x11, 0x10, 0x40, 0x08, 0x21, 0x04, 0x20, 0x82, 0x20, 0x44, 0x09,
  0x01, 0x20, 0x28, 0x05, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0xE0, 0x00, 0x1F, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0xFC, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x21,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x01, 0x80, 0xFF, 0xFF, 0xFC,
  0x08, 0x08, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x10, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x43, 0x80, 0x71, 0x8F,
};

const GFXglyph NotoSans_Condensed_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 4, 0, -16 },
  { 11, 5, 6, 6, 2, -16 },
  { 15, 10, 16, 10, 0, -16 },
  { 35, 9, 18, 9, 0, -17 },
  { 56, 11, 16, 13, 1, -16 },
  { 78, 9, 16, 9, 0, -16 },
  { 96, 2, 6, 3, 2, -16 },
  { 98, 6, 19, 5, 1, -16 },
  { 113, 6, 19, 5, -1, -16 },
  { 128, 6, 7, 8, 3, -17 },
  { 134, 8, 10, 10, 1, -13 },
  { 144, 3, 5, 4, -1, -2 },
  { 146, 4, 1, 6, 1, -6 },
  { 147, 2, 1, 4, 0, -1 },
  { 148, 9, 16, 7, -1, -16 },
  { 166, 8, 16, 9, 1, -16 },
  { 182, 4, 16, 9, 3, -16 },
  { 190, 9, 16, 9, 0, -16 },
  { 208, 9, 16, 9, 0, -16 },
  { 226, 9, 16, 9, 0, -16 },
  { 244, 9, 16, 9, 0, -16 },
  { 262, 8, 16, 9, 1, -16 },
  { 278, 9, 16, 9, 1, -16 },
  { 296, 9, 16, 9, 0, -16 },
  { 314, 9, 16, 9, 0, -16 },
  { 332, 4, 12, 4, 0, -12 },
  { 338, 5, 15, 4, -1, -12 },
  { 348, 8, 9, 10, 1, -12 },
  { 357, 8, 5, 10, 1, -10 },
  { 362, 8, 9, 10, 1, -12 },
  { 371, 6, 16, 6, 1, -16 },
  { 383, 12, 18, 13, 1, -16 },
  { 410, 8, 16, 9, -1, -16 },
  { 426, 10, 16, 10, 0, -16 },
  { 446, 10, 16, 9, 1, -16 },
  { 466, 10, 16, 11, 0, -16 },
  { 486, 10, 16, 9, 0, -16 },
  { 506, 10, 16, 8, 0, -16 },
  { 526, 11, 16, 12, 1, -16 },
  { 548, 11, 16, 11, 0, -16 },
  { 570, 7, 16, 4, -1, -16 },
  { 584, 7, 20, 4, -3, -16 },
  { 602, 11, 16, 9, 0, -16 },
  { 624, 6, 16, 8, 0, -16 },
  { 636, 15, 16, 14, 0, -16 },
  { 666, 12, 16, 12, 0, -16 },
  { 690, 10, 16, 12, 1, -16 },
  { 710, 9, 16, 9, 0, -16 },
  { 728, 10, 20, 12, 1, -16 },
  { 753, 9, 16, 9, 0, -16 },
  { 771, 9, 16, 9, 0, -16 },
  { 789, 8, 16, 8, 2, -16 },
  { 805, 10, 16, 11, 1, -16 },
  { 825, 9, 16, 9, 2, -16 },
  { 843, 14, 16, 15, 2, -16 },
  { 871, 10, 16, 8, -1, -16 },
  { 891, 8, 16, 8, 2, -16 },
  { 907, 10, 16, 8, -1, -16 },
  { 927, 8, 19, 6, 0, -16 },
  { 946, 3, 16, 7, 2, -16 },
  { 952, 7, 19, 6, -1, -16 },
  { 969, 8, 8, 10, 1, -16 },
  { 977, 7, 1, 6, -2, 2 },
  { 978, 2, 4, 5, 3, -17 },
  { 979, 8, 12, 9, 1, -12 },
  { 991, 9, 17, 9, 0, -17 },
  { 1011, 7, 12, 7, 1, -12 },
  { 1022, 9, 17, 10, 1, -17 },
  { 1042, 7, 12, 8, 1, -12 },
  { 1053, 10, 22, 5, -3, -17 },
  { 1081, 9, 17, 10, 0, -12 },
  { 1101, 8, 17, 9, 0, -17 },
  { 1118, 4, 16, 4, 0, -16 },
  { 1126, 7, 21, 4, -3, -16 },
  { 1145, 8, 17, 7, 0, -17 },
  { 1162, 4, 17, 4, 0, -17 },
  { 1171, 13, 12, 14, 0, -12 },
  { 1191, 8, 12, 9, 0, -12 },
  { 1203, 7, 12, 9, 1, -12 },
  { 1214, 10, 17, 9, -1, -12 },
  { 1236, 8, 17, 10, 1, -12 },
  { 1253, 7, 12, 6, 0, -12 },
  { 1264, 7, 12, 7, 0, -12 },
  { 1275, 4, 14, 5, 1, -14 },
  { 1282, 8, 12, 9, 1, -12 },
  { 1294, 7, 12, 7, 1, -12 },
  { 1305, 11, 12, 11, 1, -12 },
  { 1322, 9, 12, 7, -1, -12 },
  { 1336, 11, 17, 7, -3, -12 },
  { 1360, 8, 12, 6, -1, -12 },
  { 1372, 7, 19, 7, 1, -16 },
  { 1389, 1, 22, 9, 4, -17 },
  { 1392, 7, 19, 7, -1, -16 },
  { 1409, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_THINITALIC22PT7B_H_
