#ifndef _NOTOSANS_CONDENSED_THINITALIC71PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x60, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x18, 0x40, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x10, 0xC0,
  0xC2, 0x03, 0x18, 0x0C, 0x60, 0x21, 0x80, 0x84, 0x06, 0x10, 0x18, 0xC0,
  0x63, 0x01, 0x08, 0x04, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x20, 0xF0, 0x07, 0x06, 0x02, 0x00, 0xC0,
  0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x38, 0x04, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x4E, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x20, 0x30, 0x08, 0x06, 0x06, 0x00, 0xE0,
  0x63, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0x80, 0x3D, 0xE0, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x0C, 0x03,
  0x81, 0x80, 0x03, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x60, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x03, 0x03, 0x00,
  0x0C, 0x00, 0x40, 0xC0, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x03, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0xC1, 0xF1, 0x80, 0x18, 0x30, 0x7F, 0x30, 0x03,
  0x0C, 0x18, 0x36, 0x00, 0x61, 0x86, 0x06, 0xC0, 0x18, 0x61, 0x80, 0x78,
  0x03, 0x0C, 0x70, 0x0F, 0x00, 0xC3, 0x0C, 0x01, 0xB0, 0x38, 0x61, 0x80,
  0x36, 0x0E, 0x18, 0x60, 0x06, 0x77, 0x86, 0x0C, 0x00, 0xC7, 0xE0, 0xC3,
  0x00, 0x18, 0x00, 0x30, 0x60, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x01,
  0x81, 0x80, 0x18, 0x00, 0x30, 0x60, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x80,
  0x60, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0x18, 0x18, 0x03, 0x00, 0x03, 0x86,
  0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x0C, 0x18,
  0x06, 0x00, 0xC1, 0x80, 0x18, 0x06, 0x18, 0x00, 0xC0, 0x30, 0xC0, 0x03,
  0x03, 0x0C, 0x00, 0x18, 0x18, 0x60, 0x00, 0xC1, 0x86, 0x00, 0x03, 0x0C,
  0x30, 0x00, 0x18, 0xC1, 0x80, 0x00, 0x66, 0x0C, 0x00, 0x03, 0x60, 0xC0,
  0x00, 0x1B, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x1B, 0x01, 0x80, 0x01, 0x8C,
  0x0E, 0x00, 0x18, 0x60, 0x38, 0x03, 0x83, 0x00, 0xF0, 0x78, 0x0C, 0x03,
  0xFF, 0x80, 0x60, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x61, 0x86, 0x18, 0x43,
  0x0C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x08, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x80, 0x0E, 0x04, 0x00, 0x18, 0x20, 0x00, 0x33, 0x00, 0x80, 0xF0,
  0xFE, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x0C, 0xC0, 0x01,
  0xC2, 0x00, 0x18, 0x18, 0x01, 0x80, 0x40, 0x38, 0x03, 0x00, 0x80, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x27, 0x7F, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x84, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x07, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x76, 0x03, 0x98, 0x1C, 0x60,
  0xC3, 0x0E, 0x0C, 0x70, 0x33, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x3E, 0x00, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x02, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x03, 0xF8, 0x00, 0x61,
  0xFF, 0xC0, 0x0C, 0xF0, 0x1C, 0x01, 0x38, 0x01, 0xC0, 0x6E, 0x00, 0x18,
  0x0D, 0x80, 0x01, 0x81, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x41, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xD0, 0x18, 0x00, 0x36, 0x03, 0x80, 0x0E, 0xC0, 0x38, 0x07, 0x18,
  0x03, 0xFF, 0xC2, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x0F, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0x3E, 0x01, 0x80,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x07, 0xF8, 0x03, 0x06, 0x00, 0x1F, 0xFC, 0x03, 0x06, 0x00, 0x38, 0x18,
  0x03, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x0C,
  0x01, 0x80, 0x18, 0x02, 0x18, 0x01, 0x80, 0x30, 0x06, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x18, 0x07, 0x00, 0x30, 0x06, 0x30, 0x06, 0x00, 0x30, 0x06,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x30, 0x0C,
  0x00, 0x60, 0x0C, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x60, 0x18, 0x00, 0xC0,
  0x0C, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x60,
  0x18, 0x01, 0xC0, 0x18, 0x60, 0x18, 0x01, 0x80, 0x18, 0x60, 0x18, 0x01,
  0x80, 0x30, 0x40, 0x10, 0x03, 0x80, 0x30, 0xC0, 0x10, 0x03, 0x80, 0x60,
  0xC0, 0x18, 0x07, 0x80, 0x60, 0xC0, 0x18, 0x0D, 0x80, 0xC0, 0xC0, 0x18,
  0x0C, 0x81, 0x80, 0xC0, 0x1C, 0x18, 0xC3, 0x00, 0xC0, 0x0F, 0xF0, 0xFE,
  0x00, 0x40, 0x07, 0xC0, 0x7C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x01, 0xF0, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x38, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0x60, 0x01, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x30, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xE0,
  0x10, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x01, 0xE0, 0x00,
  0x60, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x83, 0x00, 0x00, 0xFF, 0xE0, 0xC0,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0x03, 0x36, 0x00, 0x00, 0x01, 0x33, 0x00,
  0x00, 0x01, 0xB0, 0xC0, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x20, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x60, 0x02, 0xC0,
  0x00, 0x00, 0x0D, 0x80, 0x19, 0x00, 0x00, 0x00, 0x64, 0x00, 0x64, 0x00,
  0x00, 0x01, 0xB0, 0x01, 0x90, 0x00, 0x00, 0x0C, 0xC0, 0x06, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x11, 0x80, 0x00, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x60, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x40, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x60, 0x80, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x00, 0x60, 0xC0,
  0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x08,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x30, 0x03, 0x00, 0x40,
  0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x18,
  0x01, 0x00, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x83, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x31, 0x80, 0x06, 0x00,
  0x20, 0x00, 0xCC, 0x00, 0x18, 0x01, 0x80, 0x03, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x0D, 0x80, 0x03, 0x00, 0x18, 0x00, 0x36, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x00, 0x60,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x18, 0x00, 0x98, 0x00,
  0x00, 0xC0, 0x0C, 0xC0, 0x00, 0x0C, 0x00, 0x66, 0x00, 0x00, 0x60, 0x03,
  0x30, 0x00, 0x03, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x00, 0x86, 0x00, 0x00,
  0x80, 0x0C, 0x30, 0x00, 0x0C, 0x00, 0x61, 0x80, 0x00, 0x60, 0x03, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x30, 0x00, 0x18, 0x01, 0x81, 0x80, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0x03, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x20, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x10, 0x01, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x60, 0x03, 0x00, 0x03, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x30, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x60, 0x00, 0x18, 0x60, 0x02, 0x00, 0x00, 0xC3, 0x00, 0x30, 0x00,
  0x06, 0x30, 0x01, 0x80, 0x00, 0x19, 0x80, 0x0C, 0x00, 0x00, 0xCC, 0x00,
  0x60, 0x00, 0x06, 0x60, 0x02, 0x00, 0x00, 0x32, 0x00, 0x30, 0x00, 0x00,
  0xF0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x60,
  0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0C, 0x01, 0xE0, 0x00,
  0x60, 0x03, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x10, 0x00, 0x70, 0x01, 0x80,
  0x0F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0C, 0x01, 0xE0,
  0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x10, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x18,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x05,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x04, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x08, 0x00,
  0x60, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x40, 0x60, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x10, 0x30, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00,
  0x04, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x20, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0x06, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x43,
  0x00, 0x00, 0xC6, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60, 0x00, 0x11, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x26, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x20, 0x00, 0x03,
  0xC0, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC8, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x10, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x06, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0,
  0x0C, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC1, 0x81,
  0x83, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFC, 0x30, 0x07, 0x01, 0x8C, 0x03, 0x00, 0x33, 0x01, 0x80, 0x0C, 0x80,
  0xC0, 0x01, 0xA0, 0x60, 0x00, 0x78, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x08, 0x00, 0x03, 0x82, 0x00,
  0x00, 0xE0, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0F, 0x03,
  0x00, 0x03, 0xC0, 0xC0, 0x01, 0xA0, 0x38, 0x00, 0xC8, 0x06, 0x00, 0x66,
  0x01, 0xC0, 0x39, 0x80, 0x3C, 0x3C, 0x60, 0x07, 0xFC, 0x10, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xFC, 0x00,
  0x18, 0x7F, 0xE0, 0x06, 0x38, 0x0E, 0x00, 0xCE, 0x00, 0xC0, 0x1B, 0x80,
  0x0C, 0x03, 0x60, 0x01, 0x80, 0x58, 0x00, 0x18, 0x1E, 0x00, 0x03, 0x03,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x18, 0x0D,
  0x80, 0x06, 0x01, 0x30, 0x01, 0xC0, 0x23, 0x00, 0x70, 0x0C, 0x78, 0x3C,
  0x01, 0x83, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xF0, 0x07, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x06, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x60,
  0x00, 0xFF, 0xE1, 0x00, 0x07, 0x01, 0xCC, 0x00, 0x30, 0x03, 0x30, 0x01,
  0x80, 0x06, 0xC0, 0x0C, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x28, 0x01, 0x80,
  0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x38, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03,
  0x80, 0x20, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x78, 0x03, 0x00, 0x01, 0xE0,
  0x0C, 0x00, 0x0D, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xB0, 0x03,
  0x00, 0x0E, 0xC0, 0x06, 0x00, 0x72, 0x00, 0x1C, 0x03, 0x88, 0x00, 0x3C,
  0x3C, 0x60, 0x00, 0x7F, 0xC1, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0x03, 0x80, 0x30, 0x07, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C,
  0x70, 0x00, 0x31, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x70, 0x60, 0x07, 0x81, 0x80, 0x78,
  0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x60, 0x1E, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x1F, 0xFC, 0x20,
  0x00, 0xE0, 0x38, 0x80, 0x06, 0x00, 0x66, 0x00, 0x30, 0x00, 0xD8, 0x01,
  0x80, 0x03, 0x60, 0x0C, 0x00, 0x05, 0x00, 0x30, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x70, 0x04, 0x00, 0x01,
  0xC0, 0x10, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xE0,
  0x06, 0x00, 0x07, 0x80, 0x18, 0x00, 0x36, 0x00, 0x60, 0x01, 0xD8, 0x00,
  0xC0, 0x0E, 0x40, 0x03, 0x80, 0x73, 0x00, 0x07, 0x87, 0x8C, 0x00, 0x0F,
  0xF8, 0x30, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC1, 0xFC, 0x00, 0x31, 0xFF, 0xC0, 0x08, 0xE0, 0x38, 0x06, 0x60, 0x06,
  0x01, 0xB0, 0x00, 0xC0, 0x78, 0x00, 0x30, 0x16, 0x00, 0x0C, 0x0F, 0x00,
  0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C,
  0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x04, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x04, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x02,
  0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x10, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x38,
  0x00, 0x03, 0x1E, 0x00, 0x00, 0xCC, 0xC0, 0x00, 0x36, 0x30, 0x00, 0x0B,
  0x8C, 0x00, 0x06, 0xC3, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x18, 0x01, 0x80,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x43, 0xFF, 0x03, 0xFF,
  0x00, 0x63, 0x01, 0x83, 0x01, 0xC0, 0x33, 0x00, 0x63, 0x00, 0x70, 0x1B,
  0x00, 0x33, 0x00, 0x18, 0x0B, 0x00, 0x0B, 0x00, 0x0C, 0x05, 0x00, 0x05,
  0x00, 0x06, 0x07, 0x80, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x81, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x70, 0x00, 0x30, 0x00, 0x10, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x21, 0xFF, 0xC0,
  0x18, 0xE0, 0x38, 0x06, 0x60, 0x06, 0x01, 0xB0, 0x01, 0xC0, 0x58, 0x00,
  0x30, 0x14, 0x00, 0x0C, 0x0F, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x04, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0,
  0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30, 0x07, 0x00, 0x1C, 0x1E, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x41,
  0xFF, 0x80, 0x01, 0x1C, 0x07, 0x00, 0x0C, 0xE0, 0x0C, 0x00, 0x37, 0x00,
  0x18, 0x00, 0xD8, 0x00, 0x60, 0x02, 0xC0, 0x00, 0xC0, 0x1B, 0x00, 0x03,
  0x00, 0x78, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x18, 0x03, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x03, 0x00, 0x34, 0x00,
  0x18, 0x00, 0xD8, 0x00, 0xE0, 0x02, 0x30, 0x07, 0x00, 0x18, 0xF0, 0x70,
  0x00, 0x61, 0xFF, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x07, 0xFF, 0x08,
  0x01, 0xC0, 0x71, 0x00, 0x60, 0x06, 0x60, 0x18, 0x00, 0x6C, 0x06, 0x00,
  0x0D, 0x81, 0x80, 0x00, 0xA0, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0xE0,
  0x40, 0x00, 0x1C, 0x08, 0x00, 0x07, 0x81, 0x80, 0x00, 0xF0, 0x30, 0x00,
  0x3C, 0x06, 0x00, 0x07, 0x80, 0xC0, 0x01, 0xB0, 0x18, 0x00, 0x76, 0x01,
  0x80, 0x1C, 0xC0, 0x38, 0x07, 0x30, 0x03, 0xC3, 0xC6, 0x00, 0x3F, 0xE0,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x04, 0x3F, 0xC0, 0x63, 0x80, 0x03, 0x30, 0x00, 0x1B, 0x00,
  0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x02, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0xF8, 0x0E, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0xFF, 0xF8, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x10, 0x1F, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x01,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xC0, 0x40, 0x00, 0x70, 0x10, 0x00, 0x1C, 0x0C, 0x00, 0x0F, 0x03, 0x00,
  0x06, 0x80, 0x60, 0x01, 0xA0, 0x18, 0x00, 0xD8, 0x07, 0x00, 0xE6, 0x00,
  0xE0, 0xF1, 0x80, 0x1F, 0xF0, 0x40, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x40, 0x06, 0x01, 0x00, 0x18,
  0x04, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x06,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0B,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x06, 0xC0, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x0A, 0x00, 0x0C, 0xC0, 0x01,
  0xA0, 0x00, 0xCC, 0x00, 0x1A, 0x00, 0x18, 0xC0, 0x03, 0x20, 0x01, 0x8C,
  0x00, 0x32, 0x00, 0x30, 0xC0, 0x06, 0x20, 0x03, 0x0C, 0x00, 0x62, 0x00,
  0x20, 0xC0, 0x04, 0x20, 0x06, 0x0C, 0x00, 0xC2, 0x00, 0x60, 0xC0, 0x0C,
  0x20, 0x0C, 0x0C, 0x01, 0x82, 0x00, 0xC0, 0xC0, 0x18, 0x20, 0x08, 0x0C,
  0x03, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x20, 0x18, 0x04, 0x06, 0x02, 0x03,
  0x00, 0x40, 0x60, 0x20, 0x30, 0x04, 0x04, 0x03, 0x06, 0x00, 0x40, 0xC0,
  0x30, 0x60, 0x04, 0x0C, 0x03, 0x04, 0x00, 0x41, 0x80, 0x30, 0xC0, 0x04,
  0x18, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x31, 0x80, 0x04, 0x30, 0x03, 0x18,
  0x00, 0x46, 0x00, 0x31, 0x00, 0x04, 0x60, 0x03, 0x30, 0x00, 0x44, 0x00,
  0x33, 0x00, 0x04, 0xC0, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x36, 0x00, 0x05,
  0x80, 0x03, 0x40, 0x00, 0x58, 0x00, 0x3C, 0x00, 0x05, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x70, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x05, 0xC0, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0xE8, 0x00, 0x1F,
  0xF9, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 51, 14, 1, -51 },
  { 91, 14, 19, 19, 7, -51 },
  { 125, 31, 51, 31, 1, -51 },
  { 323, 28, 58, 29, 1, -54 },
  { 526, 35, 52, 42, 4, -51 },
  { 754, 29, 52, 31, 0, -51 },
  { 943, 6, 19, 11, 7, -51 },
  { 958, 19, 61, 17, 2, -50 },
  { 1103, 20, 61, 17, -5, -50 },
  { 1256, 21, 22, 27, 9, -54 },
  { 1314, 27, 32, 32, 3, -41 },
  { 1422, 9, 16, 12, -3, -7 },
  { 1440, 16, 2, 20, 2, -20 },
  { 1444, 4, 5, 12, 1, -5 },
  { 1447, 29, 51, 21, -3, -51 },
  { 1632, 26, 52, 29, 2, -51 },
  { 1801, 14, 51, 29, 9, -51 },
  { 1891, 30, 51, 29, -2, -51 },
  { 2083, 29, 52, 29, -1, -51 },
  { 2272, 29, 51, 29, -1, -51 },
  { 2457, 30, 52, 29, -1, -51 },
  { 2652, 27, 52, 29, 3, -51 },
  { 2828, 27, 51, 29, 4, -51 },
  { 3001, 29, 52, 29, 0, -51 },
  { 3190, 27, 52, 29, 1, -51 },
  { 3366, 10, 38, 12, 1, -38 },
  { 3414, 15, 47, 12, -3, -38 },
  { 3503, 27, 30, 32, 3, -40 },
  { 3605, 27, 16, 32, 3, -33 },
  { 3659, 27, 30, 32, 3, -40 },
  { 3761, 21, 51, 21, 2, -51 },
  { 3895, 40, 57, 43, 2, -51 },
  { 4180, 27, 51, 28, -4, -51 },
  { 4353, 30, 51, 31, 1, -51 },
  { 4545, 30, 52, 29, 4, -51 },
  { 4740, 32, 51, 35, 1, -51 },
  { 4944, 30, 51, 28, 1, -51 },
  { 5136, 30, 51, 26, 1, -51 },
  { 5328, 34, 52, 37, 4, -51 },
  { 5549, 36, 51, 36, 1, -51 },
  { 5779, 21, 51, 14, -3, -51 },
  { 5913, 25, 63, 13, -11, -51 },
  { 6110, 33, 51, 29, 1, -51 },
  { 6321, 19, 51, 25, 1, -51 },
  { 6443, 46, 51, 46, 1, -51 },
  { 6737, 37, 51, 37, 1, -51 },
  { 6973, 33, 52, 37, 3, -51 },
  { 7188, 29, 51, 29, 1, -51 },
  { 7373, 33, 63, 37, 3, -51 },
  { 7633, 29, 51, 30, 1, -51 },
  { 7818, 30, 52, 28, -1, -51 },
  { 8013, 25, 51, 25, 6, -51 },
  { 8173, 34, 52, 36, 3, -51 },
  { 8394, 28, 51, 28, 6, -51 },
  { 8573, 45, 51, 47, 7, -51 },
  { 8860, 35, 51, 25, -4, -51 },
  { 9084, 25, 51, 25, 6, -51 },
  { 9244, 32, 51, 27, -2, -51 },
  { 9448, 26, 62, 20, -1, -51 },
  { 9650, 10, 51, 22, 7, -51 },
  { 9714, 26, 62, 20, -5, -51 },
  { 9916, 28, 27, 31, 2, -51 },
  { 10011, 21, 2, 21, -6, 7 },
  { 10017, 7, 11, 15, 10, -54 },
  { 10027, 26, 39, 30, 3, -38 },
  { 10154, 27, 55, 31, 1, -54 },
  { 10340, 22, 39, 23, 3, -38 },
  { 10448, 30, 55, 31, 3, -54 },
  { 10655, 22, 39, 27, 3, -38 },
  { 10763, 33, 71, 15, -9, -54 },
  { 11056, 30, 55, 31, 0, -38 },
  { 11263, 26, 54, 30, 1, -54 },
  { 11439, 13, 51, 12, 1, -51 },
  { 11522, 24, 68, 12, -10, -51 },
  { 11726, 26, 54, 24, 1, -54 },
  { 11902, 13, 54, 12, 1, -54 },
  { 11990, 41, 38, 45, 1, -38 },
  { 12185, 26, 38, 30, 1, -38 },
  { 12309, 24, 39, 30, 3, -38 },
  { 12426, 30, 54, 31, -2, -38 },
  { 12629, 27, 55, 31, 3, -38 },
  { 12815, 21, 38, 19, 1, -38 },
  { 12915, 24, 39, 23, -1, -38 },
  { 13032, 15, 48, 16, 2, -47 },
  { 13122, 26, 38, 30, 2, -37 },
  { 13246, 22, 37, 22, 4, -37 },
  { 13348, 36, 37, 37, 4, -37 },
  { 13515, 29, 37, 24, -3, -37 },
  { 13650, 35, 54, 23, -8, -37 },
  { 13887, 24, 37, 21, -2, -37 },
  { 13998, 25, 62, 22, 2, -51 },
  { 14192, 2, 71, 28, 14, -54 },
  { 14210, 24, 62, 22, -4, -51 },
  { 14396, 27, 6, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_ThinItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_THINITALIC71PT7B_H_
