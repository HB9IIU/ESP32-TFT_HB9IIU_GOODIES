#ifndef _NOTOSANS_CONDENSED_THINITALIC6PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0x80, 0x7F, 0x40, 0x79, 0xC0, 0xFD, 0xF0, 0xDF, 0x80, 0x6A,
  0x80, 0xF8, 0xB0, 0x5D, 0x00, 0xC0, 0x80, 0x00, 0x5A, 0xFF, 0xF0, 0x57,
  0x57, 0x7D, 0xE7, 0xFA, 0xE0, 0x69, 0x40, 0xDF, 0xF7, 0x00, 0x30, 0xEC,
  0xFC, 0xF8, 0x58, 0x7E, 0xAC, 0x40, 0x7F, 0xFE, 0xE0, 0xF2, 0x60, 0xF6,
  0xE0, 0xFA, 0x60, 0xFA, 0x40, 0xF2, 0xF0, 0xBE, 0xD0, 0xEA, 0x55, 0xC0,
  0xBB, 0x60, 0xAB, 0x99, 0xAD, 0xAE, 0xD0, 0xF6, 0xF0, 0xF7, 0x40, 0xF6,
  0xD4, 0xF7, 0x60, 0xE7, 0xEA, 0xB6, 0xF0, 0xEA, 0xFF, 0x60, 0xAA, 0x60,
  0xEA, 0x6A, 0x60, 0xEA, 0x80, 0xF0, 0x56, 0x80, 0x54, 0x80, 0x80, 0xFC,
  0x6F, 0xC0, 0xEC, 0x2E, 0xDC, 0xEC, 0x29, 0x25, 0x80, 0xF7, 0x60, 0x6F,
  0xC0, 0x70, 0x15, 0xC0, 0x6E, 0xC0, 0xF8, 0xFD, 0xD0, 0xFC, 0xFC, 0xFE,
  0xF7, 0x20, 0xE8, 0xDC, 0xF0, 0xFC, 0xE8, 0xFF, 0x00, 0xEC, 0x69, 0x60,
  0x68, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_ThinItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 2, 0, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 2, 4, 3, 0, -4 },
  { 10, 1, 1, 1, 0, -4 },
  { 11, 2, 5, 1, 0, -4 },
  { 13, 1, 5, 1, 0, -4 },
  { 14, 2, 2, 2, 1, -5 },
  { 15, 3, 3, 3, 0, -4 },
  { 17, 1, 2, 1, 0, -1 },
  { 18, 1, 1, 2, 0, -2 },
  { 19, 1, 1, 1, 0, -1 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 1, 4, 2, 1, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 2, 4, 2, 0, -4 },
  { 27, 3, 4, 2, 0, -4 },
  { 29, 3, 4, 2, 0, -4 },
  { 31, 2, 4, 2, 0, -4 },
  { 32, 2, 4, 2, 0, -4 },
  { 33, 1, 3, 1, 0, -3 },
  { 34, 1, 4, 1, 0, -3 },
  { 35, 3, 2, 3, 0, -3 },
  { 36, 3, 2, 3, 0, -3 },
  { 37, 3, 2, 3, 0, -3 },
  { 38, 2, 4, 2, 0, -4 },
  { 39, 4, 5, 4, 0, -4 },
  { 42, 2, 4, 2, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 3, 4, 2, 0, -4 },
  { 47, 3, 4, 3, 0, -4 },
  { 49, 3, 4, 2, 0, -4 },
  { 51, 3, 4, 2, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 2, 4, 1, 0, -4 },
  { 58, 2, 5, 1, -1, -4 },
  { 60, 3, 4, 2, 0, -4 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 3, 4, 2, 0, -4 },
  { 71, 3, 5, 3, 0, -4 },
  { 73, 3, 4, 3, 0, -4 },
  { 75, 2, 4, 2, 0, -4 },
  { 76, 2, 4, 2, 1, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 2, 4, 2, 1, -4 },
  { 80, 3, 4, 4, 1, -4 },
  { 82, 3, 4, 2, 0, -4 },
  { 84, 2, 4, 2, 1, -4 },
  { 85, 3, 4, 2, 0, -4 },
  { 87, 2, 5, 2, 0, -4 },
  { 89, 1, 4, 2, 1, -4 },
  { 90, 2, 5, 2, 0, -4 },
  { 92, 3, 2, 3, 0, -4 },
  { 93, 1, 1, 2, 0, 0 },
  { 94, 1, 1, 1, 1, -5 },
  { 95, 2, 3, 3, 0, -3 },
  { 96, 2, 5, 3, 0, -5 },
  { 98, 2, 3, 2, 0, -3 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 2, 3, 2, 0, -3 },
  { 102, 3, 6, 1, -1, -5 },
  { 105, 3, 4, 3, 0, -3 },
  { 107, 2, 5, 3, 0, -5 },
  { 109, 1, 4, 1, 0, -4 },
  { 110, 2, 5, 1, -1, -4 },
  { 112, 2, 5, 2, 0, -5 },
  { 114, 1, 5, 1, 0, -5 },
  { 115, 4, 3, 4, 0, -3 },
  { 117, 2, 3, 3, 0, -3 },
  { 118, 2, 3, 3, 0, -3 },
  { 119, 2, 4, 3, 0, -3 },
  { 120, 3, 4, 3, 0, -3 },
  { 122, 2, 3, 2, 0, -3 },
  { 123, 2, 3, 2, 0, -3 },
  { 124, 1, 4, 1, 0, -4 },
  { 125, 2, 3, 3, 0, -3 },
  { 126, 2, 3, 2, 0, -3 },
  { 127, 3, 3, 3, 0, -3 },
  { 129, 2, 3, 2, 0, -3 },
  { 130, 3, 4, 2, -1, -3 },
  { 132, 2, 3, 2, 0, -3 },
  { 133, 2, 5, 2, 0, -4 },
  { 135, 1, 6, 2, 1, -5 },
  { 136, 2, 5, 2, 0, -4 },
  { 138, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_ThinItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_THINITALIC6PT7B_H_
