#ifndef _NOTOSANS_CONDENSED_THINITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x10, 0xCC, 0x22,
  0x08, 0x86, 0x21, 0x08, 0x44, 0x11, 0x04, 0x41, 0x10, 0x8C, 0x20, 0x00,
  0x20, 0x40, 0x04, 0x08, 0x01, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x03, 0xFF, 0xFC, 0x7F,
  0xFF, 0x80, 0x81, 0x00, 0x30, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30,
  0x20, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x04, 0x0C, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x06, 0x0C, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x0C,
  0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x81, 0x00, 0x10, 0x20,
  0x06, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0xFF, 0x80, 0x62, 0x10, 0x20, 0x80, 0x10, 0x40, 0x04, 0x10, 0x03,
  0x04, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0x62,
  0x00, 0x0C, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40,
  0x00, 0x48, 0x00, 0x21, 0x00, 0x08, 0x60, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x60, 0x80, 0x10, 0x20, 0x04, 0x10, 0x01, 0x04, 0x00, 0x42, 0x0C, 0x33,
  0x00, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x41, 0x84, 0x02, 0x04,
  0x10, 0x08, 0x20, 0x40, 0x40, 0x81, 0x01, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x60, 0x40, 0x41, 0x03, 0x01, 0x0C, 0x08, 0x0C, 0x20, 0x20, 0x21, 0x00,
  0x80, 0x84, 0x02, 0x02, 0x20, 0x88, 0x19, 0x8F, 0xA0, 0x44, 0x42, 0x83,
  0x32, 0x0E, 0x08, 0x98, 0x38, 0x64, 0x40, 0xDF, 0x11, 0x03, 0x20, 0x8C,
  0x0C, 0x06, 0x20, 0x20, 0x10, 0x80, 0x80, 0xC2, 0x02, 0x02, 0x18, 0x08,
  0x10, 0x40, 0x60, 0x41, 0x01, 0x02, 0x04, 0x04, 0x18, 0x10, 0x30, 0x40,
  0x40, 0x83, 0x01, 0x86, 0x08, 0x02, 0x10, 0x60, 0x0F, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x0C, 0x30, 0x06, 0x04, 0x01, 0x01,
  0x00, 0x40, 0x40, 0x10, 0x10, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC0, 0x80,
  0x30, 0x40, 0x04, 0x30, 0x01, 0x18, 0x00, 0x4C, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x01, 0x90, 0x00, 0xC4, 0x00, 0x60, 0x81, 0x10, 0x20,
  0x48, 0x0C, 0x26, 0x01, 0x09, 0x00, 0x46, 0x40, 0x09, 0x30, 0x02, 0xCC,
  0x00, 0xE2, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x07, 0x84, 0x03, 0x21, 0x81,
  0x88, 0x3F, 0xC1, 0x00, 0x13, 0x22, 0x22, 0x44, 0x44, 0xC0, 0x00, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x10, 0x10, 0x40, 0xE1, 0x00, 0x64, 0x00,
  0x6F, 0xC0, 0xC0, 0x05, 0x00, 0x24, 0x03, 0x08, 0x18, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F,
  0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x21, 0x84,
  0x10, 0x82, 0x10, 0x42, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0x00, 0x60, 0xC0, 0x60, 0x20, 0x20, 0x10, 0x30,
  0x0C, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x62,
  0x00, 0x33, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x60, 0x01,
  0x30, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x18, 0x80, 0x08, 0xC0, 0x04, 0x60, 0x04, 0x10, 0x02, 0x08, 0x03, 0x04,
  0x01, 0x02, 0x01, 0x01, 0x81, 0x80, 0x41, 0x80, 0x1F, 0x80, 0x00, 0x03,
  0x07, 0x09, 0x33, 0x62, 0x82, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x08, 0x00, 0x1F, 0xE0,
  0x06, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x30, 0x18, 0x10, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xE0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x02,
  0x01, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x02, 0x60, 0x01, 0x90, 0x00,
  0x44, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04, 0x20, 0x02, 0x08, 0x01, 0x02,
  0x00, 0xC0, 0x80, 0x20, 0x60, 0x10, 0x10, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x40, 0xC0, 0x30, 0x20, 0x08, 0x10, 0x02, 0x0C, 0x00, 0x83, 0xFF,
  0xFE, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xC0, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x07, 0xF8, 0x00, 0x81, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x08, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xC0,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x0C,
  0x01, 0x1F, 0xC0, 0xB0, 0x30, 0x70, 0x0C, 0x70, 0x02, 0x30, 0x01, 0x18,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C,
  0x40, 0x04, 0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x04, 0x01, 0x81, 0x01,
  0x80, 0xC1, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x18, 0x18, 0x0C, 0x03, 0x02,
  0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x08, 0x18, 0x06, 0x02, 0x03, 0x00, 0x41, 0x80, 0x18, 0xC0,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0xC1, 0x80, 0x60, 0x30, 0x30,
  0x04, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x10, 0x01, 0x06, 0x00, 0xC0,
  0xC0, 0x60, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x18, 0x10,
  0x0C, 0x06, 0x06, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x0C, 0x20, 0x03, 0x08,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x18, 0x40, 0x06, 0x18, 0x03, 0x82, 0x01, 0xE0, 0xC0, 0xD0,
  0x1F, 0xE4, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x18, 0x60, 0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x7F, 0xC0, 0x81,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x0F, 0xC1, 0x30,
  0x18, 0x41, 0x20, 0x20, 0xC1, 0x20, 0x40, 0x81, 0x60, 0xC0, 0x81, 0x40,
  0x80, 0x81, 0x41, 0x81, 0x81, 0xC1, 0x01, 0x03, 0x81, 0x01, 0x02, 0x83,
  0x01, 0x02, 0x82, 0x03, 0x02, 0x82, 0x02, 0x06, 0x82, 0x02, 0x04, 0x82,
  0x06, 0x0C, 0x82, 0x06, 0x08, 0x83, 0x0A, 0x18, 0x81, 0x13, 0x30, 0x80,
  0xE1, 0xC0, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x16, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x0C, 0x08, 0x02, 0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x3F, 0xF8,
  0x08, 0x02, 0x06, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x20, 0x02, 0x08,
  0x00, 0x84, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0x58, 0x00,
  0x14, 0x00, 0x07, 0x00, 0x01, 0x03, 0xFE, 0x00, 0x40, 0x30, 0x08, 0x03,
  0x01, 0x00, 0x20, 0x20, 0x06, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03,
  0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80, 0x10,
  0x10, 0x06, 0x06, 0x1F, 0x00, 0xFF, 0xC0, 0x10, 0x0C, 0x02, 0x00, 0x40,
  0x40, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x03, 0x04,
  0x00, 0xC1, 0x80, 0x30, 0x20, 0x1C, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x03, 0xFF, 0x00, 0x60, 0x20, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x20,
  0x38, 0x02, 0x00, 0xC0, 0x20, 0x04, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04,
  0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x02,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x63, 0x00, 0x04, 0x20, 0x00,
  0x42, 0x00, 0x0C, 0x20, 0x00, 0x82, 0x00, 0x18, 0x60, 0x01, 0x04, 0x00,
  0x30, 0x40, 0x06, 0x04, 0x00, 0x40, 0xC0, 0x18, 0x08, 0x03, 0x00, 0x81,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x20, 0x7F, 0xF0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFC, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xC0, 0x06, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0x8C, 0x00, 0x02,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x60, 0x00, 0x80, 0x80, 0x06, 0x03, 0x00, 0x10, 0x07, 0x00, 0xC0,
  0x07, 0xFE, 0x00, 0x03, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40,
  0x80, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00,
  0x02, 0x04, 0x00, 0x18, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x02, 0x00, 0x04,
  0x08, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x80, 0x02, 0x07, 0xFF, 0xF8, 0x10,
  0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x20, 0x00,
  0x40, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81,
  0x00, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x02, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0xCC, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x18, 0x10, 0x01, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x18,
  0x03, 0x01, 0x80, 0x10, 0x18, 0x00, 0x81, 0x80, 0x04, 0x08, 0x00, 0x60,
  0x80, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x8C, 0x00, 0x04, 0xC0, 0x00,
  0x6E, 0x00, 0x02, 0x50, 0x00, 0x14, 0xC0, 0x00, 0xC2, 0x00, 0x04, 0x10,
  0x00, 0x60, 0x80, 0x02, 0x06, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04,
  0x06, 0x00, 0x60, 0x10, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x0C, 0x00, 0x80, 0x40, 0x06, 0x02, 0x00, 0x30, 0x10, 0x00, 0x80, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x1F, 0xFE, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xA0, 0x28, 0x00, 0x0D, 0x03, 0x40, 0x00, 0x58, 0x12, 0x00, 0x06,
  0x80, 0x90, 0x00, 0x24, 0x04, 0x80, 0x03, 0x20, 0x64, 0x00, 0x11, 0x03,
  0x20, 0x01, 0x90, 0x11, 0x00, 0x08, 0x80, 0x88, 0x00, 0xC4, 0x04, 0x60,
  0x04, 0x20, 0x63, 0x00, 0x63, 0x02, 0x08, 0x02, 0x10, 0x10, 0x40, 0x30,
  0x80, 0x82, 0x01, 0x04, 0x04, 0x10, 0x18, 0x20, 0x60, 0x80, 0x83, 0x02,
  0x04, 0x0C, 0x10, 0x10, 0x20, 0x40, 0x80, 0x81, 0x04, 0x04, 0x04, 0x08,
  0x20, 0x20, 0x60, 0x42, 0x03, 0x02, 0x03, 0x10, 0x10, 0x10, 0x09, 0x00,
  0x80, 0x80, 0x48, 0x04, 0x0C, 0x02, 0x80, 0x60, 0x40, 0x14, 0x02, 0x02,
  0x00, 0xC0, 0x10, 0x10, 0x06, 0x00, 0x80, 0x03, 0x00, 0x02, 0x06, 0x00,
  0x0C, 0x0E, 0x00, 0x10, 0x14, 0x00, 0x20, 0x28, 0x00, 0x40, 0xD0, 0x00,
  0x81, 0x30, 0x03, 0x02, 0x20, 0x04, 0x04, 0x40, 0x08, 0x18, 0x80, 0x10,
  0x21, 0x80, 0x60, 0x41, 0x00, 0xC0, 0x82, 0x01, 0x01, 0x04, 0x02, 0x06,
  0x0C, 0x04, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x60, 0x81, 0x80, 0x41, 0x02, 0x00, 0x86, 0x04, 0x01, 0x08, 0x08, 0x03,
  0x10, 0x10, 0x02, 0x20, 0x60, 0x04, 0x40, 0x80, 0x09, 0x81, 0x00, 0x1A,
  0x02, 0x00, 0x14, 0x0C, 0x00, 0x28, 0x10, 0x00, 0x70, 0x20, 0x00, 0x40,
  0x40, 0x00, 0x80, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x30, 0x10, 0x02,
  0x00, 0x40, 0x20, 0x03, 0x02, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x02,
  0x18, 0x00, 0x10, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x01, 0x90, 0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00,
  0x32, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0xC6, 0x00, 0x04, 0x30,
  0x00, 0x60, 0x80, 0x02, 0x04, 0x00, 0x30, 0x30, 0x03, 0x00, 0x80, 0x30,
  0x02, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x80, 0xC0, 0x20,
  0x18, 0x08, 0x02, 0x02, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01,
  0x04, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x0C, 0x20, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x41, 0x80, 0x30, 0x40, 0x18, 0x10, 0x1C, 0x07, 0xFC, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00,
  0x30, 0x10, 0x02, 0x00, 0x40, 0x20, 0x03, 0x02, 0x00, 0x08, 0x30, 0x00,
  0x41, 0x00, 0x02, 0x18, 0x00, 0x10, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x40,
  0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02,
  0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00,
  0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0xC6,
  0x00, 0x04, 0x30, 0x00, 0x60, 0x80, 0x02, 0x04, 0x00, 0x30, 0x30, 0x03,
  0x00, 0x80, 0x30, 0x02, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x80, 0xC0, 0x20,
  0x18, 0x08, 0x02, 0x02, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01,
  0x04, 0x00, 0x41, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x82,
  0x00, 0x41, 0x80, 0x20, 0x40, 0x30, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0x06,
  0x00, 0xC0, 0x80, 0x20, 0x20, 0x08, 0x08, 0x02, 0x03, 0x00, 0x80, 0x40,
  0x60, 0x10, 0x10, 0x04, 0x04, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x08, 0x20,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x30, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x03,
  0x00, 0x80, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x06, 0x01, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x30,
  0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x18, 0x00,
  0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x18,
  0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x06,
  0x18, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC3, 0x00,
  0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81,
  0x80, 0x0C, 0x04, 0x00, 0x40, 0x20, 0x04, 0x00, 0xC0, 0x40, 0x03, 0xFC,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02,
  0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x02, 0x04,
  0x01, 0x81, 0x00, 0x40, 0x40, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x40, 0x40, 0x10, 0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x10, 0xC0, 0x04, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xA0, 0x01, 0x80, 0x05,
  0x00, 0x0C, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x40, 0x05, 0x00, 0x32, 0x00,
  0x68, 0x01, 0x10, 0x02, 0x40, 0x08, 0x80, 0x12, 0x00, 0xC6, 0x01, 0x10,
  0x04, 0x30, 0x08, 0x80, 0x61, 0x80, 0xC4, 0x02, 0x0C, 0x04, 0x20, 0x10,
  0x60, 0x61, 0x01, 0x03, 0x02, 0x08, 0x08, 0x18, 0x10, 0x40, 0xC0, 0xC1,
  0x02, 0x04, 0x06, 0x08, 0x10, 0x60, 0x30, 0xC0, 0x82, 0x01, 0x84, 0x04,
  0x10, 0x0C, 0x20, 0x21, 0x00, 0x62, 0x01, 0x08, 0x03, 0x10, 0x08, 0xC0,
  0x19, 0x80, 0x44, 0x00, 0xC8, 0x02, 0x20, 0x06, 0xC0, 0x12, 0x00, 0x34,
  0x00, 0x90, 0x01, 0xA0, 0x05, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x70, 0x01,
  0x40, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x10, 0x04, 0x00, 0x40, 0x20, 0x01,
  0x80, 0x80, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x84,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x04,
  0x80, 0x00, 0x32, 0x00, 0x00, 0x8C, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40,
  0x00, 0x81, 0x00, 0x06, 0x04, 0x00, 0x10, 0x18, 0x00, 0x80, 0x20, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x08, 0x06, 0x00, 0x20, 0x30, 0x00,
  0x40, 0x80, 0x03, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x08, 0x40, 0x08, 0x40,
  0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x60, 0x60, 0x40, 0x20, 0x80, 0x21,
  0x80, 0x21, 0x00, 0x23, 0x00, 0x22, 0x00, 0x24, 0x00, 0x34, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x00,
  0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08,
  0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0xC3,
  0x00, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x05,
  0x00, 0x02, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0x40, 0x08, 0x10,
  0x04, 0x06, 0x01, 0x00, 0x80, 0x80, 0x30, 0x60, 0x04, 0x10, 0x01, 0x0C,
  0x00, 0x62, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0x40, 0xFF, 0xFC, 0x88,
  0x44, 0x21, 0x10, 0x01, 0xF1, 0x83, 0x04, 0x83, 0x01, 0x41, 0x00, 0xA1,
  0x00, 0x51, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x06, 0x20, 0x03,
  0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31, 0x00,
  0x10, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x06, 0x10, 0x06, 0x08, 0x07, 0x06,
  0x02, 0x81, 0x06, 0x40, 0x7E, 0x20, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x1F, 0x01, 0xB0, 0xC0, 0xB0, 0x10, 0x50, 0x08,
  0x30, 0x06, 0x18, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x33, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x30,
  0x01, 0x18, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x43, 0x00, 0x62, 0x80, 0x21,
  0x40, 0x20, 0x90, 0x20, 0x47, 0xE0, 0x00, 0x01, 0xFC, 0x1C, 0x10, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x04, 0x0F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x07, 0xC2, 0x03, 0x06, 0xC0, 0xC0, 0x50, 0x10, 0x0E, 0x04, 0x00,
  0xC1, 0x80, 0x18, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01,
  0x0C, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C,
  0x10, 0x01, 0x82, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x50,
  0x20, 0x1E, 0x06, 0x02, 0x80, 0x41, 0x90, 0x07, 0xE2, 0x00, 0x01, 0xF0,
  0x1C, 0x20, 0xC0, 0xC2, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0xD8, 0x02,
  0x40, 0x19, 0x00, 0xCC, 0x0C, 0x27, 0xE0, 0xF0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x01, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x20, 0x38, 0x64, 0x0C, 0x05, 0x01, 0x00,
  0xE0, 0x40, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x04, 0x10, 0x00,
  0x82, 0x00, 0x10, 0xC0, 0x06, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02,
  0x08, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0xC0, 0x80, 0x18,
  0x10, 0x05, 0x02, 0x01, 0xE0, 0x60, 0x68, 0x04, 0x19, 0x00, 0x7E, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x80, 0x60, 0x1C, 0x70, 0x00,
  0x78, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x7C, 0x0D, 0x86, 0x0B, 0x03, 0x0E, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18,
  0x01, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x30, 0x02, 0x30, 0x02, 0x20,
  0x06, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x03,
  0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x01,
  0x30, 0x03, 0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x03, 0x0C, 0x06, 0x08, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20,
  0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x11, 0x00, 0x33, 0x00, 0x25, 0x00,
  0x29, 0x00, 0x38, 0x80, 0x30, 0x80, 0x60, 0x80, 0x40, 0xC0, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x60, 0x80, 0x20, 0x80, 0x20, 0x80, 0x20,
  0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x04, 0xFC,
  0x1F, 0x02, 0x61, 0x18, 0x60, 0xA0, 0x2C, 0x0C, 0x30, 0x0A, 0x01, 0x0C,
  0x03, 0x00, 0x42, 0x00, 0xC0, 0x11, 0x80, 0x20, 0x0C, 0x60, 0x08, 0x02,
  0x10, 0x06, 0x00, 0x84, 0x01, 0x00, 0x23, 0x00, 0x40, 0x08, 0x80, 0x10,
  0x04, 0x20, 0x04, 0x01, 0x08, 0x03, 0x00, 0x42, 0x00, 0x80, 0x11, 0x80,
  0x20, 0x0C, 0x40, 0x08, 0x02, 0x10, 0x02, 0x00, 0x84, 0x01, 0x80, 0x21,
  0x00, 0x40, 0x08, 0xC0, 0x10, 0x06, 0x20, 0x04, 0x01, 0x08, 0x03, 0x00,
  0x42, 0x00, 0x80, 0x10, 0x04, 0x7C, 0x09, 0x86, 0x0B, 0x03, 0x0E, 0x01,
  0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02,
  0x30, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x18,
  0x80, 0x10, 0x80, 0x10, 0x01, 0xF0, 0x0C, 0x18, 0x30, 0x10, 0x40, 0x31,
  0x00, 0x26, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x40, 0x02, 0x80, 0x0D,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x03, 0x18, 0x0C, 0x18, 0x30, 0x1F,
  0xC0, 0x00, 0x8F, 0x80, 0x13, 0x0C, 0x01, 0x60, 0x20, 0x14, 0x02, 0x01,
  0x80, 0x30, 0x18, 0x01, 0x03, 0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x10,
  0x20, 0x01, 0x06, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02,
  0x04, 0x00, 0x20, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x0C, 0x00,
  0x80, 0xC0, 0x18, 0x1C, 0x01, 0x01, 0x40, 0x20, 0x12, 0x0C, 0x01, 0x3F,
  0x80, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xF0, 0x83, 0x06, 0x43, 0x01, 0x41, 0x00, 0xE1, 0x00,
  0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10,
  0x01, 0x98, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31, 0x00, 0x18,
  0x80, 0x08, 0x40, 0x0C, 0x20, 0x06, 0x10, 0x05, 0x08, 0x07, 0x86, 0x02,
  0x81, 0x06, 0x40, 0x7E, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x04, 0x78, 0x4C, 0x02, 0xC0, 0x14, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x03, 0xF8, 0x18, 0x30, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x08, 0x0C, 0x3F, 0xE0,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x03, 0xFC, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0xC0,
  0x1F, 0x00, 0x18, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x30, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x18, 0x80, 0x10,
  0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x80, 0x50, 0x80, 0xE0, 0xC1, 0xA0,
  0x7E, 0x20, 0xC0, 0x05, 0x00, 0x34, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00,
  0xC4, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x06, 0xC0, 0x1A,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40,
  0x48, 0x09, 0x03, 0x20, 0x64, 0x08, 0x81, 0x10, 0x22, 0x0C, 0x41, 0x08,
  0x21, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x82, 0x10, 0x46, 0x08, 0x81,
  0x10, 0x22, 0x04, 0x40, 0x98, 0x12, 0x02, 0x40, 0x48, 0x0B, 0x01, 0x60,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x02, 0x00, 0x40, 0x80, 0x20, 0x20, 0x18, 0x04, 0x04, 0x01,
  0x02, 0x00, 0x41, 0x80, 0x18, 0x40, 0x02, 0x20, 0x00, 0x98, 0x00, 0x24,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x12, 0x00,
  0x08, 0x80, 0x06, 0x20, 0x01, 0x04, 0x00, 0x81, 0x00, 0x60, 0x40, 0x10,
  0x18, 0x08, 0x02, 0x06, 0x00, 0x83, 0x00, 0x30, 0x00, 0x80, 0x04, 0x02,
  0x00, 0x20, 0x0C, 0x00, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x10, 0x01, 0x00,
  0xC0, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x02, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x33, 0xC0, 0x60, 0x38, 0xD0, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 32, 9, 1, -32 },
  { 33, 10, 11, 12, 4, -32 },
  { 47, 19, 32, 20, 1, -32 },
  { 123, 18, 37, 18, 0, -34 },
  { 207, 22, 34, 27, 3, -33 },
  { 301, 18, 33, 19, 0, -33 },
  { 376, 4, 11, 7, 4, -32 },
  { 382, 13, 39, 11, 1, -32 },
  { 446, 12, 39, 11, -3, -32 },
  { 505, 14, 14, 17, 5, -34 },
  { 530, 17, 20, 20, 2, -26 },
  { 573, 6, 10, 7, -2, -4 },
  { 581, 10, 1, 12, 1, -13 },
  { 583, 2, 3, 8, 1, -3 },
  { 584, 19, 32, 13, -2, -32 },
  { 660, 17, 33, 18, 1, -33 },
  { 731, 8, 32, 18, 6, -32 },
  { 763, 19, 33, 18, -1, -33 },
  { 842, 18, 34, 18, 0, -33 },
  { 919, 18, 32, 18, 0, -32 },
  { 991, 18, 32, 18, 0, -32 },
  { 1063, 17, 33, 18, 2, -33 },
  { 1134, 17, 32, 18, 3, -32 },
  { 1202, 18, 33, 18, 0, -33 },
  { 1277, 18, 33, 18, 0, -33 },
  { 1352, 7, 24, 8, 0, -24 },
  { 1373, 9, 30, 8, -2, -24 },
  { 1407, 17, 18, 20, 2, -25 },
  { 1446, 17, 10, 20, 2, -21 },
  { 1468, 17, 18, 20, 2, -25 },
  { 1507, 14, 33, 13, 1, -33 },
  { 1565, 24, 36, 27, 2, -32 },
  { 1673, 18, 32, 18, -3, -32 },
  { 1745, 19, 32, 20, 1, -32 },
  { 1821, 20, 33, 19, 2, -33 },
  { 1904, 20, 32, 22, 1, -32 },
  { 1984, 18, 32, 18, 1, -32 },
  { 2056, 19, 32, 16, 1, -32 },
  { 2132, 22, 33, 24, 2, -33 },
  { 2223, 22, 32, 23, 1, -32 },
  { 2311, 14, 32, 9, -2, -32 },
  { 2367, 16, 40, 8, -7, -32 },
  { 2447, 21, 32, 18, 1, -32 },
  { 2531, 12, 32, 16, 1, -32 },
  { 2579, 29, 32, 29, 1, -32 },
  { 2695, 23, 32, 24, 1, -32 },
  { 2787, 21, 33, 24, 2, -33 },
  { 2874, 18, 32, 19, 1, -32 },
  { 2946, 21, 41, 24, 2, -33 },
  { 3054, 18, 32, 19, 1, -32 },
  { 3126, 19, 33, 17, -1, -33 },
  { 3205, 15, 32, 16, 4, -32 },
  { 3265, 21, 32, 23, 2, -32 },
  { 3349, 18, 32, 18, 4, -32 },
  { 3421, 29, 32, 30, 4, -32 },
  { 3537, 22, 32, 16, -3, -32 },
  { 3625, 16, 32, 16, 4, -32 },
  { 3689, 20, 32, 17, -1, -32 },
  { 3769, 17, 39, 13, -1, -32 },
  { 3852, 6, 32, 14, 5, -32 },
  { 3876, 16, 39, 13, -3, -32 },
  { 3954, 18, 17, 20, 1, -32 },
  { 3993, 14, 1, 13, -4, 4 },
  { 3995, 4, 7, 10, 7, -34 },
  { 3999, 17, 24, 19, 2, -24 },
  { 4050, 17, 34, 19, 1, -34 },
  { 4123, 14, 24, 15, 2, -24 },
  { 4165, 19, 34, 20, 2, -34 },
  { 4246, 14, 24, 17, 2, -24 },
  { 4288, 21, 45, 9, -6, -34 },
  { 4407, 19, 35, 20, 0, -24 },
  { 4491, 16, 34, 19, 1, -34 },
  { 4559, 8, 32, 8, 1, -32 },
  { 4591, 15, 43, 8, -6, -32 },
  { 4672, 16, 34, 15, 1, -34 },
  { 4740, 8, 34, 7, 1, -34 },
  { 4774, 26, 24, 29, 1, -24 },
  { 4852, 16, 24, 19, 1, -24 },
  { 4900, 15, 24, 19, 2, -24 },
  { 4945, 20, 34, 19, -2, -24 },
  { 5030, 17, 34, 20, 2, -24 },
  { 5103, 13, 24, 12, 1, -24 },
  { 5142, 14, 24, 14, 0, -24 },
  { 5184, 10, 30, 10, 1, -30 },
  { 5222, 16, 24, 19, 2, -24 },
  { 5270, 14, 24, 14, 2, -24 },
  { 5312, 22, 24, 23, 3, -24 },
  { 5378, 18, 24, 15, -2, -24 },
  { 5432, 22, 35, 15, -5, -24 },
  { 5529, 15, 24, 13, -1, -24 },
  { 5574, 16, 39, 14, 1, -32 },
  { 5652, 1, 45, 18, 9, -34 },
  { 5658, 16, 39, 14, -3, -32 },
  { 5736, 17, 4, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_THINITALIC45PT7B_H_
