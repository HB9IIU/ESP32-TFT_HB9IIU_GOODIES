#ifndef _NOTOSANS_CONDENSED_THINITALIC63PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x18, 0xC0,
  0xC6, 0x04, 0x20, 0x61, 0x03, 0x18, 0x18, 0xC0, 0x84, 0x04, 0x20, 0x61,
  0x03, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20, 0x61, 0x03, 0x18, 0x10, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x20, 0x08, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xE1, 0x0F, 0x00, 0x60, 0xC0, 0x80, 0x30, 0x30, 0x00, 0x18, 0x08,
  0x00, 0x06, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x10, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x20, 0x20, 0x00, 0x18, 0x18, 0x08, 0x06, 0x1C, 0x03, 0xE1, 0x3C, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x1C, 0x70,
  0x00, 0xC0, 0x30, 0x60, 0x01, 0x00, 0xC0, 0x40, 0x06, 0x03, 0x00, 0x80,
  0x08, 0x06, 0x01, 0x00, 0x30, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x40, 0x08, 0x06, 0x01, 0x80, 0x10, 0x08, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x00, 0xC0, 0x40, 0x08, 0x01, 0x81, 0x80, 0x30, 0x03, 0x06, 0x00,
  0x60, 0x04, 0x0C, 0x00, 0xC0, 0x18, 0x30, 0x01, 0x80, 0x30, 0x40, 0x03,
  0x00, 0x61, 0x80, 0x04, 0x00, 0x82, 0x0F, 0xC8, 0x03, 0x0C, 0x31, 0xD0,
  0x06, 0x30, 0xC1, 0xA0, 0x18, 0x63, 0x01, 0x40, 0x31, 0x8C, 0x02, 0xC0,
  0xC2, 0x18, 0x07, 0x81, 0x8C, 0x20, 0x0D, 0x8E, 0x10, 0xC0, 0x13, 0xF8,
  0x61, 0x80, 0x20, 0x81, 0x86, 0x00, 0x40, 0x03, 0x0C, 0x00, 0x80, 0x0C,
  0x18, 0x03, 0x00, 0x18, 0x20, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x81,
  0x80, 0x18, 0x03, 0x03, 0x00, 0x20, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C,
  0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x04, 0x00, 0x80, 0x20, 0x18, 0x01, 0x80, 0xC0, 0x20, 0x03, 0x03,
  0x00, 0xC0, 0x06, 0x06, 0x03, 0x00, 0x06, 0x18, 0x06, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x20,
  0x00, 0xC0, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x04, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0x40, 0x10, 0xC0, 0x30, 0x18,
  0xC0, 0x18, 0x08, 0xC0, 0x04, 0x0C, 0x60, 0x03, 0x06, 0x60, 0x00, 0x82,
  0x30, 0x00, 0x63, 0x10, 0x00, 0x33, 0x08, 0x00, 0x09, 0x8C, 0x00, 0x07,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0x40, 0x00,
  0xD0, 0x30, 0x00, 0x6C, 0x18, 0x00, 0x66, 0x06, 0x00, 0xE1, 0x03, 0x81,
  0xC0, 0xC0, 0x7F, 0xC0, 0x20, 0x0E, 0x00, 0x00, 0x18, 0xC6, 0x21, 0x18,
  0xC4, 0x21, 0x18, 0xC4, 0x21, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x20,
  0x10, 0x0E, 0x04, 0x00, 0xE1, 0x00, 0x0C, 0x80, 0x40, 0xE3, 0xF0, 0x0F,
  0x00, 0x07, 0x00, 0x02, 0x40, 0x03, 0x18, 0x01, 0x82, 0x00, 0xC0, 0xC0,
  0xE0, 0x10, 0x10, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x03, 0x02,
  0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x6F, 0xB0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x60, 0xE0, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x0C,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x62, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60,
  0x60, 0x01, 0x80, 0x40, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x01,
  0x80, 0xE0, 0x01, 0x83, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x0F, 0x01, 0xF0, 0x32, 0x0E, 0x21, 0xC6, 0x30, 0x6E, 0x06,
  0x40, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x06,
  0x00, 0xF0, 0x07, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0xFF, 0x80, 0x31, 0xC1, 0xC0, 0x37, 0x00, 0x60, 0x24, 0x00, 0x30, 0x28,
  0x00, 0x30, 0x78, 0x00, 0x10, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x40,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x02, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x02,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xEC, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x20, 0x60, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E,
  0x08, 0x00, 0x1E, 0x0C, 0x00, 0x14, 0x0C, 0x00, 0x34, 0x06, 0x00, 0xEC,
  0x03, 0x83, 0x8C, 0x01, 0xFF, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0x80, 0xF0, 0x70, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x7F, 0x80, 0xC3, 0x00, 0x1C, 0x70, 0x18, 0x60, 0x0E,
  0x06, 0x03, 0x08, 0x03, 0x00, 0xC0, 0x63, 0x00, 0x60, 0x10, 0x0C, 0x60,
  0x18, 0x06, 0x01, 0x98, 0x06, 0x00, 0xC0, 0x33, 0x00, 0xC0, 0x18, 0x04,
  0x60, 0x30, 0x02, 0x00, 0x88, 0x06, 0x00, 0xC0, 0x33, 0x00, 0x80, 0x18,
  0x06, 0x60, 0x30, 0x02, 0x00, 0xCC, 0x06, 0x00, 0xC0, 0x11, 0x80, 0x80,
  0x18, 0x06, 0x20, 0x30, 0x03, 0x00, 0xCC, 0x06, 0x00, 0x40, 0x19, 0x80,
  0xC0, 0x18, 0x06, 0x30, 0x18, 0x03, 0x00, 0xC6, 0x03, 0x00, 0xE0, 0x30,
  0xC0, 0x60, 0x1C, 0x06, 0x18, 0x0C, 0x07, 0x81, 0x83, 0x01, 0x81, 0x90,
  0x30, 0x60, 0x18, 0x73, 0x0C, 0x0C, 0x01, 0xFC, 0x7F, 0x01, 0x80, 0x1E,
  0x07, 0x80, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x88, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x62, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x18, 0x20, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x08, 0x00,
  0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xFF,
  0xC0, 0x18, 0x00, 0x60, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x41, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x60,
  0x00, 0x04, 0x20, 0x00, 0x03, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x04,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x10, 0x06, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x20, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x08, 0x00,
  0x38, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0x80, 0x7C, 0x00, 0x20, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x06,
  0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x02, 0x03, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x01, 0x00, 0x0E, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0x10, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x06, 0x00, 0x38, 0x00, 0x40,
  0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38,
  0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x04, 0x00, 0x38, 0x00, 0x40,
  0x0F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x80, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x78, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0xE1, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x80, 0x01,
  0x80, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x18, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x20, 0x07, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x80, 0x01,
  0x80, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x80, 0xE0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x67,
  0x80, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x1B, 0x20, 0x00, 0x00, 0xB1, 0x80,
  0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x0A, 0x00,
  0x00, 0x01, 0xE0, 0x05, 0x00, 0x00, 0x00, 0xF0, 0x06, 0x80, 0x00, 0x00,
  0xD0, 0x03, 0x60, 0x00, 0x00, 0x48, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x98, 0x00, 0x00, 0x26, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00, 0x66, 0x00,
  0x00, 0x11, 0x00, 0x33, 0x00, 0x00, 0x18, 0x80, 0x18, 0x80, 0x00, 0x08,
  0xC0, 0x08, 0x40, 0x00, 0x0C, 0x60, 0x0C, 0x20, 0x00, 0x04, 0x30, 0x06,
  0x10, 0x00, 0x06, 0x10, 0x03, 0x08, 0x00, 0x02, 0x18, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x83, 0x00, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x01, 0x81, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x10,
  0x30, 0x00, 0xC0, 0xC0, 0x08, 0x08, 0x00, 0x60, 0x60, 0x0C, 0x04, 0x00,
  0x60, 0x20, 0x06, 0x02, 0x00, 0x30, 0x10, 0x03, 0x01, 0x00, 0x30, 0x18,
  0x01, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x10, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x83, 0x00, 0x20, 0x06, 0x00, 0x41, 0x80, 0x30, 0x03, 0x00,
  0x21, 0x80, 0x18, 0x01, 0x00, 0x10, 0x80, 0x0C, 0x01, 0x80, 0x08, 0xC0,
  0x04, 0x00, 0xC0, 0x06, 0x40, 0x02, 0x00, 0x60, 0x03, 0x60, 0x03, 0x00,
  0x20, 0x01, 0xA0, 0x01, 0x80, 0x10, 0x00, 0xF0, 0x00, 0xC0, 0x18, 0x00,
  0x70, 0x00, 0x40, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x00, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0A, 0x00,
  0x00, 0x60, 0x05, 0x80, 0x00, 0x30, 0x06, 0xC0, 0x00, 0x10, 0x03, 0x60,
  0x00, 0x18, 0x01, 0x90, 0x00, 0x0C, 0x00, 0x8C, 0x00, 0x06, 0x00, 0x46,
  0x00, 0x03, 0x00, 0x63, 0x00, 0x01, 0x00, 0x30, 0x80, 0x01, 0x80, 0x18,
  0x60, 0x00, 0xC0, 0x08, 0x30, 0x00, 0x60, 0x0C, 0x18, 0x00, 0x30, 0x06,
  0x04, 0x00, 0x10, 0x03, 0x03, 0x00, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x00,
  0x80, 0xC0, 0x06, 0x00, 0xC0, 0x20, 0x02, 0x00, 0x60, 0x18, 0x01, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x10, 0x18,
  0x01, 0x00, 0x08, 0x0C, 0x00, 0x80, 0x06, 0x06, 0x00, 0xC0, 0x03, 0x02,
  0x00, 0x60, 0x00, 0x83, 0x00, 0x30, 0x00, 0x61, 0x80, 0x10, 0x00, 0x30,
  0xC0, 0x18, 0x00, 0x18, 0x40, 0x0C, 0x00, 0x04, 0x20, 0x06, 0x00, 0x03,
  0x30, 0x03, 0x00, 0x01, 0x98, 0x01, 0x00, 0x00, 0xCC, 0x01, 0x80, 0x00,
  0x24, 0x00, 0xC0, 0x00, 0x1A, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x20, 0x00,
  0x07, 0x80, 0x10, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x03, 0x80, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x20, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x40, 0x00, 0x20, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x03, 0x80, 0x10, 0x07, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x00, 0xE0, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00,
  0x60, 0x0F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x20, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x10, 0x00, 0x60, 0x06, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00, 0xC0,
  0x08, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00,
  0x60, 0x10, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x1C, 0x00, 0x20, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x40, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0x40, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x0C, 0x00,
  0x40, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x10, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0x60, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x41, 0x80, 0x00, 0x41, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x68, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x02, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0xC0, 0x00, 0x28, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00, 0x0C,
  0xC0, 0x00, 0x48, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x18, 0xC0, 0x00,
  0xC8, 0x00, 0x18, 0xC0, 0x00, 0x88, 0x00, 0x10, 0xC0, 0x01, 0x88, 0x00,
  0x30, 0xC0, 0x01, 0x08, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x60, 0xC0,
  0x03, 0x08, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x08,
  0x00, 0xC0, 0xC0, 0x04, 0x08, 0x00, 0x80, 0xC0, 0x0C, 0x08, 0x01, 0x80,
  0xC0, 0x08, 0x08, 0x01, 0x80, 0xC0, 0x18, 0x08, 0x03, 0x00, 0xC0, 0x18,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x00, 0xC0, 0x60, 0x08, 0x0C, 0x00, 0xC0,
  0x60, 0x08, 0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x08, 0x00, 0xC0, 0xC0, 0x18,
  0x18, 0x00, 0xC0, 0x80, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x00,
  0xC1, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x00, 0xC4, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x20, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x31,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x08, 0x00, 0x30, 0x20, 0x00, 0x80, 0xC0,
  0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x40, 0x18,
  0x01, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x18, 0x00, 0x08, 0x60, 0x00, 0x23, 0x00, 0x00, 0xC8,
  0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x0C, 0x06, 0x01, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01,
  0x84, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x04, 0x10, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xE3, 0x00, 0xE0, 0x63, 0x01, 0xC0, 0x32, 0x03, 0x80, 0x1A, 0x03,
  0x00, 0x1A, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x10, 0x60, 0x00, 0x10, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0x40, 0x03, 0x40, 0x60,
  0x02, 0xC0, 0x60, 0x06, 0xC0, 0x30, 0x0C, 0x80, 0x38, 0x38, 0x80, 0x0F,
  0xE0, 0x80, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x83, 0xE0, 0x01, 0x0F, 0xF8, 0x01, 0x1C, 0x1C, 0x03, 0x30, 0x0E, 0x03,
  0x60, 0x06, 0x02, 0xC0, 0x02, 0x02, 0x80, 0x03, 0x07, 0x80, 0x03, 0x07,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08,
  0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10,
  0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x50,
  0x00, 0x60, 0x58, 0x00, 0xC0, 0x58, 0x01, 0xC0, 0xCC, 0x03, 0x80, 0xC6,
  0x07, 0x00, 0x83, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0x00, 0xE0, 0x10, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x03, 0xE0, 0x40, 0x01, 0xFF, 0x18, 0x00, 0xE0, 0x73, 0x00, 0x38, 0x02,
  0x60, 0x0E, 0x00, 0x6C, 0x01, 0x80, 0x05, 0x00, 0x60, 0x00, 0xE0, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x3C, 0x01, 0x00, 0x0D,
  0x00, 0x30, 0x01, 0xA0, 0x06, 0x00, 0x64, 0x00, 0x60, 0x19, 0x80, 0x0E,
  0x0E, 0x30, 0x00, 0xFF, 0x84, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x03, 0xFC, 0x00, 0xE0, 0x60, 0x1C, 0x03, 0x03, 0x80, 0x30, 0x30,
  0x01, 0x06, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x20, 0x07, 0x06,
  0x01, 0xE0, 0x6F, 0xF8, 0x07, 0xF8, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x10, 0x1C, 0x06, 0x00, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x10, 0x03, 0x81,
  0xC4, 0x01, 0xC0, 0x13, 0x00, 0xE0, 0x06, 0xC0, 0x30, 0x00, 0xA0, 0x18,
  0x00, 0x28, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x01, 0xE0, 0x10, 0x00,
  0xD0, 0x06, 0x00, 0x34, 0x01, 0x80, 0x1B, 0x00, 0x30, 0x0C, 0xC0, 0x0E,
  0x0E, 0x30, 0x01, 0xFF, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x08, 0x01, 0xC0, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0xF8, 0x00, 0x87, 0xFC, 0x01, 0x38, 0x1C, 0x06, 0xE0, 0x18, 0x0D,
  0x00, 0x18, 0x16, 0x00, 0x30, 0x38, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0,
  0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x40, 0x00, 0x40,
  0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x10,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x02, 0x00,
  0x02, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x40, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x80, 0x80, 0x06, 0x01, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x0C,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x04, 0x0C, 0x00,
  0x08, 0x18, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01,
  0x1E, 0x00, 0x02, 0x6C, 0x00, 0x0D, 0x98, 0x00, 0x1A, 0x10, 0x00, 0x2C,
  0x30, 0x00, 0x70, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x00, 0x80, 0x06, 0x01,
  0x80, 0x08, 0x03, 0x00, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x02, 0x00, 0x10, 0x04, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x11,
  0xFF, 0x03, 0xFC, 0x01, 0x38, 0x38, 0xE0, 0x60, 0x36, 0x01, 0x98, 0x03,
  0x03, 0xC0, 0x09, 0x00, 0x10, 0x28, 0x00, 0xF0, 0x01, 0x03, 0x80, 0x0E,
  0x00, 0x10, 0x70, 0x00, 0xE0, 0x01, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x60,
  0x00, 0xC0, 0x03, 0x06, 0x00, 0x08, 0x00, 0x30, 0x60, 0x01, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x02, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x80, 0x01, 0x00, 0x06, 0x08, 0x00, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x00, 0x04, 0x18, 0x00, 0x30, 0x00, 0x41, 0x80, 0x02, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0x00, 0x83, 0x00, 0x06, 0x00, 0x08, 0x30, 0x00, 0x40, 0x01, 0x82, 0x00,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x10,
  0x60, 0x00, 0x80, 0x03, 0x04, 0x00, 0x08, 0x00, 0x30, 0x40, 0x01, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x02, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x02, 0x1F, 0xF0, 0x04, 0xE0, 0x70,
  0x1B, 0x80, 0x60, 0x34, 0x00, 0x60, 0x58, 0x00, 0xC0, 0xE0, 0x01, 0x83,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x02, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x81, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10,
  0x30, 0x00, 0x20, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x0E,
  0x07, 0x00, 0x70, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x60, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x11, 0x80, 0x00, 0x44,
  0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0x90, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0x40, 0x00,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x1C, 0x1C, 0x00,
  0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x3F,
  0xE0, 0x00, 0x8E, 0x0E, 0x00, 0x33, 0x00, 0xC0, 0x06, 0xC0, 0x0C, 0x00,
  0xB0, 0x00, 0x80, 0x16, 0x00, 0x18, 0x07, 0x80, 0x03, 0x00, 0xE0, 0x00,
  0x60, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x14, 0x00, 0x30, 0x02,
  0xC0, 0x0E, 0x00, 0xCC, 0x03, 0x80, 0x19, 0xC1, 0xE0, 0x03, 0x0F, 0xF0,
  0x00, 0x40, 0x60, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE1, 0x00, 0xE0, 0x71, 0x01, 0xC0, 0x13,
  0x03, 0x80, 0x1B, 0x03, 0x00, 0x0A, 0x06, 0x00, 0x0A, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xE0,
  0x40, 0x03, 0x40, 0x60, 0x03, 0x40, 0x60, 0x06, 0xC0, 0x30, 0x0C, 0xC0,
  0x38, 0x38, 0xC0, 0x1F, 0xF0, 0x80, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x21, 0xF8, 0x04, 0xE0, 0x01, 0xB8,
  0x00, 0x26, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x30, 0x0E, 0x03, 0x00, 0x10, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x10, 0x00, 0xC0,
  0xF0, 0x1C, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x3F, 0xF8, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0x7E, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x20, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x06, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x40, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00,
  0x14, 0x0C, 0x00, 0x68, 0x18, 0x01, 0xB0, 0x18, 0x06, 0x60, 0x38, 0x38,
  0x80, 0x3F, 0xE1, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x06,
  0x40, 0x00, 0x64, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00, 0x18, 0x40, 0x01,
  0x84, 0x00, 0x30, 0x40, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0xC0, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x02,
  0x08, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00,
  0x26, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0A, 0x00, 0x0E, 0x00, 0x34, 0x00, 0x3C, 0x00, 0x68, 0x00, 0x58,
  0x00, 0x90, 0x01, 0xB0, 0x03, 0x20, 0x03, 0x60, 0x04, 0x40, 0x04, 0xC0,
  0x18, 0x80, 0x19, 0x80, 0x31, 0x00, 0x23, 0x00, 0xC2, 0x00, 0xC6, 0x01,
  0x84, 0x01, 0x0C, 0x02, 0x08, 0x06, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x10,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x81, 0x81, 0x01,
  0x83, 0x03, 0x06, 0x03, 0x04, 0x06, 0x08, 0x06, 0x18, 0x0C, 0x30, 0x0C,
  0x20, 0x18, 0x60, 0x18, 0xC0, 0x30, 0x80, 0x31, 0x80, 0x63, 0x00, 0x66,
  0x00, 0xC4, 0x00, 0xCC, 0x01, 0x98, 0x01, 0x90, 0x01, 0x20, 0x03, 0x60,
  0x02, 0xC0, 0x06, 0x80, 0x05, 0x80, 0x0F, 0x00, 0x0A, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x10, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x08, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x63, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x23, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x78, 0xE8, 0x00,
  0x7F, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 45, 13, 1, -45 },
  { 69, 13, 16, 17, 6, -45 },
  { 95, 28, 45, 28, 1, -45 },
  { 253, 26, 52, 25, 0, -48 },
  { 422, 31, 47, 37, 4, -46 },
  { 605, 25, 47, 27, 0, -46 },
  { 752, 5, 16, 10, 6, -45 },
  { 762, 17, 55, 15, 2, -45 },
  { 879, 17, 55, 15, -4, -45 },
  { 996, 18, 20, 24, 8, -48 },
  { 1041, 23, 29, 28, 3, -37 },
  { 1125, 8, 14, 10, -3, -6 },
  { 1139, 14, 2, 17, 2, -18 },
  { 1143, 3, 4, 11, 1, -4 },
  { 1145, 26, 45, 19, -3, -45 },
  { 1292, 23, 47, 26, 2, -46 },
  { 1428, 12, 45, 26, 8, -45 },
  { 1496, 26, 46, 26, -1, -46 },
  { 1646, 26, 47, 26, -1, -46 },
  { 1799, 26, 45, 26, -1, -45 },
  { 1946, 27, 46, 26, -1, -45 },
  { 2102, 24, 47, 26, 2, -46 },
  { 2243, 23, 45, 26, 4, -45 },
  { 2373, 26, 47, 26, 0, -46 },
  { 2526, 24, 47, 26, 1, -46 },
  { 2667, 9, 33, 11, 1, -33 },
  { 2705, 13, 41, 11, -3, -33 },
  { 2772, 23, 27, 28, 3, -36 },
  { 2850, 23, 15, 28, 3, -30 },
  { 2894, 23, 27, 28, 3, -36 },
  { 2972, 18, 46, 18, 2, -46 },
  { 3076, 35, 51, 38, 2, -45 },
  { 3300, 25, 45, 25, -4, -45 },
  { 3441, 27, 45, 28, 1, -45 },
  { 3593, 27, 47, 26, 3, -46 },
  { 3752, 28, 45, 31, 1, -45 },
  { 3910, 26, 45, 25, 1, -45 },
  { 4057, 26, 45, 23, 1, -45 },
  { 4204, 30, 47, 33, 3, -46 },
  { 4381, 32, 45, 32, 1, -45 },
  { 4561, 18, 45, 13, -2, -45 },
  { 4663, 21, 56, 11, -9, -45 },
  { 4810, 29, 45, 26, 1, -45 },
  { 4974, 17, 45, 23, 1, -45 },
  { 5070, 41, 45, 41, 1, -45 },
  { 5301, 33, 45, 33, 1, -45 },
  { 5487, 29, 47, 33, 3, -46 },
  { 5658, 26, 45, 26, 1, -45 },
  { 5805, 29, 57, 33, 3, -46 },
  { 6012, 26, 45, 26, 1, -45 },
  { 6159, 27, 47, 24, -1, -46 },
  { 6318, 22, 45, 22, 5, -45 },
  { 6442, 30, 46, 32, 3, -45 },
  { 6615, 24, 45, 25, 6, -45 },
  { 6750, 40, 45, 42, 6, -45 },
  { 6975, 31, 45, 23, -4, -45 },
  { 7150, 22, 45, 22, 5, -45 },
  { 7274, 29, 45, 24, -2, -45 },
  { 7438, 23, 55, 18, -1, -45 },
  { 7597, 9, 45, 20, 6, -45 },
  { 7648, 23, 55, 18, -4, -45 },
  { 7807, 25, 23, 28, 2, -45 },
  { 7879, 18, 2, 19, -5, 6 },
  { 7884, 6, 10, 13, 9, -48 },
  { 7892, 24, 35, 27, 2, -34 },
  { 7997, 24, 49, 27, 1, -48 },
  { 8144, 20, 35, 20, 2, -34 },
  { 8232, 27, 49, 27, 2, -48 },
  { 8398, 20, 35, 24, 2, -34 },
  { 8486, 29, 63, 13, -8, -48 },
  { 8715, 26, 49, 27, 0, -34 },
  { 8875, 23, 48, 26, 1, -48 },
  { 9013, 11, 45, 11, 1, -45 },
  { 9075, 22, 60, 11, -9, -45 },
  { 9240, 23, 48, 21, 1, -48 },
  { 9378, 12, 48, 10, 1, -48 },
  { 9450, 36, 34, 40, 1, -34 },
  { 9603, 23, 34, 26, 1, -34 },
  { 9701, 22, 35, 27, 2, -34 },
  { 9798, 27, 48, 27, -2, -34 },
  { 9960, 24, 49, 27, 2, -34 },
  { 10107, 19, 34, 17, 1, -34 },
  { 10188, 21, 35, 20, -1, -34 },
  { 10280, 13, 42, 14, 2, -41 },
  { 10349, 23, 34, 26, 2, -33 },
  { 10447, 20, 33, 20, 3, -33 },
  { 10530, 31, 33, 33, 4, -33 },
  { 10658, 26, 33, 21, -3, -33 },
  { 10766, 31, 48, 21, -7, -33 },
  { 10952, 22, 33, 18, -2, -33 },
  { 11043, 22, 55, 20, 2, -45 },
  { 11195, 2, 63, 25, 12, -48 },
  { 11211, 22, 55, 20, -4, -45 },
  { 11363, 23, 5, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_THINITALIC63PT7B_H_
