#ifndef _NOTOSANS_CONDENSED_THINITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x40, 0x08, 0xB6, 0xD0, 0x0A, 0x12, 0x12,
  0x7F, 0x14, 0x24, 0x24, 0xBE, 0x48, 0x48, 0x50, 0x90, 0x08, 0x38, 0xAA,
  0x44, 0x86, 0x04, 0x0C, 0x14, 0x28, 0x95, 0xC6, 0x04, 0x00, 0x71, 0x52,
  0x92, 0x94, 0x9A, 0xAD, 0xB5, 0x59, 0x29, 0x29, 0x49, 0xCE, 0x1C, 0x48,
  0x91, 0x22, 0x82, 0x1C, 0x25, 0x8D, 0x0A, 0x27, 0xA0, 0xF0, 0x08, 0x88,
  0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x21, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x22, 0x44, 0x80, 0x25, 0x1E, 0xC9, 0x00, 0x20, 0x82, 0x08, 0xFC,
  0x82, 0x08, 0x56, 0xF0, 0x80, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x00, 0x3D, 0x14, 0x61, 0x86, 0x18, 0x62, 0x8A, 0x29,
  0x38, 0x3C, 0x92, 0x92, 0x4A, 0x40, 0x3C, 0x04, 0x08, 0x10, 0x40, 0x82,
  0x08, 0x20, 0x82, 0x07, 0xC0, 0x3E, 0x04, 0x08, 0x10, 0x47, 0x02, 0x02,
  0x04, 0x08, 0x27, 0x80, 0x02, 0x08, 0x30, 0xA1, 0x44, 0x91, 0x44, 0xFC,
  0x10, 0x20, 0x40, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x01, 0x02, 0x04, 0x08,
  0x27, 0x80, 0x3D, 0x04, 0x20, 0xB3, 0x28, 0xA2, 0x8A, 0x28, 0xBC, 0x7C,
  0x10, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x3E, 0x44, 0x89, 0x12,
  0x43, 0x1A, 0x42, 0x85, 0x0A, 0x13, 0xC0, 0x3C, 0x45, 0x0A, 0x14, 0x28,
  0x9B, 0x0A, 0x04, 0x10, 0x27, 0x80, 0x20, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x00, 0x02, 0x44, 0x80, 0x04, 0x66, 0x20, 0x40, 0xC0, 0x81, 0xFC, 0x00,
  0x3F, 0x81, 0x03, 0x03, 0x08, 0xC4, 0x20, 0xF0, 0x42, 0x21, 0x11, 0x10,
  0x80, 0x01, 0x00, 0x1F, 0x10, 0x50, 0x29, 0x99, 0x2D, 0x26, 0x93, 0x49,
  0xA9, 0x5F, 0x20, 0x10, 0x0C, 0x00, 0xC0, 0x04, 0x18, 0x30, 0x51, 0x22,
  0x48, 0x9F, 0x42, 0x86, 0x0C, 0x10, 0x3E, 0x44, 0x89, 0x12, 0x27, 0x91,
  0x21, 0x42, 0x86, 0x17, 0xC0, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x03, 0xC0, 0x3E, 0x21, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x42, 0x42, 0x84, 0xF8, 0x3E, 0x40, 0x81, 0x02, 0x07, 0x90, 0x20, 0x40,
  0x82, 0x07, 0xC0, 0x3E, 0x40, 0x81, 0x02, 0x08, 0x1F, 0x20, 0x40, 0x82,
  0x04, 0x00, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x8E, 0x82, 0x82, 0x82,
  0x84, 0x7C, 0x20, 0x90, 0x48, 0x24, 0x22, 0x11, 0xF9, 0x04, 0x84, 0x42,
  0x21, 0x20, 0x90, 0x40, 0x18, 0x84, 0x21, 0x10, 0x84, 0x21, 0x11, 0xC0,
  0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x4E, 0x00,
  0x21, 0x22, 0x24, 0x28, 0x30, 0x50, 0x70, 0x48, 0x48, 0x48, 0x84, 0x84,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0xF0, 0x10, 0x22, 0x04, 0xC1,
  0x98, 0x53, 0x0A, 0xA2, 0x94, 0x52, 0x92, 0x4A, 0x49, 0x92, 0x32, 0x44,
  0x40, 0x10, 0x88, 0x4C, 0x25, 0x12, 0x92, 0x49, 0x24, 0x8A, 0x46, 0x23,
  0x20, 0x90, 0x40, 0x3E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x78, 0x3E, 0x44, 0x89, 0x12, 0x28, 0x9E, 0x20, 0x40, 0x82,
  0x04, 0x00, 0x3E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84,
  0x84, 0x68, 0x10, 0x10, 0x08, 0x3E, 0x44, 0x89, 0x12, 0x28, 0x9E, 0x24,
  0x48, 0x92, 0x24, 0x20, 0x3E, 0x81, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x27, 0x80, 0xFC, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20,
  0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0xF0,
  0x86, 0x18, 0xA2, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x20, 0x88, 0x71, 0x0A,
  0x51, 0x4A, 0x49, 0x49, 0x4A, 0x29, 0x46, 0x28, 0xC6, 0x10, 0x82, 0x10,
  0x42, 0x00, 0x11, 0x11, 0x12, 0x14, 0x08, 0x08, 0x08, 0x18, 0x28, 0x44,
  0x44, 0x84, 0x86, 0x14, 0x92, 0x51, 0x82, 0x10, 0x41, 0x04, 0x20, 0x1F,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x3C,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0E, 0x00, 0xAA,
  0xA9, 0x55, 0x1C, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x8E, 0x00, 0x10, 0xA4, 0x92, 0x86, 0x10, 0xF8, 0x94, 0x3D, 0x18, 0x61,
  0x8A, 0x28, 0xA4, 0xE8, 0x10, 0x40, 0x81, 0x03, 0xC4, 0x50, 0xA1, 0x42,
  0x85, 0x14, 0x2F, 0x80, 0x3A, 0x21, 0x08, 0x42, 0x10, 0xF0, 0x02, 0x04,
  0x08, 0x23, 0xC8, 0xA1, 0x42, 0x89, 0x12, 0x24, 0xCE, 0x80, 0x3A, 0x63,
  0x2E, 0x42, 0x10, 0xF0, 0x07, 0x04, 0x08, 0x08, 0x1C, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1E, 0x45, 0x0A,
  0x14, 0x50, 0xA1, 0x46, 0x74, 0x10, 0x20, 0x4F, 0x00, 0x10, 0x82, 0x08,
  0x3C, 0x94, 0x51, 0x45, 0x18, 0x61, 0x88, 0x20, 0x12, 0x92, 0x52, 0x40,
  0x08, 0x00, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x11, 0x18, 0x10, 0x82,
  0x08, 0x24, 0xA4, 0x94, 0x71, 0x49, 0x22, 0x88, 0x24, 0x92, 0x52, 0x4A,
  0x48, 0x3D, 0xC8, 0x94, 0x45, 0x11, 0x44, 0x51, 0x18, 0x8A, 0x22, 0x88,
  0x80, 0x3C, 0x94, 0x51, 0x45, 0x18, 0x61, 0x88, 0x39, 0x18, 0x61, 0x86,
  0x28, 0xA2, 0xF0, 0x1E, 0x11, 0x21, 0x21, 0x21, 0x21, 0x22, 0x42, 0x7C,
  0x40, 0x40, 0x80, 0x80, 0x3D, 0x18, 0x61, 0x8A, 0x28, 0xA6, 0xE8, 0x41,
  0x04, 0x10, 0x39, 0x10, 0x84, 0x22, 0x10, 0x80, 0x3A, 0x10, 0x82, 0x08,
  0x22, 0xF0, 0x22, 0x74, 0x44, 0x44, 0x88, 0xC0, 0x46, 0x18, 0x62, 0x8A,
  0x28, 0xA4, 0xF0, 0x8C, 0x65, 0x2A, 0x53, 0x18, 0x80, 0x89, 0x99, 0x99,
  0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x88, 0x22, 0x28, 0x50, 0xC1, 0x05, 0x0A,
  0x24, 0x84, 0x11, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x08, 0x08, 0x10,
  0x10, 0x20, 0xC0, 0x38, 0x44, 0x22, 0x21, 0x10, 0xF0, 0x19, 0x08, 0x42,
  0x21, 0x10, 0x42, 0x21, 0x08, 0x41, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x20,
  0x82, 0x08, 0x20, 0x83, 0x10, 0x41, 0x08, 0x20, 0x8C, 0x00, 0xE6, 0x60,
};

const GFXglyph NotoSans_Condensed_ThinItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 3, 0, -12 },
  { 7, 3, 4, 5, 2, -12 },
  { 9, 8, 12, 7, 0, -12 },
  { 21, 7, 14, 7, 0, -13 },
  { 34, 8, 12, 10, 1, -12 },
  { 46, 7, 12, 7, 0, -12 },
  { 57, 1, 4, 3, 2, -12 },
  { 58, 5, 15, 4, 0, -12 },
  { 68, 4, 15, 4, -1, -12 },
  { 76, 5, 5, 6, 2, -13 },
  { 80, 6, 8, 8, 1, -10 },
  { 86, 2, 4, 3, -1, -2 },
  { 87, 4, 1, 5, 0, -5 },
  { 88, 1, 1, 3, 0, -1 },
  { 89, 7, 12, 5, -1, -12 },
  { 100, 6, 12, 7, 1, -12 },
  { 109, 3, 12, 7, 2, -12 },
  { 114, 7, 12, 7, 0, -12 },
  { 125, 7, 12, 7, 0, -12 },
  { 136, 7, 12, 7, 0, -12 },
  { 147, 7, 12, 7, 0, -12 },
  { 158, 6, 12, 7, 1, -12 },
  { 167, 6, 12, 7, 1, -12 },
  { 176, 7, 12, 7, 0, -12 },
  { 187, 7, 12, 7, 0, -12 },
  { 198, 3, 9, 3, 0, -9 },
  { 202, 4, 11, 3, -1, -9 },
  { 208, 6, 8, 8, 1, -10 },
  { 214, 6, 4, 8, 1, -8 },
  { 217, 6, 8, 8, 1, -10 },
  { 223, 5, 12, 5, 1, -12 },
  { 231, 9, 14, 10, 1, -12 },
  { 247, 7, 12, 7, -1, -12 },
  { 258, 7, 12, 8, 0, -12 },
  { 269, 7, 12, 7, 1, -12 },
  { 280, 8, 12, 8, 0, -12 },
  { 292, 7, 12, 7, 0, -12 },
  { 303, 7, 12, 6, 0, -12 },
  { 314, 8, 12, 9, 1, -12 },
  { 326, 9, 12, 9, 0, -12 },
  { 340, 5, 12, 3, -1, -12 },
  { 348, 6, 15, 3, -3, -12 },
  { 360, 8, 12, 7, 0, -12 },
  { 372, 5, 12, 6, 0, -12 },
  { 380, 11, 12, 11, 0, -12 },
  { 397, 9, 12, 9, 0, -12 },
  { 411, 8, 12, 9, 1, -12 },
  { 423, 7, 12, 7, 0, -12 },
  { 434, 8, 15, 9, 1, -12 },
  { 449, 7, 12, 7, 0, -12 },
  { 460, 7, 12, 7, 0, -12 },
  { 471, 6, 12, 6, 1, -12 },
  { 480, 8, 12, 9, 1, -12 },
  { 492, 6, 12, 7, 2, -12 },
  { 501, 11, 12, 11, 2, -12 },
  { 518, 8, 12, 6, -1, -12 },
  { 530, 6, 12, 6, 1, -12 },
  { 539, 8, 12, 6, -1, -12 },
  { 551, 6, 15, 5, 0, -12 },
  { 563, 2, 12, 5, 2, -12 },
  { 566, 6, 15, 5, -1, -12 },
  { 578, 6, 6, 7, 1, -12 },
  { 583, 5, 1, 5, -1, 1 },
  { 584, 2, 3, 4, 2, -13 },
  { 585, 6, 9, 7, 1, -9 },
  { 592, 7, 13, 7, 0, -13 },
  { 604, 5, 9, 6, 1, -9 },
  { 610, 7, 13, 7, 1, -13 },
  { 622, 5, 9, 6, 1, -9 },
  { 628, 8, 17, 4, -2, -13 },
  { 645, 7, 13, 7, 0, -9 },
  { 657, 6, 13, 7, 0, -13 },
  { 667, 3, 12, 3, 0, -12 },
  { 672, 5, 16, 3, -2, -12 },
  { 682, 6, 13, 6, 0, -13 },
  { 692, 3, 13, 3, 0, -13 },
  { 697, 10, 9, 11, 0, -9 },
  { 709, 6, 9, 7, 0, -9 },
  { 716, 6, 9, 7, 1, -9 },
  { 723, 8, 13, 7, -1, -9 },
  { 736, 6, 13, 7, 1, -9 },
  { 746, 5, 9, 5, 0, -9 },
  { 752, 5, 9, 5, 0, -9 },
  { 758, 4, 11, 4, 0, -11 },
  { 764, 6, 9, 7, 1, -9 },
  { 771, 5, 9, 5, 1, -9 },
  { 777, 8, 9, 9, 1, -9 },
  { 786, 7, 9, 6, -1, -9 },
  { 794, 8, 13, 6, -2, -9 },
  { 807, 5, 9, 5, 0, -9 },
  { 813, 5, 15, 5, 1, -12 },
  { 823, 1, 17, 7, 3, -13 },
  { 826, 6, 15, 5, -1, -12 },
  { 838, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ThinItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_THINITALIC17PT7B_H_
