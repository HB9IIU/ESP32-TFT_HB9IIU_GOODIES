#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_Condensed_ThinItalic6pt7b, 6, "NotoSans_Condensed_ThinItalic6pt7b" },
  { &NotoSans_Condensed_ThinItalic7pt7b, 7, "NotoSans_Condensed_ThinItalic7pt7b" },
  { &NotoSans_Condensed_ThinItalic8pt7b, 8, "NotoSans_Condensed_ThinItalic8pt7b" },
  { &NotoSans_Condensed_ThinItalic9pt7b, 9, "NotoSans_Condensed_ThinItalic9pt7b" },
  { &NotoSans_Condensed_ThinItalic10pt7b, 10, "NotoSans_Condensed_ThinItalic10pt7b" },
  { &NotoSans_Condensed_ThinItalic11pt7b, 11, "NotoSans_Condensed_ThinItalic11pt7b" },
  { &NotoSans_Condensed_ThinItalic12pt7b, 12, "NotoSans_Condensed_ThinItalic12pt7b" },
  { &NotoSans_Condensed_ThinItalic13pt7b, 13, "NotoSans_Condensed_ThinItalic13pt7b" },
  { &NotoSans_Condensed_ThinItalic14pt7b, 14, "NotoSans_Condensed_ThinItalic14pt7b" },
  { &NotoSans_Condensed_ThinItalic15pt7b, 15, "NotoSans_Condensed_ThinItalic15pt7b" },
  { &NotoSans_Condensed_ThinItalic16pt7b, 16, "NotoSans_Condensed_ThinItalic16pt7b" },
  { &NotoSans_Condensed_ThinItalic17pt7b, 17, "NotoSans_Condensed_ThinItalic17pt7b" },
  { &NotoSans_Condensed_ThinItalic18pt7b, 18, "NotoSans_Condensed_ThinItalic18pt7b" },
  { &NotoSans_Condensed_ThinItalic19pt7b, 19, "NotoSans_Condensed_ThinItalic19pt7b" },
  { &NotoSans_Condensed_ThinItalic20pt7b, 20, "NotoSans_Condensed_ThinItalic20pt7b" },
  { &NotoSans_Condensed_ThinItalic21pt7b, 21, "NotoSans_Condensed_ThinItalic21pt7b" },
  { &NotoSans_Condensed_ThinItalic22pt7b, 22, "NotoSans_Condensed_ThinItalic22pt7b" },
  { &NotoSans_Condensed_ThinItalic23pt7b, 23, "NotoSans_Condensed_ThinItalic23pt7b" },
  { &NotoSans_Condensed_ThinItalic24pt7b, 24, "NotoSans_Condensed_ThinItalic24pt7b" },
  { &NotoSans_Condensed_ThinItalic25pt7b, 25, "NotoSans_Condensed_ThinItalic25pt7b" },
  { &NotoSans_Condensed_ThinItalic26pt7b, 26, "NotoSans_Condensed_ThinItalic26pt7b" },
  { &NotoSans_Condensed_ThinItalic27pt7b, 27, "NotoSans_Condensed_ThinItalic27pt7b" },
  { &NotoSans_Condensed_ThinItalic28pt7b, 28, "NotoSans_Condensed_ThinItalic28pt7b" },
  { &NotoSans_Condensed_ThinItalic29pt7b, 29, "NotoSans_Condensed_ThinItalic29pt7b" },
  { &NotoSans_Condensed_ThinItalic30pt7b, 30, "NotoSans_Condensed_ThinItalic30pt7b" },
  { &NotoSans_Condensed_ThinItalic31pt7b, 31, "NotoSans_Condensed_ThinItalic31pt7b" },
  { &NotoSans_Condensed_ThinItalic32pt7b, 32, "NotoSans_Condensed_ThinItalic32pt7b" },
  { &NotoSans_Condensed_ThinItalic33pt7b, 33, "NotoSans_Condensed_ThinItalic33pt7b" },
  { &NotoSans_Condensed_ThinItalic34pt7b, 34, "NotoSans_Condensed_ThinItalic34pt7b" },
  { &NotoSans_Condensed_ThinItalic35pt7b, 35, "NotoSans_Condensed_ThinItalic35pt7b" },
  { &NotoSans_Condensed_ThinItalic36pt7b, 36, "NotoSans_Condensed_ThinItalic36pt7b" },
  { &NotoSans_Condensed_ThinItalic37pt7b, 37, "NotoSans_Condensed_ThinItalic37pt7b" },
  { &NotoSans_Condensed_ThinItalic38pt7b, 38, "NotoSans_Condensed_ThinItalic38pt7b" },
  { &NotoSans_Condensed_ThinItalic39pt7b, 39, "NotoSans_Condensed_ThinItalic39pt7b" },
  { &NotoSans_Condensed_ThinItalic40pt7b, 40, "NotoSans_Condensed_ThinItalic40pt7b" },
  { &NotoSans_Condensed_ThinItalic41pt7b, 41, "NotoSans_Condensed_ThinItalic41pt7b" },
  { &NotoSans_Condensed_ThinItalic42pt7b, 42, "NotoSans_Condensed_ThinItalic42pt7b" },
  { &NotoSans_Condensed_ThinItalic43pt7b, 43, "NotoSans_Condensed_ThinItalic43pt7b" },
  { &NotoSans_Condensed_ThinItalic44pt7b, 44, "NotoSans_Condensed_ThinItalic44pt7b" },
  { &NotoSans_Condensed_ThinItalic45pt7b, 45, "NotoSans_Condensed_ThinItalic45pt7b" },
  { &NotoSans_Condensed_ThinItalic46pt7b, 46, "NotoSans_Condensed_ThinItalic46pt7b" },
  { &NotoSans_Condensed_ThinItalic47pt7b, 47, "NotoSans_Condensed_ThinItalic47pt7b" },
  { &NotoSans_Condensed_ThinItalic48pt7b, 48, "NotoSans_Condensed_ThinItalic48pt7b" },
  { &NotoSans_Condensed_ThinItalic49pt7b, 49, "NotoSans_Condensed_ThinItalic49pt7b" },
  { &NotoSans_Condensed_ThinItalic50pt7b, 50, "NotoSans_Condensed_ThinItalic50pt7b" },
  { &NotoSans_Condensed_ThinItalic51pt7b, 51, "NotoSans_Condensed_ThinItalic51pt7b" },
  { &NotoSans_Condensed_ThinItalic52pt7b, 52, "NotoSans_Condensed_ThinItalic52pt7b" },
  { &NotoSans_Condensed_ThinItalic53pt7b, 53, "NotoSans_Condensed_ThinItalic53pt7b" },
  { &NotoSans_Condensed_ThinItalic54pt7b, 54, "NotoSans_Condensed_ThinItalic54pt7b" },
  { &NotoSans_Condensed_ThinItalic55pt7b, 55, "NotoSans_Condensed_ThinItalic55pt7b" },
  { &NotoSans_Condensed_ThinItalic56pt7b, 56, "NotoSans_Condensed_ThinItalic56pt7b" },
  { &NotoSans_Condensed_ThinItalic57pt7b, 57, "NotoSans_Condensed_ThinItalic57pt7b" },
  { &NotoSans_Condensed_ThinItalic58pt7b, 58, "NotoSans_Condensed_ThinItalic58pt7b" },
  { &NotoSans_Condensed_ThinItalic59pt7b, 59, "NotoSans_Condensed_ThinItalic59pt7b" },
  { &NotoSans_Condensed_ThinItalic60pt7b, 60, "NotoSans_Condensed_ThinItalic60pt7b" },
  { &NotoSans_Condensed_ThinItalic61pt7b, 61, "NotoSans_Condensed_ThinItalic61pt7b" },
  { &NotoSans_Condensed_ThinItalic62pt7b, 62, "NotoSans_Condensed_ThinItalic62pt7b" },
  { &NotoSans_Condensed_ThinItalic63pt7b, 63, "NotoSans_Condensed_ThinItalic63pt7b" },
  { &NotoSans_Condensed_ThinItalic64pt7b, 64, "NotoSans_Condensed_ThinItalic64pt7b" },
  { &NotoSans_Condensed_ThinItalic65pt7b, 65, "NotoSans_Condensed_ThinItalic65pt7b" },
  { &NotoSans_Condensed_ThinItalic66pt7b, 66, "NotoSans_Condensed_ThinItalic66pt7b" },
  { &NotoSans_Condensed_ThinItalic67pt7b, 67, "NotoSans_Condensed_ThinItalic67pt7b" },
  { &NotoSans_Condensed_ThinItalic68pt7b, 68, "NotoSans_Condensed_ThinItalic68pt7b" },
  { &NotoSans_Condensed_ThinItalic69pt7b, 69, "NotoSans_Condensed_ThinItalic69pt7b" },
  { &NotoSans_Condensed_ThinItalic70pt7b, 70, "NotoSans_Condensed_ThinItalic70pt7b" },
  { &NotoSans_Condensed_ThinItalic71pt7b, 71, "NotoSans_Condensed_ThinItalic71pt7b" },
  { &NotoSans_Condensed_ThinItalic72pt7b, 72, "NotoSans_Condensed_ThinItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
