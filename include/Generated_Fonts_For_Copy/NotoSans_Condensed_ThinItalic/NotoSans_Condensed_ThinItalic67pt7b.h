#ifndef _NOTOSANS_CONDENSED_THINITALIC67PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x78, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x18, 0xC0, 0xC4, 0x06,
  0x60, 0x23, 0x03, 0x18, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x23, 0x03, 0x18,
  0x18, 0x80, 0x84, 0x04, 0x60, 0x23, 0x03, 0x10, 0x18, 0x80, 0x80, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04,
  0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x04, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0xC0, 0x00, 0x10,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20,
  0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF9, 0x3F, 0x00, 0x70, 0xC0, 0xC0, 0x30,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x40, 0x60, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x20, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0xE0, 0x30, 0x10, 0xE0, 0x0F, 0xEF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0x00, 0xE3, 0x80, 0x03, 0x00, 0xE0, 0xC0, 0x01, 0x80, 0x60, 0x20, 0x01,
  0x80, 0x60, 0x10, 0x00, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x40, 0x30, 0x06, 0x00, 0x60, 0x10, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x18, 0x18, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0x02, 0x06, 0x00, 0x30, 0x03, 0x06, 0x00, 0x18, 0x01,
  0x82, 0x00, 0x0C, 0x00, 0xC3, 0x07, 0xC6, 0x00, 0xC3, 0x07, 0xF3, 0x00,
  0x61, 0x86, 0x0D, 0x80, 0x21, 0x86, 0x06, 0xC0, 0x30, 0xC6, 0x01, 0xE0,
  0x10, 0xC3, 0x00, 0xF0, 0x18, 0x63, 0x00, 0x6C, 0x18, 0x61, 0x80, 0x37,
  0x38, 0x21, 0x80, 0x19, 0xF8, 0x30, 0xC0, 0x0C, 0x20, 0x30, 0x60, 0x06,
  0x00, 0x18, 0x60, 0x02, 0x00, 0x18, 0x30, 0x03, 0x00, 0x0C, 0x18, 0x01,
  0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x04, 0x04, 0x00, 0x60, 0x06, 0x06, 0x00,
  0x30, 0x06, 0x03, 0x00, 0x30, 0x03, 0x01, 0x80, 0x18, 0x03, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x18,
  0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x60, 0x03,
  0x01, 0x80, 0x60, 0x00, 0xC1, 0x80, 0x30, 0x00, 0x61, 0xC0, 0x30, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00,
  0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07,
  0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x30, 0x06, 0x1C, 0x06, 0x00,
  0xC3, 0x00, 0x60, 0x10, 0xC0, 0x0C, 0x06, 0x30, 0x00, 0xC0, 0xC6, 0x00,
  0x18, 0x31, 0x80, 0x03, 0x06, 0x30, 0x00, 0x31, 0x86, 0x00, 0x06, 0x30,
  0xC0, 0x00, 0x4C, 0x10, 0x00, 0x0D, 0x86, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x1C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x36, 0x06,
  0x00, 0x0C, 0xC0, 0xE0, 0x03, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0xE0, 0x70,
  0x10, 0x0F, 0xFC, 0x03, 0x00, 0x7C, 0x00, 0x00, 0x18, 0xC4, 0x63, 0x18,
  0x84, 0x63, 0x18, 0x84, 0x63, 0x10, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x04, 0x02, 0x00,
  0xE0, 0x20, 0x03, 0x82, 0x00, 0x0C, 0x20, 0x00, 0x34, 0x0F, 0x01, 0xDF,
  0x80, 0x06, 0x00, 0x01, 0xA0, 0x00, 0x32, 0x00, 0x06, 0x10, 0x00, 0xC1,
  0x00, 0x18, 0x08, 0x06, 0x00, 0xC0, 0x40, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x01, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x67, 0xE6, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x87,
  0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x01, 0x01, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x07, 0x01, 0xF0, 0x3B, 0x06, 0x21,
  0xC2, 0x38, 0x66, 0x06, 0xC0, 0x68, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7C, 0x3C, 0x00, 0x1C, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x10, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x40, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x08, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x1C, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x3F, 0x80, 0x04, 0x3F, 0xF8,
  0x03, 0x38, 0x07, 0x00, 0xDC, 0x00, 0xE0, 0x34, 0x00, 0x18, 0x0B, 0x00,
  0x03, 0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x70, 0x38,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x87,
  0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0x40, 0x00, 0x1C,
  0x20, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x0F, 0x06, 0x00, 0x0D,
  0x81, 0x80, 0x0E, 0xC0, 0x60, 0x0E, 0x40, 0x1C, 0x3C, 0x60, 0x07, 0xF8,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x80, 0x70, 0x3C, 0x0E, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x0F,
  0x83, 0x80, 0x40, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x7F, 0x80, 0x60, 0xC0, 0x07, 0xBE, 0x03, 0x0C,
  0x00, 0x60, 0x30, 0x18, 0x60, 0x06, 0x01, 0x00, 0xC2, 0x00, 0x60, 0x18,
  0x06, 0x30, 0x06, 0x00, 0xC0, 0x31, 0x80, 0x60, 0x06, 0x01, 0x88, 0x03,
  0x00, 0x60, 0x0C, 0xC0, 0x30, 0x03, 0x00, 0x66, 0x01, 0x80, 0x18, 0x03,
  0x30, 0x08, 0x00, 0xC0, 0x11, 0x00, 0xC0, 0x0C, 0x01, 0x98, 0x06, 0x00,
  0x60, 0x0C, 0xC0, 0x20, 0x03, 0x00, 0x66, 0x03, 0x00, 0x10, 0x02, 0x30,
  0x18, 0x01, 0x80, 0x31, 0x00, 0xC0, 0x0C, 0x01, 0x88, 0x06, 0x00, 0x60,
  0x18, 0xC0, 0x30, 0x07, 0x00, 0xC6, 0x01, 0x80, 0x30, 0x04, 0x30, 0x0C,
  0x03, 0x80, 0x61, 0x80, 0x60, 0x14, 0x06, 0x0C, 0x03, 0x01, 0xB0, 0x30,
  0x60, 0x1C, 0x19, 0x83, 0x03, 0x00, 0x71, 0x86, 0x70, 0x18, 0x01, 0xF8,
  0x3F, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x01, 0x90, 0x00, 0x00, 0x44, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x06, 0x10, 0x00, 0x01, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x7F, 0xFF, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x08,
  0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x30, 0x00,
  0x08, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x30, 0x03, 0xC0, 0x02, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x30, 0x03, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x04, 0x00, 0x1C, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x0E, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x78, 0x00, 0x08, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70,
  0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x70, 0x06, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x18, 0x00, 0x0F, 0xFC,
  0x0C, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x02, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x20, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x87, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x06, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x08, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0x67, 0x80, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x03, 0x36,
  0x00, 0x00, 0x06, 0xC6, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x70, 0x10, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x06, 0x80, 0x00,
  0x00, 0x34, 0x00, 0xD0, 0x00, 0x00, 0x07, 0x80, 0x1A, 0x00, 0x00, 0x01,
  0xB0, 0x02, 0x40, 0x00, 0x00, 0x36, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x19, 0x80, 0x00, 0x01, 0x90, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x08, 0xC0, 0x00, 0x03, 0x18, 0x03, 0x18, 0x00,
  0x00, 0x62, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x0C, 0x20, 0x00, 0x02,
  0x18, 0x01, 0x84, 0x00, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x00, 0x10, 0x60,
  0x0C, 0x10, 0x00, 0x06, 0x08, 0x01, 0x83, 0x00, 0x00, 0x83, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x30, 0x30, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x10, 0x18, 0x00, 0x60, 0x30,
  0x06, 0x01, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x18,
  0x04, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x40, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x81, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x30, 0x03, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x40, 0x0C,
  0x00, 0x41, 0x80, 0x18, 0x01, 0x80, 0x08, 0x60, 0x03, 0x00, 0x20, 0x01,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x33, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x60,
  0x01, 0x00, 0x30, 0x00, 0xD8, 0x00, 0x60, 0x06, 0x00, 0x1B, 0x00, 0x0C,
  0x00, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x70, 0x00, 0x20, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x08, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x06,
  0x80, 0x00, 0x0C, 0x00, 0xD8, 0x00, 0x01, 0x80, 0x1B, 0x00, 0x00, 0x20,
  0x02, 0x60, 0x00, 0x0C, 0x00, 0xC4, 0x00, 0x01, 0x80, 0x18, 0xC0, 0x00,
  0x30, 0x03, 0x18, 0x00, 0x06, 0x00, 0x63, 0x00, 0x01, 0x80, 0x08, 0x20,
  0x00, 0x30, 0x03, 0x06, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x0C,
  0x18, 0x00, 0x10, 0x01, 0x81, 0x00, 0x06, 0x00, 0x20, 0x30, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x18, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x30, 0x08, 0x00,
  0x40, 0x06, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x10,
  0x01, 0x80, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x20, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x40, 0x01, 0x81,
  0x80, 0x18, 0x00, 0x18, 0x30, 0x03, 0x00, 0x03, 0x06, 0x00, 0x60, 0x00,
  0x60, 0x80, 0x0C, 0x00, 0x0C, 0x30, 0x01, 0x00, 0x00, 0xC6, 0x00, 0x60,
  0x00, 0x18, 0xC0, 0x0C, 0x00, 0x03, 0x18, 0x01, 0x80, 0x00, 0x62, 0x00,
  0x20, 0x00, 0x06, 0xC0, 0x0C, 0x00, 0x00, 0xD8, 0x01, 0x80, 0x00, 0x1B,
  0x00, 0x30, 0x00, 0x01, 0x60, 0x06, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x1C, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x20,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0x70, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x06,
  0x00, 0x0E, 0x00, 0x80, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x06, 0x00, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x10, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00,
  0x18, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x20, 0x00, 0x60, 0x04, 0x00, 0x04, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x80,
  0x00, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x30, 0x04, 0x00, 0x0C,
  0x01, 0x00, 0x06, 0x00, 0x40, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08,
  0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x60, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xE0,
  0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00,
  0x66, 0x00, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x00, 0x26, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x98, 0x00, 0x18, 0x20, 0x00,
  0x63, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x0C,
  0x00, 0x18, 0x10, 0x00, 0x61, 0x80, 0x06, 0x02, 0x00, 0x08, 0x30, 0x00,
  0xC0, 0x40, 0x03, 0x06, 0x00, 0x10, 0x08, 0x00, 0x60, 0xC0, 0x06, 0x01,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x20, 0x03, 0x03, 0x00, 0x30, 0x04, 0x00,
  0x40, 0x60, 0x06, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x01,
  0x80, 0x30, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x08, 0x06, 0x00, 0xC0, 0x30, 0x01, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0x20, 0x10, 0x03, 0x01, 0x80, 0x04, 0x06, 0x00, 0x60, 0x20, 0x00, 0x80,
  0xC0, 0x0C, 0x0C, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x02, 0x06, 0x00,
  0x30, 0x60, 0x00, 0x40, 0x80, 0x06, 0x0C, 0x00, 0x08, 0x30, 0x00, 0xC1,
  0x00, 0x01, 0x06, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00,
  0x04, 0x30, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x11,
  0x80, 0x01, 0x88, 0x00, 0x02, 0x20, 0x00, 0x33, 0x00, 0x00, 0x4C, 0x00,
  0x06, 0x40, 0x00, 0x09, 0x80, 0x00, 0xD8, 0x00, 0x01, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x88, 0x00, 0x06, 0x10, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x20, 0x30, 0x00, 0x40, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x09, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C,
  0x06, 0x03, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x03,
  0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x10, 0x00, 0x07,
  0xC0, 0x40, 0x0F, 0xFC, 0x20, 0x07, 0x03, 0x88, 0x03, 0x80, 0x26, 0x01,
  0x80, 0x0D, 0x80, 0xC0, 0x01, 0x60, 0x30, 0x00, 0x50, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x70, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x10, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x08, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x70, 0x18, 0x00, 0x38, 0x06,
  0x00, 0x1A, 0x01, 0x80, 0x0C, 0x80, 0x30, 0x03, 0x60, 0x0C, 0x03, 0x98,
  0x01, 0xC1, 0xC4, 0x00, 0x3F, 0xC1, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x07, 0xC0, 0x01, 0x87, 0xFC, 0x00, 0x63, 0x01, 0x80, 0x13, 0x80,
  0x30, 0x04, 0xC0, 0x0C, 0x03, 0x60, 0x01, 0x80, 0xF0, 0x00, 0x60, 0x3C,
  0x00, 0x18, 0x0E, 0x00, 0x02, 0x03, 0x80, 0x00, 0x81, 0xC0, 0x00, 0x30,
  0x70, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00,
  0x18, 0x1E, 0x00, 0x0C, 0x05, 0x80, 0x06, 0x01, 0x30, 0x03, 0x80, 0xCC,
  0x01, 0xC0, 0x31, 0xC1, 0xE0, 0x08, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x1C, 0x02, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x81, 0x80, 0x0F, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x18,
  0x00, 0x3F, 0xF0, 0xC0, 0x03, 0x80, 0xC6, 0x00, 0x38, 0x03, 0x20, 0x03,
  0x00, 0x0B, 0x00, 0x30, 0x00, 0x78, 0x01, 0x80, 0x03, 0xC0, 0x18, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x04, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00,
  0x1C, 0x00, 0x80, 0x01, 0xE0, 0x06, 0x00, 0x0F, 0x00, 0x30, 0x00, 0xD8,
  0x01, 0x80, 0x0E, 0x80, 0x06, 0x00, 0xE4, 0x00, 0x30, 0x0E, 0x20, 0x00,
  0xE0, 0xE3, 0x00, 0x03, 0xFC, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x06, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x10, 0x00, 0x30, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x1E, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x02, 0x01, 0xE0, 0x70, 0x01,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC3, 0x00, 0x1C, 0x06, 0x30,
  0x03, 0x80, 0x32, 0x00, 0x60, 0x01, 0x20, 0x0C, 0x00, 0x1E, 0x00, 0xC0,
  0x01, 0xE0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x10, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x70, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1E, 0x03,
  0x00, 0x01, 0xC0, 0x10, 0x00, 0x3C, 0x01, 0x80, 0x03, 0xC0, 0x18, 0x00,
  0x6C, 0x01, 0x80, 0x0E, 0x80, 0x0C, 0x01, 0xC8, 0x00, 0xC0, 0x39, 0x80,
  0x07, 0x07, 0x18, 0x00, 0x3F, 0xC1, 0x80, 0x00, 0x60, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x80, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x81, 0xF8, 0x01, 0x87, 0xFC, 0x01, 0x9C, 0x06, 0x01, 0xB0, 0x03,
  0x01, 0x60, 0x03, 0x03, 0x40, 0x03, 0x03, 0xC0, 0x01, 0x03, 0x80, 0x03,
  0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x10, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00, 0x30,
  0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x20,
  0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x02, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xD8, 0x00, 0x09,
  0x98, 0x00, 0x1B, 0x18, 0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x10, 0x04, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0x1F, 0xF0, 0x3F, 0xF0, 0x06, 0x60, 0x30, 0xE0,
  0x70, 0x09, 0x80, 0x33, 0x00, 0x60, 0x16, 0x00, 0x6C, 0x00, 0x60, 0x78,
  0x00, 0xD0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x80,
  0x03, 0x03, 0x00, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x00, 0x10, 0x30, 0x00, 0x30, 0x00, 0x60, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x20, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0x81,
  0x80, 0x01, 0x80, 0x01, 0x03, 0x00, 0x02, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x08, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0x01, 0x81, 0x80, 0x03,
  0x00, 0x03, 0x02, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x30, 0x00, 0x20, 0x00, 0x60, 0x40, 0x00,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03, 0x00, 0x02,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x87, 0xFC,
  0x01, 0x1C, 0x06, 0x01, 0x30, 0x03, 0x01, 0x60, 0x03, 0x03, 0x40, 0x03,
  0x03, 0xC0, 0x01, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x10, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x20, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x70, 0x18, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x1C, 0x0E, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0x87, 0xFC, 0x00, 0x0C, 0x70, 0x30, 0x00, 0x46, 0x00, 0xC0,
  0x02, 0x60, 0x06, 0x00, 0x36, 0x00, 0x18, 0x01, 0xE0, 0x00, 0xC0, 0x0F,
  0x00, 0x02, 0x00, 0x70, 0x00, 0x10, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08,
  0x07, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x3C, 0x00,
  0x18, 0x01, 0xE0, 0x01, 0x80, 0x09, 0x00, 0x1C, 0x00, 0xCC, 0x01, 0xC0,
  0x06, 0x38, 0x3C, 0x00, 0x30, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x30, 0x07, 0x01, 0x8C,
  0x03, 0x00, 0x32, 0x01, 0x80, 0x0C, 0x80, 0xC0, 0x01, 0xE0, 0x30, 0x00,
  0x78, 0x18, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x70,
  0x10, 0x00, 0x3C, 0x06, 0x00, 0x1B, 0x01, 0x80, 0x0E, 0x80, 0x30, 0x03,
  0x20, 0x0C, 0x03, 0x98, 0x01, 0xC1, 0xC6, 0x00, 0x3F, 0xC1, 0x80, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x18, 0x7F, 0x01, 0x1C, 0x00, 0x13,
  0x80, 0x01, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x28, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x60, 0x01, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x1C, 0x0F, 0x01, 0xE0, 0x0F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xF0, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x10, 0x1F, 0xC0, 0x1C, 0x00, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x10, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10,
  0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x02,
  0x02, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x10, 0x00, 0x38, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x1E, 0x06, 0x00, 0x0A, 0x03, 0x00, 0x0D, 0x00, 0xC0,
  0x0D, 0x80, 0x60, 0x0C, 0xC0, 0x1C, 0x1C, 0x40, 0x07, 0xF8, 0x20, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x04, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x30, 0x04, 0x03, 0x00,
  0x40, 0x60, 0x04, 0x06, 0x00, 0x40, 0xC0, 0x04, 0x0C, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xD8, 0x00, 0x38, 0x00, 0x6C,
  0x00, 0x3C, 0x00, 0x26, 0x00, 0x16, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x19,
  0x80, 0x09, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x04,
  0x30, 0x06, 0x30, 0x06, 0x18, 0x03, 0x18, 0x02, 0x0C, 0x01, 0x0C, 0x03,
  0x06, 0x01, 0x82, 0x01, 0x83, 0x00, 0x81, 0x01, 0x81, 0x80, 0xC0, 0x80,
  0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x60, 0x30, 0x30, 0x10,
  0x30, 0x18, 0x30, 0x08, 0x30, 0x0C, 0x18, 0x04, 0x18, 0x06, 0x08, 0x02,
  0x08, 0x03, 0x0C, 0x01, 0x0C, 0x01, 0x84, 0x00, 0x84, 0x00, 0xC6, 0x00,
  0x46, 0x00, 0x63, 0x00, 0x23, 0x00, 0x33, 0x00, 0x11, 0x00, 0x19, 0x80,
  0x09, 0x80, 0x0D, 0x80, 0x04, 0x80, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0x40,
  0x01, 0x60, 0x01, 0xE0, 0x00, 0xA0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x04, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x5C, 0x1E,
  0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF4, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 48, 14, 1, -48 },
  { 79, 13, 17, 18, 7, -48 },
  { 107, 29, 48, 29, 1, -48 },
  { 281, 26, 55, 27, 1, -51 },
  { 460, 33, 50, 40, 4, -49 },
  { 667, 27, 50, 29, 0, -49 },
  { 836, 5, 17, 10, 7, -48 },
  { 847, 18, 59, 16, 2, -48 },
  { 980, 18, 59, 16, -4, -48 },
  { 1113, 20, 21, 26, 8, -51 },
  { 1166, 25, 31, 30, 3, -39 },
  { 1263, 9, 16, 11, -3, -7 },
  { 1281, 15, 2, 19, 2, -19 },
  { 1285, 4, 4, 11, 1, -4 },
  { 1287, 28, 48, 20, -3, -48 },
  { 1455, 25, 50, 27, 2, -49 },
  { 1612, 12, 48, 27, 9, -48 },
  { 1684, 27, 49, 27, -1, -49 },
  { 1850, 28, 50, 27, -1, -49 },
  { 2025, 28, 48, 27, -1, -48 },
  { 2193, 28, 49, 27, -1, -48 },
  { 2365, 26, 50, 27, 2, -49 },
  { 2528, 25, 48, 27, 4, -48 },
  { 2678, 27, 50, 27, 0, -49 },
  { 2847, 25, 50, 27, 1, -49 },
  { 3004, 10, 36, 11, 1, -36 },
  { 3049, 14, 45, 12, -3, -36 },
  { 3128, 25, 28, 30, 3, -38 },
  { 3216, 25, 16, 30, 3, -32 },
  { 3266, 25, 28, 30, 3, -38 },
  { 3354, 20, 49, 19, 2, -49 },
  { 3477, 37, 54, 41, 2, -48 },
  { 3727, 26, 48, 26, -4, -48 },
  { 3883, 28, 48, 30, 1, -48 },
  { 4051, 29, 50, 28, 3, -49 },
  { 4233, 30, 48, 33, 1, -48 },
  { 4413, 28, 48, 27, 1, -48 },
  { 4581, 28, 48, 24, 1, -48 },
  { 4749, 33, 50, 35, 3, -49 },
  { 4956, 34, 48, 34, 1, -48 },
  { 5160, 20, 48, 13, -3, -48 },
  { 5280, 23, 60, 12, -10, -48 },
  { 5453, 31, 48, 27, 1, -48 },
  { 5639, 18, 48, 24, 1, -48 },
  { 5747, 43, 48, 44, 1, -48 },
  { 6005, 35, 48, 35, 1, -48 },
  { 6215, 31, 50, 35, 3, -49 },
  { 6409, 27, 48, 28, 1, -48 },
  { 6571, 31, 60, 35, 3, -49 },
  { 6804, 27, 48, 28, 1, -48 },
  { 6966, 28, 50, 26, -1, -49 },
  { 7141, 23, 48, 24, 6, -48 },
  { 7279, 32, 49, 34, 3, -48 },
  { 7475, 26, 48, 27, 6, -48 },
  { 7631, 43, 48, 45, 6, -48 },
  { 7889, 33, 48, 24, -4, -48 },
  { 8087, 23, 48, 23, 6, -48 },
  { 8225, 31, 48, 25, -2, -48 },
  { 8411, 24, 59, 19, -1, -48 },
  { 8588, 9, 48, 21, 7, -48 },
  { 8642, 24, 59, 19, -4, -48 },
  { 8819, 26, 25, 29, 2, -48 },
  { 8901, 19, 2, 20, -5, 6 },
  { 8906, 6, 10, 14, 10, -51 },
  { 8914, 26, 37, 29, 2, -36 },
  { 9035, 26, 52, 29, 1, -51 },
  { 9204, 21, 37, 22, 2, -36 },
  { 9302, 29, 52, 29, 2, -51 },
  { 9491, 22, 37, 25, 2, -36 },
  { 9593, 31, 67, 14, -9, -51 },
  { 9853, 28, 52, 29, 0, -36 },
  { 10035, 24, 51, 28, 1, -51 },
  { 10188, 12, 48, 11, 1, -48 },
  { 10260, 22, 64, 12, -9, -48 },
  { 10436, 24, 51, 23, 1, -51 },
  { 10589, 12, 51, 11, 1, -51 },
  { 10666, 39, 36, 42, 1, -36 },
  { 10842, 24, 36, 28, 1, -36 },
  { 10950, 24, 37, 28, 2, -36 },
  { 11061, 29, 51, 29, -2, -36 },
  { 11246, 26, 52, 29, 2, -36 },
  { 11415, 20, 36, 18, 1, -36 },
  { 11505, 22, 37, 21, -1, -36 },
  { 11607, 14, 45, 15, 2, -44 },
  { 11686, 25, 36, 28, 2, -35 },
  { 11799, 20, 35, 21, 4, -35 },
  { 11887, 33, 35, 35, 4, -35 },
  { 12032, 27, 35, 22, -3, -35 },
  { 12151, 33, 51, 22, -8, -35 },
  { 12362, 23, 35, 20, -2, -35 },
  { 12463, 23, 59, 21, 2, -48 },
  { 12633, 2, 67, 27, 13, -51 },
  { 12650, 23, 59, 21, -4, -48 },
  { 12820, 25, 6, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_THINITALIC67PT7B_H_
