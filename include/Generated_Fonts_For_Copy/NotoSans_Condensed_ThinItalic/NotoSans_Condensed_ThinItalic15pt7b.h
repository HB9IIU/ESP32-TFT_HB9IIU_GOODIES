#ifndef _NOTOSANS_CONDENSED_THINITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0x55, 0xAA, 0x12, 0x28, 0x53, 0xF2,
  0x85, 0x0A, 0x7E, 0x50, 0xA2, 0x40, 0x08, 0xF5, 0x14, 0x30, 0x41, 0x0A,
  0x2A, 0xE6, 0x10, 0x63, 0x2A, 0x55, 0x4A, 0xF7, 0x76, 0x95, 0x52, 0xA6,
  0x30, 0x18, 0x92, 0x4A, 0x30, 0x85, 0x65, 0x8A, 0x2F, 0x80, 0x5A, 0x08,
  0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x04, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x12, 0x24, 0x80, 0x2B, 0x4A, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x58, 0xF0,
  0x80, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x18,
  0x94, 0x51, 0x45, 0x18, 0x62, 0x8A, 0x27, 0x00, 0x3C, 0xA4, 0x92, 0x92,
  0x00, 0x38, 0x10, 0x41, 0x04, 0x21, 0x08, 0x42, 0x0F, 0x00, 0x38, 0x10,
  0x41, 0x08, 0xC0, 0x82, 0x08, 0x2F, 0x00, 0x04, 0x31, 0x45, 0x29, 0x24,
  0xA2, 0x74, 0x41, 0x00, 0x3C, 0x82, 0x10, 0x70, 0x20, 0x82, 0x08, 0x2F,
  0x00, 0x3A, 0x11, 0x0E, 0x4A, 0x31, 0x94, 0xB8, 0x7C, 0x20, 0x84, 0x10,
  0x82, 0x10, 0x42, 0x08, 0x00, 0x18, 0x94, 0x51, 0x28, 0xC4, 0xA2, 0x8A,
  0x27, 0x00, 0x18, 0x94, 0x51, 0x45, 0x13, 0xC2, 0x08, 0x4E, 0x00, 0x40,
  0x02, 0x20, 0x00, 0x02, 0x50, 0x1B, 0x20, 0x83, 0x04, 0xF8, 0x3E, 0xC1,
  0x82, 0x26, 0x40, 0x70, 0x42, 0x11, 0x11, 0x08, 0x00, 0x20, 0x1E, 0x21,
  0x41, 0x9D, 0xA5, 0xA5, 0xA9, 0xCA, 0xDA, 0xA4, 0x80, 0xF0, 0x04, 0x30,
  0xC5, 0x14, 0x93, 0xD1, 0x46, 0x18, 0x40, 0x3C, 0x44, 0x89, 0x14, 0x4F,
  0x11, 0x22, 0x85, 0x13, 0xC0, 0x1C, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x0F, 0x00, 0x3C, 0x44, 0x89, 0x14, 0x28, 0x50, 0xA1, 0x85, 0x13, 0xC0,
  0x3E, 0x40, 0x81, 0x04, 0x0F, 0x10, 0x20, 0x81, 0x03, 0xC0, 0x3E, 0x40,
  0x81, 0x04, 0x0F, 0x10, 0x20, 0x81, 0x02, 0x00, 0x1E, 0x41, 0x04, 0x08,
  0x11, 0x21, 0x42, 0x85, 0x09, 0xE0, 0x21, 0x21, 0x21, 0x22, 0x42, 0x7E,
  0x42, 0x42, 0x84, 0x84, 0x84, 0x18, 0x84, 0x22, 0x10, 0x84, 0x22, 0x38,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x60, 0x22, 0x48, 0x91,
  0x45, 0x0C, 0x14, 0x28, 0x89, 0x12, 0x20, 0x22, 0x22, 0x44, 0x44, 0x88,
  0xF0, 0x20, 0x48, 0x12, 0x08, 0x85, 0x51, 0x94, 0xA5, 0x29, 0x52, 0x95,
  0x26, 0x48, 0x90, 0x21, 0x21, 0x31, 0x31, 0x52, 0x4A, 0x4A, 0x4A, 0x8A,
  0x84, 0x84, 0x38, 0x89, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0x13, 0xC0,
  0x38, 0x92, 0x49, 0x45, 0x27, 0x10, 0x82, 0x08, 0x00, 0x38, 0x89, 0x0C,
  0x18, 0x30, 0x61, 0x42, 0x85, 0x13, 0x41, 0x01, 0x02, 0x00, 0x38, 0x92,
  0x49, 0x45, 0x27, 0x14, 0x8A, 0x28, 0x80, 0x3D, 0x04, 0x10, 0x20, 0x81,
  0x02, 0x08, 0x2F, 0x00, 0xF9, 0x08, 0x42, 0x21, 0x08, 0x44, 0x20, 0x42,
  0x85, 0x0C, 0x28, 0x50, 0xA1, 0x44, 0x89, 0x13, 0xC0, 0x86, 0x18, 0xA2,
  0x8A, 0x49, 0x28, 0xA3, 0x04, 0x00, 0x84, 0x62, 0x18, 0x8A, 0x52, 0x94,
  0xA5, 0x4A, 0x52, 0x98, 0xC6, 0x31, 0x08, 0x40, 0x22, 0x24, 0x50, 0xA0,
  0x82, 0x04, 0x14, 0x48, 0x92, 0x20, 0x86, 0x28, 0xA4, 0x61, 0x04, 0x10,
  0x42, 0x08, 0x00, 0x3C, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0x0F, 0x00,
  0x19, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x0C, 0x00, 0xAA, 0xAA, 0x94,
  0x18, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x4E, 0x00, 0x10, 0x62, 0x89,
  0x46, 0x10, 0xF0, 0x90, 0x7C, 0x63, 0x18, 0xCA, 0x5E, 0x20, 0x82, 0x17,
  0x65, 0x14, 0x51, 0x86, 0x2F, 0x00, 0x78, 0x88, 0x88, 0x8E, 0x04, 0x10,
  0x5E, 0x8A, 0x28, 0xA2, 0x92, 0x4F, 0x00, 0x79, 0x9E, 0x88, 0x8E, 0x0E,
  0x10, 0x20, 0xE1, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x20,
  0x00, 0x3D, 0x14, 0x51, 0x86, 0x28, 0x9E, 0x08, 0x21, 0x38, 0x20, 0x82,
  0x1F, 0x45, 0x14, 0x52, 0x8A, 0x28, 0x80, 0x20, 0x24, 0x92, 0x92, 0x00,
  0x08, 0x00, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x22, 0x00, 0x20, 0x82,
  0x11, 0x49, 0x46, 0x14, 0x92, 0x49, 0x00, 0x24, 0xA4, 0x92, 0x92, 0x00,
  0x7B, 0xA2, 0x51, 0x29, 0x14, 0x8C, 0x4A, 0x25, 0x22, 0x7D, 0x14, 0x51,
  0x4A, 0x28, 0xA2, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x2E, 0x64, 0x89, 0x12,
  0x28, 0x51, 0x3C, 0x40, 0x82, 0x00, 0x7C, 0x63, 0x18, 0xCA, 0x5E, 0x10,
  0x88, 0x40, 0x5B, 0x10, 0x84, 0x42, 0x10, 0x7A, 0x10, 0x82, 0x08, 0x5C,
  0x22, 0x54, 0x44, 0x48, 0x8C, 0x8C, 0x63, 0x19, 0x4A, 0x5C, 0x99, 0x9A,
  0xAC, 0x88, 0x93, 0x26, 0xCD, 0xAD, 0x5B, 0x22, 0x48, 0x24, 0x91, 0x84,
  0x10, 0xC4, 0xA2, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18, 0x18, 0x10, 0x10,
  0x20, 0x20, 0xC0, 0x78, 0x84, 0x44, 0x22, 0x1C, 0x0C, 0x41, 0x08, 0x20,
  0x8C, 0x10, 0x41, 0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x42, 0x11, 0x08,
  0x22, 0x11, 0x08, 0x4E, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 7, 11, 7, 0, -11 },
  { 18, 6, 12, 6, 0, -11 },
  { 27, 7, 11, 9, 1, -11 },
  { 37, 6, 11, 6, 0, -11 },
  { 46, 2, 4, 2, 1, -11 },
  { 47, 5, 13, 4, 0, -11 },
  { 56, 4, 13, 4, -1, -11 },
  { 63, 4, 4, 6, 2, -11 },
  { 65, 5, 7, 7, 1, -9 },
  { 70, 2, 3, 2, -1, -1 },
  { 71, 4, 1, 4, 0, -5 },
  { 72, 1, 1, 3, 0, -1 },
  { 73, 7, 11, 4, -1, -11 },
  { 83, 6, 11, 6, 0, -11 },
  { 92, 3, 11, 6, 2, -11 },
  { 97, 6, 11, 6, 0, -11 },
  { 106, 6, 11, 6, 0, -11 },
  { 115, 6, 11, 6, 0, -11 },
  { 124, 6, 11, 6, 0, -11 },
  { 133, 5, 11, 6, 1, -11 },
  { 140, 6, 11, 6, 1, -11 },
  { 149, 6, 11, 6, 0, -11 },
  { 158, 6, 11, 6, 0, -11 },
  { 167, 2, 8, 3, 0, -8 },
  { 169, 3, 10, 3, -1, -8 },
  { 173, 5, 6, 7, 1, -8 },
  { 177, 5, 3, 7, 1, -7 },
  { 179, 5, 6, 7, 1, -8 },
  { 183, 5, 11, 4, 0, -11 },
  { 190, 8, 12, 9, 1, -11 },
  { 202, 6, 11, 6, -1, -11 },
  { 211, 7, 11, 7, 0, -11 },
  { 221, 6, 11, 6, 1, -11 },
  { 230, 7, 11, 7, 0, -11 },
  { 240, 7, 11, 6, 0, -11 },
  { 250, 7, 11, 5, 0, -11 },
  { 260, 7, 11, 8, 1, -11 },
  { 270, 8, 11, 8, 0, -11 },
  { 281, 5, 11, 3, -1, -11 },
  { 288, 5, 14, 3, -2, -11 },
  { 297, 7, 11, 6, 0, -11 },
  { 307, 4, 11, 5, 0, -11 },
  { 313, 10, 11, 10, 0, -11 },
  { 327, 8, 11, 8, 0, -11 },
  { 338, 7, 11, 8, 1, -11 },
  { 348, 6, 11, 6, 0, -11 },
  { 357, 7, 14, 8, 1, -11 },
  { 370, 6, 11, 6, 0, -11 },
  { 379, 6, 11, 6, 0, -11 },
  { 388, 5, 11, 5, 1, -11 },
  { 395, 7, 11, 8, 1, -11 },
  { 405, 6, 11, 6, 1, -11 },
  { 414, 10, 11, 10, 1, -11 },
  { 428, 7, 11, 5, -1, -11 },
  { 438, 6, 11, 5, 1, -11 },
  { 447, 6, 11, 6, 0, -11 },
  { 456, 5, 13, 4, 0, -11 },
  { 465, 2, 11, 5, 2, -11 },
  { 468, 5, 13, 4, -1, -11 },
  { 477, 6, 6, 7, 0, -11 },
  { 482, 4, 1, 4, -1, 1 },
  { 483, 2, 2, 3, 2, -11 },
  { 484, 5, 8, 6, 1, -8 },
  { 489, 6, 11, 6, 0, -11 },
  { 498, 4, 8, 5, 1, -8 },
  { 502, 6, 11, 7, 1, -11 },
  { 511, 4, 8, 6, 1, -8 },
  { 515, 7, 15, 3, -2, -11 },
  { 529, 6, 12, 7, 0, -8 },
  { 538, 6, 11, 6, 0, -11 },
  { 547, 3, 11, 3, 0, -11 },
  { 552, 5, 15, 3, -2, -11 },
  { 562, 6, 11, 5, 0, -11 },
  { 571, 3, 11, 2, 0, -11 },
  { 576, 9, 8, 10, 0, -8 },
  { 585, 6, 8, 6, 0, -8 },
  { 591, 5, 8, 6, 1, -8 },
  { 596, 7, 11, 6, -1, -8 },
  { 606, 5, 12, 7, 1, -8 },
  { 614, 5, 8, 4, 0, -8 },
  { 619, 5, 8, 5, 0, -8 },
  { 624, 4, 10, 3, 0, -10 },
  { 629, 5, 8, 6, 1, -8 },
  { 634, 4, 8, 5, 1, -8 },
  { 638, 7, 8, 8, 1, -8 },
  { 645, 6, 8, 5, -1, -8 },
  { 651, 8, 12, 5, -2, -8 },
  { 663, 5, 8, 4, 0, -8 },
  { 668, 6, 13, 5, 0, -11 },
  { 678, 1, 15, 6, 3, -11 },
  { 680, 5, 13, 5, -1, -11 },
  { 689, 5, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_THINITALIC15PT7B_H_
