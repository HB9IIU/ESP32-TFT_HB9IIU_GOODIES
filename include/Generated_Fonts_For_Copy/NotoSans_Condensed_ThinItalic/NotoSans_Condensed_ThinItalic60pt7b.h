#ifndef _NOTOSANS_CONDENSED_THINITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x31, 0x03, 0x10, 0x23, 0x02,
  0x30, 0x62, 0x06, 0x20, 0x62, 0x04, 0x60, 0x46, 0x0C, 0x40, 0xC4, 0x08,
  0x40, 0x8C, 0x08, 0x81, 0x88, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x60, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03,
  0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x18, 0x00, 0x18, 0x04, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x30, 0x08,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x40, 0x00, 0x60,
  0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x80, 0x60, 0x00, 0x60, 0x10, 0x00, 0x18, 0x04, 0x00, 0x04, 0x03, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30,
  0x08, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x60, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x20, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x78, 0x87, 0x00, 0xE0, 0x81, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03,
  0x01, 0x00, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xE4, 0x00, 0x00, 0x74, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00,
  0x20, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00,
  0x40, 0xC0, 0x80, 0x41, 0x80, 0xF0, 0x47, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x60, 0x30, 0xC0, 0x02,
  0x03, 0x06, 0x00, 0x30, 0x30, 0x10, 0x01, 0x01, 0x80, 0xC0, 0x18, 0x18,
  0x06, 0x00, 0x80, 0xC0, 0x30, 0x0C, 0x04, 0x01, 0x80, 0xC0, 0x60, 0x08,
  0x06, 0x03, 0x00, 0x40, 0x60, 0x10, 0x02, 0x02, 0x01, 0x80, 0x30, 0x30,
  0x0C, 0x01, 0x81, 0x00, 0x60, 0x0C, 0x18, 0x03, 0x00, 0x41, 0x80, 0x10,
  0x02, 0x0C, 0x00, 0x80, 0x30, 0xC0, 0x04, 0x01, 0x84, 0x1F, 0x20, 0x08,
  0x61, 0xDD, 0x00, 0xC2, 0x18, 0x28, 0x06, 0x31, 0x81, 0xC0, 0x63, 0x18,
  0x0E, 0x03, 0x18, 0xC0, 0x78, 0x31, 0x8C, 0x03, 0xE3, 0x08, 0x60, 0x1B,
  0xF0, 0xC2, 0x00, 0xC0, 0x04, 0x30, 0x06, 0x00, 0x61, 0x80, 0x30, 0x06,
  0x0C, 0x01, 0x00, 0x30, 0x40, 0x08, 0x03, 0x06, 0x00, 0xC0, 0x10, 0x30,
  0x06, 0x01, 0x81, 0x80, 0x30, 0x08, 0x0C, 0x01, 0x00, 0xC0, 0x60, 0x18,
  0x04, 0x02, 0x00, 0xC0, 0x60, 0x10, 0x04, 0x06, 0x00, 0x80, 0x60, 0x30,
  0x04, 0x03, 0x03, 0x00, 0x30, 0x30, 0x10, 0x01, 0x83, 0x01, 0x80, 0x06,
  0x38, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x20, 0x08,
  0x00, 0x60, 0x08, 0x00, 0x60, 0x08, 0x00, 0x40, 0x08, 0x00, 0x40, 0x18,
  0x00, 0x40, 0x18, 0x00, 0x40, 0x18, 0x00, 0x40, 0x30, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x63, 0x80,
  0x00, 0x27, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0x88, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x04, 0x00,
  0x0C, 0x06, 0x03, 0x18, 0x06, 0x03, 0x10, 0x02, 0x02, 0x30, 0x03, 0x06,
  0x20, 0x01, 0x04, 0x60, 0x01, 0x8C, 0x60, 0x01, 0x8C, 0x40, 0x00, 0x98,
  0xC0, 0x00, 0xD0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xE0, 0x40, 0x01, 0xB0, 0x60, 0x03, 0x30, 0x70, 0x06, 0x10,
  0x38, 0x1C, 0x18, 0x1F, 0xF0, 0x08, 0x03, 0x00, 0x00, 0x18, 0x84, 0x63,
  0x10, 0x84, 0x63, 0x10, 0x84, 0x62, 0x10, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x40, 0x40, 0x3C, 0x10,
  0x01, 0x84, 0x00, 0x19, 0x03, 0x03, 0x9F, 0x80, 0x38, 0x00, 0x14, 0x00,
  0x09, 0x00, 0x0C, 0x20, 0x06, 0x0C, 0x03, 0x01, 0x01, 0x80, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x30,
  0x60, 0xC3, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x00, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE1, 0xC0, 0x06,
  0x03, 0x00, 0x30, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x20, 0x30, 0x00,
  0xC0, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00,
  0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40,
  0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x18, 0x04, 0x00, 0x40, 0x18, 0x03, 0x00, 0x20, 0x18, 0x00, 0xE1, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x1C, 0x0F, 0x83, 0x20,
  0xC4, 0x71, 0x98, 0x36, 0x06, 0x80, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x0E,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1E, 0x07, 0x00, 0x3C, 0x01, 0x80, 0x18, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x80, 0x03, 0x80, 0x78, 0x07, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x10, 0x10, 0x00, 0x18, 0x08, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x00, 0x80,
  0x04, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x00, 0x06, 0x01, 0x80, 0x02,
  0x01, 0x80, 0x01, 0x00, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x06, 0x00, 0xE0, 0x1C, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFC,
  0x00, 0x38, 0x08, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC3, 0xF8,
  0x01, 0x8F, 0x1C, 0x02, 0x70, 0x0C, 0x05, 0x80, 0x0C, 0x1A, 0x00, 0x18,
  0x38, 0x00, 0x10, 0x70, 0x00, 0x20, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC2,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60,
  0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x10, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x60, 0x06, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x70, 0x00, 0x7F, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01,
  0x01, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0x03,
  0x01, 0x00, 0x03, 0x01, 0x00, 0x02, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x60, 0x00, 0x31, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x76, 0x00, 0x01, 0xC3, 0x00,
  0x03, 0x81, 0x80, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10,
  0x40, 0x00, 0x10, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x01, 0x03,
  0x00, 0x02, 0x04, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00,
  0x02, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0xE1, 0x80, 0x03, 0x81, 0x00, 0x05, 0x03, 0x00, 0x1A, 0x03, 0x00, 0xEC,
  0x03, 0x87, 0x18, 0x03, 0xFC, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x01, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x01,
  0xC0, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x03, 0x01, 0x80, 0x00, 0x10,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0x03, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x01,
  0xC0, 0x18, 0x60, 0x07, 0xFC, 0x04, 0x30, 0x06, 0x06, 0x02, 0x30, 0x06,
  0x02, 0x01, 0x18, 0x06, 0x03, 0x01, 0x88, 0x06, 0x01, 0x80, 0xCC, 0x03,
  0x00, 0xC0, 0x66, 0x03, 0x00, 0x40, 0x32, 0x01, 0x00, 0x60, 0x1B, 0x01,
  0x80, 0x30, 0x09, 0x80, 0xC0, 0x18, 0x04, 0xC0, 0x40, 0x08, 0x06, 0x40,
  0x60, 0x0C, 0x03, 0x20, 0x30, 0x06, 0x01, 0xB0, 0x18, 0x03, 0x00, 0x98,
  0x08, 0x03, 0x00, 0xCC, 0x04, 0x01, 0x80, 0x46, 0x02, 0x00, 0xC0, 0x63,
  0x01, 0x00, 0xE0, 0x31, 0x80, 0x80, 0x70, 0x30, 0xC0, 0x60, 0x58, 0x10,
  0x60, 0x30, 0x64, 0x18, 0x30, 0x0C, 0x63, 0x38, 0x18, 0x03, 0xE0, 0xF0,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x34, 0x00, 0x00, 0x24, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x44, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x84, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x10, 0x06, 0x00, 0x30, 0x06, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x06, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x02, 0x01,
  0x80, 0x02, 0x01, 0x80, 0x02, 0x03, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02,
  0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x10, 0x03, 0x80, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x20, 0x20, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x04, 0x00,
  0x04, 0x02, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x0E, 0x00, 0xC0,
  0x7C, 0x00, 0x7F, 0xF0, 0x00, 0x20, 0x1F, 0x00, 0x30, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x08, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x80, 0x03, 0x80, 0x40, 0x03, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x1C,
  0x00, 0x70, 0x02, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0x00, 0x78, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x03, 0x00, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x20, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x60, 0x10, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x70, 0x02, 0x00, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x80, 0x3F, 0xFF, 0x80, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xF0, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x01, 0xC0, 0x1E,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x10,
  0x07, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x0C,
  0x00, 0x08, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x67, 0x00, 0x00, 0x04, 0xD0,
  0x00, 0x00, 0x59, 0x80, 0x00, 0x0D, 0x18, 0x00, 0x00, 0xE0, 0x80, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10, 0x03, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x20,
  0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x0D, 0x80, 0x2C, 0x00, 0x00, 0x1A, 0x00, 0x48, 0x00, 0x00, 0x6C,
  0x01, 0x90, 0x00, 0x00, 0xD8, 0x03, 0x20, 0x00, 0x03, 0x30, 0x04, 0x40,
  0x00, 0x06, 0x40, 0x08, 0x80, 0x00, 0x18, 0x80, 0x31, 0x00, 0x00, 0x33,
  0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x01, 0x0C,
  0x00, 0x06, 0x10, 0x02, 0x18, 0x00, 0x08, 0x20, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x18, 0x20, 0x00, 0x41, 0x80, 0x30, 0x40, 0x01, 0x83, 0x00, 0x40,
  0x80, 0x02, 0x04, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x03, 0x02, 0x00, 0x10,
  0x30, 0x06, 0x04, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x10,
  0x18, 0x03, 0x01, 0x00, 0x60, 0x30, 0x04, 0x06, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x04,
  0x01, 0x01, 0x00, 0x40, 0x18, 0x02, 0x06, 0x01, 0x80, 0x30, 0x04, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x30, 0x06, 0x00, 0x80, 0x10, 0xC0, 0x08, 0x01,
  0x00, 0x31, 0x80, 0x10, 0x06, 0x00, 0x66, 0x00, 0x60, 0x0C, 0x00, 0xCC,
  0x00, 0xC0, 0x18, 0x01, 0xB0, 0x01, 0x80, 0x20, 0x03, 0x60, 0x02, 0x00,
  0xC0, 0x07, 0x80, 0x04, 0x01, 0x80, 0x07, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x10, 0x07, 0x80, 0x00, 0x20, 0x0F, 0x00, 0x00, 0xC0, 0x1A,
  0x00, 0x01, 0x80, 0x24, 0x00, 0x03, 0x00, 0x4C, 0x00, 0x04, 0x01, 0x98,
  0x00, 0x08, 0x03, 0x10, 0x00, 0x30, 0x04, 0x20, 0x00, 0x60, 0x08, 0x60,
  0x00, 0xC0, 0x30, 0xC0, 0x01, 0x00, 0x60, 0x80, 0x02, 0x00, 0xC1, 0x80,
  0x0C, 0x01, 0x03, 0x00, 0x18, 0x02, 0x06, 0x00, 0x30, 0x0C, 0x04, 0x00,
  0x40, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0x40, 0x30, 0x06,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x60, 0x10, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x01, 0x80, 0xC0, 0x10, 0x01, 0x01, 0x80, 0x60, 0x03, 0x02, 0x00,
  0xC0, 0x06, 0x04, 0x01, 0x80, 0x0C, 0x18, 0x02, 0x00, 0x08, 0x30, 0x04,
  0x00, 0x18, 0x60, 0x18, 0x00, 0x30, 0x80, 0x30, 0x00, 0x23, 0x00, 0x60,
  0x00, 0x46, 0x00, 0x80, 0x00, 0xCC, 0x01, 0x00, 0x01, 0x90, 0x06, 0x00,
  0x01, 0x20, 0x0C, 0x00, 0x02, 0xC0, 0x18, 0x00, 0x07, 0x80, 0x20, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x10, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x40, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80,
  0x01, 0x01, 0x80, 0x01, 0x01, 0x00, 0x01, 0x03, 0x00, 0x01, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x04, 0x00, 0x38, 0x04, 0x00,
  0x70, 0x0C, 0x01, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x40, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03,
  0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01,
  0x01, 0x00, 0x01, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x02, 0x02, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x04, 0x00, 0x30, 0x04, 0x00, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x02, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x30, 0x01, 0x00, 0x20, 0x01, 0x80,
  0x20, 0x01, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0xC0,
  0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x60,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0x81, 0xF0, 0x03, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x10, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x20, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40,
  0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x40,
  0x01, 0x80, 0x60, 0x01, 0x00, 0x60, 0x03, 0x00, 0x60, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x08, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20,
  0x80, 0x00, 0x21, 0x80, 0x00, 0x21, 0x00, 0x00, 0x23, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x24, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xA0, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x12, 0x00,
  0x03, 0xC0, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x03, 0x20, 0x00, 0x6C, 0x00,
  0x18, 0x80, 0x01, 0x30, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x08, 0x00,
  0x33, 0x00, 0x0C, 0x20, 0x00, 0x8C, 0x00, 0x20, 0x80, 0x06, 0x30, 0x01,
  0x82, 0x00, 0x10, 0xC0, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x30, 0x20, 0x02,
  0x0C, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x02, 0x02, 0x00, 0x60, 0xC0, 0x18,
  0x08, 0x01, 0x03, 0x00, 0x40, 0x20, 0x0C, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x08, 0x06, 0x03, 0x01, 0x80,
  0x20, 0x10, 0x0C, 0x04, 0x00, 0x80, 0xC0, 0x30, 0x30, 0x02, 0x02, 0x00,
  0xC0, 0xC0, 0x08, 0x18, 0x03, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x18, 0x00,
  0x83, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0xC3, 0x00, 0x08, 0x20, 0x03,
  0x08, 0x00, 0x21, 0x80, 0x0C, 0x60, 0x00, 0x84, 0x00, 0x31, 0x80, 0x02,
  0x30, 0x00, 0xC4, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0x26, 0x00, 0x0C,
  0x80, 0x00, 0x98, 0x00, 0x36, 0x00, 0x02, 0x40, 0x00, 0xD8, 0x00, 0x0B,
  0x00, 0x03, 0x40, 0x00, 0x28, 0x00, 0x0F, 0x00, 0x00, 0xA0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x10, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0xC4, 0x00,
  0x06, 0x30, 0x00, 0x61, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x01,
  0x00, 0x18, 0x08, 0x01, 0x80, 0x40, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x04,
  0x00, 0xC0, 0x60, 0x02, 0x06, 0x00, 0x10, 0x30, 0x00, 0x83, 0x00, 0x06,
  0x10, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x2C, 0x00,
  0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xC0,
  0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x20, 0x30,
  0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08,
  0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02,
  0x02, 0x03, 0x03, 0x03, 0x01, 0x01, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x20, 0x40, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x66, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xC0,
  0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x10, 0x00, 0x3F, 0x86, 0x00,
  0xE3, 0x88, 0x07, 0x01, 0x90, 0x1C, 0x01, 0x20, 0x30, 0x03, 0xC0, 0xC0,
  0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x03, 0x00,
  0x0A, 0x02, 0x00, 0x34, 0x06, 0x00, 0xD8, 0x06, 0x03, 0x30, 0x0E, 0x0C,
  0x40, 0x0F, 0xF0, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC3, 0xF8, 0x01, 0x8E, 0x38, 0x03, 0x30, 0x18, 0x04, 0xC0, 0x18, 0x0B,
  0x00, 0x30, 0x3C, 0x00, 0x20, 0x78, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00, 0x03,
  0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x08, 0x38,
  0x00, 0x30, 0x50, 0x00, 0xC0, 0xA0, 0x01, 0x81, 0x60, 0x06, 0x06, 0x40,
  0x18, 0x08, 0xE0, 0xE0, 0x10, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x02,
  0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x03, 0xF8, 0x60, 0x01, 0xC7, 0x18, 0x01, 0xC0,
  0x66, 0x00, 0xE0, 0x0D, 0x00, 0x30, 0x01, 0x40, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x1C, 0x03, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x1C,
  0x03, 0x00, 0x0F, 0x00, 0xC0, 0x03, 0xC0, 0x10, 0x01, 0xA0, 0x06, 0x00,
  0xC8, 0x01, 0x80, 0x62, 0x00, 0x38, 0x31, 0x80, 0x07, 0xF8, 0x40, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x38, 0x07, 0x01, 0x81, 0xC0,
  0x30, 0x30, 0x02, 0x0C, 0x00, 0x43, 0x00, 0x08, 0x40, 0x03, 0x18, 0x00,
  0x62, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0xC2, 0x00, 0x30, 0xC0, 0x1C,
  0x18, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x04, 0x07, 0x03, 0x80, 0x7F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x0E, 0x38, 0xC0, 0x1C,
  0x06, 0x60, 0x1C, 0x01, 0xA0, 0x0C, 0x00, 0x50, 0x0C, 0x00, 0x28, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x04,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00,
  0x78, 0x0C, 0x00, 0x3C, 0x02, 0x00, 0x34, 0x01, 0x80, 0x32, 0x00, 0xC0,
  0x33, 0x00, 0x38, 0x31, 0x80, 0x0F, 0xF0, 0x80, 0x00, 0xC0, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x10, 0x01, 0x80, 0x0E, 0x07, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0xFE, 0x00, 0xC7, 0x1C,
  0x03, 0x70, 0x18, 0x0B, 0x00, 0x20, 0x28, 0x00, 0xC1, 0xE0, 0x03, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0x20, 0x60, 0x00, 0x81, 0x80, 0x02, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x08, 0x10, 0x00, 0x20, 0xC0,
  0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x01,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x04,
  0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x08, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x08, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x18, 0x08, 0x00, 0x40,
  0x60, 0x01, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x86, 0x00,
  0x02, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x66, 0x80, 0x01, 0xB3, 0x00, 0x05,
  0x8C, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0x40, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x20, 0x08, 0x00, 0x80, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x02, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x0F, 0xC0,
  0x7F, 0x00, 0x67, 0x1C, 0x1C, 0x70, 0x09, 0x80, 0xC6, 0x03, 0x01, 0x60,
  0x09, 0x80, 0x20, 0x28, 0x01, 0x60, 0x06, 0x0E, 0x00, 0x38, 0x00, 0xC1,
  0xC0, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00,
  0x40, 0xC0, 0x02, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x02, 0x00,
  0x08, 0x00, 0x20, 0xC0, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x00, 0x04, 0x18, 0x00, 0x20, 0x00,
  0x83, 0x00, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x80, 0x06, 0x08, 0x00, 0x20,
  0x00, 0x81, 0x00, 0x04, 0x00, 0x10, 0x60, 0x01, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x20, 0x00, 0x80, 0x02, 0x04,
  0x00, 0x10, 0x00, 0x41, 0x80, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x0F, 0xE0, 0x0C, 0x71, 0xC0, 0x27,
  0x01, 0x80, 0xB0, 0x02, 0x02, 0x80, 0x0C, 0x1E, 0x00, 0x30, 0x70, 0x00,
  0xC1, 0x80, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x01, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40, 0x00,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00, 0x3F, 0x80,
  0x07, 0x8E, 0x00, 0x70, 0x18, 0x06, 0x00, 0x60, 0x70, 0x01, 0x03, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08,
  0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00,
  0x60, 0x18, 0x07, 0x00, 0xE0, 0x70, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0xFC, 0x00, 0x18, 0xE3, 0x80, 0x04, 0x60, 0x30, 0x01, 0x30,
  0x06, 0x00, 0x58, 0x01, 0x80, 0x3C, 0x00, 0x20, 0x0F, 0x00, 0x0C, 0x03,
  0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x10, 0x00,
  0x08, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x20,
  0x00, 0x18, 0x18, 0x00, 0x04, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x20, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x04, 0x03, 0x80, 0x03,
  0x00, 0xE0, 0x01, 0x80, 0x28, 0x00, 0x60, 0x0B, 0x00, 0x30, 0x06, 0x40,
  0x18, 0x01, 0x9C, 0x1C, 0x00, 0x63, 0xFC, 0x00, 0x10, 0x1C, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x82, 0x00, 0xE3, 0x8C,
  0x07, 0x01, 0x98, 0x18, 0x01, 0xA0, 0x30, 0x03, 0x40, 0xC0, 0x02, 0x83,
  0x00, 0x07, 0x06, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x43, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x83, 0x00, 0x0F, 0x02,
  0x00, 0x34, 0x06, 0x00, 0xC8, 0x0C, 0x03, 0x30, 0x0E, 0x0C, 0x60, 0x0F,
  0xF0, 0x80, 0x03, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x0F, 0xC0, 0xC7, 0x10,
  0x27, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3C, 0x7C,
  0x0C, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC1, 0x00, 0x30, 0x30, 0x0E, 0x03, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x01, 0xFF, 0x7F, 0xF0, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x7E,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00,
  0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x04,
  0x08, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10,
  0x00, 0x20, 0x40, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x20, 0x00,
  0x40, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x00, 0x02, 0x04, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00,
  0x0E, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x40, 0xC0, 0x0D, 0x01, 0x00, 0x6C,
  0x07, 0x07, 0x20, 0x0F, 0xF0, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10,
  0x00, 0xC2, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20,
  0x04, 0x04, 0x01, 0x80, 0x80, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x60,
  0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0x90,
  0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x28, 0x00, 0xF0, 0x03, 0x40, 0x05, 0x80, 0x12, 0x00,
  0x6C, 0x01, 0x90, 0x02, 0x60, 0x0C, 0x80, 0x13, 0x00, 0x44, 0x01, 0x98,
  0x06, 0x20, 0x08, 0xC0, 0x21, 0x00, 0xC6, 0x03, 0x08, 0x04, 0x30, 0x10,
  0x40, 0x61, 0x81, 0x82, 0x02, 0x0C, 0x0C, 0x10, 0x30, 0x60, 0x40, 0x81,
  0x83, 0x06, 0x04, 0x08, 0x18, 0x20, 0x20, 0xC0, 0xC3, 0x01, 0x04, 0x06,
  0x18, 0x08, 0x60, 0x10, 0x80, 0x42, 0x00, 0x8C, 0x02, 0x30, 0x04, 0x40,
  0x11, 0x00, 0x26, 0x00, 0x98, 0x01, 0x20, 0x04, 0xC0, 0x09, 0x00, 0x2C,
  0x00, 0x58, 0x01, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x80, 0x00, 0x21, 0x80, 0x00, 0x33, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x02, 0x02, 0x00, 0x06, 0x02, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x00, 0x30, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x00, 0x80, 0x06, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x87, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x1E, 0x07,
  0x00, 0xE0, 0x07, 0x8E, 0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 43, 12, 1, -43 },
  { 66, 12, 16, 16, 6, -43 },
  { 90, 26, 43, 26, 1, -43 },
  { 230, 24, 49, 24, 0, -46 },
  { 377, 29, 44, 36, 4, -43 },
  { 537, 24, 44, 26, 0, -43 },
  { 669, 5, 16, 9, 6, -43 },
  { 679, 16, 52, 14, 2, -43 },
  { 783, 16, 52, 15, -4, -43 },
  { 887, 18, 18, 23, 7, -45 },
  { 928, 22, 28, 27, 3, -35 },
  { 1005, 7, 14, 10, -2, -6 },
  { 1018, 13, 1, 17, 2, -17 },
  { 1020, 3, 4, 10, 1, -4 },
  { 1022, 25, 43, 18, -3, -43 },
  { 1157, 22, 44, 24, 2, -43 },
  { 1278, 11, 43, 24, 8, -43 },
  { 1338, 25, 43, 24, -1, -43 },
  { 1473, 25, 44, 24, -1, -43 },
  { 1611, 25, 43, 24, -1, -43 },
  { 1746, 24, 44, 24, 0, -43 },
  { 1878, 23, 45, 24, 2, -44 },
  { 2008, 22, 43, 24, 4, -43 },
  { 2127, 24, 44, 24, 0, -43 },
  { 2259, 23, 44, 24, 1, -43 },
  { 2386, 9, 32, 10, 1, -32 },
  { 2422, 13, 40, 10, -3, -32 },
  { 2487, 22, 25, 27, 3, -34 },
  { 2556, 22, 14, 27, 3, -28 },
  { 2595, 22, 25, 27, 3, -34 },
  { 2664, 17, 43, 17, 2, -43 },
  { 2756, 33, 48, 36, 2, -43 },
  { 2954, 24, 43, 24, -4, -43 },
  { 3083, 25, 43, 26, 1, -43 },
  { 3218, 26, 45, 25, 3, -44 },
  { 3365, 27, 43, 29, 1, -43 },
  { 3511, 25, 43, 24, 1, -43 },
  { 3646, 25, 43, 22, 1, -43 },
  { 3781, 29, 45, 31, 3, -44 },
  { 3945, 30, 43, 31, 1, -43 },
  { 4107, 18, 43, 12, -2, -43 },
  { 4204, 21, 53, 11, -9, -43 },
  { 4344, 28, 43, 24, 1, -43 },
  { 4495, 16, 43, 22, 1, -43 },
  { 4581, 39, 43, 39, 1, -43 },
  { 4791, 31, 43, 32, 1, -43 },
  { 4958, 27, 44, 32, 3, -43 },
  { 5107, 24, 43, 25, 1, -43 },
  { 5236, 27, 53, 32, 3, -43 },
  { 5415, 24, 43, 25, 1, -43 },
  { 5544, 26, 44, 23, -1, -43 },
  { 5687, 21, 43, 21, 5, -43 },
  { 5800, 28, 44, 30, 3, -43 },
  { 5954, 24, 43, 24, 5, -43 },
  { 6083, 38, 43, 40, 6, -43 },
  { 6288, 29, 43, 22, -3, -43 },
  { 6444, 21, 43, 21, 5, -43 },
  { 6557, 28, 43, 23, -2, -43 },
  { 6708, 22, 52, 17, -1, -43 },
  { 6851, 8, 43, 19, 6, -43 },
  { 6894, 22, 52, 17, -4, -43 },
  { 7037, 23, 22, 26, 2, -43 },
  { 7101, 18, 1, 18, -5, 6 },
  { 7104, 6, 10, 13, 9, -46 },
  { 7112, 23, 33, 26, 2, -32 },
  { 7207, 23, 47, 26, 1, -46 },
  { 7343, 19, 33, 19, 2, -32 },
  { 7422, 26, 47, 26, 2, -46 },
  { 7575, 19, 33, 23, 2, -32 },
  { 7654, 28, 60, 12, -8, -46 },
  { 7864, 25, 46, 26, 0, -32 },
  { 8008, 22, 46, 25, 1, -46 },
  { 8135, 11, 43, 10, 1, -43 },
  { 8195, 20, 57, 11, -8, -43 },
  { 8338, 22, 46, 20, 1, -46 },
  { 8465, 11, 46, 10, 1, -46 },
  { 8529, 35, 32, 38, 1, -32 },
  { 8669, 22, 32, 25, 1, -32 },
  { 8757, 21, 33, 25, 2, -32 },
  { 8844, 26, 46, 26, -2, -32 },
  { 8994, 23, 46, 26, 2, -32 },
  { 9127, 18, 32, 16, 1, -32 },
  { 9199, 19, 33, 19, 0, -32 },
  { 9278, 12, 40, 13, 2, -39 },
  { 9338, 22, 33, 25, 2, -32 },
  { 9429, 19, 32, 19, 3, -32 },
  { 9505, 29, 32, 31, 4, -32 },
  { 9621, 24, 32, 20, -2, -32 },
  { 9717, 30, 47, 20, -7, -32 },
  { 9894, 21, 32, 18, -2, -32 },
  { 9978, 20, 52, 19, 2, -43 },
  { 10108, 1, 61, 24, 12, -46 },
  { 10116, 21, 52, 19, -4, -43 },
  { 10253, 22, 5, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_THINITALIC60PT7B_H_
