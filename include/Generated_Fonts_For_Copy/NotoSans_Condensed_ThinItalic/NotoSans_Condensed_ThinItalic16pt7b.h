#ifndef _NOTOSANS_CONDENSED_THINITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0xB7, 0x60, 0x12, 0x24, 0x53, 0xF2,
  0x45, 0x0A, 0x6E, 0x50, 0xA2, 0x40, 0x08, 0x3C, 0xA2, 0x45, 0x06, 0x04,
  0x0C, 0x24, 0x52, 0xE3, 0x02, 0x00, 0x20, 0x52, 0x92, 0x94, 0x98, 0xAF,
  0xB5, 0x59, 0x29, 0x29, 0x4A, 0x8E, 0x18, 0x92, 0x49, 0x28, 0x43, 0x15,
  0x8E, 0x28, 0xBD, 0xF0, 0x18, 0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x04,
  0x20, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x25, 0x1E, 0xC9, 0x00,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x56, 0xF0, 0x80, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x32, 0x53, 0x18, 0xC6, 0x31,
  0x8C, 0xA5, 0xC0, 0x74, 0x94, 0x92, 0x92, 0x00, 0x18, 0x90, 0x41, 0x04,
  0x10, 0x84, 0x21, 0x08, 0x3E, 0x18, 0x90, 0x41, 0x04, 0x23, 0x82, 0x04,
  0x20, 0xBC, 0x04, 0x10, 0xC5, 0x14, 0x94, 0x92, 0xFC, 0x21, 0x04, 0x3C,
  0x82, 0x10, 0x70, 0x20, 0x41, 0x04, 0x2F, 0x00, 0x1C, 0x84, 0x10, 0x83,
  0xC8, 0xA2, 0x8A, 0x29, 0x38, 0x7C, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42,
  0x08, 0x00, 0x1C, 0x44, 0x8A, 0x12, 0x45, 0x0C, 0x24, 0x85, 0x0A, 0x23,
  0xC0, 0x18, 0x94, 0x51, 0x45, 0x14, 0xCD, 0x04, 0x21, 0x38, 0x20, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x44, 0x48, 0x0C, 0xC4, 0x20, 0x60, 0x60, 0x40,
  0xFC, 0x00, 0x3F, 0x81, 0x81, 0x83, 0x31, 0x08, 0x00, 0x61, 0x11, 0x12,
  0x48, 0x80, 0x08, 0x3F, 0x41, 0x41, 0x9D, 0xA5, 0xA5, 0xA5, 0xA9, 0xBE,
  0x80, 0x80, 0xF8, 0x04, 0x30, 0xC5, 0x14, 0x93, 0xD1, 0x46, 0x18, 0x40,
  0x3E, 0x44, 0x89, 0x16, 0x4B, 0x91, 0x22, 0x45, 0x0B, 0xE0, 0x1E, 0x41,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0xC0, 0x3E, 0x44, 0x89,
  0x14, 0x28, 0x50, 0xA1, 0x85, 0x1B, 0xC0, 0x3E, 0x40, 0x81, 0x07, 0xC8,
  0x10, 0x20, 0x81, 0x03, 0xE0, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x10, 0x20,
  0x81, 0x02, 0x00, 0x1E, 0x21, 0x40, 0x40, 0x80, 0x80, 0x8E, 0x82, 0x84,
  0x84, 0x84, 0x7C, 0x21, 0x21, 0x21, 0x21, 0x7D, 0x42, 0x42, 0x42, 0x82,
  0x82, 0x84, 0x18, 0x84, 0x22, 0x10, 0x84, 0x22, 0x38, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x60, 0x23, 0x24, 0x28, 0x28, 0x50, 0x70,
  0x50, 0x48, 0x88, 0x88, 0x84, 0x22, 0x22, 0x44, 0x44, 0x88, 0xF0, 0x20,
  0x64, 0x08, 0xC3, 0x18, 0x65, 0x14, 0xA2, 0x94, 0xA2, 0x94, 0x94, 0x92,
  0x92, 0x22, 0x00, 0x20, 0x98, 0x8C, 0x46, 0x24, 0x92, 0x49, 0x28, 0x94,
  0x86, 0x42, 0x21, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85,
  0x0A, 0x27, 0x80, 0x3E, 0x44, 0x89, 0x14, 0x4F, 0x10, 0x20, 0x41, 0x02,
  0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x27, 0x81,
  0x02, 0x04, 0x00, 0x3E, 0x44, 0x89, 0x14, 0x4F, 0x14, 0x24, 0x89, 0x12,
  0x20, 0x1E, 0x41, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x10, 0x27, 0x80,
  0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x00, 0x42, 0x85, 0x0C,
  0x18, 0x50, 0xA1, 0x42, 0x85, 0x13, 0xC0, 0x83, 0x0A, 0x14, 0x48, 0x92,
  0x24, 0x50, 0xA0, 0x81, 0x00, 0x88, 0x66, 0x29, 0x8A, 0x64, 0xA9, 0x2A,
  0x4C, 0xA3, 0x28, 0x8C, 0x23, 0x08, 0x80, 0x11, 0x12, 0x14, 0x14, 0x08,
  0x08, 0x18, 0x28, 0x48, 0x44, 0x84, 0x86, 0x24, 0x94, 0x61, 0x84, 0x10,
  0x41, 0x08, 0x00, 0x1F, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0xFC, 0x3C, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x83,
  0x80, 0xAA, 0xA9, 0x54, 0x1C, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x08, 0x23, 0x80, 0x30, 0xC4, 0xA2, 0x86, 0x10, 0xF0, 0x90, 0x35, 0x28,
  0xA2, 0x8A, 0x28, 0xA4, 0xF0, 0x20, 0x82, 0x0E, 0x65, 0x14, 0x51, 0x46,
  0x18, 0xBE, 0x3A, 0x21, 0x08, 0x42, 0x10, 0xF0, 0x04, 0x10, 0x4D, 0x4A,
  0x28, 0xA2, 0x8A, 0x29, 0x3C, 0x32, 0x63, 0x2E, 0x42, 0x10, 0xF0, 0x06,
  0x10, 0x20, 0xE0, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10,
  0x60, 0x18, 0x4D, 0x12, 0x24, 0x50, 0xA1, 0x44, 0x78, 0x10, 0x20, 0x8E,
  0x00, 0x20, 0x82, 0x0E, 0x25, 0x14, 0x51, 0x46, 0x28, 0xA2, 0x20, 0x14,
  0x92, 0x92, 0x00, 0x08, 0x00, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x23,
  0x00, 0x20, 0x82, 0x09, 0x29, 0x25, 0x18, 0x52, 0x49, 0x22, 0x24, 0x92,
  0x92, 0x52, 0x40, 0x19, 0x89, 0x94, 0x45, 0x11, 0x44, 0x92, 0x28, 0x8A,
  0x22, 0x88, 0x80, 0x18, 0x94, 0x51, 0x45, 0x18, 0xA2, 0x88, 0x32, 0x63,
  0x18, 0xC6, 0x32, 0xE0, 0x0C, 0x64, 0x89, 0x12, 0x24, 0x48, 0xA2, 0x7C,
  0x81, 0x04, 0x08, 0x00, 0x31, 0x38, 0xA2, 0x8A, 0x28, 0xA4, 0xF0, 0x41,
  0x04, 0x20, 0x19, 0x10, 0x84, 0x22, 0x10, 0x80, 0x3A, 0x10, 0x82, 0x08,
  0x42, 0xF0, 0x22, 0x34, 0x44, 0x44, 0x88, 0xC0, 0x8C, 0x63, 0x18, 0xCA,
  0x5E, 0x8C, 0xA5, 0x4A, 0x62, 0x10, 0x91, 0x92, 0xAA, 0xAA, 0xCC, 0xC8,
  0x88, 0x88, 0x26, 0x28, 0x60, 0x81, 0x05, 0x12, 0x44, 0x11, 0x12, 0x12,
  0x14, 0x14, 0x18, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x78, 0x84, 0x44,
  0x22, 0x1C, 0x1C, 0x41, 0x04, 0x20, 0x8C, 0x08, 0x41, 0x04, 0x10, 0x40,
  0x80, 0xFF, 0xFF, 0x18, 0x20, 0x82, 0x08, 0x40, 0xC4, 0x10, 0x42, 0x08,
  0x23, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 4, 2, -11 },
  { 8, 7, 11, 7, 0, -11 },
  { 18, 7, 13, 6, 0, -12 },
  { 30, 8, 12, 9, 1, -12 },
  { 42, 6, 12, 7, 0, -12 },
  { 51, 1, 4, 2, 2, -11 },
  { 52, 5, 14, 4, 0, -11 },
  { 61, 4, 14, 4, -1, -11 },
  { 68, 5, 5, 6, 2, -12 },
  { 72, 6, 7, 7, 1, -9 },
  { 78, 2, 4, 3, -1, -2 },
  { 79, 4, 1, 4, 0, -5 },
  { 80, 1, 1, 3, 0, -1 },
  { 81, 7, 11, 5, -1, -11 },
  { 91, 5, 12, 6, 1, -12 },
  { 99, 3, 11, 6, 2, -11 },
  { 104, 6, 12, 6, 0, -12 },
  { 113, 6, 12, 6, 0, -12 },
  { 122, 6, 12, 6, 0, -12 },
  { 131, 6, 11, 6, 0, -11 },
  { 140, 6, 12, 6, 1, -12 },
  { 149, 6, 11, 6, 1, -11 },
  { 158, 7, 12, 6, 0, -12 },
  { 169, 6, 12, 6, 0, -12 },
  { 178, 3, 8, 3, 0, -8 },
  { 181, 4, 10, 3, -1, -8 },
  { 186, 6, 7, 7, 1, -9 },
  { 192, 6, 4, 7, 1, -8 },
  { 195, 6, 7, 7, 1, -9 },
  { 201, 4, 12, 5, 1, -12 },
  { 207, 8, 12, 10, 1, -11 },
  { 219, 6, 11, 6, -1, -11 },
  { 228, 7, 11, 7, 0, -11 },
  { 238, 7, 12, 7, 1, -12 },
  { 249, 7, 11, 8, 0, -11 },
  { 259, 7, 11, 6, 0, -11 },
  { 269, 7, 11, 6, 0, -11 },
  { 279, 8, 12, 8, 1, -12 },
  { 291, 8, 11, 8, 0, -11 },
  { 302, 5, 11, 3, -1, -11 },
  { 309, 5, 14, 3, -2, -11 },
  { 318, 8, 11, 6, 0, -11 },
  { 329, 4, 11, 6, 0, -11 },
  { 335, 11, 11, 10, 0, -11 },
  { 351, 9, 11, 8, 0, -11 },
  { 364, 7, 12, 8, 1, -12 },
  { 375, 7, 11, 7, 0, -11 },
  { 385, 7, 15, 8, 1, -12 },
  { 399, 7, 11, 7, 0, -11 },
  { 409, 7, 12, 6, 0, -12 },
  { 420, 6, 11, 6, 1, -11 },
  { 429, 7, 11, 8, 1, -11 },
  { 439, 7, 11, 6, 1, -11 },
  { 449, 10, 11, 11, 2, -11 },
  { 463, 8, 11, 6, -1, -11 },
  { 474, 6, 11, 6, 1, -11 },
  { 483, 8, 11, 6, -1, -11 },
  { 494, 6, 14, 5, 0, -11 },
  { 505, 2, 11, 5, 2, -11 },
  { 508, 6, 14, 5, -1, -11 },
  { 519, 6, 6, 7, 1, -11 },
  { 524, 4, 1, 5, -1, 1 },
  { 525, 2, 2, 3, 2, -12 },
  { 526, 6, 9, 7, 1, -9 },
  { 533, 6, 12, 7, 0, -12 },
  { 542, 5, 9, 5, 1, -9 },
  { 548, 6, 12, 7, 1, -12 },
  { 557, 5, 9, 6, 1, -9 },
  { 563, 7, 16, 3, -2, -12 },
  { 577, 7, 13, 7, 0, -9 },
  { 589, 6, 12, 7, 0, -12 },
  { 598, 3, 11, 3, 0, -11 },
  { 603, 5, 15, 3, -2, -11 },
  { 613, 6, 12, 5, 0, -12 },
  { 622, 3, 12, 3, 0, -12 },
  { 627, 10, 9, 10, 0, -9 },
  { 639, 6, 9, 7, 0, -9 },
  { 646, 5, 9, 7, 1, -9 },
  { 652, 7, 13, 7, -1, -9 },
  { 664, 6, 13, 7, 1, -9 },
  { 674, 5, 9, 4, 0, -9 },
  { 680, 5, 9, 5, 0, -9 },
  { 686, 4, 11, 4, 0, -11 },
  { 692, 5, 8, 7, 1, -8 },
  { 697, 5, 8, 5, 1, -8 },
  { 702, 8, 8, 8, 1, -8 },
  { 710, 7, 8, 5, -1, -8 },
  { 717, 8, 12, 5, -2, -8 },
  { 729, 5, 8, 5, 0, -8 },
  { 734, 6, 14, 5, 0, -11 },
  { 745, 1, 16, 6, 3, -12 },
  { 747, 6, 14, 5, -1, -11 },
  { 758, 6, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_THINITALIC16PT7B_H_
