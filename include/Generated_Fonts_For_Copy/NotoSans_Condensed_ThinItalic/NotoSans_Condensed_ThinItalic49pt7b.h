#ifndef _NOTOSANS_CONDENSED_THINITALIC49PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x30, 0x00, 0x30, 0xC8, 0x22, 0x08, 0x82, 0x61, 0x90,
  0x44, 0x11, 0x04, 0x41, 0x30, 0xC8, 0x22, 0x08, 0x82, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00,
  0x10, 0x20, 0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x04,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x18, 0x10, 0x00, 0x80, 0x80, 0x04,
  0x0C, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80,
  0x0C, 0x08, 0x00, 0x40, 0x40, 0x02, 0x06, 0x03, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x08, 0x18, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01,
  0x03, 0x00, 0x18, 0x10, 0x00, 0x80, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x40,
  0x02, 0x02, 0x00, 0x10, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x0C, 0x47, 0x01, 0x84, 0x10,
  0x20, 0xC0, 0x06, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x04, 0x18, 0x00, 0x41, 0x00, 0x06, 0x10, 0x00, 0x21, 0x00, 0x03, 0x10,
  0x00, 0x1B, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x06,
  0xC0, 0x00, 0x46, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00,
  0xC1, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x82, 0x00,
  0x18, 0x60, 0x81, 0x0C, 0x0F, 0x97, 0x80, 0x1F, 0xC0, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x07, 0xC0,
  0x04, 0x0C, 0x60, 0x0C, 0x18, 0x20, 0x08, 0x10, 0x20, 0x18, 0x30, 0x20,
  0x10, 0x20, 0x20, 0x20, 0x60, 0x20, 0x60, 0x40, 0x20, 0x40, 0x40, 0x20,
  0xC0, 0x40, 0x20, 0x80, 0xC0, 0x61, 0x80, 0xC0, 0x61, 0x00, 0x80, 0x42,
  0x00, 0x80, 0x46, 0x00, 0x80, 0xC4, 0x3E, 0x80, 0x8C, 0x42, 0x80, 0x88,
  0x83, 0x81, 0x19, 0x83, 0x83, 0x11, 0x01, 0xC2, 0x23, 0x01, 0x7C, 0x22,
  0x03, 0x00, 0x42, 0x03, 0x00, 0xC6, 0x03, 0x00, 0x84, 0x02, 0x01, 0x84,
  0x02, 0x01, 0x04, 0x02, 0x03, 0x04, 0x06, 0x02, 0x0C, 0x06, 0x04, 0x0C,
  0x04, 0x0C, 0x0C, 0x04, 0x08, 0x0C, 0x0C, 0x18, 0x0C, 0x08, 0x10, 0x04,
  0x10, 0x30, 0x04, 0x30, 0x60, 0x07, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0x00, 0x06, 0x18, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x01, 0x80, 0x80, 0x18,
  0x08, 0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x01, 0x80, 0x10, 0x10, 0x01,
  0x03, 0x00, 0x18, 0x60, 0x01, 0x84, 0x00, 0x08, 0x80, 0x00, 0xB0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x06, 0x20, 0x00, 0xC2, 0x00,
  0x18, 0x30, 0x31, 0x01, 0x02, 0x30, 0x18, 0x26, 0x00, 0x86, 0x40, 0x08,
  0x44, 0x00, 0xCC, 0x40, 0x04, 0x8C, 0x00, 0x78, 0xC0, 0x03, 0x0C, 0x00,
  0x20, 0xC0, 0x07, 0x04, 0x00, 0xD0, 0x60, 0x19, 0x03, 0x03, 0x08, 0x1F,
  0xC0, 0x80, 0x32, 0x22, 0x64, 0x44, 0x4C, 0x88, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x20, 0x40, 0xC1, 0x00, 0xC4, 0x00, 0x90, 0xC1,
  0xFC, 0x03, 0x00, 0x34, 0x01, 0x88, 0x0C, 0x20, 0xC0, 0x41, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x30, 0x82,
  0x18, 0x43, 0x08, 0x61, 0x08, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0x40, 0x10, 0x60, 0x08,
  0x60, 0x04, 0x20, 0x02, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x4C, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x06, 0x80, 0x03, 0x40,
  0x01, 0xA0, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x28, 0x00, 0x34, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x06, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0xC1, 0x80, 0x40, 0x40, 0x60, 0x30,
  0x60, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x68, 0x32, 0x31, 0x98, 0x4C,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x00,
  0x00, 0x7F, 0x80, 0x1C, 0x06, 0x00, 0x80, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x27,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x08, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x0C,
  0x80, 0x01, 0x10, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x02, 0x10, 0x00, 0x82,
  0x00, 0x30, 0x40, 0x04, 0x18, 0x01, 0x02, 0x00, 0x60, 0x40, 0x08, 0x08,
  0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x01, 0x01, 0x80, 0x20,
  0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x20, 0xC0, 0x04, 0x1F, 0xFF, 0xF8,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xF0, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x09, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x08, 0x07, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x8F, 0xE0, 0x6C, 0x0C, 0x16, 0x01, 0x87, 0x00, 0x21, 0x80, 0x08, 0xC0,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0xC3,
  0x00, 0x20, 0xC0, 0x18, 0x10, 0x0C, 0x02, 0x06, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0C, 0x0C, 0x01,
  0x80, 0x60, 0x30, 0x02, 0x02, 0x00, 0x30, 0x20, 0x01, 0x06, 0x00, 0x10,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04,
  0x03, 0x00, 0xC0, 0x10, 0x18, 0x00, 0x86, 0x00, 0x0C, 0xC0, 0x00, 0x70,
  0x00, 0x1D, 0x00, 0x03, 0x08, 0x00, 0xC0, 0x40, 0x18, 0x02, 0x03, 0x00,
  0x30, 0x20, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0x40, 0x03, 0x06,
  0x00, 0x20, 0x20, 0x06, 0x03, 0x81, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x60, 0x40, 0x30, 0x08, 0x18, 0x02, 0x04, 0x00, 0xC3, 0x00, 0x10,
  0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0xC0,
  0x01, 0x30, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x10, 0x01,
  0x84, 0x00, 0xE1, 0x80, 0x68, 0x30, 0x36, 0x07, 0xF1, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x0F, 0xE0, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xC1, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x60, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x0C, 0x60, 0x0F, 0x81, 0x88, 0x06, 0x18, 0x33, 0x01, 0x83, 0x06, 0x40,
  0x60, 0x40, 0xC8, 0x08, 0x08, 0x1B, 0x02, 0x03, 0x02, 0x40, 0xC0, 0x40,
  0x48, 0x10, 0x08, 0x09, 0x02, 0x01, 0x01, 0x60, 0xC0, 0x60, 0x6C, 0x10,
  0x08, 0x09, 0x02, 0x01, 0x01, 0x20, 0x40, 0x60, 0x64, 0x08, 0x0C, 0x08,
  0x81, 0x01, 0x83, 0x10, 0x20, 0x70, 0x42, 0x04, 0x1A, 0x18, 0x40, 0xC6,
  0x46, 0x08, 0x0F, 0x8F, 0x81, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x04, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01,
  0xA0, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x40,
  0x80, 0x18, 0x10, 0x02, 0x02, 0x00, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x1F, 0xFE, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03,
  0x04, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02,
  0x60, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x01, 0xFF, 0x00, 0x08, 0x0E, 0x00, 0x40, 0x18, 0x06,
  0x00, 0x60, 0x30, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x60, 0x40, 0x02,
  0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x40,
  0x06, 0x06, 0x00, 0x20, 0x20, 0x06, 0x01, 0x00, 0xE0, 0x0F, 0xFC, 0x00,
  0x40, 0x70, 0x06, 0x00, 0xC0, 0x20, 0x03, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x08,
  0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x20, 0x00, 0x81, 0x00, 0x0C,
  0x08, 0x00, 0xC0, 0xC0, 0x0C, 0x04, 0x03, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0x80, 0x80, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x04, 0x0F, 0x00, 0x10, 0x06, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x10, 0x08, 0x00, 0x60, 0x20, 0x00, 0x80, 0x80, 0x02,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00, 0x03, 0x04,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00,
  0x08, 0x20, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80,
  0x01, 0x82, 0x00, 0x04, 0x18, 0x00, 0x30, 0x40, 0x01, 0x81, 0x00, 0x0C,
  0x04, 0x00, 0x60, 0x10, 0x03, 0x00, 0xC0, 0x38, 0x02, 0x07, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x38, 0x07, 0x00, 0x60, 0x01, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x07, 0xF8, 0x40,
  0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x60, 0x60, 0x00, 0x60, 0x20, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x18, 0x00, 0x40, 0x0E, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x40, 0x00, 0x40, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x80, 0x40, 0x00, 0x40, 0x60, 0x00, 0x60, 0x20, 0x00, 0x20, 0x10, 0x00,
  0x10, 0x0F, 0xFF, 0xF8, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x02, 0x00,
  0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x20, 0x00, 0x20,
  0x00, 0x01, 0xFE, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0x80, 0x06, 0x02, 0x00, 0x10, 0x04, 0x00, 0x40,
  0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x18, 0x00, 0x80, 0x60, 0x01,
  0x01, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x30, 0x00, 0x20,
  0xC0, 0x00, 0x43, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x04, 0xE0,
  0x00, 0x09, 0x40, 0x00, 0x34, 0x80, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x82, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x30, 0x00, 0x80, 0x20, 0x03, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x3F, 0xFE, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x28, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0x40, 0x58, 0x00, 0x06, 0x80, 0xB0, 0x00, 0x09, 0x01, 0x20, 0x00, 0x32,
  0x06, 0x40, 0x00, 0x4C, 0x0C, 0x80, 0x01, 0x90, 0x11, 0x00, 0x02, 0x20,
  0x22, 0x00, 0x0C, 0x40, 0x44, 0x00, 0x11, 0x81, 0x88, 0x00, 0x63, 0x02,
  0x10, 0x00, 0x84, 0x04, 0x20, 0x03, 0x08, 0x08, 0x60, 0x04, 0x10, 0x30,
  0xC0, 0x18, 0x60, 0x60, 0x80, 0x20, 0x80, 0x81, 0x00, 0xC1, 0x01, 0x02,
  0x01, 0x02, 0x02, 0x04, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x41, 0x80, 0x80, 0x80, 0x82,
  0x03, 0x03, 0x01, 0x8C, 0x06, 0x06, 0x03, 0x10, 0x08, 0x08, 0x02, 0x60,
  0x10, 0x10, 0x04, 0x80, 0x20, 0x20, 0x0A, 0x00, 0xC0, 0xC0, 0x14, 0x01,
  0x01, 0x00, 0x30, 0x02, 0x02, 0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x78, 0x00, 0x20, 0x34, 0x00,
  0x10, 0x12, 0x00, 0x08, 0x09, 0x00, 0x0C, 0x04, 0xC0, 0x06, 0x06, 0x20,
  0x02, 0x03, 0x10, 0x01, 0x01, 0x08, 0x00, 0x80, 0x86, 0x00, 0xC0, 0x41,
  0x00, 0x40, 0x60, 0x80, 0x20, 0x20, 0x40, 0x10, 0x10, 0x30, 0x18, 0x08,
  0x08, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x01, 0x81, 0x01,
  0x00, 0x41, 0x80, 0x80, 0x20, 0xC0, 0xC0, 0x10, 0x40, 0x60, 0x0C, 0x20,
  0x20, 0x02, 0x10, 0x10, 0x01, 0x18, 0x08, 0x00, 0x88, 0x0C, 0x00, 0x64,
  0x06, 0x00, 0x12, 0x02, 0x00, 0x09, 0x01, 0x00, 0x07, 0x80, 0x80, 0x03,
  0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x20, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x30,
  0x00, 0xC0, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x04,
  0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x18, 0x18, 0x00, 0x60, 0x10, 0x01, 0x80, 0x30, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x10, 0x38, 0x01, 0x00, 0xC0,
  0x30, 0x06, 0x03, 0x00, 0x20, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00,
  0x20, 0xC0, 0x06, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x01, 0x80, 0x80,
  0x30, 0x18, 0x1C, 0x01, 0xFF, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xC0, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x30, 0x00, 0xC0, 0xC0,
  0x00, 0x81, 0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x88, 0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x19,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00,
  0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x10, 0x18, 0x00,
  0x60, 0x10, 0x01, 0x80, 0x30, 0x06, 0x00, 0x30, 0x18, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFE, 0x00, 0x10, 0x38, 0x01, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0x20, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x08,
  0x00, 0xC0, 0x80, 0x08, 0x08, 0x03, 0x00, 0x80, 0x60, 0x1F, 0xF8, 0x01,
  0x02, 0x00, 0x10, 0x30, 0x01, 0x01, 0x00, 0x30, 0x10, 0x03, 0x01, 0x00,
  0x20, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x80, 0x60, 0x0C,
  0x04, 0x00, 0xC0, 0x40, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x06, 0x08, 0x00,
  0x60, 0x80, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0x00, 0xC0, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08,
  0x30, 0x00, 0x30, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x06,
  0x00, 0x06, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40,
  0x00, 0x41, 0x80, 0x01, 0x82, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x01,
  0x02, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x38, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x28, 0x00,
  0x0D, 0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x02,
  0x04, 0x00, 0xC0, 0x80, 0x10, 0x10, 0x06, 0x02, 0x00, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x20, 0x04, 0x04, 0x00, 0x81, 0x80,
  0x10, 0x20, 0x02, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00,
  0x33, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x01, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x38, 0x00, 0x68,
  0x00, 0x50, 0x00, 0x90, 0x00, 0xA0, 0x03, 0x20, 0x02, 0x40, 0x04, 0x40,
  0x04, 0x80, 0x08, 0x80, 0x19, 0x00, 0x31, 0x00, 0x22, 0x00, 0x42, 0x00,
  0xC4, 0x01, 0x84, 0x01, 0x08, 0x02, 0x08, 0x02, 0x10, 0x0C, 0x10, 0x08,
  0x20, 0x10, 0x20, 0x10, 0x40, 0x20, 0x40, 0x60, 0x80, 0xC0, 0x80, 0x81,
  0x01, 0x01, 0x03, 0x02, 0x06, 0x02, 0x04, 0x04, 0x08, 0x04, 0x08, 0x08,
  0x10, 0x08, 0x30, 0x10, 0x40, 0x10, 0x40, 0x20, 0x80, 0x21, 0x80, 0x43,
  0x00, 0x42, 0x00, 0x84, 0x00, 0x84, 0x01, 0x18, 0x01, 0x10, 0x02, 0x20,
  0x02, 0x20, 0x04, 0x40, 0x04, 0xC0, 0x09, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x16, 0x00, 0x2C, 0x00, 0x28, 0x00, 0x50, 0x00, 0x50, 0x00, 0xA0, 0x00,
  0xE0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x20, 0x08, 0x00, 0x20, 0x18, 0x00, 0x20, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x30, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x82, 0x00,
  0x01, 0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x02, 0x00, 0x04, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x01, 0x00,
  0x20, 0x01, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0xE0,
  0x00, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30,
  0xC0, 0x10, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x0C, 0x02, 0x04,
  0x01, 0x84, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x13, 0x00, 0x09, 0x00, 0x05,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x81, 0x03, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x60, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x02, 0x04, 0x08,
  0x18, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x40, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x02, 0x18, 0x00,
  0xC1, 0x00, 0x10, 0x20, 0x06, 0x06, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x0C,
  0x00, 0x81, 0x00, 0x10, 0x60, 0x03, 0x08, 0x00, 0x23, 0x00, 0x06, 0x40,
  0x00, 0x58, 0x00, 0x0C, 0xFF, 0xFC, 0xC2, 0x18, 0x41, 0x08, 0x20, 0x00,
  0xFC, 0x40, 0xC1, 0x90, 0x60, 0x24, 0x30, 0x07, 0x08, 0x01, 0x84, 0x00,
  0x63, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x06, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x05,
  0x0C, 0x03, 0x81, 0x01, 0xA0, 0x60, 0xC8, 0x0F, 0xE2, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0xFC, 0x04, 0xC1, 0x81, 0x60, 0x20, 0xF0, 0x0C, 0x28, 0x01, 0x0E, 0x00,
  0x43, 0x00, 0x10, 0xC0, 0x04, 0x60, 0x01, 0x18, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x01, 0x30, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x08, 0x80,
  0x02, 0x60, 0x01, 0x98, 0x00, 0x46, 0x00, 0x31, 0x80, 0x08, 0x60, 0x06,
  0x38, 0x03, 0x0B, 0x00, 0x82, 0x60, 0xC0, 0x8F, 0xE0, 0x00, 0x00, 0xFE,
  0x06, 0x04, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x20, 0x3F, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x01, 0xF8, 0x80, 0x30, 0x64, 0x03, 0x01, 0xA0,
  0x30, 0x07, 0x01, 0x00, 0x38, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00,
  0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x81, 0x00, 0x04, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x0C,
  0x08, 0x00, 0x60, 0x40, 0x07, 0x02, 0x00, 0x30, 0x10, 0x03, 0x80, 0x80,
  0x14, 0x06, 0x01, 0xA0, 0x10, 0x1B, 0x00, 0xC1, 0x90, 0x03, 0xF8, 0x80,
  0x00, 0x00, 0xFC, 0x06, 0x0C, 0x18, 0x08, 0x60, 0x10, 0x80, 0x22, 0x00,
  0x4C, 0x00, 0x90, 0x03, 0x20, 0x04, 0xC0, 0x11, 0x00, 0xE2, 0x07, 0x0F,
  0xF8, 0x1F, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x30,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x2E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x10, 0x0C, 0x19, 0x01, 0x80,
  0xD0, 0x30, 0x05, 0x02, 0x00, 0x70, 0x40, 0x06, 0x0C, 0x00, 0x60, 0x80,
  0x06, 0x08, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x41, 0x00, 0x04, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x82,
  0x00, 0x18, 0x20, 0x03, 0x82, 0x00, 0x30, 0x20, 0x07, 0x02, 0x00, 0x50,
  0x30, 0x0D, 0x01, 0x01, 0xB0, 0x18, 0x32, 0x00, 0xFE, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x08, 0x06, 0x00, 0xFB,
  0xC0, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x8F, 0xE0, 0x4C, 0x18, 0x2C, 0x04, 0x3C, 0x02,
  0x14, 0x01, 0x0C, 0x00, 0x86, 0x00, 0x42, 0x00, 0x23, 0x00, 0x11, 0x80,
  0x18, 0x80, 0x0C, 0x40, 0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x01, 0x88,
  0x00, 0x84, 0x00, 0x46, 0x00, 0x23, 0x00, 0x11, 0x00, 0x18, 0x80, 0x08,
  0x40, 0x04, 0x60, 0x02, 0x30, 0x03, 0x10, 0x01, 0x88, 0x00, 0x80, 0x01,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x06, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x10, 0x40, 0x10, 0x20,
  0x10, 0x30, 0x18, 0x10, 0x18, 0x08, 0x18, 0x04, 0x18, 0x02, 0x08, 0x03,
  0x08, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x4E, 0x00, 0x2D, 0x00, 0x3C, 0x80,
  0x14, 0x60, 0x0C, 0x10, 0x04, 0x08, 0x06, 0x04, 0x03, 0x03, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x60, 0x18, 0x20, 0x04, 0x10, 0x02, 0x08,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x00, 0x04, 0x7E, 0x0F, 0xC0,
  0x4C, 0x31, 0x86, 0x05, 0x01, 0x20, 0x30, 0xE0, 0x1C, 0x01, 0x0E, 0x01,
  0xC0, 0x10, 0xC0, 0x18, 0x01, 0x0C, 0x01, 0x80, 0x10, 0x80, 0x10, 0x03,
  0x18, 0x01, 0x00, 0x31, 0x80, 0x10, 0x02, 0x10, 0x03, 0x00, 0x21, 0x00,
  0x30, 0x02, 0x10, 0x02, 0x00, 0x63, 0x00, 0x20, 0x06, 0x20, 0x02, 0x00,
  0x42, 0x00, 0x60, 0x04, 0x20, 0x04, 0x00, 0x46, 0x00, 0x40, 0x0C, 0x60,
  0x04, 0x00, 0x84, 0x00, 0x40, 0x08, 0x40, 0x0C, 0x00, 0x84, 0x00, 0x80,
  0x08, 0xC0, 0x08, 0x01, 0x8C, 0x00, 0x80, 0x10, 0x80, 0x18, 0x01, 0x08,
  0x01, 0x00, 0x10, 0x04, 0x7F, 0x02, 0x60, 0xC1, 0x40, 0x21, 0xC0, 0x10,
  0xA0, 0x08, 0x60, 0x04, 0x30, 0x02, 0x10, 0x01, 0x18, 0x00, 0x8C, 0x00,
  0xC4, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x80, 0x08, 0x80, 0x0C, 0x40,
  0x04, 0x20, 0x02, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x42,
  0x00, 0x23, 0x00, 0x11, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x04, 0x00, 0x01,
  0xFC, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x80, 0x21, 0x80, 0x18, 0x80, 0x0C,
  0xC0, 0x06, 0x40, 0x01, 0x20, 0x00, 0xB0, 0x00, 0xD0, 0x00, 0x68, 0x00,
  0x3C, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x03, 0x40,
  0x01, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x43, 0x00, 0x60,
  0x80, 0x60, 0x60, 0x60, 0x1F, 0xE0, 0x00, 0x00, 0x87, 0xE0, 0x04, 0xC1,
  0x80, 0x2C, 0x04, 0x03, 0xC0, 0x30, 0x14, 0x00, 0x80, 0xE0, 0x04, 0x06,
  0x00, 0x20, 0x30, 0x01, 0x03, 0x00, 0x08, 0x18, 0x00, 0x40, 0xC0, 0x02,
  0x04, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80,
  0x02, 0x04, 0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x08, 0x18, 0x00, 0xC0,
  0xC0, 0x04, 0x06, 0x00, 0x60, 0x70, 0x06, 0x03, 0xC0, 0x20, 0x13, 0x06,
  0x00, 0x8F, 0xE0, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x40,
  0xC1, 0x90, 0x60, 0x34, 0x30, 0x05, 0x08, 0x01, 0xC4, 0x00, 0x63, 0x00,
  0x18, 0x80, 0x06, 0x20, 0x01, 0x98, 0x00, 0x64, 0x00, 0x11, 0x00, 0x04,
  0xC0, 0x01, 0x30, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x20,
  0x01, 0x88, 0x00, 0x62, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x07, 0x0C, 0x03,
  0x41, 0x01, 0xB0, 0x60, 0xC8, 0x0F, 0xE2, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x04, 0x7C, 0x13,
  0x00, 0x58, 0x03, 0xC0, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x00, 0x01, 0xFC, 0x06, 0x07, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x80, 0xC0, 0xFF, 0x80, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x0F, 0xF8, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0xE0, 0x08, 0x00, 0xC2, 0x00, 0x21,
  0x80, 0x08, 0x60, 0x02, 0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x10, 0xC0,
  0x04, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02,
  0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x30, 0x03, 0x08,
  0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06, 0x08, 0x02, 0x82, 0x01,
  0x60, 0xC0, 0xD0, 0x1F, 0xC4, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x34,
  0x00, 0x48, 0x01, 0x90, 0x02, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x61, 0x00,
  0x82, 0x03, 0x04, 0x04, 0x0C, 0x18, 0x18, 0x20, 0x30, 0xC0, 0x61, 0x00,
  0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x68,
  0x04, 0x80, 0x48, 0x0C, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88,
  0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x30, 0x83, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x86, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0xC0, 0x88, 0x08,
  0x80, 0x88, 0x09, 0x80, 0x98, 0x09, 0x00, 0x90, 0x09, 0x00, 0xB0, 0x0A,
  0x00, 0xA0, 0x0A, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x02, 0x00, 0x30, 0x30, 0x06, 0x01, 0x00, 0x40, 0x10, 0x08, 0x01,
  0x01, 0x80, 0x18, 0x10, 0x00, 0x82, 0x00, 0x08, 0x60, 0x00, 0xC4, 0x00,
  0x04, 0x80, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0x10, 0x00, 0x21, 0x00, 0x06, 0x18,
  0x00, 0x40, 0x80, 0x08, 0x08, 0x01, 0x80, 0x80, 0x30, 0x0C, 0x02, 0x00,
  0x40, 0x60, 0x04, 0x0C, 0x00, 0x40, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x40, 0x01, 0x00,
  0x20, 0x00, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10,
  0x08, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01,
  0x02, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x08, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x50, 0x30,
  0x18, 0x03, 0xF8, 0x00, 0x1C,
};

const GFXglyph NotoSans_Condensed_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 35, 10, 1, -35 },
  { 41, 10, 13, 13, 5, -35 },
  { 58, 21, 35, 22, 1, -35 },
  { 150, 20, 40, 20, 0, -37 },
  { 250, 24, 36, 29, 3, -35 },
  { 358, 20, 35, 21, 0, -35 },
  { 446, 4, 13, 7, 5, -35 },
  { 453, 14, 43, 12, 1, -35 },
  { 529, 13, 43, 12, -3, -35 },
  { 599, 14, 15, 19, 6, -37 },
  { 626, 19, 23, 22, 2, -29 },
  { 681, 6, 11, 8, -2, -5 },
  { 690, 11, 1, 14, 1, -14 },
  { 692, 2, 3, 8, 1, -3 },
  { 693, 20, 35, 15, -2, -35 },
  { 781, 17, 35, 20, 2, -35 },
  { 856, 10, 35, 20, 6, -35 },
  { 900, 20, 35, 20, -1, -35 },
  { 988, 20, 36, 20, 0, -35 },
  { 1078, 19, 35, 20, 0, -35 },
  { 1162, 20, 35, 20, 0, -35 },
  { 1250, 18, 36, 20, 2, -36 },
  { 1331, 18, 35, 20, 3, -35 },
  { 1410, 20, 35, 20, 0, -35 },
  { 1498, 18, 35, 20, 1, -35 },
  { 1577, 7, 26, 8, 1, -26 },
  { 1600, 10, 32, 8, -2, -26 },
  { 1640, 18, 21, 22, 2, -28 },
  { 1688, 19, 12, 22, 2, -23 },
  { 1717, 18, 21, 22, 2, -28 },
  { 1765, 14, 35, 14, 2, -35 },
  { 1827, 27, 39, 30, 2, -35 },
  { 1959, 19, 35, 19, -3, -35 },
  { 2043, 21, 35, 22, 1, -35 },
  { 2135, 22, 36, 20, 2, -36 },
  { 2234, 22, 35, 24, 1, -35 },
  { 2331, 20, 35, 19, 1, -35 },
  { 2419, 20, 35, 18, 1, -35 },
  { 2507, 24, 36, 26, 2, -36 },
  { 2615, 25, 35, 25, 1, -35 },
  { 2725, 15, 35, 10, -2, -35 },
  { 2791, 17, 43, 9, -7, -35 },
  { 2883, 23, 35, 20, 1, -35 },
  { 2984, 13, 35, 18, 1, -35 },
  { 3041, 31, 35, 32, 1, -35 },
  { 3177, 25, 35, 26, 1, -35 },
  { 3287, 23, 35, 26, 2, -35 },
  { 3388, 20, 35, 20, 1, -35 },
  { 3476, 23, 43, 26, 2, -35 },
  { 3600, 20, 35, 20, 1, -35 },
  { 3688, 21, 35, 19, -1, -35 },
  { 3780, 17, 35, 17, 4, -35 },
  { 3855, 23, 35, 25, 2, -35 },
  { 3956, 19, 35, 20, 4, -35 },
  { 4040, 31, 35, 33, 5, -35 },
  { 4176, 24, 35, 18, -3, -35 },
  { 4281, 17, 35, 17, 4, -35 },
  { 4356, 23, 35, 18, -2, -35 },
  { 4457, 18, 43, 14, -1, -35 },
  { 4554, 7, 35, 15, 5, -35 },
  { 4585, 17, 43, 14, -3, -35 },
  { 4677, 19, 18, 22, 2, -35 },
  { 4720, 14, 1, 14, -4, 5 },
  { 4722, 5, 7, 10, 7, -37 },
  { 4727, 18, 26, 21, 2, -26 },
  { 4786, 18, 37, 21, 1, -37 },
  { 4870, 15, 26, 16, 2, -26 },
  { 4919, 21, 37, 21, 2, -37 },
  { 5017, 15, 26, 18, 2, -26 },
  { 5066, 22, 49, 10, -6, -37 },
  { 5201, 20, 38, 21, 0, -26 },
  { 5296, 17, 37, 20, 1, -37 },
  { 5375, 9, 35, 8, 1, -35 },
  { 5415, 17, 47, 9, -7, -35 },
  { 5515, 17, 37, 17, 1, -37 },
  { 5594, 9, 37, 8, 1, -37 },
  { 5636, 28, 26, 31, 1, -26 },
  { 5727, 17, 26, 20, 1, -26 },
  { 5783, 17, 26, 21, 2, -26 },
  { 5839, 21, 37, 21, -2, -26 },
  { 5937, 18, 37, 21, 2, -26 },
  { 6021, 14, 26, 13, 1, -26 },
  { 6067, 16, 26, 16, 0, -26 },
  { 6119, 11, 32, 11, 1, -32 },
  { 6163, 18, 26, 20, 2, -26 },
  { 6222, 15, 26, 15, 3, -26 },
  { 6271, 24, 26, 25, 3, -26 },
  { 6349, 20, 26, 16, -2, -26 },
  { 6414, 25, 38, 16, -6, -26 },
  { 6533, 16, 26, 14, -1, -26 },
  { 6585, 16, 43, 15, 2, -35 },
  { 6671, 2, 49, 20, 9, -37 },
  { 6684, 17, 43, 15, -3, -35 },
  { 6776, 18, 4, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_THINITALIC49PT7B_H_
