#ifndef _NOTOSANS_CONDENSED_THINITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6D, 0x7C, 0x79, 0x2C, 0xDE, 0xF5, 0xA0, 0x49, 0x5C,
  0xC0, 0x6A, 0xA0, 0xFC, 0xE0, 0x5D, 0x00, 0xC0, 0xC0, 0x00, 0x29, 0x48,
  0x76, 0xDC, 0xF8, 0x64, 0xAC, 0x65, 0x1C, 0x2A, 0xF4, 0x71, 0x9C, 0x73,
  0xDC, 0x65, 0x28, 0x75, 0x5E, 0x77, 0x9C, 0x80, 0x98, 0x71, 0x80, 0xE0,
  0xC7, 0x00, 0x56, 0x80, 0x7B, 0xFB, 0xC4, 0x5F, 0xC0, 0x77, 0xDE, 0x72,
  0x4C, 0x76, 0xDE, 0x73, 0x4C, 0x73, 0x48, 0x78, 0x8A, 0xE0, 0x59, 0xFA,
  0xA0, 0x6A, 0x80, 0x55, 0x70, 0x79, 0x6A, 0x6A, 0xC0, 0x4A, 0x95, 0xED,
  0x00, 0x5D, 0xDA, 0xA0, 0x79, 0x99, 0xE0, 0x77, 0xC8, 0x79, 0x99, 0xA4,
  0x76, 0xEA, 0xF1, 0x1C, 0xEA, 0x80, 0x59, 0xAA, 0xE0, 0xFA, 0x80, 0xDD,
  0xDE, 0xC0, 0x69, 0x6C, 0xEA, 0x80, 0x65, 0x4C, 0x6A, 0xA0, 0xF8, 0x55,
  0x60, 0x56, 0x80, 0xE0, 0x80, 0x76, 0xE0, 0x4E, 0xDE, 0x6B, 0x2E, 0xDC,
  0x7B, 0x29, 0x24, 0xA0, 0x76, 0xE5, 0x00, 0x4E, 0xDA, 0x78, 0x15, 0x58,
  0x55, 0x6C, 0xF8, 0x7B, 0xBD, 0x76, 0xD0, 0x56, 0xE0, 0x76, 0xF9, 0x00,
  0x76, 0xE4, 0x80, 0x6A, 0xE7, 0x6A, 0x80, 0xB6, 0xE0, 0xBA, 0x40, 0xBD,
  0xAA, 0xBA, 0x60, 0x56, 0x24, 0x48, 0x5A, 0x69, 0x49, 0x00, 0xFE, 0x55,
  0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 1, 2, 2, 1, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 3, 5, 3, 0, -5 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 1, 6, 2, 0, -5 },
  { 16, 2, 2, 3, 1, -5 },
  { 17, 3, 3, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 3, 5, 2, 0, -5 },
  { 24, 3, 5, 3, 0, -5 },
  { 26, 1, 5, 3, 1, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 1, 4, 1, 0, -4 },
  { 44, 1, 5, 1, 0, -4 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 5, 2, 0, -5 },
  { 52, 4, 6, 4, 0, -5 },
  { 55, 2, 5, 3, 0, -5 },
  { 57, 3, 5, 3, 0, -5 },
  { 59, 3, 5, 3, 0, -5 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 3, 5, 3, 0, -5 },
  { 65, 3, 5, 3, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 2, 5, 1, 0, -5 },
  { 75, 2, 6, 1, -1, -5 },
  { 77, 3, 5, 3, 0, -5 },
  { 79, 2, 5, 3, 0, -5 },
  { 81, 5, 5, 5, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 3, 5, 3, 0, -5 },
  { 93, 4, 6, 4, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 2, 5, 2, 1, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 2, 5, 3, 1, -5 },
  { 107, 4, 5, 5, 1, -5 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 2, 5, 2, 1, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 2, 6, 2, 0, -5 },
  { 118, 1, 5, 2, 1, -5 },
  { 119, 2, 6, 2, 0, -5 },
  { 121, 3, 3, 3, 0, -5 },
  { 123, 3, 1, 2, -1, 0 },
  { 124, 1, 1, 1, 1, -5 },
  { 125, 3, 4, 3, 0, -4 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 2, 4, 2, 0, -4 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 2, 4, 3, 0, -4 },
  { 133, 3, 7, 1, -1, -5 },
  { 136, 3, 6, 3, 0, -4 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 1, 5, 1, 0, -5 },
  { 142, 2, 7, 1, -1, -5 },
  { 144, 3, 5, 2, 0, -5 },
  { 146, 1, 5, 1, 0, -5 },
  { 147, 4, 4, 4, 0, -4 },
  { 149, 3, 4, 3, 0, -4 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 3, 6, 3, 0, -4 },
  { 156, 3, 6, 3, 0, -4 },
  { 159, 2, 4, 2, 0, -4 },
  { 160, 2, 4, 2, 0, -4 },
  { 161, 2, 5, 2, 0, -5 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 3, 4, 2, 0, -4 },
  { 167, 4, 4, 4, 0, -4 },
  { 169, 3, 4, 2, 0, -4 },
  { 171, 4, 6, 2, -1, -4 },
  { 174, 2, 4, 2, 0, -4 },
  { 175, 3, 6, 2, 0, -5 },
  { 178, 1, 7, 3, 1, -5 },
  { 179, 2, 6, 2, 0, -5 },
  { 181, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_THINITALIC7PT7B_H_
