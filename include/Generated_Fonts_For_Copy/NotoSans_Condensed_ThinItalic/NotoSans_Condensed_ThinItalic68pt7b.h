#ifndef _NOTOSANS_CONDENSED_THINITALIC68PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0x18, 0x18, 0xC0,
  0xC6, 0x06, 0x20, 0x33, 0x01, 0x18, 0x18, 0xC0, 0xC4, 0x06, 0x20, 0x33,
  0x01, 0x18, 0x18, 0xC0, 0xC4, 0x06, 0x20, 0x23, 0x01, 0x18, 0x08, 0x80,
  0xC4, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x40, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x01, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x10, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x10, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x40, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x38,
  0x41, 0xE0, 0x1C, 0x08, 0x08, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x30, 0x00, 0x01,
  0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x08, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x30, 0x10, 0xF0, 0x07, 0xFB, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x06, 0x00, 0xFF, 0x00, 0x03,
  0x00, 0xC1, 0x80, 0x03, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x30, 0x01,
  0x80, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x40, 0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0,
  0x30, 0x04, 0x00, 0x60, 0x30, 0x06, 0x00, 0x20, 0x18, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0x03, 0x06, 0x00, 0x30, 0x03, 0x06, 0x00, 0x18, 0x01,
  0x83, 0x01, 0x0C, 0x00, 0xC3, 0x07, 0xE6, 0x00, 0xC1, 0x06, 0x1B, 0x00,
  0x61, 0x86, 0x07, 0x80, 0x21, 0x86, 0x03, 0xC0, 0x30, 0xC6, 0x01, 0xE0,
  0x18, 0xC3, 0x00, 0xF0, 0x18, 0x63, 0x00, 0x6C, 0x18, 0x61, 0x80, 0x37,
  0xF8, 0x30, 0xC0, 0x19, 0xF8, 0x30, 0xC0, 0x0C, 0x00, 0x30, 0x60, 0x06,
  0x00, 0x18, 0x30, 0x03, 0x00, 0x18, 0x10, 0x01, 0x80, 0x0C, 0x18, 0x00,
  0xC0, 0x0C, 0x0C, 0x00, 0x40, 0x06, 0x06, 0x00, 0x60, 0x06, 0x03, 0x00,
  0x30, 0x06, 0x01, 0x00, 0x18, 0x03, 0x00, 0x80, 0x08, 0x03, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x40, 0x06, 0x01, 0x80, 0x60, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x30, 0x00, 0x70, 0xC0, 0x30, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x03, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x30, 0x02, 0x1C, 0x03, 0x00,
  0xC3, 0x00, 0x60, 0x18, 0xC0, 0x04, 0x02, 0x30, 0x00, 0xC0, 0xC6, 0x00,
  0x18, 0x11, 0x80, 0x01, 0x86, 0x30, 0x00, 0x30, 0xC6, 0x00, 0x02, 0x30,
  0xC0, 0x00, 0x66, 0x10, 0x00, 0x0D, 0x86, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x1C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x36, 0x06,
  0x00, 0x0E, 0x40, 0xE0, 0x03, 0x8C, 0x0E, 0x00, 0xE1, 0x80, 0xE0, 0x70,
  0x18, 0x0F, 0xFC, 0x03, 0x00, 0x7C, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18,
  0xC4, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x40, 0x30, 0x0E, 0x03, 0x00, 0x30, 0x20, 0x01,
  0xC2, 0x00, 0x06, 0x20, 0x30, 0x1A, 0x7F, 0x00, 0x7C, 0x00, 0x0E, 0x00,
  0x01, 0xA0, 0x00, 0x31, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x80, 0x30, 0x0C,
  0x06, 0x00, 0x40, 0x20, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x01, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFE, 0x77,
  0xE6, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x07, 0x01, 0x80, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x38, 0x00, 0x38, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x3C, 0x03, 0x60, 0x73, 0x07, 0x18,
  0x60, 0x8E, 0x0C, 0xE0, 0x66, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0x80, 0x30, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x18, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x11, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x3C, 0x00, 0x18, 0x7F, 0xC0, 0x04, 0x78, 0x3C, 0x03, 0x38, 0x03, 0x80,
  0xD8, 0x00, 0x60, 0x3C, 0x00, 0x0C, 0x0A, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0x10, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x38, 0x38, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x60, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x80,
  0x60, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x82,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0D,
  0x01, 0x80, 0x06, 0xC0, 0x70, 0x03, 0xB0, 0x0E, 0x03, 0x8C, 0x01, 0xFF,
  0xC2, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x02,
  0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x3C, 0x06, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7E, 0xF8, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x7C, 0x00, 0xC1, 0x80, 0x07, 0xFC, 0x03, 0x06, 0x00, 0x70, 0x30, 0x0C,
  0x30, 0x03, 0x80, 0xC0, 0x30, 0xC0, 0x1C, 0x03, 0x00, 0xC6, 0x00, 0x60,
  0x08, 0x03, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x60, 0x18, 0x01, 0x80, 0x31,
  0x00, 0x60, 0x06, 0x00, 0x8C, 0x03, 0x00, 0x10, 0x06, 0x30, 0x0C, 0x00,
  0xC0, 0x18, 0xC0, 0x30, 0x03, 0x00, 0x66, 0x01, 0x80, 0x0C, 0x01, 0x98,
  0x06, 0x00, 0x60, 0x04, 0x60, 0x18, 0x01, 0x80, 0x31, 0x80, 0x40, 0x06,
  0x00, 0xC6, 0x03, 0x00, 0x18, 0x03, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x40,
  0x30, 0x03, 0x00, 0x63, 0x00, 0xC0, 0x1C, 0x03, 0x0C, 0x03, 0x00, 0x70,
  0x0C, 0x30, 0x0C, 0x03, 0xC0, 0x60, 0xC0, 0x30, 0x0F, 0x01, 0x83, 0x00,
  0xC0, 0x6C, 0x0C, 0x0C, 0x01, 0x83, 0x10, 0x60, 0x30, 0x07, 0x18, 0x77,
  0x00, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x02,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0C, 0x01, 0xF0, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x30, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x38, 0x01, 0x80, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x38, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x3E, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x80, 0x00, 0x70, 0x03, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x10, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x18, 0x00,
  0x0F, 0xFE, 0x0C, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x07, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x02, 0x06, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x20, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x02, 0x7C, 0x00, 0x00,
  0x06, 0x66, 0x00, 0x00, 0x06, 0xC6, 0x00, 0x00, 0x07, 0x86, 0x00, 0x00,
  0x07, 0x02, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x40, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x02, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x28, 0x00, 0x00, 0x01, 0xE0, 0x06,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x06, 0xC0,
  0x00, 0x00, 0x64, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x0C, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0xCC, 0x00, 0x00, 0x18, 0x80, 0x08, 0xC0, 0x00, 0x03, 0x18,
  0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x18, 0x40, 0x00, 0x06, 0x18, 0x01,
  0x84, 0x00, 0x00, 0x61, 0x80, 0x18, 0x60, 0x00, 0x0C, 0x10, 0x01, 0x06,
  0x00, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x30, 0x60, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0x60, 0x06, 0x02, 0x00, 0x0C, 0x04, 0x00,
  0x60, 0x20, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x08, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x18, 0x01,
  0x00, 0x18, 0x01, 0x01, 0x00, 0x30, 0x01, 0x00, 0x10, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x8C, 0x00, 0x20, 0x03, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x60, 0x01,
  0x98, 0x00, 0x60, 0x06, 0x00, 0x19, 0x80, 0x06, 0x00, 0x60, 0x01, 0xB0,
  0x00, 0x60, 0x06, 0x00, 0x1B, 0x00, 0x04, 0x00, 0x40, 0x01, 0xE0, 0x00,
  0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x02, 0x80, 0x00, 0x04, 0x00,
  0xD8, 0x00, 0x01, 0x80, 0x1B, 0x00, 0x00, 0x30, 0x03, 0x60, 0x00, 0x06,
  0x00, 0x64, 0x00, 0x00, 0xC0, 0x18, 0xC0, 0x00, 0x30, 0x03, 0x18, 0x00,
  0x06, 0x00, 0x63, 0x00, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x18, 0x01, 0x06,
  0x00, 0x02, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x18, 0x01,
  0x81, 0x80, 0x03, 0x00, 0x30, 0x30, 0x00, 0x60, 0x04, 0x06, 0x00, 0x08,
  0x01, 0x80, 0xC0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x02,
  0x00, 0x10, 0x04, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x00, 0x80, 0xC0, 0x08, 0x00, 0x18,
  0x10, 0x03, 0x00, 0x03, 0x06, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x0C, 0x00,
  0x04, 0x18, 0x01, 0x80, 0x00, 0xC3, 0x00, 0x20, 0x00, 0x18, 0x40, 0x0C,
  0x00, 0x03, 0x18, 0x01, 0x80, 0x00, 0x23, 0x00, 0x30, 0x00, 0x06, 0x60,
  0x06, 0x00, 0x00, 0xCC, 0x01, 0x80, 0x00, 0x19, 0x00, 0x30, 0x00, 0x01,
  0x60, 0x06, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x10, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x0F,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x30,
  0x0F, 0x00, 0x03, 0x00, 0x38, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00,
  0x20, 0x00, 0xE0, 0x06, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x40, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0x7F, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x20, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x1F, 0x00, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x30, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x60, 0x08,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x02, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x10, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x13, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x68, 0x00, 0x01,
  0x40, 0x00, 0x19, 0x00, 0x00, 0x68, 0x00, 0x03, 0x20, 0x00, 0x0D, 0x00,
  0x00, 0x64, 0x00, 0x01, 0x20, 0x00, 0x18, 0x80, 0x00, 0x64, 0x00, 0x03,
  0x10, 0x00, 0x0C, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x10, 0x00, 0x18, 0x40,
  0x00, 0x62, 0x00, 0x02, 0x08, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x00, 0x03,
  0x08, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x06, 0x04, 0x00, 0x18, 0x20,
  0x00, 0xC0, 0x80, 0x03, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x80, 0x06,
  0x02, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x02, 0x00, 0x30, 0x08,
  0x00, 0xC0, 0x40, 0x06, 0x01, 0x00, 0x18, 0x08, 0x01, 0x80, 0x20, 0x06,
  0x01, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x02, 0x00, 0x80, 0x10, 0x0C,
  0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x40, 0x60, 0x01,
  0x01, 0x80, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x20, 0x60, 0x00, 0x81, 0x80, 0x04, 0x0C, 0x00, 0x10, 0x30, 0x00,
  0x83, 0x00, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x02, 0x08,
  0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0x21, 0x00, 0x03, 0x18, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x00, 0x8C,
  0x00, 0x0C, 0x40, 0x00, 0x13, 0x00, 0x01, 0x98, 0x00, 0x02, 0x60, 0x00,
  0x32, 0x00, 0x00, 0x48, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0x60, 0x00, 0x1A, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x40, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x20,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x09, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xF0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x30, 0x03, 0xC3, 0x8C, 0x01,
  0x80, 0x63, 0x00, 0xC0, 0x0C, 0x80, 0x60, 0x01, 0x20, 0x30, 0x00, 0x78,
  0x1C, 0x00, 0x1E, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x70, 0x10,
  0x00, 0x1C, 0x06, 0x00, 0x0F, 0x01, 0x80, 0x06, 0xC0, 0x60, 0x01, 0xA0,
  0x0C, 0x00, 0xC8, 0x03, 0x80, 0x66, 0x00, 0x70, 0x71, 0x80, 0x0F, 0xF0,
  0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x80, 0x01, 0x83, 0xFC,
  0x00, 0x63, 0xC3, 0x80, 0x19, 0xC0, 0x30, 0x06, 0xE0, 0x0E, 0x01, 0x70,
  0x01, 0x80, 0xD8, 0x00, 0x60, 0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x40, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x07, 0x80,
  0x03, 0x01, 0x60, 0x01, 0xC0, 0x4C, 0x00, 0xE0, 0x33, 0x80, 0x70, 0x0C,
  0x70, 0x78, 0x03, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xC0, 0x1E, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x18, 0x00, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0xF0, 0xE3, 0x00, 0x06, 0x00,
  0xCC, 0x00, 0x30, 0x01, 0x30, 0x01, 0x80, 0x06, 0x80, 0x0C, 0x00, 0x0A,
  0x00, 0x70, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x10, 0x00, 0x1E, 0x00, 0x40,
  0x00, 0x70, 0x01, 0x80, 0x03, 0x40, 0x06, 0x00, 0x1F, 0x00, 0x18, 0x00,
  0x6C, 0x00, 0x30, 0x03, 0x30, 0x00, 0xE0, 0x38, 0x80, 0x01, 0xC1, 0xC2,
  0x00, 0x03, 0xFE, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0x00, 0x1E, 0x3C, 0x01, 0x80, 0x60, 0x18, 0x01, 0x81, 0x80,
  0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x31, 0x80, 0x03,
  0x0C, 0x00, 0x70, 0x60, 0x0F, 0x06, 0x03, 0xE0, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x40, 0x38, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xCF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3F, 0xC1, 0x00, 0x0F, 0x0E, 0x10, 0x01, 0x80, 0x33, 0x00,
  0x30, 0x01, 0x30, 0x06, 0x00, 0x1B, 0x00, 0xC0, 0x00, 0xA0, 0x1C, 0x00,
  0x0A, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x70, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x10,
  0x00, 0x1E, 0x01, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x34, 0x01, 0x80, 0x07,
  0xC0, 0x18, 0x00, 0xEC, 0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0x03, 0x88, 0x00,
  0x70, 0x71, 0x80, 0x03, 0xFE, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0xC0, 0x01, 0x83, 0xFC, 0x00, 0xC7, 0x87, 0x00,
  0x66, 0x00, 0xC0, 0x36, 0x00, 0x60, 0x16, 0x00, 0x18, 0x1A, 0x00, 0x0C,
  0x0F, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0x01, 0x80, 0x00,
  0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x10, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x20,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x4F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x03,
  0x80, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x30, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x02, 0x01,
  0x80, 0x01, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xF0, 0x00, 0x0C,
  0xF8, 0x00, 0x06, 0x6C, 0x00, 0x02, 0x66, 0x00, 0x03, 0x61, 0x80, 0x01,
  0xE0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x03,
  0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x80, 0x03, 0x0F, 0xF0, 0x0F,
  0xF0, 0x06, 0x38, 0x70, 0x70, 0x70, 0x0C, 0xC0, 0x31, 0x80, 0x70, 0x13,
  0x00, 0x66, 0x00, 0x60, 0x2C, 0x00, 0x58, 0x00, 0xC0, 0xF0, 0x00, 0xA0,
  0x00, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0x03, 0x80, 0x03, 0x00, 0x02, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0x81,
  0x80, 0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x83, 0x00, 0x02, 0x00, 0x02,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x40, 0x80, 0x00, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC1, 0xFE, 0x00, 0x63,
  0xC3, 0x80, 0x33, 0x00, 0x60, 0x13, 0x00, 0x30, 0x0B, 0x00, 0x0C, 0x0F,
  0x00, 0x06, 0x07, 0x80, 0x03, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x10, 0x00, 0x08, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20,
  0x00, 0x10, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x38, 0x03, 0x80, 0x1E, 0x0E, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0x83,
  0xFC, 0x00, 0x0C, 0x78, 0x70, 0x00, 0x67, 0x00, 0xC0, 0x02, 0x70, 0x07,
  0x00, 0x13, 0x00, 0x18, 0x01, 0xB0, 0x00, 0xC0, 0x0F, 0x00, 0x03, 0x00,
  0x78, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x01, 0xE0,
  0x00, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0xE0, 0x06, 0x60, 0x0E,
  0x00, 0x31, 0xC1, 0xE0, 0x01, 0x87, 0xFC, 0x00, 0x0C, 0x07, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xFC, 0x10, 0x03, 0xC3, 0x84, 0x01, 0x80, 0x33, 0x00, 0xC0, 0x0C, 0xC0,
  0x60, 0x01, 0xB0, 0x30, 0x00, 0x68, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x70, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x78, 0x10, 0x00, 0x1C, 0x06, 0x00, 0x0D, 0x01,
  0x80, 0x07, 0xC0, 0x60, 0x01, 0xB0, 0x0C, 0x00, 0xCC, 0x03, 0x00, 0x62,
  0x00, 0x70, 0x71, 0x80, 0x0F, 0xF8, 0x60, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x83, 0xF0, 0x18, 0xF1, 0x01, 0x18, 0x00, 0x13, 0x00, 0x01, 0x60,
  0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0,
  0x01, 0xE0, 0xF8, 0x06, 0x00, 0x20, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x07, 0x03, 0x00, 0x1C, 0x07, 0x80,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x40, 0x7F, 0x00, 0x78, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x40, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08, 0x00,
  0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x07, 0x03, 0x00, 0x07, 0x81, 0x80, 0x06, 0x80, 0x60, 0x06, 0x40,
  0x30, 0x06, 0x60, 0x0E, 0x0E, 0x30, 0x03, 0xFE, 0x18, 0x00, 0x78, 0x00,
  0x00, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x86, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x06, 0x03, 0x00, 0x30, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x01, 0x80,
  0x10, 0x0C, 0x00, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC4, 0x00, 0x06, 0x60, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x2C, 0x00, 0x1C, 0x00,
  0x1B, 0x00, 0x07, 0x00, 0x06, 0xC0, 0x01, 0x40, 0x03, 0x30, 0x00, 0xD0,
  0x00, 0xCC, 0x00, 0x24, 0x00, 0x63, 0x00, 0x19, 0x00, 0x18, 0xC0, 0x06,
  0x40, 0x04, 0x30, 0x03, 0x10, 0x03, 0x0C, 0x00, 0xC4, 0x00, 0xC3, 0x00,
  0x61, 0x00, 0x60, 0xC0, 0x18, 0x40, 0x18, 0x30, 0x04, 0x10, 0x04, 0x0C,
  0x03, 0x04, 0x03, 0x03, 0x00, 0x81, 0x00, 0xC0, 0xC0, 0x60, 0x40, 0x60,
  0x30, 0x18, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x04, 0x03, 0x03, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x10, 0x06,
  0x18, 0x03, 0x0C, 0x01, 0x84, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x18, 0x80, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x01,
  0x40, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07,
  0x00, 0x40, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x5C, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 49, 14, 1, -49 },
  { 81, 13, 18, 19, 7, -49 },
  { 111, 30, 49, 30, 1, -49 },
  { 295, 27, 56, 27, 1, -52 },
  { 484, 33, 50, 40, 4, -49 },
  { 691, 27, 50, 29, 0, -49 },
  { 860, 5, 18, 10, 7, -49 },
  { 872, 18, 59, 16, 2, -48 },
  { 1005, 19, 59, 16, -5, -48 },
  { 1146, 20, 21, 26, 8, -51 },
  { 1199, 25, 32, 31, 3, -40 },
  { 1299, 9, 16, 11, -3, -7 },
  { 1317, 15, 1, 19, 2, -19 },
  { 1319, 4, 4, 12, 1, -4 },
  { 1321, 28, 48, 20, -3, -48 },
  { 1489, 25, 50, 28, 2, -49 },
  { 1646, 13, 49, 28, 9, -49 },
  { 1726, 29, 49, 28, -2, -49 },
  { 1904, 28, 50, 28, -1, -49 },
  { 2079, 28, 49, 28, -1, -49 },
  { 2251, 29, 50, 28, -1, -49 },
  { 2433, 26, 50, 28, 2, -49 },
  { 2596, 26, 49, 28, 4, -49 },
  { 2756, 28, 50, 28, 0, -49 },
  { 2931, 26, 50, 28, 1, -49 },
  { 3094, 10, 36, 12, 1, -36 },
  { 3139, 14, 45, 12, -3, -36 },
  { 3218, 25, 28, 31, 3, -38 },
  { 3306, 25, 16, 31, 3, -32 },
  { 3356, 25, 28, 31, 3, -38 },
  { 3444, 20, 49, 20, 2, -49 },
  { 3567, 38, 55, 41, 2, -49 },
  { 3829, 26, 49, 27, -4, -49 },
  { 3989, 29, 49, 30, 1, -49 },
  { 4167, 30, 50, 28, 3, -49 },
  { 4355, 31, 49, 33, 1, -49 },
  { 4545, 28, 49, 27, 1, -49 },
  { 4717, 29, 49, 25, 1, -49 },
  { 4895, 33, 50, 36, 3, -49 },
  { 5102, 34, 49, 35, 1, -49 },
  { 5311, 21, 49, 14, -3, -49 },
  { 5440, 23, 61, 12, -10, -49 },
  { 5616, 32, 49, 28, 1, -49 },
  { 5812, 18, 49, 24, 1, -49 },
  { 5923, 44, 49, 44, 1, -49 },
  { 6193, 35, 49, 36, 1, -49 },
  { 6408, 31, 50, 36, 3, -49 },
  { 6602, 28, 49, 28, 1, -49 },
  { 6774, 31, 61, 36, 3, -49 },
  { 7011, 28, 49, 28, 1, -49 },
  { 7183, 29, 50, 26, -1, -49 },
  { 7365, 23, 49, 24, 6, -49 },
  { 7506, 32, 50, 34, 3, -49 },
  { 7706, 27, 49, 27, 6, -49 },
  { 7872, 43, 49, 45, 7, -49 },
  { 8136, 33, 49, 24, -4, -49 },
  { 8339, 24, 49, 24, 6, -49 },
  { 8486, 31, 49, 26, -2, -49 },
  { 8676, 24, 60, 19, -1, -49 },
  { 8856, 9, 49, 21, 7, -49 },
  { 8912, 24, 60, 19, -4, -49 },
  { 9092, 27, 26, 30, 2, -49 },
  { 9180, 20, 1, 20, -5, 7 },
  { 9183, 7, 11, 14, 10, -52 },
  { 9193, 26, 38, 29, 2, -37 },
  { 9317, 26, 53, 29, 1, -52 },
  { 9490, 21, 38, 22, 3, -37 },
  { 9590, 30, 53, 30, 2, -52 },
  { 9789, 21, 38, 26, 3, -37 },
  { 9889, 32, 68, 14, -9, -52 },
  { 10161, 28, 53, 30, 0, -37 },
  { 10347, 25, 52, 28, 1, -52 },
  { 10510, 12, 49, 12, 1, -49 },
  { 10584, 23, 65, 12, -9, -49 },
  { 10771, 25, 52, 23, 1, -52 },
  { 10934, 13, 52, 11, 1, -52 },
  { 11019, 39, 37, 43, 1, -37 },
  { 11200, 25, 37, 28, 1, -37 },
  { 11316, 24, 38, 29, 2, -37 },
  { 11430, 29, 53, 29, -2, -37 },
  { 11623, 26, 53, 30, 2, -37 },
  { 11796, 20, 36, 19, 1, -36 },
  { 11886, 23, 38, 22, -1, -37 },
  { 11996, 14, 46, 15, 2, -45 },
  { 12077, 25, 37, 28, 2, -36 },
  { 12193, 21, 36, 21, 4, -36 },
  { 12288, 34, 36, 35, 4, -36 },
  { 12441, 28, 36, 23, -3, -36 },
  { 12567, 34, 53, 22, -8, -36 },
  { 12793, 23, 36, 20, -2, -36 },
  { 12897, 23, 60, 21, 2, -49 },
  { 13070, 2, 69, 27, 13, -52 },
  { 13088, 23, 60, 21, -4, -49 },
  { 13261, 25, 6, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_THINITALIC68PT7B_H_
