#ifndef _NOTOSANS_CONDENSED_THINITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x66,
  0x0C, 0xC1, 0x90, 0x22, 0x04, 0x41, 0x98, 0x32, 0x04, 0x40, 0x88, 0x11,
  0x06, 0x60, 0xC8, 0x11, 0x02, 0x20, 0x40, 0x00, 0x06, 0x03, 0x00, 0x02,
  0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00,
  0x40, 0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x08, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x10, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x08, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x40,
  0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x08, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x43,
  0x80, 0x60, 0x81, 0x01, 0x81, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x80, 0x01,
  0x02, 0x00, 0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x17, 0x00, 0x00, 0x23, 0x00, 0x00, 0x42, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x06, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x30, 0x38, 0x31, 0xC0, 0x3F, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x60, 0x31, 0x80, 0x0C,
  0x06, 0x08, 0x00, 0x80, 0xC0, 0xC0, 0x18, 0x08, 0x0C, 0x01, 0x01, 0x80,
  0xC0, 0x30, 0x10, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C,
  0x02, 0x00, 0x80, 0x80, 0x60, 0x08, 0x18, 0x06, 0x00, 0x81, 0x00, 0x60,
  0x18, 0x30, 0x04, 0x01, 0x82, 0x00, 0x40, 0x18, 0x60, 0x04, 0x01, 0x0C,
  0x00, 0xC0, 0x30, 0x83, 0xCC, 0x03, 0x18, 0x7E, 0xC0, 0x21, 0x0C, 0x3C,
  0x06, 0x31, 0x83, 0xC0, 0x42, 0x30, 0x14, 0x0C, 0x62, 0x01, 0x61, 0x8C,
  0x60, 0x16, 0x30, 0xC6, 0x01, 0x3E, 0x18, 0x40, 0x10, 0x01, 0x0C, 0x03,
  0x00, 0x30, 0xC0, 0x30, 0x02, 0x08, 0x03, 0x00, 0x60, 0x80, 0x30, 0x04,
  0x18, 0x02, 0x00, 0xC1, 0x80, 0x20, 0x18, 0x18, 0x06, 0x01, 0x01, 0x80,
  0x60, 0x30, 0x10, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x04,
  0x01, 0x00, 0x80, 0xC0, 0x18, 0x18, 0x18, 0x01, 0x83, 0x01, 0x00, 0x08,
  0x60, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x01, 0x00, 0x08,
  0x02, 0x00, 0x30, 0x04, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x10, 0x60, 0x00, 0x21, 0x80, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x33, 0x00, 0x00,
  0xC2, 0x00, 0x03, 0x06, 0x01, 0x0C, 0x0C, 0x06, 0x30, 0x08, 0x08, 0xC0,
  0x18, 0x31, 0x00, 0x10, 0x66, 0x00, 0x30, 0x8C, 0x00, 0x63, 0x10, 0x00,
  0x44, 0x20, 0x00, 0xD8, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03,
  0x06, 0x00, 0x0E, 0x04, 0x00, 0x36, 0x0C, 0x00, 0x4C, 0x18, 0x03, 0x08,
  0x1C, 0x0C, 0x18, 0x1F, 0xF0, 0x10, 0x03, 0x00, 0x00, 0x33, 0x32, 0x22,
  0x64, 0x44, 0x4C, 0x88, 0x80, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x08, 0x08, 0x03, 0x04, 0x00, 0xE2, 0x00, 0x19, 0x07,
  0x03, 0xFE, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x88, 0x01, 0x84, 0x01, 0x81,
  0x01, 0x80, 0x80, 0x80, 0x20, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x0C,
  0x30, 0x60, 0x83, 0x04, 0x18, 0x30, 0x41, 0x02, 0x08, 0x00, 0xFF, 0xF0,
  0x5F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x86, 0x00, 0x38,
  0x18, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40,
  0xC0, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x30,
  0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x40, 0x00, 0xC2,
  0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01,
  0x81, 0x80, 0x08, 0x0C, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0x80, 0xC0, 0x06,
  0x0C, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x07,
  0x83, 0xB0, 0xC4, 0x30, 0x9C, 0x36, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x70, 0x03,
  0x80, 0x30, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x0C,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x80, 0x03, 0x00,
  0xE0, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x16, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x06, 0x08, 0x00, 0x04, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x10, 0x00, 0x10, 0x10, 0x00, 0x30, 0x10,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x20, 0x01, 0x80, 0x20,
  0x03, 0x00, 0x60, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x40,
  0x08, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x20, 0x00, 0x80,
  0x60, 0x00, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x20, 0x03, 0x80, 0x60, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x38, 0x20, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x7C, 0x00,
  0xCF, 0xFC, 0x02, 0x70, 0x38, 0x0B, 0x00, 0x20, 0x78, 0x00, 0xC1, 0xC0,
  0x01, 0x06, 0x00, 0x04, 0x18, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x10, 0x30, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x80, 0x18, 0x02, 0x00, 0xC0,
  0x0E, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x70, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x00, 0x81, 0x80,
  0x01, 0x03, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x60, 0x06, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x60, 0x00, 0xC3, 0x80, 0x00, 0xDC, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xC0, 0xC0, 0x07, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x08, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00,
  0x21, 0x80, 0x00, 0x43, 0x00, 0x01, 0x82, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x0C, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x01,
  0x0C, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80,
  0x00, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x18,
  0x80, 0x00, 0xC4, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x05, 0x06, 0x00,
  0x78, 0x38, 0x06, 0xC0, 0xF1, 0xC4, 0x01, 0xFC, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x10, 0x18, 0x00,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x07, 0x07, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0xC0, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xF8, 0x0E, 0x0E, 0x08, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x10, 0xC0, 0x0F, 0xF0, 0x21,
  0x00, 0x38, 0xC0, 0x46, 0x00, 0xC0, 0x80, 0x88, 0x02, 0x03, 0x01, 0x10,
  0x0C, 0x06, 0x02, 0x60, 0x30, 0x08, 0x04, 0x80, 0x40, 0x10, 0x19, 0x01,
  0x80, 0x60, 0x36, 0x02, 0x00, 0xC0, 0x6C, 0x0C, 0x01, 0x00, 0xD0, 0x18,
  0x06, 0x01, 0x20, 0x20, 0x0C, 0x06, 0xC0, 0x40, 0x18, 0x0D, 0x81, 0x80,
  0x20, 0x13, 0x03, 0x00, 0xC0, 0x66, 0x06, 0x01, 0x80, 0xCC, 0x0C, 0x07,
  0x01, 0x18, 0x18, 0x0E, 0x06, 0x20, 0x30, 0x3C, 0x18, 0x40, 0x60, 0x58,
  0x30, 0x80, 0x61, 0x10, 0xC1, 0x80, 0xFC, 0x3F, 0x03, 0x00, 0x60, 0x10,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x02, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x06, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x02,
  0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x30, 0x01, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x02, 0x00, 0xFF, 0xFC, 0x01, 0x00, 0x08, 0x06,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80,
  0x01, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xC0, 0x1C, 0x00, 0x80, 0x06, 0x00, 0x80, 0x02, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x02, 0x00, 0x06,
  0x02, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x04, 0x00, 0x30,
  0x04, 0x01, 0xE0, 0x07, 0xFF, 0x00, 0x0C, 0x07, 0x80, 0x0C, 0x00, 0xE0,
  0x08, 0x00, 0x30, 0x08, 0x00, 0x30, 0x18, 0x00, 0x10, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x30,
  0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80,
  0x40, 0x07, 0x00, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0E, 0x07, 0x00, 0x38, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0C, 0x03,
  0x80, 0x02, 0x00, 0x38, 0x00, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x10, 0x06, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20,
  0x30, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x30, 0x20, 0x00, 0x08, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x40, 0x00, 0x18, 0x10, 0x00,
  0x04, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x20,
  0x00, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0x40, 0x01, 0x80, 0x10, 0x01, 0xC0, 0x0C, 0x01, 0xE0, 0x03, 0x0F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x0F,
  0xFF, 0xC0, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xFE, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x07, 0x00, 0x04, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x80, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x10, 0x04, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x02, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0x40, 0x38, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0x1C, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x0D, 0xB0, 0x00, 0x03, 0xC4,
  0x00, 0x00, 0xA1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x08, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x10, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x80, 0x08, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x40,
  0x01, 0x80, 0x10, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x01,
  0x40, 0x00, 0x00, 0xA0, 0x0A, 0x00, 0x00, 0x0F, 0x00, 0xD0, 0x00, 0x00,
  0x58, 0x06, 0x80, 0x00, 0x06, 0x80, 0x34, 0x00, 0x00, 0x24, 0x01, 0x20,
  0x00, 0x03, 0x60, 0x09, 0x80, 0x00, 0x13, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x06, 0x60, 0x00, 0x08, 0x80, 0x33, 0x00, 0x00, 0xC4, 0x01, 0x08, 0x00,
  0x0C, 0x60, 0x08, 0x40, 0x00, 0x63, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x06,
  0x10, 0x00, 0x30, 0x80, 0x20, 0x80, 0x03, 0x04, 0x01, 0x04, 0x00, 0x18,
  0x60, 0x18, 0x20, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x06, 0x0C,
  0x00, 0xC0, 0x80, 0x20, 0x60, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x60, 0x60,
  0x18, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x40, 0x30, 0x10, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x18, 0x0C, 0x01, 0x00, 0x80, 0x80, 0x60, 0x18,
  0x04, 0x0C, 0x02, 0x00, 0xC0, 0x20, 0x40, 0x10, 0x04, 0x01, 0x86, 0x00,
  0x80, 0x20, 0x0C, 0x20, 0x0C, 0x03, 0x00, 0x63, 0x00, 0x60, 0x18, 0x03,
  0x10, 0x02, 0x00, 0xC0, 0x19, 0x80, 0x10, 0x04, 0x00, 0x48, 0x01, 0x80,
  0x20, 0x02, 0xC0, 0x0C, 0x03, 0x00, 0x14, 0x00, 0x60, 0x18, 0x00, 0xE0,
  0x02, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x08, 0x07,
  0x00, 0x00, 0x40, 0x38, 0x00, 0x06, 0x01, 0x40, 0x00, 0x30, 0x0A, 0x00,
  0x01, 0x00, 0xD8, 0x00, 0x08, 0x06, 0xC0, 0x00, 0x40, 0x32, 0x00, 0x06,
  0x01, 0x10, 0x00, 0x30, 0x08, 0xC0, 0x01, 0x00, 0xC6, 0x00, 0x08, 0x06,
  0x10, 0x00, 0xC0, 0x20, 0x80, 0x06, 0x01, 0x06, 0x00, 0x30, 0x08, 0x30,
  0x01, 0x00, 0xC0, 0x80, 0x08, 0x06, 0x04, 0x00, 0xC0, 0x20, 0x30, 0x06,
  0x01, 0x01, 0x80, 0x30, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x0C, 0x06, 0x01, 0x00, 0x20, 0x20, 0x18, 0x01,
  0x01, 0x00, 0xC0, 0x0C, 0x18, 0x06, 0x00, 0x60, 0xC0, 0x20, 0x01, 0x06,
  0x01, 0x00, 0x08, 0x20, 0x18, 0x00, 0x61, 0x00, 0xC0, 0x03, 0x18, 0x04,
  0x00, 0x08, 0xC0, 0x20, 0x00, 0x66, 0x03, 0x00, 0x03, 0x20, 0x18, 0x00,
  0x19, 0x00, 0xC0, 0x00, 0x58, 0x04, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x18, 0x18,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08,
  0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x06, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20, 0x00,
  0x01, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x04, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x40,
  0x08, 0x00, 0x30, 0x03, 0x00, 0x38, 0x00, 0x70, 0x18, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0x00, 0xE0, 0x04, 0x00, 0xE0, 0x08, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x02, 0x02, 0x00, 0x04, 0x0C, 0x00,
  0x08, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80, 0x01,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x10, 0x00, 0x40,
  0x20, 0x01, 0x80, 0xC0, 0x0E, 0x01, 0x80, 0x70, 0x03, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x20,
  0x00, 0x18, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0x40, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x40, 0x08, 0x00, 0x30, 0x03, 0x00, 0x38, 0x00, 0x70, 0x18,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0xE0, 0x04, 0x00,
  0x60, 0x08, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x08, 0x08, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x20, 0x03, 0x00, 0xC0,
  0x1C, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x08, 0x00, 0x60, 0x10, 0x00, 0x80, 0x30, 0x01, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x80, 0x20, 0x03, 0x00,
  0x40, 0x06, 0x01, 0x80, 0x04, 0x03, 0x00, 0x08, 0x04, 0x00, 0x18, 0x08,
  0x00, 0x30, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x3C, 0x0F, 0x00, 0x70, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x80, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x06, 0x02, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x18, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08,
  0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x13,
  0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x00,
  0x03, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x04,
  0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x06, 0x01, 0x00, 0x10, 0x04,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x03,
  0x00, 0x10, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x01, 0x80, 0x06, 0x04, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x18,
  0xC0, 0x00, 0x62, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x09, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0xB0, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0F,
  0x00, 0x02, 0x20, 0x00, 0x58, 0x00, 0x31, 0x00, 0x06, 0xC0, 0x01, 0x08,
  0x00, 0x36, 0x00, 0x18, 0x40, 0x01, 0x30, 0x00, 0xC2, 0x00, 0x19, 0x80,
  0x04, 0x10, 0x00, 0x8C, 0x00, 0x60, 0x80, 0x0C, 0x60, 0x02, 0x04, 0x00,
  0x43, 0x00, 0x30, 0x20, 0x02, 0x18, 0x01, 0x01, 0x00, 0x30, 0xC0, 0x18,
  0x08, 0x01, 0x06, 0x00, 0xC0, 0x40, 0x18, 0x30, 0x04, 0x02, 0x00, 0x81,
  0x80, 0x60, 0x10, 0x0C, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x60, 0x30, 0x04,
  0x02, 0x03, 0x01, 0x80, 0x20, 0x30, 0x18, 0x08, 0x01, 0x01, 0x00, 0xC0,
  0xC0, 0x08, 0x18, 0x04, 0x04, 0x00, 0x40, 0x80, 0x20, 0x60, 0x02, 0x0C,
  0x01, 0x02, 0x00, 0x10, 0x60, 0x08, 0x30, 0x00, 0x82, 0x00, 0x41, 0x80,
  0x04, 0x30, 0x02, 0x08, 0x00, 0x21, 0x00, 0x10, 0xC0, 0x01, 0x18, 0x00,
  0x84, 0x00, 0x08, 0xC0, 0x04, 0x60, 0x00, 0x44, 0x00, 0x22, 0x00, 0x02,
  0x60, 0x01, 0x10, 0x00, 0x12, 0x00, 0x09, 0x80, 0x00, 0xB0, 0x00, 0x48,
  0x00, 0x05, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x14, 0x00, 0x01, 0xC0,
  0x00, 0xA0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x30, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x01, 0x00, 0x10, 0x00, 0x10,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x20, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0x40,
  0x00, 0x84, 0x00, 0x18, 0x40, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x06,
  0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x02, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x18, 0x00, 0x1B, 0x00, 0x01, 0xA0, 0x00, 0x1E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x80,
  0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20,
  0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x08, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02,
  0x02, 0x02, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00,
  0x0D, 0x80, 0x00, 0x22, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x30,
  0x40, 0x01, 0x81, 0x80, 0x04, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x40, 0x30, 0x01, 0x80, 0xC0, 0x02, 0x06, 0x00, 0x0C, 0x10,
  0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x02, 0xC0, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x04,
  0x00, 0x0C, 0x00, 0x03, 0xF8, 0x40, 0x70, 0x62, 0x06, 0x01, 0x90, 0x60,
  0x05, 0x83, 0x00, 0x3C, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x80, 0x01, 0x8C, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x10, 0x01, 0x40, 0x80,
  0x12, 0x06, 0x01, 0xB0, 0x18, 0x39, 0x00, 0x7F, 0x08, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x0C, 0x7F, 0x80, 0x23, 0x07, 0x00, 0x98, 0x0C, 0x06, 0xC0, 0x18, 0x1E,
  0x00, 0x60, 0x50, 0x00, 0x81, 0xC0, 0x02, 0x06, 0x00, 0x0C, 0x38, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x08, 0x60, 0x00, 0x21,
  0x80, 0x00, 0x86, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00,
  0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0x82, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x60, 0x00, 0xC1, 0xC0, 0x02, 0x05, 0x00, 0x18, 0x14,
  0x00, 0xC0, 0xD8, 0x06, 0x02, 0x30, 0x30, 0x08, 0x7F, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1C, 0x04, 0x0E, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x02, 0x00, 0xFF, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0xC0, 0x03, 0xFC, 0x60, 0x07, 0x03, 0x20,
  0x06, 0x00, 0x90, 0x06, 0x00, 0x68, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0E,
  0x01, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x40, 0x00, 0x60, 0x20, 0x00, 0x20, 0x30, 0x00, 0x10, 0x18, 0x00,
  0x18, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x02, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x3C, 0x03,
  0x00, 0x34, 0x00, 0x80, 0x1A, 0x00, 0x60, 0x19, 0x00, 0x18, 0x38, 0x80,
  0x07, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xC0,
  0x1C, 0x18, 0x0E, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x10, 0xC0, 0x04, 0x20,
  0x03, 0x18, 0x00, 0xC4, 0x00, 0x23, 0x00, 0x18, 0x80, 0x0C, 0x60, 0x06,
  0x18, 0x03, 0x04, 0x07, 0x81, 0xFF, 0x00, 0x78, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x03, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE3, 0x00, 0x70,
  0x33, 0x00, 0xC0, 0x12, 0x01, 0x80, 0x1A, 0x01, 0x80, 0x0A, 0x03, 0x00,
  0x0E, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x01, 0xE0, 0x30, 0x03,
  0x40, 0x10, 0x03, 0x40, 0x18, 0x06, 0x40, 0x0C, 0x1C, 0xC0, 0x07, 0xF0,
  0xC0, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x38,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x31, 0xFE, 0x02, 0x70, 0x70, 0x2C, 0x03, 0x06,
  0x80, 0x10, 0x70, 0x01, 0x07, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10,
  0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x21, 0x80, 0x02,
  0x18, 0x00, 0x21, 0x80, 0x06, 0x10, 0x00, 0x61, 0x00, 0x04, 0x30, 0x00,
  0x43, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00,
  0x08, 0x60, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x00, 0x00, 0x40, 0x30, 0x1C, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x03, 0x02, 0x00, 0x60,
  0x20, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x40, 0x60,
  0x04, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0x82, 0x00, 0x08, 0x60,
  0x01, 0x8C, 0x00, 0x19, 0xE0, 0x01, 0xB6, 0x00, 0x16, 0x60, 0x01, 0xC2,
  0x00, 0x38, 0x30, 0x03, 0x03, 0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x04, 0x00, 0x80, 0x40, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0x80, 0x06, 0x00, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x00, 0x00, 0x06, 0x00, 0x30, 0x01, 0x1F, 0xE0, 0xFF,
  0x00, 0x98, 0x18, 0xC0, 0xC0, 0x58, 0x0C, 0xC0, 0x30, 0x78, 0x02, 0xC0,
  0x18, 0x38, 0x01, 0x40, 0x0C, 0x1C, 0x00, 0xE0, 0x06, 0x0C, 0x00, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x01, 0x86, 0x00, 0x10, 0x00, 0x83, 0x00, 0x08,
  0x00, 0x41, 0x80, 0x0C, 0x00, 0x20, 0x80, 0x06, 0x00, 0x30, 0xC0, 0x02,
  0x00, 0x18, 0x60, 0x01, 0x00, 0x08, 0x30, 0x01, 0x80, 0x04, 0x10, 0x00,
  0xC0, 0x02, 0x08, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x20, 0x01, 0x86, 0x00,
  0x10, 0x00, 0x83, 0x00, 0x18, 0x00, 0x41, 0x00, 0x0C, 0x00, 0x60, 0x80,
  0x04, 0x00, 0x30, 0xC0, 0x02, 0x00, 0x18, 0x60, 0x03, 0x00, 0x08, 0x20,
  0x01, 0x80, 0x04, 0x10, 0x00, 0xC0, 0x06, 0x08, 0x00, 0x40, 0x03, 0x0C,
  0x00, 0x20, 0x01, 0x06, 0x00, 0x30, 0x00, 0x82, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x21, 0xFE, 0x02, 0x70, 0x70, 0x2C, 0x03, 0x06, 0x80,
  0x10, 0x70, 0x01, 0x07, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x21, 0x80, 0x02, 0x18,
  0x00, 0x21, 0x80, 0x06, 0x10, 0x00, 0x61, 0x00, 0x04, 0x30, 0x00, 0x43,
  0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x08,
  0x60, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01,
  0x0C, 0x00, 0x30, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01,
  0xC1, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x02, 0x0C, 0x00, 0x30,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x20, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00,
  0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00,
  0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0x40,
  0x02, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x83, 0x80, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x21, 0xFE, 0x00, 0x11, 0x83, 0x80,
  0x09, 0x80, 0xC0, 0x0D, 0x80, 0x30, 0x07, 0x80, 0x08, 0x02, 0x80, 0x04,
  0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00,
  0x04, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x08, 0x02,
  0x80, 0x0C, 0x01, 0x40, 0x0C, 0x01, 0xB0, 0x0C, 0x00, 0xCC, 0x1C, 0x00,
  0x43, 0xFC, 0x00, 0x20, 0x60, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xFE, 0x30, 0x1C, 0x1C, 0xC0, 0xC0, 0x12, 0x06, 0x00, 0x68, 0x18, 0x00,
  0xA0, 0xC0, 0x03, 0x82, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00,
  0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x1E, 0x0C, 0x00, 0x50, 0x10, 0x03,
  0x40, 0x60, 0x19, 0x00, 0xC1, 0xCC, 0x01, 0xFC, 0x30, 0x01, 0xC0, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x02, 0x01,
  0x0F, 0xC0, 0x9C, 0x00, 0x58, 0x00, 0x68, 0x00, 0x2C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0x30, 0x1C, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x80, 0x18, 0x30, 0x1C, 0x0F, 0xFE,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x07, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x07, 0xE0, 0x0C, 0x00, 0x04, 0x00, 0x18, 0x20, 0x00, 0x83, 0x00,
  0x04, 0x18, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x83,
  0x00, 0x04, 0x18, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x10, 0x60, 0x00,
  0x83, 0x00, 0x04, 0x18, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x10, 0x60,
  0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x10,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00,
  0x70, 0x30, 0x06, 0x81, 0x80, 0x64, 0x06, 0x06, 0x60, 0x1F, 0xE2, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C,
  0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x00, 0x30, 0x40, 0x0C, 0x10,
  0x06, 0x04, 0x01, 0x81, 0x00, 0xC0, 0x40, 0x30, 0x10, 0x18, 0x04, 0x06,
  0x01, 0x01, 0x00, 0x40, 0xC0, 0x10, 0x20, 0x06, 0x18, 0x01, 0x84, 0x00,
  0x63, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01, 0x90, 0x00, 0x6C, 0x00, 0x1A,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x1E, 0x00, 0x18, 0x00, 0xB0, 0x01, 0xC0, 0x0D, 0x80, 0x0E,
  0x00, 0x4C, 0x00, 0xF0, 0x06, 0x20, 0x05, 0x80, 0x31, 0x00, 0x6C, 0x01,
  0x08, 0x02, 0x60, 0x18, 0x40, 0x33, 0x00, 0x82, 0x01, 0x18, 0x0C, 0x10,
  0x08, 0xC0, 0x40, 0x80, 0xC6, 0x02, 0x04, 0x04, 0x30, 0x30, 0x20, 0x61,
  0x81, 0x01, 0x02, 0x04, 0x18, 0x08, 0x30, 0x20, 0x80, 0x41, 0x01, 0x0C,
  0x02, 0x18, 0x08, 0x60, 0x10, 0x80, 0x42, 0x00, 0x84, 0x02, 0x30, 0x04,
  0x60, 0x11, 0x00, 0x22, 0x00, 0x98, 0x01, 0x30, 0x04, 0x80, 0x09, 0x00,
  0x24, 0x00, 0x58, 0x01, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x08, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x20, 0x40, 0x00,
  0x41, 0x80, 0x00, 0xC6, 0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x40,
  0x00, 0x40, 0x80, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x08, 0x02, 0x00,
  0x30, 0x04, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x04, 0x00, 0x10, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x02, 0x00, 0x01, 0x00, 0x30, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x10, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x70, 0x38, 0x07,
  0x00, 0x78, 0xE8, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 41, 12, 1, -41 },
  { 58, 11, 15, 16, 6, -41 },
  { 79, 25, 41, 25, 1, -41 },
  { 208, 23, 46, 23, 0, -43 },
  { 341, 28, 42, 34, 3, -41 },
  { 488, 23, 42, 25, 0, -41 },
  { 609, 4, 15, 9, 6, -41 },
  { 617, 15, 50, 14, 2, -41 },
  { 711, 16, 50, 14, -4, -41 },
  { 811, 17, 18, 22, 7, -43 },
  { 850, 22, 26, 26, 2, -33 },
  { 922, 7, 13, 9, -2, -6 },
  { 934, 12, 1, 16, 2, -16 },
  { 936, 3, 4, 10, 1, -4 },
  { 938, 24, 41, 17, -3, -41 },
  { 1061, 21, 42, 23, 2, -41 },
  { 1172, 11, 41, 23, 7, -41 },
  { 1229, 23, 41, 23, -1, -41 },
  { 1347, 24, 42, 23, -1, -41 },
  { 1473, 24, 41, 23, -1, -41 },
  { 1596, 23, 42, 23, 0, -41 },
  { 1717, 22, 42, 23, 2, -41 },
  { 1833, 22, 41, 23, 3, -41 },
  { 1946, 23, 42, 23, 0, -41 },
  { 2067, 21, 42, 23, 1, -41 },
  { 2178, 8, 30, 10, 1, -30 },
  { 2208, 12, 37, 10, -3, -30 },
  { 2264, 22, 24, 26, 2, -32 },
  { 2330, 22, 14, 26, 2, -27 },
  { 2369, 22, 24, 26, 2, -32 },
  { 2435, 16, 41, 17, 2, -41 },
  { 2517, 31, 46, 35, 2, -41 },
  { 2696, 23, 41, 22, -4, -41 },
  { 2814, 24, 41, 25, 1, -41 },
  { 2937, 24, 42, 24, 3, -41 },
  { 3063, 26, 41, 28, 1, -41 },
  { 3197, 24, 41, 23, 1, -41 },
  { 3320, 24, 41, 21, 1, -41 },
  { 3443, 27, 42, 30, 3, -41 },
  { 3585, 29, 41, 29, 1, -41 },
  { 3734, 17, 41, 11, -2, -41 },
  { 3822, 20, 51, 10, -9, -41 },
  { 3950, 26, 41, 23, 1, -41 },
  { 4084, 15, 41, 20, 1, -41 },
  { 4161, 37, 41, 37, 1, -41 },
  { 4351, 29, 41, 30, 1, -41 },
  { 4500, 26, 42, 30, 3, -41 },
  { 4637, 23, 41, 24, 1, -41 },
  { 4755, 26, 51, 30, 3, -41 },
  { 4921, 23, 41, 24, 1, -41 },
  { 5039, 24, 42, 22, -1, -41 },
  { 5165, 20, 41, 20, 5, -41 },
  { 5268, 27, 42, 29, 3, -41 },
  { 5410, 22, 41, 23, 5, -41 },
  { 5523, 37, 41, 38, 5, -41 },
  { 5713, 28, 41, 20, -3, -41 },
  { 5857, 20, 41, 20, 5, -41 },
  { 5960, 26, 41, 21, -2, -41 },
  { 6094, 21, 50, 16, -1, -41 },
  { 6226, 8, 41, 18, 6, -41 },
  { 6267, 21, 50, 16, -4, -41 },
  { 6399, 22, 21, 25, 2, -41 },
  { 6457, 16, 2, 17, -4, 5 },
  { 6461, 6, 9, 12, 8, -44 },
  { 6468, 21, 32, 24, 2, -31 },
  { 6552, 22, 44, 25, 1, -43 },
  { 6673, 18, 32, 18, 2, -31 },
  { 6745, 25, 44, 25, 2, -43 },
  { 6883, 18, 32, 21, 2, -31 },
  { 6955, 26, 58, 12, -7, -44 },
  { 7144, 24, 45, 25, 0, -31 },
  { 7279, 20, 43, 24, 1, -43 },
  { 7387, 10, 41, 10, 1, -41 },
  { 7439, 19, 55, 10, -8, -41 },
  { 7570, 20, 43, 19, 1, -43 },
  { 7678, 10, 43, 9, 1, -43 },
  { 7732, 33, 31, 36, 1, -31 },
  { 7860, 20, 31, 24, 1, -31 },
  { 7938, 20, 32, 24, 2, -31 },
  { 8018, 25, 44, 25, -2, -31 },
  { 8156, 22, 44, 25, 2, -31 },
  { 8277, 17, 31, 16, 1, -31 },
  { 8343, 18, 32, 18, 0, -31 },
  { 8415, 13, 38, 12, 1, -37 },
  { 8477, 21, 31, 24, 2, -30 },
  { 8559, 18, 30, 18, 3, -30 },
  { 8627, 29, 30, 29, 3, -30 },
  { 8736, 23, 30, 19, -2, -30 },
  { 8823, 29, 44, 19, -7, -30 },
  { 8983, 20, 30, 17, -2, -30 },
  { 9058, 19, 50, 18, 2, -41 },
  { 9177, 1, 57, 23, 11, -43 },
  { 9185, 19, 50, 18, -3, -41 },
  { 9304, 21, 5, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_THINITALIC57PT7B_H_
