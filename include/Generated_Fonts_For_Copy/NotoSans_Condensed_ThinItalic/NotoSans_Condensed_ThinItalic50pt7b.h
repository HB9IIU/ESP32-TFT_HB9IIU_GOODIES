#ifndef _NOTOSANS_CONDENSED_THINITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x30, 0x4C,
  0x32, 0x0C, 0x82, 0x20, 0x98, 0x24, 0x19, 0x04, 0x41, 0x10, 0x4C, 0x12,
  0x08, 0x82, 0x00, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x18,
  0x10, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x08, 0x07, 0xFF, 0xFF,
  0x00, 0x80, 0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01,
  0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x3F, 0xFF, 0xF0, 0x08, 0x08, 0x00,
  0x20, 0x20, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40,
  0xC0, 0x03, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x81, 0x80,
  0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x07, 0xDF, 0x01, 0x84, 0x10,
  0x30, 0x40, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x04, 0x08, 0x00, 0x41, 0x80, 0x06, 0x18, 0x00, 0x21, 0x00, 0x03, 0x10,
  0x00, 0x19, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x24, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x04, 0x10, 0x00,
  0x41, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00,
  0x08, 0x30, 0x01, 0x82, 0x08, 0x10, 0xC0, 0xF9, 0x78, 0x01, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xC0, 0x02, 0x0C, 0x60, 0x04, 0x08, 0x20, 0x0C, 0x10, 0x30,
  0x08, 0x30, 0x30, 0x18, 0x20, 0x30, 0x10, 0x20, 0x30, 0x30, 0x60, 0x30,
  0x20, 0x40, 0x20, 0x40, 0x40, 0x20, 0xC0, 0x40, 0x20, 0x80, 0xC0, 0x21,
  0x80, 0xC0, 0x61, 0x00, 0x80, 0x43, 0x00, 0x80, 0x42, 0x1C, 0x80, 0xC4,
  0x37, 0x80, 0x8C, 0x41, 0x80, 0x88, 0xC1, 0x81, 0x99, 0x81, 0xC3, 0x11,
  0x01, 0x46, 0x31, 0x01, 0x3C, 0x23, 0x01, 0x00, 0x42, 0x01, 0x00, 0xC2,
  0x01, 0x00, 0x86, 0x01, 0x01, 0x86, 0x03, 0x01, 0x04, 0x03, 0x03, 0x04,
  0x02, 0x02, 0x04, 0x02, 0x04, 0x04, 0x06, 0x04, 0x04, 0x04, 0x08, 0x04,
  0x04, 0x18, 0x04, 0x08, 0x10, 0x04, 0x18, 0x30, 0x06, 0x10, 0x60, 0x03,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x03, 0x18, 0x00, 0x40, 0x80,
  0x0C, 0x0C, 0x00, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C,
  0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x86,
  0x00, 0x08, 0xC0, 0x00, 0x98, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x1E,
  0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x30, 0x01, 0x81, 0x01, 0x10,
  0x18, 0x32, 0x00, 0x82, 0x60, 0x08, 0x64, 0x00, 0xC4, 0x40, 0x04, 0xCC,
  0x00, 0x68, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70,
  0x40, 0x0D, 0x06, 0x01, 0x88, 0x30, 0x30, 0x81, 0xFC, 0x0C, 0x02, 0x00,
  0x00, 0x33, 0x22, 0x26, 0x44, 0x44, 0xC8, 0x80, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x10, 0x0C, 0x20,
  0x06, 0x40, 0x83, 0xBF, 0x03, 0x80, 0x0A, 0x00, 0x22, 0x00, 0x84, 0x02,
  0x04, 0x08, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xF0,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x30, 0x82, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x00, 0xFF,
  0xE0, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x30,
  0xC0, 0x18, 0x18, 0x0C, 0x02, 0x06, 0x00, 0x81, 0x00, 0x30, 0xC0, 0x0C,
  0x20, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03, 0x20,
  0x00, 0xC8, 0x00, 0x26, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x64, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x10, 0x80,
  0x0C, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00, 0x40, 0xC0, 0x30, 0x10, 0x18,
  0x06, 0x0C, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x38,
  0x32, 0x18, 0x8C, 0x2C, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x07, 0x07, 0x00, 0x60,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x03, 0x00, 0x60, 0x0C,
  0x02, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x30, 0x06, 0x00,
  0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x98, 0x00, 0x0C,
  0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00,
  0x20, 0x80, 0x03, 0x04, 0x00, 0x30, 0x20, 0x01, 0x03, 0x00, 0x18, 0x10,
  0x01, 0x80, 0x80, 0x08, 0x04, 0x00, 0xC0, 0x20, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x60, 0x04, 0x02, 0x00, 0x60, 0x20, 0x03, 0x03,
  0x00, 0x10, 0x1F, 0xFF, 0xFD, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x01, 0x80, 0x80, 0x30, 0x07, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x06, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x38, 0x01, 0x3D, 0xE0, 0x6C, 0x06, 0x0B, 0x00, 0x41, 0xC0, 0x0C, 0x30,
  0x01, 0x8C, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x03, 0x10, 0x00, 0x62, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00,
  0x0C, 0x20, 0x01, 0x06, 0x00, 0x60, 0x40, 0x18, 0x0C, 0x06, 0x00, 0xC1,
  0x80, 0x0F, 0xE0, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x06,
  0x0C, 0x01, 0x80, 0x60, 0x10, 0x03, 0x03, 0x00, 0x10, 0x20, 0x01, 0x02,
  0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x30,
  0x20, 0x02, 0x03, 0x00, 0x40, 0x10, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x60,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xD8, 0x00, 0x70, 0xC0, 0x0C, 0x06,
  0x01, 0x80, 0x30, 0x30, 0x01, 0x06, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00,
  0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x84, 0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x60, 0x18, 0x1C, 0x00,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x60, 0x0C, 0x02,
  0x01, 0x00, 0x60, 0x60, 0x04, 0x18, 0x00, 0x82, 0x00, 0x18, 0x40, 0x03,
  0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04,
  0x60, 0x00, 0x8C, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC2, 0x00, 0x38,
  0x60, 0x0E, 0x04, 0x03, 0x40, 0xE1, 0xC8, 0x07, 0xE3, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x02, 0x06, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x04, 0x0C, 0x38,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x83, 0x00, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xE0, 0x60, 0xE0, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xE0,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x04, 0x20, 0x02, 0x00, 0x8C, 0x03, 0xF8, 0x11, 0x00, 0xC1, 0x02, 0x60,
  0x30, 0x60, 0x48, 0x0C, 0x0C, 0x09, 0x01, 0x01, 0x01, 0x60, 0x40, 0x20,
  0x28, 0x18, 0x0C, 0x0D, 0x03, 0x01, 0x81, 0xA0, 0x40, 0x20, 0x2C, 0x18,
  0x04, 0x05, 0x83, 0x01, 0x81, 0xA0, 0x40, 0x30, 0x34, 0x08, 0x04, 0x04,
  0x81, 0x01, 0x81, 0x90, 0x20, 0x30, 0x22, 0x04, 0x0A, 0x0C, 0x40, 0xC1,
  0x41, 0x08, 0x18, 0x4C, 0x41, 0x01, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x04,
  0x80, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x0C, 0x20, 0x01, 0x04, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x03,
  0x00, 0x40, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x10, 0x06,
  0x03, 0xFF, 0xC0, 0xC0, 0x08, 0x10, 0x01, 0x06, 0x00, 0x20, 0x80, 0x04,
  0x30, 0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x09,
  0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x10,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x40, 0x18, 0x02, 0x00, 0x60, 0x10,
  0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00,
  0x30, 0x30, 0x03, 0x01, 0x80, 0x30, 0x08, 0x1F, 0x00, 0x7F, 0xE0, 0x02,
  0x01, 0xC0, 0x30, 0x03, 0x01, 0x00, 0x08, 0x08, 0x00, 0x60, 0x40, 0x01,
  0x02, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x60,
  0x40, 0x06, 0x06, 0x00, 0x60, 0x30, 0x1E, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xC0, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x10, 0x06, 0x00, 0x40, 0x0C,
  0x01, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00,
  0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0x80, 0x00,
  0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x04,
  0x00, 0x10, 0x10, 0x01, 0x80, 0x40, 0x0E, 0x03, 0x00, 0x60, 0x08, 0x1F,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xF8, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0E, 0x03, 0xC0, 0x1C, 0x00, 0x40,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0x08, 0x00, 0xFF, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10,
  0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x20,
  0x03, 0x80, 0x30, 0x00, 0x7F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x10, 0x18, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x02,
  0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0,
  0x40, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30, 0x00, 0x10, 0x10, 0x00, 0x18,
  0x08, 0x00, 0x0C, 0x07, 0xFF, 0xFC, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01,
  0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x60, 0x00,
  0x20, 0x30, 0x00, 0x10, 0x10, 0x00, 0x18, 0x08, 0x00, 0x08, 0x04, 0x00,
  0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x80, 0x40, 0x00, 0x40, 0x60, 0x00, 0x20, 0x20, 0x00, 0x30, 0x10,
  0x00, 0x18, 0x00, 0x00, 0xFE, 0x02, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x01,
  0xF8, 0x00, 0xB8, 0x00, 0x00, 0x01, 0x80, 0x06, 0x02, 0x00, 0x18, 0x04,
  0x00, 0x60, 0x08, 0x00, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x30, 0x01, 0x00, 0xC0, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x86, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x60, 0x00, 0x09, 0xC0, 0x00, 0x16, 0x80, 0x00, 0x29, 0x80, 0x00,
  0xE1, 0x00, 0x01, 0x82, 0x00, 0x02, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18,
  0x08, 0x00, 0x30, 0x10, 0x00, 0x40, 0x30, 0x00, 0x80, 0x20, 0x01, 0x00,
  0x40, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x03,
  0x00, 0x40, 0x06, 0x01, 0x80, 0x04, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0xFF, 0xF0,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0A, 0x03, 0x40, 0x00, 0x1A,
  0x02, 0x40, 0x00, 0x16, 0x02, 0x40, 0x00, 0x36, 0x02, 0x40, 0x00, 0x24,
  0x06, 0x40, 0x00, 0x64, 0x06, 0x40, 0x00, 0x44, 0x04, 0x40, 0x00, 0xCC,
  0x04, 0x40, 0x00, 0x88, 0x04, 0x40, 0x01, 0x88, 0x0C, 0x60, 0x01, 0x08,
  0x0C, 0x60, 0x03, 0x08, 0x08, 0x20, 0x02, 0x18, 0x08, 0x20, 0x06, 0x10,
  0x08, 0x20, 0x04, 0x10, 0x18, 0x20, 0x08, 0x10, 0x10, 0x20, 0x08, 0x30,
  0x10, 0x20, 0x10, 0x30, 0x10, 0x20, 0x10, 0x20, 0x30, 0x20, 0x20, 0x20,
  0x30, 0x20, 0x60, 0x20, 0x20, 0x30, 0x40, 0x60, 0x20, 0x30, 0xC0, 0x40,
  0x20, 0x30, 0x80, 0x40, 0x60, 0x11, 0x80, 0x40, 0x60, 0x11, 0x00, 0x40,
  0x40, 0x13, 0x00, 0xC0, 0x40, 0x12, 0x00, 0x80, 0x40, 0x16, 0x00, 0x80,
  0xC0, 0x14, 0x00, 0x80, 0x80, 0x1C, 0x01, 0x80, 0x80, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x18, 0x00, 0x08, 0x07, 0x00,
  0x02, 0x03, 0x40, 0x01, 0x80, 0xD0, 0x00, 0x60, 0x24, 0x00, 0x10, 0x09,
  0x80, 0x04, 0x02, 0x20, 0x01, 0x01, 0x88, 0x00, 0xC0, 0x62, 0x00, 0x20,
  0x10, 0xC0, 0x08, 0x04, 0x10, 0x02, 0x01, 0x04, 0x01, 0x80, 0xC1, 0x00,
  0x60, 0x20, 0x60, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x30, 0x10, 0x04, 0x08, 0x04, 0x01, 0x02, 0x01,
  0x00, 0x60, 0x80, 0xC0, 0x18, 0x60, 0x30, 0x02, 0x18, 0x08, 0x00, 0x84,
  0x02, 0x00, 0x31, 0x00, 0x80, 0x0C, 0x40, 0x60, 0x01, 0x30, 0x18, 0x00,
  0x48, 0x04, 0x00, 0x1A, 0x01, 0x00, 0x02, 0x80, 0x40, 0x00, 0xA0, 0x30,
  0x00, 0x38, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x60, 0xE0, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x40,
  0x40, 0x00, 0x81, 0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x60, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x26, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0xC8, 0x00, 0x01,
  0x90, 0x00, 0x02, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x23,
  0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x30, 0x30, 0x00, 0x40, 0x20, 0x01, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x30, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF8, 0x01, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x00, 0x30, 0x30, 0x03, 0x02,
  0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10,
  0x40, 0x03, 0x04, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x04,
  0x08, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x07, 0x01, 0xFF, 0xC0, 0x1F, 0xE0,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x60, 0xE0, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x10, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x82, 0x00,
  0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00, 0x08, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x26, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24,
  0x00, 0x00, 0xC8, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00,
  0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x30, 0x00, 0x40, 0x20, 0x01,
  0x00, 0x60, 0x04, 0x00, 0x60, 0x30, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x00,
  0x30, 0x30, 0x03, 0x02, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60,
  0x01, 0x06, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C,
  0x00, 0x60, 0xC0, 0x0C, 0x08, 0x01, 0x80, 0x80, 0x30, 0x08, 0x0E, 0x01,
  0xFF, 0x80, 0x10, 0x30, 0x01, 0x01, 0x00, 0x10, 0x10, 0x03, 0x01, 0x80,
  0x30, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x0C,
  0x06, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0x80, 0x02, 0x08, 0x00, 0x20, 0x00, 0x1F, 0xE0, 0x01, 0xC0, 0xF0,
  0x0C, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x01, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x01,
  0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02,
  0x04, 0x00, 0x06, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x04,
  0x0C, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x08,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x10, 0x00, 0x10,
  0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x30,
  0x20, 0x00, 0x20, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x40, 0x00, 0x60,
  0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x40, 0x01, 0x00, 0x60, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC2,
  0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x04,
  0x00, 0x80, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08,
  0x0C, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x08,
  0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x06, 0x80, 0x03, 0x80, 0x04, 0x80, 0x07, 0x80, 0x04, 0x80, 0x05,
  0x80, 0x0C, 0x80, 0x05, 0x80, 0x08, 0x80, 0x0D, 0x80, 0x18, 0x80, 0x09,
  0x80, 0x10, 0x80, 0x19, 0x80, 0x10, 0x80, 0x11, 0x80, 0x30, 0x80, 0x11,
  0x80, 0x20, 0x80, 0x21, 0x80, 0x60, 0x80, 0x21, 0x80, 0x40, 0x80, 0x61,
  0x80, 0xC0, 0x80, 0x41, 0x80, 0x80, 0x80, 0xC1, 0x80, 0x80, 0x80, 0x81,
  0x81, 0x80, 0x80, 0x81, 0x81, 0x00, 0x81, 0x81, 0x03, 0x00, 0x81, 0x01,
  0x02, 0x00, 0x83, 0x01, 0x02, 0x00, 0x82, 0x01, 0x06, 0x00, 0x82, 0x01,
  0x04, 0x00, 0x84, 0x01, 0x0C, 0x00, 0x84, 0x01, 0x08, 0x00, 0x8C, 0x01,
  0x18, 0x00, 0x88, 0x01, 0x10, 0x00, 0x98, 0x01, 0x10, 0x00, 0x90, 0x01,
  0x30, 0x00, 0x90, 0x01, 0x20, 0x00, 0xB0, 0x01, 0x60, 0x00, 0xA0, 0x01,
  0x40, 0x00, 0xE0, 0x01, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x01, 0x80, 0x20, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0x80, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x30, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x10,
  0x00, 0x02, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x40, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x18, 0x00, 0x01, 0x84, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x40, 0x60, 0x00, 0x40, 0x10, 0x00, 0x60, 0x08, 0x00,
  0x20, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00, 0xC0,
  0x18, 0x00, 0x20, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x24,
  0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x01, 0x86, 0x00, 0x41, 0x80,
  0x30, 0x20, 0x18, 0x08, 0x04, 0x02, 0x03, 0x00, 0x80, 0x80, 0x20, 0x60,
  0x0C, 0x10, 0x01, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01,
  0x20, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0xFE, 0x00, 0x81, 0x03, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40,
  0x81, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x03,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x24, 0x00,
  0x08, 0x80, 0x03, 0x18, 0x00, 0x41, 0x00, 0x18, 0x30, 0x02, 0x06, 0x00,
  0xC0, 0x40, 0x30, 0x0C, 0x04, 0x00, 0x81, 0x80, 0x18, 0x20, 0x03, 0x0C,
  0x00, 0x21, 0x00, 0x06, 0x60, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0xFF, 0xFE, 0xC2, 0x18, 0x43, 0x08, 0x21, 0x00, 0x78, 0x20, 0x39, 0xC8,
  0x0C, 0x09, 0x02, 0x00, 0xA0, 0xC0, 0x14, 0x30, 0x03, 0x84, 0x00, 0x61,
  0x80, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0x84,
  0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x20,
  0x05, 0x06, 0x01, 0xA0, 0x40, 0x6C, 0x0C, 0x19, 0x00, 0xFE, 0x20, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x0F, 0x00, 0x47, 0x78, 0x09, 0x81, 0x01,
  0x60, 0x30, 0x78, 0x02, 0x0A, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x02, 0x10,
  0x00, 0x46, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x62, 0x00, 0x08, 0xC0,
  0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0xC3, 0x80,
  0x10, 0x48, 0x06, 0x09, 0x83, 0x81, 0x1F, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x7C, 0x03, 0xDC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x40,
  0x7F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0xF0, 0x40,
  0x1E, 0xE6, 0x01, 0x81, 0xA0, 0x10, 0x05, 0x01, 0x80, 0x28, 0x18, 0x00,
  0xC0, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x30,
  0x00, 0xC1, 0x00, 0x06, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18,
  0x20, 0x00, 0xC1, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00,
  0x18, 0x10, 0x01, 0xC0, 0x80, 0x0C, 0x04, 0x00, 0xE0, 0x30, 0x0D, 0x00,
  0x80, 0xC8, 0x06, 0x0C, 0x40, 0x1F, 0xC4, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xCE, 0x03, 0x02, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x10,
  0x03, 0x30, 0x02, 0x20, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x30, 0x40,
  0xE0, 0xFF, 0x80, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x30, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x61, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xDC, 0x40, 0x30, 0x36, 0x02, 0x00, 0xA0,
  0x30, 0x05, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x08, 0x00,
  0x20, 0x40, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x04, 0x18,
  0x00, 0x20, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x0C,
  0x08, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x38, 0x10, 0x01, 0x80, 0x80,
  0x1C, 0x06, 0x01, 0xA0, 0x10, 0x19, 0x00, 0xC1, 0x98, 0x03, 0xF8, 0x80,
  0x02, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x70, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x78, 0x04,
  0x77, 0x81, 0x20, 0x20, 0x50, 0x0C, 0x38, 0x01, 0x0E, 0x00, 0x43, 0x00,
  0x30, 0xC0, 0x0C, 0x20, 0x02, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00, 0x08,
  0x40, 0x06, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x20,
  0x03, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01,
  0x0C, 0x00, 0x43, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03, 0x00, 0x01, 0x00,
  0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x02, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x01,
  0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x20, 0x30, 0x10, 0x0C, 0x0C, 0x02,
  0x06, 0x00, 0x83, 0x00, 0x20, 0x80, 0x18, 0x40, 0x04, 0x20, 0x01, 0x18,
  0x00, 0x4E, 0x00, 0x16, 0x80, 0x0F, 0x30, 0x02, 0x84, 0x00, 0xC1, 0x00,
  0x20, 0x40, 0x18, 0x18, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0C, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x06, 0x00, 0x00,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x27, 0xB8,
  0x77, 0x01, 0x60, 0x44, 0x04, 0x0A, 0x01, 0x40, 0x30, 0xE0, 0x0E, 0x01,
  0x87, 0x00, 0x60, 0x0C, 0x30, 0x02, 0x00, 0x61, 0x80, 0x10, 0x03, 0x08,
  0x01, 0x80, 0x10, 0xC0, 0x08, 0x00, 0x86, 0x00, 0x40, 0x04, 0x20, 0x02,
  0x00, 0x61, 0x00, 0x30, 0x02, 0x08, 0x01, 0x80, 0x10, 0xC0, 0x08, 0x00,
  0x84, 0x00, 0x40, 0x0C, 0x20, 0x02, 0x00, 0x61, 0x00, 0x30, 0x02, 0x18,
  0x01, 0x80, 0x10, 0xC0, 0x08, 0x00, 0x84, 0x00, 0x40, 0x0C, 0x20, 0x02,
  0x00, 0x61, 0x00, 0x30, 0x02, 0x18, 0x01, 0x00, 0x10, 0xC0, 0x08, 0x00,
  0x84, 0x00, 0x40, 0x0C, 0x20, 0x06, 0x00, 0x40, 0x00, 0x1E, 0x01, 0x1D,
  0xE0, 0x48, 0x08, 0x14, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x10, 0xC0, 0x0C,
  0x30, 0x03, 0x08, 0x00, 0x86, 0x00, 0x21, 0x80, 0x08, 0x40, 0x06, 0x10,
  0x01, 0x84, 0x00, 0x43, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00,
  0xC6, 0x00, 0x21, 0x80, 0x08, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x43,
  0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0xE7, 0x00, 0xC0, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0xC0, 0x04, 0x40, 0x02,
  0x60, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x28, 0x00, 0x14, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x64, 0x00, 0x23, 0x00, 0x31, 0x80, 0x30,
  0x40, 0x30, 0x38, 0x30, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xC0,
  0x02, 0x3B, 0xC0, 0x09, 0x81, 0x00, 0x2C, 0x02, 0x01, 0xE0, 0x08, 0x05,
  0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20,
  0x60, 0x00, 0x81, 0x80, 0x02, 0x04, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40,
  0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x0C,
  0x07, 0x00, 0x20, 0x1A, 0x01, 0x80, 0x4C, 0x1C, 0x01, 0x1F, 0xC0, 0x04,
  0x08, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3B, 0xC4, 0x0C,
  0x0D, 0x82, 0x00, 0xA0, 0xC0, 0x14, 0x30, 0x03, 0x84, 0x00, 0x31, 0x80,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x06, 0x20, 0x00, 0xC4, 0x00,
  0x11, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00,
  0x42, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0xE1, 0x00, 0x1C, 0x20, 0x07,
  0x06, 0x01, 0xA0, 0x40, 0x24, 0x0C, 0x19, 0x80, 0xFE, 0x20, 0x02, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x1E, 0x08, 0xE8, 0x12, 0x00, 0x28, 0x00, 0xE0,
  0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xDF, 0x06, 0x01,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x80, 0x60, 0xFF, 0x80,
  0x0C, 0x00, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x01,
  0xFF, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x7C, 0x02,
  0x00, 0x08, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x30, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00, 0x61, 0x00,
  0x18, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x18,
  0x20, 0x06, 0x08, 0x02, 0x82, 0x01, 0xA0, 0xC0, 0xC8, 0x1F, 0xC4, 0x00,
  0x80, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x48, 0x01, 0x90,
  0x02, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x61, 0x80, 0x83, 0x03, 0x06, 0x04,
  0x0C, 0x18, 0x18, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00, 0x8C, 0x01,
  0x10, 0x02, 0x60, 0x04, 0x80, 0x0B, 0x00, 0x14, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0x00,
  0xD0, 0x07, 0x00, 0x48, 0x02, 0x80, 0x24, 0x03, 0x40, 0x22, 0x01, 0x20,
  0x11, 0x00, 0x90, 0x18, 0x80, 0x88, 0x08, 0x40, 0x44, 0x0C, 0x20, 0x63,
  0x04, 0x10, 0x21, 0x82, 0x08, 0x30, 0xC3, 0x04, 0x10, 0x61, 0x02, 0x18,
  0x31, 0x81, 0x08, 0x18, 0x80, 0x84, 0x0C, 0x40, 0x44, 0x06, 0x40, 0x22,
  0x03, 0x20, 0x13, 0x01, 0xB0, 0x09, 0x00, 0xD0, 0x07, 0x80, 0x28, 0x02,
  0x80, 0x18, 0x01, 0x40, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x10, 0x06, 0x01, 0x00, 0x40, 0x10, 0x08, 0x01,
  0x81, 0x80, 0x08, 0x10, 0x00, 0x82, 0x00, 0x0C, 0x60, 0x00, 0x4C, 0x00,
  0x04, 0x80, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x19, 0x00, 0x01, 0x10, 0x00, 0x21, 0x80, 0x06, 0x08,
  0x00, 0x40, 0x80, 0x08, 0x08, 0x01, 0x80, 0xC0, 0x30, 0x04, 0x02, 0x00,
  0x40, 0x60, 0x04, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x60, 0x01, 0x00,
  0x20, 0x00, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10,
  0x08, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x08, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x07, 0xC0, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0x01, 0x81, 0xC0,
  0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 36, 10, 1, -36 },
  { 46, 10, 13, 14, 5, -36 },
  { 63, 22, 36, 22, 1, -36 },
  { 162, 20, 41, 20, 0, -38 },
  { 265, 24, 37, 30, 3, -36 },
  { 376, 20, 37, 22, 0, -36 },
  { 469, 4, 13, 8, 5, -36 },
  { 476, 14, 44, 12, 1, -36 },
  { 553, 13, 44, 12, -3, -36 },
  { 625, 15, 16, 19, 6, -38 },
  { 655, 19, 23, 23, 2, -29 },
  { 710, 6, 11, 8, -2, -5 },
  { 719, 11, 1, 14, 1, -14 },
  { 721, 2, 3, 9, 1, -3 },
  { 722, 20, 36, 15, -2, -36 },
  { 812, 18, 37, 20, 2, -36 },
  { 896, 10, 36, 20, 6, -36 },
  { 941, 21, 36, 20, -1, -36 },
  { 1036, 21, 37, 20, -1, -36 },
  { 1134, 21, 36, 20, -1, -36 },
  { 1229, 20, 37, 20, 0, -36 },
  { 1322, 19, 37, 20, 2, -36 },
  { 1410, 19, 36, 20, 3, -36 },
  { 1496, 20, 37, 20, 0, -36 },
  { 1589, 19, 37, 20, 1, -36 },
  { 1677, 7, 27, 9, 1, -27 },
  { 1701, 10, 33, 9, -2, -27 },
  { 1743, 19, 21, 23, 2, -28 },
  { 1793, 19, 12, 23, 2, -24 },
  { 1822, 19, 21, 23, 2, -28 },
  { 1872, 14, 36, 15, 2, -36 },
  { 1935, 27, 41, 30, 2, -36 },
  { 2074, 19, 36, 20, -3, -36 },
  { 2160, 21, 36, 22, 1, -36 },
  { 2255, 21, 37, 21, 3, -36 },
  { 2353, 22, 36, 25, 1, -36 },
  { 2452, 21, 36, 20, 1, -36 },
  { 2547, 21, 36, 18, 1, -36 },
  { 2642, 25, 37, 26, 2, -36 },
  { 2758, 25, 36, 26, 1, -36 },
  { 2871, 15, 36, 10, -2, -36 },
  { 2939, 18, 45, 9, -8, -36 },
  { 3041, 23, 36, 20, 1, -36 },
  { 3145, 13, 36, 18, 1, -36 },
  { 3204, 32, 36, 33, 1, -36 },
  { 3348, 26, 36, 26, 1, -36 },
  { 3465, 23, 37, 26, 2, -36 },
  { 3572, 20, 36, 21, 1, -36 },
  { 3662, 23, 45, 26, 2, -36 },
  { 3792, 20, 36, 21, 1, -36 },
  { 3882, 22, 37, 19, -1, -36 },
  { 3984, 18, 36, 18, 4, -36 },
  { 4065, 24, 37, 25, 2, -36 },
  { 4176, 19, 36, 20, 5, -36 },
  { 4262, 32, 36, 33, 5, -36 },
  { 4406, 25, 36, 18, -3, -36 },
  { 4519, 18, 36, 17, 4, -36 },
  { 4600, 23, 36, 19, -2, -36 },
  { 4704, 18, 44, 14, -1, -36 },
  { 4803, 7, 36, 16, 5, -36 },
  { 4835, 18, 44, 14, -3, -36 },
  { 4934, 19, 19, 22, 2, -36 },
  { 4980, 15, 1, 15, -4, 5 },
  { 4982, 5, 8, 11, 7, -38 },
  { 4987, 19, 28, 21, 2, -27 },
  { 5054, 19, 39, 22, 1, -38 },
  { 5147, 15, 28, 16, 2, -27 },
  { 5200, 21, 39, 22, 2, -38 },
  { 5303, 16, 28, 19, 2, -27 },
  { 5359, 24, 50, 10, -7, -38 },
  { 5509, 21, 39, 22, 0, -27 },
  { 5612, 18, 38, 21, 1, -38 },
  { 5698, 9, 36, 9, 1, -36 },
  { 5739, 17, 48, 9, -7, -36 },
  { 5841, 18, 38, 17, 1, -38 },
  { 5927, 9, 38, 8, 1, -38 },
  { 5970, 29, 27, 32, 1, -27 },
  { 6068, 18, 27, 21, 1, -27 },
  { 6129, 17, 28, 21, 2, -27 },
  { 6189, 22, 38, 22, -2, -27 },
  { 6294, 19, 39, 22, 2, -27 },
  { 6387, 15, 27, 14, 1, -27 },
  { 6438, 16, 28, 16, 0, -27 },
  { 6494, 11, 34, 11, 1, -33 },
  { 6541, 18, 27, 21, 2, -26 },
  { 6602, 15, 26, 16, 3, -26 },
  { 6651, 25, 26, 26, 3, -26 },
  { 6733, 20, 26, 17, -2, -26 },
  { 6798, 25, 38, 16, -6, -26 },
  { 6917, 17, 26, 15, -1, -26 },
  { 6973, 17, 44, 16, 2, -36 },
  { 7067, 1, 50, 20, 10, -38 },
  { 7074, 17, 44, 16, -3, -36 },
  { 7168, 19, 4, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_THINITALIC50PT7B_H_
