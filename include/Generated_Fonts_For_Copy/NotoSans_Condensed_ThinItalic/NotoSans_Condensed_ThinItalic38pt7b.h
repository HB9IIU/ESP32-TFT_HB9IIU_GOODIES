#ifndef _NOTOSANS_CONDENSED_THINITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x00, 0x00, 0x00, 0x01, 0x82,
  0x00, 0x22, 0x85, 0x0A, 0x14, 0x48, 0xA1, 0x42, 0x85, 0x10, 0x00, 0x41,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x04,
  0x10, 0x02, 0x08, 0x1F, 0xFF, 0x80, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x08, 0x20, 0x7F, 0xFF,
  0x02, 0x08, 0x03, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x41,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x40, 0x00, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x70, 0x03, 0xA7, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80,
  0x03, 0x80, 0x00, 0x80, 0x01, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x84, 0x60,
  0xFF, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0xA0, 0x18, 0x42, 0x02, 0x18, 0x40, 0x82, 0x08, 0x10, 0x41, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x20, 0x40, 0x88, 0x08, 0x11, 0x02, 0x04, 0x40,
  0x40, 0x88, 0xC8, 0x12, 0x2D, 0x04, 0x48, 0x60, 0x92, 0x0E, 0x24, 0x41,
  0x78, 0x90, 0x22, 0x22, 0x04, 0x04, 0x40, 0x81, 0x10, 0x20, 0x22, 0x04,
  0x08, 0x40, 0x83, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x04, 0x30,
  0x80, 0x84, 0x30, 0x0F, 0x00, 0x00, 0x20, 0x01, 0xF0, 0x04, 0x20, 0x10,
  0x40, 0x20, 0xC0, 0x41, 0x01, 0x02, 0x02, 0x04, 0x04, 0x18, 0x04, 0x20,
  0x08, 0x80, 0x12, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x04, 0x40, 0x10,
  0x82, 0x41, 0x05, 0x81, 0x0A, 0x02, 0x24, 0x02, 0x50, 0x05, 0x20, 0x0E,
  0x40, 0x08, 0x80, 0x30, 0x80, 0x91, 0x02, 0x21, 0xF8, 0x60, 0x29, 0x24,
  0xA4, 0x90, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x00, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x10, 0x42, 0x06,
  0x40, 0x2B, 0xC3, 0x80, 0xA0, 0x22, 0x08, 0x42, 0x04, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x44, 0x21, 0x10, 0x88, 0xC0, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x06, 0xE0, 0x20,
  0x81, 0x01, 0x0C, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x68, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20,
  0x10, 0x40, 0x41, 0x02, 0x06, 0x10, 0x0F, 0x80, 0x06, 0x14, 0x4B, 0x28,
  0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x00, 0x00, 0x20, 0x01, 0xDC,
  0x02, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xFF, 0xF0, 0x00, 0x60, 0x07, 0x70, 0x30, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC2, 0x03, 0x07, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x14, 0x00, 0x30, 0x00, 0xA0, 0x02, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x44,
  0x01, 0x88, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x41, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x20, 0x20, 0x80, 0x41, 0x00, 0x87, 0xFF, 0xE0, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x61, 0x01,
  0x83, 0xFC, 0x00, 0x00, 0x18, 0x01, 0xEC, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x08, 0x02, 0xE6, 0x0B, 0x02, 0x18, 0x04, 0x30, 0x04, 0x40, 0x08, 0x80,
  0x11, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x20, 0x04, 0x60, 0x10,
  0x40, 0x20, 0x80, 0x80, 0x82, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x03, 0xB8, 0x08, 0x10, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00,
  0x84, 0x01, 0x08, 0x02, 0x18, 0x08, 0x10, 0x30, 0x30, 0xC0, 0x32, 0x00,
  0x38, 0x00, 0xF0, 0x06, 0x30, 0x10, 0x30, 0x40, 0x21, 0x00, 0x22, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0xC0, 0x10, 0x80, 0x60,
  0x81, 0x80, 0xFE, 0x00, 0x00, 0x20, 0x03, 0xF0, 0x08, 0x10, 0x20, 0x20,
  0x80, 0x21, 0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x31, 0x00, 0x42, 0x01, 0x84, 0x03, 0x0C, 0x0A, 0x0F, 0xE4,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x07, 0xF0, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x30,
  0x01, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x00, 0x04, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x00, 0x02, 0x03, 0xB8, 0x41, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x03, 0x00, 0x60, 0x0C,
  0x06, 0x00, 0x20, 0x60, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x23, 0x00,
  0x01, 0x10, 0x3F, 0x09, 0x83, 0x08, 0x48, 0x30, 0x82, 0x41, 0x04, 0x14,
  0x10, 0x20, 0xA0, 0x81, 0x05, 0x08, 0x10, 0x28, 0x40, 0x82, 0x42, 0x04,
  0x14, 0x10, 0x60, 0xA0, 0x83, 0x09, 0x04, 0x30, 0x48, 0x21, 0x44, 0x41,
  0x92, 0x42, 0x07, 0x0C, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x50, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x11,
  0x00, 0x22, 0x00, 0x84, 0x01, 0x08, 0x04, 0x10, 0x08, 0x20, 0x20, 0x40,
  0x40, 0x81, 0x01, 0x03, 0xFE, 0x0C, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80,
  0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A,
  0x00, 0x18, 0x07, 0xF8, 0x04, 0x06, 0x04, 0x02, 0x04, 0x03, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x02, 0x10, 0x06, 0x10, 0x0C,
  0x10, 0x18, 0x1F, 0xE0, 0x10, 0x70, 0x20, 0x18, 0x20, 0x08, 0x20, 0x08,
  0x20, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18,
  0x80, 0x10, 0x80, 0x20, 0x80, 0xC0, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xF7,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x02, 0x06, 0x01, 0x00, 0x80, 0x80,
  0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x06, 0x10, 0x01, 0x08, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x41, 0x00, 0x41, 0x00, 0x60, 0x80, 0x60, 0x40, 0xC0, 0x3F,
  0x80, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0xFF, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3D,
  0xE0, 0x10, 0x04, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0xFC, 0x80, 0x03, 0x20, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x43,
  0x00, 0x10, 0x40, 0x04, 0x18, 0x01, 0x03, 0x00, 0x80, 0x3F, 0xE0, 0x04,
  0x00, 0x20, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0x40,
  0x02, 0x08, 0x00, 0x81, 0xFF, 0xF0, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00,
  0x10, 0x20, 0x02, 0x04, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x03, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0xD8, 0x01,
  0x00, 0x00, 0x04, 0x01, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0xC0, 0x10, 0xC0, 0x08, 0xC0, 0x08, 0x40, 0x04,
  0x40, 0x02, 0x40, 0x01, 0x60, 0x01, 0x48, 0x00, 0xC4, 0x00, 0x62, 0x00,
  0x20, 0x80, 0x10, 0x40, 0x10, 0x20, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x04, 0x00,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x05, 0x06, 0x00, 0x06, 0x0A, 0x00,
  0x0A, 0x0A, 0x00, 0x0A, 0x0A, 0x00, 0x12, 0x09, 0x00, 0x16, 0x09, 0x00,
  0x24, 0x11, 0x00, 0x24, 0x11, 0x00, 0x44, 0x11, 0x00, 0x44, 0x11, 0x00,
  0x88, 0x31, 0x01, 0x88, 0x21, 0x01, 0x08, 0x21, 0x03, 0x08, 0x21, 0x02,
  0x08, 0x21, 0x06, 0x10, 0x40, 0x84, 0x10, 0x40, 0x8C, 0x10, 0x40, 0x88,
  0x10, 0x40, 0x90, 0x10, 0x40, 0x90, 0x20, 0x80, 0xA0, 0x20, 0x80, 0xA0,
  0x20, 0x80, 0xC0, 0x20, 0x80, 0xC0, 0x40, 0x06, 0x00, 0x20, 0xC0, 0x04,
  0x18, 0x00, 0x83, 0x00, 0x20, 0x90, 0x04, 0x12, 0x00, 0x82, 0x40, 0x10,
  0x48, 0x02, 0x08, 0x80, 0x82, 0x10, 0x10, 0x42, 0x02, 0x08, 0x40, 0x41,
  0x04, 0x08, 0x60, 0x82, 0x08, 0x10, 0x41, 0x03, 0x08, 0x20, 0x21, 0x04,
  0x04, 0x61, 0x00, 0x88, 0x20, 0x19, 0x04, 0x01, 0x20, 0x80, 0x24, 0x10,
  0x05, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0xEE, 0x00, 0x80, 0x80, 0x80, 0x20, 0x80, 0x10, 0xC0,
  0x04, 0x40, 0x02, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x10, 0x40, 0x18, 0x20, 0x08, 0x08, 0x18, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x08, 0x18, 0x10, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x61, 0x00,
  0x86, 0x06, 0x0F, 0xF0, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0xEE, 0x00, 0x80, 0x80, 0x80, 0x20,
  0x80, 0x10, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x40, 0x18, 0x20, 0x08, 0x08, 0x18,
  0x03, 0xF0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x08, 0x18, 0x10, 0x10,
  0x20, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20,
  0x08, 0x40, 0x10, 0x80, 0x41, 0x01, 0x86, 0x0E, 0x0F, 0xE0, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x01, 0x03, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x77, 0xC0, 0xC0, 0x40, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x20, 0x18, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x61, 0x00, 0x10, 0x40, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x02, 0x00, 0x40, 0xC0,
  0x20, 0x10, 0x10, 0x03, 0xF8, 0x00, 0x80, 0x03, 0x00, 0x09, 0x00, 0x12,
  0x00, 0x64, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80,
  0x41, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x40, 0x20, 0x80,
  0x43, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00, 0x12,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x10, 0x01,
  0x80, 0x10, 0x02, 0x80, 0x30, 0x02, 0x80, 0x30, 0x04, 0x80, 0x50, 0x04,
  0x80, 0x50, 0x04, 0x80, 0x50, 0x08, 0x80, 0x90, 0x08, 0x80, 0x90, 0x10,
  0x81, 0x10, 0x10, 0x81, 0x10, 0x20, 0x81, 0x10, 0x20, 0x82, 0x10, 0x20,
  0x82, 0x10, 0x40, 0x84, 0x10, 0x40, 0x84, 0x10, 0x80, 0x88, 0x10, 0x80,
  0x88, 0x10, 0x80, 0x88, 0x11, 0x00, 0x90, 0x11, 0x00, 0x90, 0x12, 0x00,
  0xA0, 0x12, 0x00, 0xA0, 0x16, 0x00, 0xE0, 0x14, 0x00, 0xC0, 0x14, 0x00,
  0xC0, 0x18, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08, 0x40, 0x02, 0x10,
  0x00, 0x88, 0x00, 0x24, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x08, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x10, 0x10, 0x02, 0x08, 0x00, 0x80, 0x80, 0x0A, 0x00, 0xD0, 0x04,
  0x80, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10, 0x21, 0x81, 0x08, 0x08,
  0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x84,
  0x21, 0x04, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x20, 0x84, 0x21,
  0x08, 0x41, 0x08, 0x42, 0x03, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0xFC, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x05, 0x00, 0x11, 0x00, 0x22, 0x00, 0x82, 0x01, 0x04, 0x04,
  0x08, 0x18, 0x08, 0x20, 0x10, 0x80, 0x11, 0x00, 0x24, 0x00, 0x58, 0x00,
  0x40, 0xFF, 0xE0, 0x91, 0x22, 0x40, 0x03, 0xE2, 0x08, 0x28, 0x20, 0x30,
  0x80, 0x61, 0x00, 0xC4, 0x01, 0x88, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x11, 0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x10,
  0x40, 0x60, 0x81, 0x41, 0x86, 0x81, 0xF1, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x27, 0xC1, 0x20, 0x85, 0x03, 0x18, 0x04, 0x60, 0x11, 0x00, 0x4C, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00,
  0x90, 0x04, 0xC0, 0x13, 0x00, 0x8C, 0x06, 0x28, 0x30, 0x9F, 0x00, 0x03,
  0xF0, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x03, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x01, 0xF9, 0x01, 0x04, 0x81, 0x01, 0x81, 0x00, 0xC0, 0x80, 0x60, 0x80,
  0x30, 0x40, 0x18, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04,
  0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x60, 0x80, 0x30, 0x20, 0x30,
  0x10, 0x38, 0x0C, 0x34, 0x03, 0xF2, 0x00, 0x03, 0xE0, 0x41, 0x08, 0x11,
  0x01, 0x10, 0x12, 0x01, 0x20, 0x34, 0x06, 0x40, 0xC7, 0xF0, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x41,
  0xF8, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x7F, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF9, 0x02, 0x09, 0x04, 0x06, 0x08, 0x06, 0x08,
  0x06, 0x10, 0x06, 0x10, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x08, 0x40, 0x08, 0x40, 0x18, 0x40, 0x18, 0x60, 0x18, 0x20,
  0x30, 0x20, 0x70, 0x30, 0xD0, 0x1F, 0x90, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x81, 0x80, 0x7E,
  0x00, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x4F, 0x85, 0x82, 0x28, 0x11, 0x80, 0x88, 0x04,
  0x40, 0x26, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x00, 0x02, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x10, 0x80, 0x82, 0x04, 0x08, 0x20, 0x21, 0x00, 0x8C, 0x04,
  0x60, 0x11, 0x00, 0x4C, 0x01, 0x50, 0x0A, 0x40, 0x31, 0x00, 0x82, 0x02,
  0x08, 0x08, 0x20, 0x40, 0x81, 0x01, 0x04, 0x04, 0x10, 0x10, 0xC0, 0x60,
  0x01, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x0B, 0xF1, 0xF8, 0x50, 0x48, 0x21, 0x80,
  0xC0, 0x46, 0x02, 0x01, 0x10, 0x08, 0x04, 0x40, 0x20, 0x23, 0x01, 0x00,
  0x88, 0x04, 0x02, 0x20, 0x10, 0x08, 0x80, 0x40, 0x22, 0x02, 0x01, 0x10,
  0x08, 0x04, 0x40, 0x20, 0x11, 0x00, 0x80, 0x44, 0x02, 0x02, 0x20, 0x10,
  0x08, 0x80, 0x40, 0x22, 0x01, 0x00, 0x88, 0x04, 0x02, 0x20, 0x30, 0x10,
  0x09, 0xF0, 0xB0, 0x45, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0xC0, 0x24,
  0x01, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x80, 0x03, 0xF0, 0x10,
  0x60, 0x80, 0x84, 0x02, 0x10, 0x04, 0x80, 0x12, 0x00, 0x58, 0x01, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x40, 0x21, 0x01, 0x06, 0x08, 0x0F, 0xC0, 0x02, 0x7C, 0x04, 0x82,
  0x05, 0x03, 0x06, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x04, 0x30, 0x04, 0x30, 0x08, 0x30, 0x18, 0x28, 0x30, 0x27, 0xC0,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF2, 0x08, 0x24, 0x20, 0x30,
  0x80, 0x61, 0x00, 0xC4, 0x01, 0x88, 0x03, 0x30, 0x04, 0x40, 0x08, 0x80,
  0x11, 0x00, 0x22, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x18,
  0x40, 0x60, 0x81, 0xC1, 0x86, 0x81, 0xF9, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x09, 0xE2, 0xC0, 0x50, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x00, 0x07, 0xF1, 0x81, 0x10, 0x01, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x81, 0x0F, 0xE0, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x7F, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78,
  0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00,
  0x88, 0x02, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00,
  0x84, 0x02, 0x20, 0x18, 0x80, 0x62, 0x03, 0x04, 0x14, 0x1F, 0x90, 0x80,
  0x38, 0x02, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x08, 0x80, 0x88, 0x10, 0x41,
  0x04, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x05, 0x00, 0x50,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x01,
  0x40, 0x60, 0x28, 0x12, 0x09, 0x02, 0x41, 0x20, 0x48, 0x44, 0x11, 0x08,
  0x82, 0x21, 0x10, 0x84, 0x42, 0x10, 0x88, 0x44, 0x12, 0x08, 0x82, 0x41,
  0x20, 0x48, 0x24, 0x0A, 0x04, 0x81, 0x40, 0xA0, 0x30, 0x14, 0x06, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x00, 0x04, 0x03, 0x02, 0x02, 0x02, 0x04, 0x02,
  0x08, 0x02, 0x18, 0x01, 0x10, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x20, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x10, 0x01, 0x00, 0x40,
  0x40, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0xFF, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x03, 0x00, 0xE0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x00, 0x38, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x03, 0x00, 0xE0, 0x00, 0x7C, 0x06, 0x0C, 0x18, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 27, 8, 1, -27 },
  { 25, 7, 10, 10, 4, -27 },
  { 34, 17, 27, 17, 0, -27 },
  { 92, 16, 31, 15, 0, -29 },
  { 154, 19, 28, 23, 2, -28 },
  { 221, 15, 28, 16, 0, -28 },
  { 274, 3, 10, 6, 4, -27 },
  { 278, 10, 33, 9, 1, -27 },
  { 320, 11, 33, 9, -3, -27 },
  { 366, 11, 12, 14, 5, -29 },
  { 383, 14, 17, 17, 2, -22 },
  { 413, 5, 9, 6, -2, -4 },
  { 419, 8, 1, 11, 1, -11 },
  { 420, 2, 2, 7, 1, -2 },
  { 421, 16, 27, 11, -2, -27 },
  { 475, 14, 28, 15, 1, -28 },
  { 524, 7, 27, 15, 5, -27 },
  { 548, 16, 28, 15, -1, -28 },
  { 604, 15, 28, 15, 0, -28 },
  { 657, 15, 27, 15, 0, -27 },
  { 708, 15, 27, 15, 0, -27 },
  { 759, 15, 28, 15, 1, -28 },
  { 812, 15, 27, 15, 2, -27 },
  { 863, 15, 28, 15, 0, -28 },
  { 916, 15, 28, 15, 0, -28 },
  { 969, 6, 20, 6, 0, -20 },
  { 984, 8, 25, 7, -2, -20 },
  { 1009, 14, 16, 17, 2, -22 },
  { 1037, 14, 9, 17, 2, -18 },
  { 1053, 14, 16, 17, 2, -22 },
  { 1081, 11, 28, 11, 1, -28 },
  { 1120, 21, 30, 23, 1, -27 },
  { 1199, 15, 27, 15, -2, -27 },
  { 1250, 16, 27, 17, 1, -27 },
  { 1304, 16, 28, 16, 2, -28 },
  { 1360, 17, 27, 19, 1, -27 },
  { 1418, 15, 27, 15, 1, -27 },
  { 1469, 15, 27, 14, 1, -27 },
  { 1520, 18, 28, 20, 2, -28 },
  { 1583, 19, 27, 19, 1, -27 },
  { 1648, 11, 27, 8, -1, -27 },
  { 1686, 13, 34, 7, -6, -27 },
  { 1742, 17, 27, 15, 1, -27 },
  { 1800, 10, 27, 14, 1, -27 },
  { 1834, 24, 27, 25, 1, -27 },
  { 1915, 19, 27, 20, 1, -27 },
  { 1980, 17, 28, 20, 2, -28 },
  { 2040, 15, 27, 16, 1, -27 },
  { 2091, 17, 35, 20, 2, -28 },
  { 2166, 15, 27, 16, 1, -27 },
  { 2217, 17, 28, 15, -1, -28 },
  { 2277, 13, 27, 13, 3, -27 },
  { 2321, 18, 27, 19, 2, -27 },
  { 2382, 15, 27, 15, 3, -27 },
  { 2433, 24, 27, 25, 4, -27 },
  { 2514, 18, 27, 14, -2, -27 },
  { 2575, 13, 27, 13, 3, -27 },
  { 2619, 17, 27, 14, -1, -27 },
  { 2677, 14, 33, 11, -1, -27 },
  { 2735, 5, 27, 12, 4, -27 },
  { 2752, 13, 33, 11, -2, -27 },
  { 2806, 15, 14, 17, 1, -27 },
  { 2833, 11, 1, 11, -3, 4 },
  { 2835, 3, 6, 8, 6, -29 },
  { 2838, 15, 20, 16, 1, -20 },
  { 2876, 14, 29, 16, 1, -29 },
  { 2927, 12, 20, 12, 1, -20 },
  { 2957, 17, 29, 17, 1, -29 },
  { 3019, 12, 20, 14, 1, -20 },
  { 3049, 18, 38, 8, -5, -29 },
  { 3135, 16, 29, 16, 0, -20 },
  { 3193, 13, 29, 16, 1, -29 },
  { 3241, 6, 27, 7, 1, -27 },
  { 3262, 13, 36, 7, -5, -27 },
  { 3321, 14, 29, 13, 0, -29 },
  { 3372, 8, 29, 6, 0, -29 },
  { 3401, 22, 20, 24, 1, -20 },
  { 3456, 13, 20, 16, 1, -20 },
  { 3489, 14, 20, 16, 1, -20 },
  { 3524, 16, 29, 16, -1, -20 },
  { 3582, 15, 29, 17, 1, -20 },
  { 3637, 11, 20, 10, 1, -20 },
  { 3665, 12, 20, 12, 0, -20 },
  { 3695, 8, 25, 8, 1, -25 },
  { 3720, 14, 20, 16, 1, -20 },
  { 3755, 12, 20, 12, 2, -20 },
  { 3785, 19, 20, 20, 2, -20 },
  { 3833, 16, 20, 13, -2, -20 },
  { 3873, 18, 29, 13, -4, -20 },
  { 3939, 13, 20, 11, -1, -20 },
  { 3972, 13, 33, 12, 1, -27 },
  { 4026, 1, 38, 15, 7, -29 },
  { 4031, 13, 33, 12, -2, -27 },
  { 4085, 14, 3, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_THINITALIC38PT7B_H_
