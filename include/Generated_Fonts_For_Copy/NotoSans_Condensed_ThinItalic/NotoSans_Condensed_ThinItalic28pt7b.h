#ifndef _NOTOSANS_CONDENSED_THINITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x00, 0x00,
  0x21, 0x00, 0x4A, 0x53, 0x18, 0xCA, 0x40, 0x01, 0x10, 0x10, 0x80, 0x88,
  0x04, 0x40, 0x22, 0x02, 0x10, 0xFF, 0xE0, 0x88, 0x08, 0x40, 0x44, 0x02,
  0x20, 0x21, 0x01, 0x10, 0x7F, 0xF0, 0x84, 0x04, 0x20, 0x22, 0x01, 0x10,
  0x10, 0x80, 0x88, 0x00, 0x00, 0x80, 0x10, 0x1F, 0x04, 0x91, 0x10, 0x22,
  0x04, 0x80, 0x90, 0x12, 0x01, 0x40, 0x10, 0x01, 0x00, 0x50, 0x09, 0x01,
  0x20, 0x24, 0x08, 0x81, 0x12, 0x24, 0x3F, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x3C, 0x1A, 0x20, 0x91, 0x09, 0x08, 0x48, 0x44, 0x42, 0x22, 0x12, 0x10,
  0xA0, 0x89, 0x3C, 0x52, 0x64, 0xA3, 0xC9, 0x10, 0x50, 0x84, 0x84, 0x44,
  0x22, 0x21, 0x21, 0x11, 0x08, 0x90, 0x45, 0x83, 0xC0, 0x03, 0x80, 0x88,
  0x21, 0x04, 0x20, 0x84, 0x11, 0x02, 0x20, 0x48, 0x06, 0x01, 0x80, 0x50,
  0x11, 0x14, 0x22, 0x82, 0x60, 0x54, 0x0A, 0x80, 0x90, 0x32, 0x09, 0x3E,
  0x20, 0x56, 0xA8, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0xC0,
  0x04, 0x04, 0x32, 0x07, 0x70, 0xC0, 0xC1, 0x90, 0x88, 0x02, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x24, 0xA5, 0x20, 0xFC, 0xC0, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x00, 0x07, 0x82, 0x11, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x01,
  0x40, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20,
  0x88, 0x41, 0xE0, 0x19, 0x53, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x44, 0x21, 0x00, 0x07, 0xE0, 0x41, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xF8, 0x0F, 0xC2,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x81, 0xE0,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x7F, 0x00, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xA0, 0x14, 0x04, 0x81, 0x10,
  0x22, 0x08, 0x82, 0x10, 0x42, 0x10, 0x44, 0x09, 0x02, 0x3F, 0xF0, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x3E, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x7E, 0x00, 0x03, 0xE0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x5F, 0x0C, 0x13,
  0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81, 0x10, 0x21, 0x08,
  0x3E, 0x00, 0x7F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x07, 0xC1, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44,
  0x08, 0x42, 0x05, 0x80, 0xC0, 0x64, 0x10, 0x44, 0x09, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x11, 0x04, 0x1F, 0x00, 0x07, 0xC1, 0x08, 0x40, 0x88,
  0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x08, 0x83, 0x0F, 0xA0,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7C, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x0C, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x20,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x00, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x40, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x80, 0x01, 0xF8, 0x04, 0x08, 0x30, 0x08, 0x40, 0x11, 0x00, 0x24, 0x00,
  0x48, 0x7C, 0xA1, 0x11, 0x44, 0x22, 0x88, 0x46, 0x20, 0x8C, 0x42, 0x18,
  0x84, 0x31, 0x08, 0xA2, 0x31, 0x44, 0xA4, 0x86, 0x31, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x06, 0x30, 0x03, 0x80, 0x00, 0x00, 0x40, 0x08,
  0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x10,
  0x87, 0xF0, 0x82, 0x20, 0x44, 0x09, 0x01, 0x20, 0x28, 0x05, 0x00, 0xC0,
  0x10, 0x07, 0xE0, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x11,
  0x02, 0x10, 0x41, 0xF8, 0x20, 0xC2, 0x04, 0x20, 0x22, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x44, 0x04, 0x41, 0x8F, 0xE0, 0x03, 0xF0, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0xF0, 0x07, 0xC0, 0x41, 0x82, 0x04, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x09,
  0x00, 0x88, 0x04, 0x40, 0x42, 0x04, 0x10, 0x41, 0xFC, 0x00, 0x07, 0xF0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0xFC, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0F, 0xF0, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x3F, 0xC2, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x03, 0xF8,
  0x10, 0x10, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x0F, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02,
  0x20, 0x08, 0x40, 0x21, 0x00, 0x82, 0x02, 0x07, 0xF0, 0x08, 0x02, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x3F, 0xF0, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x10,
  0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x84, 0x01, 0x00, 0x0F,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0xE0, 0x00,
  0x08, 0x08, 0x40, 0x82, 0x08, 0x10, 0x80, 0x84, 0x08, 0x40, 0x44, 0x02,
  0x40, 0x14, 0x00, 0xE0, 0x0C, 0x80, 0x44, 0x02, 0x20, 0x10, 0x81, 0x04,
  0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x21, 0x01, 0x80, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0xFF, 0x04, 0x00, 0x61, 0x80, 0x08, 0x30, 0x03,
  0x06, 0x00, 0xA0, 0xC0, 0x14, 0x28, 0x05, 0x05, 0x00, 0xA0, 0x90, 0x24,
  0x12, 0x04, 0x82, 0x41, 0x10, 0x88, 0x24, 0x11, 0x08, 0x82, 0x21, 0x10,
  0x44, 0x42, 0x10, 0x88, 0x42, 0x12, 0x10, 0x42, 0x42, 0x08, 0x50, 0x41,
  0x06, 0x08, 0x40, 0x82, 0x00, 0x04, 0x02, 0x18, 0x04, 0x30, 0x08, 0x50,
  0x20, 0xA0, 0x42, 0x40, 0x84, 0x81, 0x08, 0x84, 0x11, 0x08, 0x22, 0x10,
  0x84, 0x21, 0x04, 0x42, 0x09, 0x04, 0x12, 0x10, 0x24, 0x20, 0x28, 0x40,
  0x50, 0x80, 0xC1, 0x00, 0x84, 0x01, 0x00, 0x03, 0xE0, 0x20, 0x82, 0x02,
  0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x03, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x42, 0x02,
  0x10, 0x20, 0x7E, 0x00, 0x07, 0xC0, 0x82, 0x08, 0x10, 0x81, 0x08, 0x11,
  0x01, 0x10, 0x11, 0x02, 0x10, 0x21, 0x04, 0x23, 0x83, 0xC0, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x03, 0xE0,
  0x20, 0x82, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x03, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x42, 0x02, 0x10, 0x20, 0x76, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x07, 0xC0, 0x82, 0x08, 0x10, 0x81, 0x08, 0x11, 0x01,
  0x10, 0x11, 0x02, 0x10, 0x21, 0x04, 0x3F, 0x82, 0x20, 0x21, 0x02, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x08, 0x40, 0x88, 0x08, 0x07, 0xE1, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x7F,
  0x00, 0xFF, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x10, 0x04, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80,
  0x42, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x40,
  0x21, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x04, 0x18, 0x0F,
  0x80, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82,
  0x21, 0x08, 0x42, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x80, 0x60, 0x20, 0x28, 0x18, 0x0A, 0x06, 0x04, 0x82,
  0x81, 0x20, 0xA0, 0x88, 0x48, 0x22, 0x12, 0x08, 0x84, 0x84, 0x22, 0x21,
  0x08, 0x88, 0x82, 0x42, 0x20, 0x90, 0x90, 0x24, 0x24, 0x0A, 0x09, 0x02,
  0x82, 0x80, 0xC0, 0xA0, 0x30, 0x30, 0x08, 0x0C, 0x02, 0x02, 0x00, 0x04,
  0x04, 0x10, 0x20, 0x20, 0x80, 0x84, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xA0, 0x04, 0x80, 0x22, 0x00,
  0x88, 0x04, 0x20, 0x10, 0x80, 0x81, 0x04, 0x04, 0x30, 0x10, 0x80, 0x60,
  0x24, 0x09, 0x04, 0x41, 0x10, 0x84, 0x41, 0x10, 0x28, 0x0A, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x07,
  0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0xFF, 0x00, 0x07, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xE0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11,
  0x07, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x43, 0xE0, 0x02, 0x00, 0xC0, 0x24, 0x04, 0x81,
  0x08, 0x21, 0x08, 0x21, 0x02, 0x40, 0x50, 0x04, 0xFF, 0x89, 0x10, 0x0F,
  0x22, 0x18, 0x81, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x24, 0x04, 0x80, 0x90,
  0x12, 0x04, 0x40, 0x88, 0x31, 0x0A, 0x1E, 0x40, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0xF0, 0xA1, 0x18, 0x22, 0x04, 0x40, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x0A, 0x02, 0x40, 0x48, 0x09, 0x02, 0x30, 0x89,
  0xE0, 0x0F, 0x88, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x01, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x0F, 0x21, 0x0A, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04,
  0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x88, 0x10, 0x83, 0x08, 0x50,
  0x79, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x0A, 0x0A, 0x19, 0xF0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0xF8, 0x00, 0x38, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x0F, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x01, 0x80, 0x00, 0x07, 0x90, 0x85, 0x10, 0x21, 0x02, 0x20,
  0x22, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0xC4, 0x08, 0x41,
  0x84, 0x38, 0x3C, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x84,
  0x07, 0x80, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0xF0,
  0xA2, 0x18, 0x22, 0x04, 0x41, 0x10, 0x22, 0x04, 0x40, 0x88, 0x12, 0x04,
  0x40, 0x88, 0x11, 0x02, 0x20, 0x48, 0x10, 0x08, 0x40, 0x00, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x18, 0x82, 0x10, 0x82, 0x20, 0x88, 0x12, 0x02, 0xC0,
  0x68, 0x09, 0x01, 0x20, 0x42, 0x08, 0x41, 0x08, 0x21, 0x08, 0x10, 0x04,
  0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x10, 0x80, 0x17, 0x8F, 0x0C, 0x28, 0x44, 0x18, 0x22, 0x08, 0x11,
  0x04, 0x09, 0x02, 0x08, 0x81, 0x04, 0x41, 0x02, 0x20, 0x81, 0x20, 0x40,
  0x90, 0x20, 0x88, 0x10, 0x44, 0x10, 0x22, 0x08, 0x12, 0x04, 0x10, 0x13,
  0xC2, 0x88, 0x60, 0x88, 0x11, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x48,
  0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x20, 0x40, 0x0F, 0x04, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81,
  0x20, 0x87, 0xC0, 0x09, 0xE0, 0xA2, 0x0C, 0x10, 0x81, 0x08, 0x11, 0x01,
  0x10, 0x11, 0x01, 0x10, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20, 0x43, 0x08,
  0x4F, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x0F,
  0x22, 0x14, 0x81, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x04, 0x80, 0x90,
  0x12, 0x06, 0x40, 0x88, 0x31, 0x0E, 0x1E, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x13, 0x8A, 0x06, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x1F,
  0x10, 0x48, 0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x23, 0xF0, 0x10, 0x42, 0x1F, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x83, 0x80, 0x20, 0x48, 0x12, 0x04, 0x81, 0x40,
  0x90, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x48, 0x12, 0x04, 0x83, 0x21, 0x47,
  0xA0, 0x81, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0,
  0xA0, 0xC0, 0xC0, 0x80, 0x82, 0x06, 0x08, 0x28, 0x60, 0xA1, 0x84, 0x8A,
  0x12, 0x28, 0x48, 0xA2, 0x24, 0x88, 0x92, 0x42, 0x89, 0x0A, 0x24, 0x30,
  0x60, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x00, 0x10, 0x21, 0x08, 0x21, 0x04,
  0x40, 0x90, 0x0A, 0x01, 0x80, 0x20, 0x0A, 0x01, 0x40, 0x48, 0x11, 0x02,
  0x10, 0x82, 0x20, 0x40, 0x04, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x04,
  0x10, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x20, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x0F, 0xE0, 0x01, 0x82, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x04, 0x0C, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0xC0, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x83, 0xC0, 0x78, 0x30, 0xF8,
};

const GFXglyph NotoSans_Condensed_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 5, 7, 8, 3, -20 },
  { 19, 13, 20, 12, 0, -20 },
  { 52, 11, 23, 11, 0, -21 },
  { 84, 13, 20, 17, 2, -20 },
  { 117, 11, 20, 12, 0, -20 },
  { 145, 2, 7, 4, 3, -20 },
  { 147, 7, 24, 7, 1, -20 },
  { 168, 8, 24, 7, -2, -20 },
  { 192, 9, 9, 11, 3, -21 },
  { 203, 11, 13, 13, 1, -16 },
  { 221, 3, 7, 5, -1, -3 },
  { 224, 6, 1, 8, 1, -8 },
  { 225, 1, 2, 5, 1, -2 },
  { 226, 11, 20, 8, -1, -20 },
  { 254, 10, 20, 11, 1, -20 },
  { 279, 5, 20, 11, 4, -20 },
  { 292, 12, 20, 11, -1, -20 },
  { 322, 11, 20, 11, 0, -20 },
  { 350, 11, 20, 11, 0, -20 },
  { 378, 11, 20, 11, 0, -20 },
  { 406, 11, 20, 11, 1, -20 },
  { 434, 10, 20, 11, 2, -20 },
  { 459, 11, 20, 11, 0, -20 },
  { 487, 11, 20, 11, 0, -20 },
  { 515, 4, 15, 5, 0, -15 },
  { 523, 6, 19, 5, -1, -15 },
  { 538, 11, 12, 13, 1, -16 },
  { 555, 11, 6, 13, 1, -13 },
  { 564, 11, 12, 13, 1, -16 },
  { 581, 8, 20, 8, 1, -20 },
  { 601, 15, 23, 17, 1, -20 },
  { 645, 11, 20, 11, -2, -20 },
  { 673, 12, 20, 12, 0, -20 },
  { 703, 12, 20, 12, 1, -20 },
  { 733, 13, 20, 14, 0, -20 },
  { 766, 12, 20, 11, 0, -20 },
  { 796, 12, 20, 10, 0, -20 },
  { 826, 14, 20, 15, 1, -20 },
  { 861, 15, 20, 14, 0, -20 },
  { 899, 8, 20, 6, -1, -20 },
  { 919, 9, 25, 5, -4, -20 },
  { 948, 13, 20, 11, 0, -20 },
  { 981, 8, 20, 10, 0, -20 },
  { 1001, 19, 20, 18, 0, -20 },
  { 1049, 15, 20, 15, 0, -20 },
  { 1087, 13, 20, 15, 1, -20 },
  { 1120, 12, 20, 12, 0, -20 },
  { 1150, 13, 25, 15, 1, -20 },
  { 1191, 12, 20, 12, 0, -20 },
  { 1221, 11, 20, 11, 0, -20 },
  { 1249, 10, 20, 10, 2, -20 },
  { 1274, 14, 20, 14, 1, -20 },
  { 1309, 10, 20, 11, 3, -20 },
  { 1334, 18, 20, 19, 3, -20 },
  { 1379, 14, 20, 10, -2, -20 },
  { 1414, 10, 20, 10, 2, -20 },
  { 1439, 13, 20, 11, -1, -20 },
  { 1472, 10, 24, 8, 0, -20 },
  { 1502, 4, 20, 9, 3, -20 },
  { 1512, 10, 24, 8, -2, -20 },
  { 1542, 11, 10, 12, 1, -20 },
  { 1556, 8, 1, 8, -2, 3 },
  { 1557, 3, 4, 6, 4, -21 },
  { 1559, 11, 15, 12, 1, -15 },
  { 1580, 11, 21, 12, 0, -21 },
  { 1609, 9, 15, 9, 1, -15 },
  { 1626, 12, 21, 12, 1, -21 },
  { 1658, 9, 15, 11, 1, -15 },
  { 1675, 13, 28, 6, -4, -21 },
  { 1721, 12, 22, 12, 0, -15 },
  { 1754, 11, 21, 12, 0, -21 },
  { 1783, 5, 20, 5, 0, -20 },
  { 1796, 10, 27, 5, -4, -20 },
  { 1830, 11, 21, 9, 0, -21 },
  { 1859, 6, 21, 5, 0, -21 },
  { 1875, 17, 15, 18, 0, -15 },
  { 1907, 11, 15, 12, 0, -15 },
  { 1928, 10, 15, 12, 1, -15 },
  { 1947, 12, 21, 12, -1, -15 },
  { 1979, 11, 22, 12, 1, -15 },
  { 2010, 9, 15, 8, 0, -15 },
  { 2027, 9, 15, 9, 0, -15 },
  { 2044, 6, 18, 6, 1, -18 },
  { 2058, 10, 15, 12, 1, -15 },
  { 2077, 8, 15, 9, 2, -15 },
  { 2092, 14, 15, 14, 2, -15 },
  { 2119, 11, 15, 9, -1, -15 },
  { 2140, 14, 22, 9, -3, -15 },
  { 2179, 10, 15, 8, -1, -15 },
  { 2198, 9, 24, 9, 1, -20 },
  { 2225, 1, 28, 11, 5, -21 },
  { 2229, 10, 24, 9, -2, -20 },
  { 2259, 11, 2, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_THINITALIC28PT7B_H_
