#ifndef _NOTOSANS_CONDENSED_THINITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x00, 0x00, 0x01, 0x03,
  0x04, 0x00, 0x21, 0x22, 0x42, 0x42, 0x42, 0x42, 0x44, 0x84, 0x84, 0x84,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x83, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x1F, 0xFF, 0xC0, 0x41, 0x00, 0x10,
  0x40, 0x08, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x41, 0x80, 0x10, 0x40,
  0x04, 0x10, 0x02, 0x04, 0x0F, 0xFF, 0xE0, 0x20, 0x80, 0x08, 0x20, 0x04,
  0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08,
  0x01, 0x06, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x01,
  0xFE, 0x06, 0x21, 0x04, 0x20, 0x08, 0x20, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x0C, 0x40, 0x04, 0x80, 0x02, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x01, 0x30, 0x01, 0x10, 0x01, 0x08, 0x01, 0x08, 0x02,
  0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x10, 0x82, 0x20, 0x7F, 0xC0, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x43, 0x10, 0x18,
  0x42, 0x02, 0x10, 0x40, 0x82, 0x08, 0x10, 0xC1, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x20, 0x40, 0x8C, 0x08, 0x11, 0x02, 0x04, 0x40, 0x40, 0x88, 0xE8,
  0x12, 0x23, 0x04, 0x48, 0x60, 0x92, 0x0A, 0x22, 0x41, 0x78, 0x98, 0x20,
  0x22, 0x04, 0x04, 0x40, 0x81, 0x08, 0x10, 0x21, 0x02, 0x08, 0x40, 0x81,
  0x08, 0x10, 0x41, 0x02, 0x18, 0x20, 0x82, 0x04, 0x10, 0x80, 0x44, 0x30,
  0x0F, 0x00, 0x00, 0xF8, 0x01, 0x08, 0x03, 0x04, 0x02, 0x04, 0x02, 0x04,
  0x02, 0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02, 0x20,
  0x02, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x80, 0x08, 0x80, 0x10, 0x81,
  0x20, 0x42, 0x60, 0x42, 0x40, 0x24, 0x40, 0x24, 0x80, 0x28, 0x80, 0x18,
  0x80, 0x10, 0x80, 0x38, 0x40, 0x68, 0x60, 0xC8, 0x3F, 0x04, 0x25, 0x24,
  0x94, 0x90, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x18, 0x00,
  0x02, 0x00, 0x40, 0x08, 0x42, 0x04, 0x40, 0x68, 0x43, 0xF0, 0x60, 0x12,
  0x04, 0x43, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88, 0xC0, 0xFF, 0x80, 0xB8, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x0C, 0x20, 0x60,
  0x41, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x30, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0xD0, 0x02, 0x40,
  0x09, 0x00, 0x2C, 0x01, 0xA0, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x20,
  0x18, 0x40, 0x41, 0x02, 0x06, 0x18, 0x0F, 0x80, 0x02, 0x0C, 0x69, 0x14,
  0x70, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x00, 0x00, 0xFC, 0x03,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x0E, 0x04, 0x04, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x07, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x80, 0xC0, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x40, 0x04,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x84, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40,
  0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08, 0x30, 0x10, 0x40, 0x21, 0x00,
  0x86, 0x01, 0x0F, 0xFF, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x11, 0x00, 0x1F, 0xE0, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x80, 0xC0,
  0xFF, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x1E,
  0x02, 0xC3, 0x0A, 0x02, 0x18, 0x02, 0x30, 0x04, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x20, 0x08, 0x40,
  0x20, 0x80, 0xC0, 0x83, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0x06, 0x06, 0x02, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x02, 0x0C, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x02, 0x18,
  0x01, 0x60, 0x01, 0x80, 0x06, 0x40, 0x08, 0x20, 0x30, 0x10, 0x20, 0x18,
  0x40, 0x08, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0xC0, 0x18, 0x40, 0x10, 0x20, 0x60, 0x1F, 0xC0, 0x01, 0xF8, 0x06, 0x08,
  0x18, 0x18, 0x20, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0xC4, 0x03,
  0x04, 0x1A, 0x07, 0xC4, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x07, 0xF0,
  0x00, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x10, 0xC0, 0x01, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x00, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x0F, 0xC1, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xC1, 0x80, 0x0C, 0x01, 0x00, 0x40, 0x06,
  0x02, 0x00, 0x08, 0x10, 0x00, 0x20, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x10,
  0x1F, 0x04, 0x40, 0xC4, 0x12, 0x04, 0x10, 0x48, 0x30, 0x41, 0x20, 0x82,
  0x05, 0x04, 0x08, 0x24, 0x10, 0x20, 0x90, 0xC0, 0x82, 0x42, 0x04, 0x09,
  0x08, 0x10, 0x4C, 0x20, 0x41, 0x20, 0x83, 0x04, 0x82, 0x0C, 0x22, 0x08,
  0x51, 0x88, 0x12, 0x6C, 0x20, 0x30, 0x40, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00,
  0xA0, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08,
  0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x02, 0x02, 0x07,
  0xFC, 0x18, 0x08, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x22, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x40, 0x02, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x07, 0xF8,
  0x04, 0x0E, 0x04, 0x02, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x03, 0x08, 0x02, 0x10, 0x06, 0x10, 0x0C, 0x10, 0x38,
  0x1F, 0xC0, 0x10, 0x30, 0x20, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x80, 0x10,
  0x80, 0x30, 0x80, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x40, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x02, 0x06, 0x01, 0x00,
  0x80, 0x80, 0x20, 0x40, 0x10, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x06, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x8C, 0x00,
  0x44, 0x00, 0x62, 0x00, 0x21, 0x00, 0x20, 0x80, 0x30, 0x80, 0x30, 0x40,
  0x30, 0x20, 0x60, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x30, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x0F, 0xC4, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x80,
  0xC0, 0x10, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02,
  0x08, 0x00, 0xC1, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x3F, 0xFE, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x82,
  0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x06, 0x00,
  0x07, 0xE0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x7C, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x02, 0x30, 0x07, 0x00, 0x00, 0x06, 0x00, 0xC1, 0x00, 0x60, 0x40, 0x30,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08,
  0x60, 0x02, 0x30, 0x01, 0x18, 0x00, 0x44, 0x00, 0x12, 0x00, 0x05, 0x40,
  0x03, 0x90, 0x00, 0xC4, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01,
  0x01, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04, 0x06, 0x01, 0x00, 0x80, 0x80,
  0x20, 0x20, 0x08, 0x08, 0x01, 0x02, 0x00, 0x40, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x50, 0x48,
  0x00, 0x68, 0x24, 0x00, 0x28, 0x12, 0x00, 0x24, 0x09, 0x00, 0x12, 0x04,
  0x80, 0x11, 0x04, 0x40, 0x08, 0x82, 0x20, 0x08, 0x81, 0x10, 0x04, 0x40,
  0x88, 0x04, 0x20, 0xC4, 0x02, 0x10, 0x42, 0x02, 0x18, 0x20, 0x81, 0x08,
  0x10, 0x41, 0x04, 0x08, 0x20, 0x82, 0x08, 0x10, 0x81, 0x04, 0x08, 0x41,
  0x02, 0x04, 0x40, 0x81, 0x02, 0x20, 0x40, 0x81, 0x20, 0x20, 0x80, 0x90,
  0x10, 0x40, 0x50, 0x10, 0x20, 0x28, 0x08, 0x10, 0x08, 0x04, 0x00, 0x06,
  0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x20, 0x50, 0x02, 0x05, 0x00, 0x20,
  0x90, 0x02, 0x09, 0x00, 0x40, 0x88, 0x04, 0x08, 0x80, 0x40, 0x88, 0x04,
  0x10, 0x80, 0x41, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x30, 0x40,
  0x82, 0x02, 0x18, 0x20, 0x21, 0x02, 0x02, 0x10, 0x20, 0x21, 0x04, 0x01,
  0x10, 0x40, 0x12, 0x04, 0x01, 0x20, 0x40, 0x12, 0x04, 0x00, 0xA0, 0x80,
  0x0A, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x00, 0xFC, 0x00,
  0x40, 0xC0, 0x60, 0x10, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00,
  0x42, 0x00, 0x30, 0x40, 0x08, 0x10, 0x04, 0x02, 0x02, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x04, 0x0C, 0x04, 0x06, 0x04, 0x02, 0x04, 0x02, 0x08, 0x03,
  0x08, 0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x04, 0x10, 0x18, 0x10, 0x30, 0x3F, 0xC0, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x40,
  0xC0, 0x60, 0x10, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08,
  0x80, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42,
  0x00, 0x30, 0x40, 0x08, 0x10, 0x04, 0x02, 0x02, 0x00, 0x7F, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x07, 0xF0, 0x08, 0x18, 0x10, 0x18, 0x20, 0x10, 0x40,
  0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x04, 0x40, 0x18,
  0x80, 0x21, 0x00, 0xC2, 0x03, 0x07, 0xF8, 0x10, 0x40, 0x20, 0x80, 0x41,
  0x00, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x18, 0x20, 0x10,
  0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x00, 0x80, 0x00, 0xFF, 0x00, 0xC0,
  0xC0, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x20, 0x08, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x08, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x03, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00,
  0x82, 0x00, 0x20, 0x80, 0x10, 0x30, 0x0C, 0x06, 0x06, 0x00, 0xFE, 0x00,
  0x80, 0x07, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20,
  0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x82, 0x01, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x30, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x04, 0x02, 0x10, 0x04,
  0x20, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x02, 0x00, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0xA0,
  0x06, 0x00, 0x50, 0x05, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01, 0x40, 0x22,
  0x01, 0x20, 0x11, 0x00, 0x90, 0x08, 0x80, 0x88, 0x08, 0x40, 0x44, 0x04,
  0x20, 0x62, 0x04, 0x10, 0x21, 0x02, 0x08, 0x10, 0x83, 0x04, 0x10, 0x41,
  0x02, 0x08, 0x20, 0x81, 0x08, 0x10, 0x80, 0x84, 0x08, 0x40, 0x42, 0x04,
  0x40, 0x22, 0x02, 0x20, 0x11, 0x01, 0x10, 0x09, 0x00, 0x90, 0x04, 0x80,
  0x48, 0x02, 0xC0, 0x28, 0x01, 0x40, 0x14, 0x00, 0xA0, 0x0A, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x00, 0x01, 0x00, 0x60,
  0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x10, 0x01, 0x04, 0x00,
  0x20, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x01, 0x40, 0x00,
  0x28, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01,
  0x20, 0x00, 0x64, 0x00, 0x08, 0x80, 0x02, 0x18, 0x00, 0x41, 0x00, 0x10,
  0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x20, 0x10, 0x08, 0x01, 0x01, 0x00,
  0x20, 0x40, 0x04, 0x00, 0x80, 0x05, 0x00, 0x24, 0x01, 0x90, 0x04, 0x40,
  0x21, 0x00, 0x84, 0x04, 0x08, 0x10, 0x20, 0x80, 0x86, 0x02, 0x10, 0x08,
  0x80, 0x22, 0x00, 0x90, 0x01, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x84, 0x21, 0x04, 0x21,
  0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x08, 0x41, 0x08,
  0x42, 0x10, 0x00, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x80,
  0x09, 0x00, 0x22, 0x00, 0x42, 0x01, 0x04, 0x06, 0x0C, 0x08, 0x08, 0x20,
  0x10, 0x40, 0x11, 0x00, 0x26, 0x00, 0x68, 0x00, 0x70, 0x00, 0x80, 0xFF,
  0xE0, 0x88, 0x44, 0x23, 0x01, 0xE2, 0x0C, 0x24, 0x30, 0x28, 0x40, 0x61,
  0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x44, 0x01, 0x98, 0x02, 0x20, 0x04, 0x40, 0x18, 0xC0, 0x30,
  0x80, 0xC1, 0x03, 0x83, 0x0D, 0x03, 0xF2, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x23, 0xC0, 0xB1, 0x85, 0x81, 0x14, 0x04, 0x60, 0x11, 0x80, 0x44, 0x01,
  0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x34, 0x00,
  0x90, 0x02, 0x40, 0x13, 0x00, 0x4C, 0x02, 0x28, 0x18, 0xA0, 0xC2, 0x7E,
  0x00, 0x01, 0xF8, 0x30, 0x83, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0xF1, 0x01, 0x84, 0x81,
  0x81, 0x40, 0x80, 0xA0, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x04,
  0x20, 0x06, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC3, 0x00,
  0x61, 0x00, 0x20, 0x80, 0x30, 0x60, 0x18, 0x10, 0x14, 0x08, 0x1A, 0x06,
  0x1A, 0x01, 0xF9, 0x00, 0x01, 0xE0, 0x30, 0x83, 0x06, 0x10, 0x11, 0x00,
  0x98, 0x0C, 0x80, 0x44, 0x06, 0x40, 0x62, 0x0C, 0x1F, 0x80, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x81, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x10, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x1F, 0x80, 0x1A, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0x03, 0x09, 0x06,
  0x05, 0x04, 0x05, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20,
  0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x60, 0x0C, 0x40,
  0x08, 0x40, 0x18, 0x60, 0x18, 0x20, 0x28, 0x20, 0x70, 0x30, 0xD0, 0x1F,
  0x90, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x81, 0x80, 0xFF, 0x00, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x23,
  0xC0, 0xB0, 0x85, 0x03, 0x18, 0x04, 0x60, 0x11, 0x00, 0x44, 0x02, 0x30,
  0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10,
  0x04, 0x40, 0x23, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x00,
  0x04, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x0F,
  0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0C, 0x10, 0x10, 0x40,
  0x40, 0x81, 0x01, 0x04, 0x02, 0x10, 0x04, 0x40, 0x11, 0x80, 0x22, 0x00,
  0x4C, 0x00, 0xA8, 0x02, 0x90, 0x06, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20,
  0x80, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x18, 0x04, 0x00, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x09, 0xE0, 0xF0, 0x28, 0x44, 0x31, 0x40,
  0xA0, 0x46, 0x03, 0x01, 0x18, 0x0C, 0x04, 0x40, 0x20, 0x11, 0x00, 0x80,
  0x4C, 0x02, 0x01, 0x20, 0x10, 0x08, 0x80, 0x40, 0x22, 0x01, 0x00, 0x88,
  0x04, 0x02, 0x40, 0x30, 0x09, 0x00, 0x80, 0x44, 0x02, 0x01, 0x10, 0x08,
  0x04, 0xC0, 0x20, 0x12, 0x01, 0x00, 0xC8, 0x04, 0x02, 0x20, 0x10, 0x08,
  0x80, 0x40, 0x20, 0x08, 0xF0, 0x2C, 0x21, 0x40, 0xC6, 0x01, 0x18, 0x04,
  0x40, 0x11, 0x00, 0x8C, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0xC0, 0x22, 0x00, 0x88, 0x02,
  0x20, 0x08, 0x80, 0x40, 0x01, 0xE0, 0x18, 0x60, 0xC0, 0x82, 0x01, 0x10,
  0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50,
  0x02, 0x40, 0x0B, 0x00, 0x2C, 0x01, 0xA0, 0x04, 0xC0, 0x11, 0x00, 0x84,
  0x06, 0x18, 0x30, 0x3F, 0x00, 0x02, 0x3C, 0x02, 0xC2, 0x05, 0x81, 0x05,
  0x01, 0x06, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x06, 0x30, 0x04, 0x30, 0x08, 0x28, 0x08, 0x28, 0x30, 0x27, 0xE0, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xE2, 0x0C, 0x24, 0x30, 0x28, 0x40,
  0x51, 0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x60, 0x04, 0x80, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x98, 0x03, 0x20, 0x04, 0x40, 0x18, 0xC0,
  0x30, 0x80, 0xA1, 0x03, 0x83, 0x0D, 0x03, 0xF2, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x08, 0xE1, 0x60, 0x50, 0x0A, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x03, 0xE0, 0xC1, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x88,
  0x18, 0xFE, 0x00, 0x04, 0x04, 0x08, 0x08, 0x08, 0x7F, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x78, 0x08, 0x06, 0x10, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x00, 0x42, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10,
  0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x80,
  0x61, 0x00, 0xC2, 0x02, 0x82, 0x09, 0x07, 0xE4, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x41, 0x04, 0x10,
  0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x50, 0x05, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x00, 0x80, 0x20, 0x18, 0x06, 0x02, 0x80, 0x60,
  0x28, 0x0A, 0x06, 0x80, 0xA0, 0x48, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x12,
  0x08, 0x82, 0x21, 0x08, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x20, 0x88,
  0x22, 0x08, 0x82, 0x40, 0x88, 0x24, 0x05, 0x02, 0x40, 0x50, 0x28, 0x06,
  0x02, 0x80, 0x60, 0x30, 0x04, 0x03, 0x00, 0x40, 0x20, 0x00, 0x04, 0x01,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x04, 0x02, 0x08, 0x01, 0x18, 0x01, 0x10,
  0x01, 0x20, 0x01, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x40,
  0x02, 0x40, 0x04, 0x40, 0x08, 0x20, 0x08, 0x20, 0x10, 0x20, 0x20, 0x20,
  0x60, 0x10, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x01,
  0x30, 0x00, 0x24, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x01, 0xC0, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x07, 0x00, 0x00, 0x7E, 0x06, 0x06, 0x38, 0x07, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 28, 8, 1, -28 },
  { 26, 8, 10, 11, 4, -28 },
  { 36, 18, 28, 17, 0, -28 },
  { 99, 16, 32, 16, 0, -30 },
  { 163, 19, 28, 23, 2, -28 },
  { 230, 16, 28, 17, 0, -28 },
  { 286, 3, 10, 6, 4, -28 },
  { 290, 11, 34, 9, 1, -28 },
  { 337, 11, 34, 9, -3, -28 },
  { 384, 11, 13, 15, 5, -30 },
  { 402, 14, 18, 18, 2, -23 },
  { 434, 5, 9, 6, -2, -4 },
  { 440, 9, 1, 11, 1, -11 },
  { 442, 2, 3, 7, 1, -3 },
  { 443, 16, 28, 12, -2, -28 },
  { 499, 14, 28, 16, 1, -28 },
  { 548, 7, 28, 16, 5, -28 },
  { 573, 16, 28, 16, -1, -28 },
  { 629, 16, 28, 16, 0, -28 },
  { 685, 15, 28, 16, 0, -28 },
  { 738, 16, 28, 16, 0, -28 },
  { 794, 15, 28, 16, 1, -28 },
  { 847, 15, 28, 16, 2, -28 },
  { 900, 16, 28, 16, 0, -28 },
  { 956, 15, 28, 16, 0, -28 },
  { 1009, 6, 21, 7, 0, -21 },
  { 1025, 8, 26, 7, -2, -21 },
  { 1051, 14, 16, 18, 2, -22 },
  { 1079, 14, 9, 18, 2, -18 },
  { 1095, 14, 16, 18, 2, -22 },
  { 1123, 12, 28, 11, 1, -28 },
  { 1165, 22, 32, 24, 1, -28 },
  { 1253, 15, 28, 15, -2, -28 },
  { 1306, 16, 28, 17, 1, -28 },
  { 1362, 17, 28, 16, 2, -28 },
  { 1422, 17, 28, 19, 1, -28 },
  { 1482, 16, 28, 15, 1, -28 },
  { 1538, 16, 28, 14, 1, -28 },
  { 1594, 19, 28, 20, 2, -28 },
  { 1661, 19, 28, 20, 1, -28 },
  { 1728, 11, 28, 8, -1, -28 },
  { 1767, 14, 35, 7, -6, -28 },
  { 1829, 18, 28, 16, 1, -28 },
  { 1892, 10, 28, 14, 1, -28 },
  { 1927, 25, 28, 25, 1, -28 },
  { 2015, 20, 28, 20, 1, -28 },
  { 2085, 18, 28, 21, 2, -28 },
  { 2148, 16, 28, 16, 1, -28 },
  { 2204, 18, 35, 21, 2, -28 },
  { 2283, 15, 28, 16, 1, -28 },
  { 2336, 17, 28, 15, -1, -28 },
  { 2396, 14, 28, 14, 3, -28 },
  { 2445, 18, 28, 20, 2, -28 },
  { 2508, 15, 28, 16, 4, -28 },
  { 2561, 25, 28, 26, 4, -28 },
  { 2649, 19, 28, 14, -2, -28 },
  { 2716, 14, 28, 14, 3, -28 },
  { 2765, 18, 28, 15, -1, -28 },
  { 2828, 14, 34, 11, -1, -28 },
  { 2888, 5, 28, 12, 4, -28 },
  { 2906, 15, 34, 11, -3, -28 },
  { 2970, 15, 15, 17, 1, -28 },
  { 2999, 11, 1, 11, -3, 4 },
  { 3001, 4, 6, 8, 6, -30 },
  { 3004, 15, 21, 17, 1, -21 },
  { 3044, 14, 30, 17, 1, -30 },
  { 3097, 13, 21, 13, 1, -21 },
  { 3132, 17, 30, 17, 1, -30 },
  { 3196, 13, 21, 15, 1, -21 },
  { 3231, 18, 39, 8, -5, -30 },
  { 3319, 16, 30, 17, 0, -21 },
  { 3379, 14, 30, 16, 1, -30 },
  { 3432, 7, 28, 7, 1, -28 },
  { 3457, 13, 37, 7, -5, -28 },
  { 3518, 15, 30, 13, 0, -30 },
  { 3575, 8, 30, 6, 0, -30 },
  { 3605, 22, 21, 25, 1, -21 },
  { 3663, 14, 21, 16, 1, -21 },
  { 3700, 14, 21, 16, 1, -21 },
  { 3737, 16, 30, 17, -1, -21 },
  { 3797, 15, 30, 17, 1, -21 },
  { 3854, 11, 21, 11, 1, -21 },
  { 3883, 12, 21, 12, 0, -21 },
  { 3915, 8, 26, 9, 1, -26 },
  { 3941, 15, 21, 16, 1, -21 },
  { 3981, 12, 21, 12, 2, -21 },
  { 4013, 20, 21, 20, 2, -21 },
  { 4066, 16, 21, 13, -2, -21 },
  { 4108, 19, 30, 13, -4, -21 },
  { 4180, 13, 21, 11, -1, -21 },
  { 4215, 14, 34, 12, 1, -28 },
  { 4275, 1, 39, 16, 8, -30 },
  { 4280, 13, 34, 12, -2, -28 },
  { 4336, 14, 3, 18, 2, -15 },
};

const GFXfont NotoSans_Condensed_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_THINITALIC39PT7B_H_
