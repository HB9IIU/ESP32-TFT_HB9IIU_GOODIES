#ifndef _NOTOSANS_CONDENSED_THINITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01,
  0x80, 0xC0, 0x00, 0x21, 0x90, 0xD8, 0x48, 0x24, 0x12, 0x19, 0x09, 0x04,
  0x82, 0x41, 0x21, 0x10, 0x80, 0x00, 0x30, 0x20, 0x02, 0x04, 0x00, 0x20,
  0x40, 0x06, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0x08,
  0x18, 0x00, 0x81, 0x00, 0x08, 0x10, 0x1F, 0xFF, 0xF0, 0x10, 0x20, 0x01,
  0x02, 0x00, 0x30, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00,
  0x40, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x0F, 0xFF, 0xF8,
  0x08, 0x10, 0x01, 0x81, 0x00, 0x10, 0x30, 0x01, 0x02, 0x00, 0x30, 0x20,
  0x02, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x08,
  0x00, 0x40, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x07, 0xF8, 0x03, 0x91, 0xC0, 0xC2, 0x00, 0x30, 0x40, 0x04,
  0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x40, 0x01, 0x88, 0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x05, 0x80, 0x00, 0x98, 0x00, 0x31, 0x80, 0x04,
  0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x81, 0x00, 0x10,
  0x60, 0x02, 0x08, 0x00, 0x42, 0x07, 0x09, 0x80, 0x3F, 0xC0, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x07,
  0x80, 0x18, 0x21, 0x00, 0x41, 0x04, 0x03, 0x0C, 0x10, 0x08, 0x20, 0x40,
  0x41, 0x81, 0x01, 0x04, 0x04, 0x08, 0x10, 0x10, 0x60, 0x40, 0x41, 0x03,
  0x01, 0x0C, 0x08, 0x04, 0x20, 0x20, 0x31, 0x80, 0x80, 0x84, 0x02, 0x02,
  0x21, 0xE8, 0x18, 0x88, 0xE0, 0x44, 0x41, 0x83, 0x33, 0x06, 0x08, 0x88,
  0x1C, 0x66, 0x60, 0x5E, 0x11, 0x01, 0x00, 0x84, 0x04, 0x02, 0x30, 0x10,
  0x10, 0x80, 0xC0, 0xC2, 0x03, 0x02, 0x08, 0x08, 0x18, 0x20, 0x20, 0x41,
  0x80, 0x82, 0x06, 0x06, 0x08, 0x18, 0x10, 0x40, 0x60, 0xC3, 0x00, 0x82,
  0x08, 0x02, 0x10, 0x60, 0x0F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x3E, 0x00,
  0x08, 0x60, 0x02, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00,
  0x40, 0x40, 0x08, 0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00,
  0x86, 0x00, 0x11, 0x80, 0x03, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x40, 0x00, 0xC8, 0x00, 0x31, 0x80, 0x8C, 0x10, 0x23, 0x03, 0x04, 0x40,
  0x21, 0x98, 0x04, 0x22, 0x00, 0xC4, 0x40, 0x09, 0x18, 0x01, 0xE3, 0x00,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0xE0, 0x80, 0x14, 0x10, 0x04, 0x83, 0x03,
  0x08, 0x3F, 0xC1, 0x00, 0x25, 0xA4, 0x94, 0x92, 0x40, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x0C, 0x20, 0x11, 0x00,
  0x68, 0xE0, 0xF8, 0x06, 0x00, 0xC8, 0x0C, 0x40, 0x81, 0x08, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x3F, 0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x30, 0x86, 0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x86, 0x02,
  0x02, 0x06, 0x03, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x03, 0x40,
  0x03, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x60, 0xC0, 0xC0, 0x61, 0x80, 0x3F,
  0x00, 0x01, 0x81, 0x83, 0x43, 0x22, 0x16, 0x1A, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x38, 0x10, 0x04, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xE0, 0x60, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x82, 0x01, 0xC0, 0xFF, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x0A,
  0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x46, 0x00, 0x31, 0x00,
  0x08, 0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0x83, 0x00, 0x40, 0x80, 0x30,
  0x20, 0x08, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x10,
  0x30, 0x04, 0x18, 0x03, 0x04, 0x00, 0x82, 0x00, 0x20, 0xFF, 0xFF, 0x80,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xE0, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x04, 0x03, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x1F, 0x01, 0x30, 0x60, 0xB0, 0x18, 0x70,
  0x04, 0x70, 0x02, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x32,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x06, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x86, 0x00, 0x81, 0x00, 0x80, 0xC1, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x18, 0x30, 0x04, 0x03, 0x01, 0x00, 0x20, 0x20, 0x06, 0x08,
  0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x18,
  0x03, 0x01, 0x00, 0xC0, 0x30, 0x30, 0x02, 0x0C, 0x00, 0x26, 0x00, 0x03,
  0x80, 0x01, 0xF0, 0x00, 0xE3, 0x00, 0x30, 0x30, 0x0C, 0x02, 0x03, 0x00,
  0x60, 0xC0, 0x04, 0x10, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x20, 0x80, 0x0C, 0x18, 0x03,
  0x01, 0x80, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x30, 0xC0, 0x10,
  0x08, 0x08, 0x02, 0x06, 0x00, 0xC1, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x01,
  0x08, 0x00, 0x46, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4,
  0x00, 0x31, 0x00, 0x08, 0x60, 0x06, 0x08, 0x03, 0x83, 0x01, 0xA0, 0x60,
  0xD8, 0x0F, 0xC4, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x0C, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x60, 0x01, 0xC0, 0x60, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE1, 0x81, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x10, 0x00, 0x30, 0x10, 0x00, 0x08, 0x18, 0x00, 0x04, 0x18, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x80, 0x44, 0x03, 0xF8, 0x26, 0x02,
  0x08, 0x12, 0x02, 0x04, 0x09, 0x02, 0x02, 0x05, 0x03, 0x03, 0x06, 0x81,
  0x01, 0x03, 0x41, 0x80, 0x81, 0x60, 0x80, 0xC0, 0xA0, 0x40, 0x40, 0x50,
  0x20, 0x20, 0x68, 0x30, 0x10, 0x24, 0x10, 0x18, 0x12, 0x08, 0x0C, 0x19,
  0x04, 0x0C, 0x08, 0x82, 0x06, 0x0C, 0x41, 0x84, 0x8C, 0x20, 0x66, 0x6C,
  0x10, 0x1C, 0x1C, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8,
  0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x10, 0x20, 0x04, 0x08, 0x02, 0x02, 0x00, 0x80, 0x80, 0x60,
  0x20, 0x10, 0x0C, 0x0F, 0xFF, 0x02, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x04,
  0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x30,
  0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x01,
  0xFE, 0x00, 0x60, 0xF0, 0x08, 0x03, 0x01, 0x00, 0x30, 0x20, 0x02, 0x04,
  0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x10,
  0x01, 0x06, 0x00, 0x20, 0x80, 0x08, 0x10, 0x02, 0x02, 0x01, 0x80, 0xFF,
  0xC0, 0x18, 0x3C, 0x02, 0x00, 0xC0, 0x40, 0x0C, 0x08, 0x00, 0x83, 0x00,
  0x10, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x0C, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80, 0x08, 0x30, 0x06,
  0x04, 0x03, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x01, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x40, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x78, 0x02, 0x00,
  0xC0, 0x20, 0x06, 0x02, 0x00, 0x20, 0x20, 0x03, 0x06, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x11,
  0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x62, 0x00, 0x04,
  0x20, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x18, 0x40, 0x03,
  0x04, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x30, 0x08, 0x1E,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x03, 0xFF, 0xC0, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0x70,
  0x0C, 0x00, 0x40, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xCC, 0x00, 0x02, 0x30, 0x00,
  0x08, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0x43, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x60,
  0x00, 0x80, 0x80, 0x02, 0x01, 0x00, 0x08, 0x07, 0x00, 0x60, 0x07, 0xFE,
  0x00, 0x01, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x03, 0x02, 0x00, 0x04,
  0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC0,
  0x80, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x04, 0x0F, 0xFF, 0xF8, 0x10,
  0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00,
  0x06, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00,
  0x40, 0xC0, 0x01, 0x81, 0x00, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08,
  0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x01, 0x00,
  0x01, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x8E, 0x00, 0x78, 0x00, 0x01, 0x00, 0x18, 0x18,
  0x01, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0x80, 0xC0, 0x04, 0x0C, 0x00, 0x20, 0xC0, 0x01, 0x04,
  0x00, 0x18, 0x40, 0x00, 0x86, 0x00, 0x04, 0x60, 0x00, 0x26, 0x00, 0x03,
  0x70, 0x00, 0x16, 0xC0, 0x00, 0xA2, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80,
  0x03, 0x06, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x06, 0x00, 0x20,
  0x10, 0x03, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x60, 0x06, 0x03, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x06, 0x00, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0xF0, 0x01, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xA0, 0x00, 0x0E,
  0x05, 0x00, 0x00, 0x50, 0x28, 0x00, 0x07, 0x01, 0x40, 0x00, 0x28, 0x1A,
  0x00, 0x03, 0x40, 0x90, 0x00, 0x12, 0x04, 0x80, 0x01, 0xB0, 0x24, 0x00,
  0x09, 0x01, 0x20, 0x00, 0x88, 0x19, 0x00, 0x04, 0x40, 0x8C, 0x00, 0x42,
  0x04, 0x20, 0x02, 0x30, 0x21, 0x00, 0x21, 0x03, 0x08, 0x01, 0x08, 0x18,
  0x40, 0x10, 0x40, 0x82, 0x00, 0x82, 0x04, 0x10, 0x08, 0x30, 0x20, 0x80,
  0x41, 0x03, 0x04, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x06,
  0x04, 0x0C, 0x30, 0x20, 0x20, 0x21, 0x01, 0x03, 0x01, 0x18, 0x08, 0x10,
  0x08, 0x80, 0x40, 0x80, 0x4C, 0x06, 0x04, 0x02, 0x40, 0x20, 0x60, 0x16,
  0x01, 0x03, 0x00, 0xA0, 0x08, 0x10, 0x07, 0x00, 0x40, 0x80, 0x30, 0x06,
  0x00, 0x01, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x80, 0x02, 0x02, 0x80,
  0x02, 0x02, 0x80, 0x06, 0x02, 0x80, 0x04, 0x06, 0xC0, 0x04, 0x04, 0x40,
  0x04, 0x04, 0x40, 0x0C, 0x04, 0x40, 0x0C, 0x04, 0x60, 0x08, 0x0C, 0x20,
  0x08, 0x08, 0x20, 0x08, 0x08, 0x30, 0x18, 0x08, 0x10, 0x10, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x10, 0x10, 0x08, 0x30, 0x10, 0x08,
  0x20, 0x30, 0x08, 0x20, 0x20, 0x0C, 0x20, 0x20, 0x04, 0x20, 0x20, 0x04,
  0x60, 0x20, 0x04, 0x40, 0x60, 0x06, 0x40, 0x40, 0x02, 0x40, 0x40, 0x02,
  0x40, 0x40, 0x02, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x01,
  0x80, 0x80, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x07, 0x07, 0x00, 0x60, 0x08,
  0x06, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00, 0x0C, 0x30, 0x00, 0x21, 0x00,
  0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00,
  0x12, 0x00, 0x00, 0x90, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60,
  0x00, 0x13, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06,
  0x30, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x30, 0x30, 0x01, 0x00, 0x80,
  0x10, 0x03, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x61, 0xE0,
  0x08, 0x06, 0x01, 0x00, 0x60, 0x20, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10,
  0x20, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x20,
  0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x06, 0x02,
  0x07, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x07, 0x00, 0x60, 0x08, 0x06, 0x00,
  0x20, 0x60, 0x01, 0x02, 0x00, 0x0C, 0x30, 0x00, 0x21, 0x00, 0x01, 0x18,
  0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x90, 0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00,
  0x00, 0x90, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x13,
  0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00,
  0x20, 0x80, 0x02, 0x04, 0x00, 0x30, 0x30, 0x01, 0x00, 0x80, 0x10, 0x03,
  0x03, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xFC, 0x00, 0xC3, 0xC0, 0x20, 0x18, 0x08, 0x03, 0x02,
  0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x04, 0x30, 0x03, 0x08, 0x00, 0x82, 0x00, 0x60, 0x80, 0x10,
  0x60, 0x08, 0x18, 0x0C, 0x07, 0xFE, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30,
  0x20, 0x08, 0x08, 0x02, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x04,
  0x04, 0x01, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x0C, 0x00, 0xC2,
  0x00, 0x30, 0x80, 0x04, 0x00, 0x00, 0x3F, 0xC0, 0x0C, 0x07, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0C, 0x01,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08,
  0x30, 0x00, 0x60, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x60,
  0x00, 0x41, 0x80, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00,
  0x83, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02,
  0x00, 0x04, 0x18, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00,
  0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x20, 0x00, 0x80, 0xC0, 0x02, 0x01, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x06, 0x80, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0x40,
  0x04, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x10, 0x10, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x10, 0x10, 0x04, 0x0C, 0x01,
  0x02, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x2C, 0x00, 0x30, 0x00, 0xB0, 0x01, 0x40, 0x04, 0xC0,
  0x05, 0x00, 0x13, 0x00, 0x34, 0x00, 0xCC, 0x00, 0x90, 0x02, 0x30, 0x02,
  0x40, 0x18, 0xC0, 0x11, 0x00, 0x43, 0x00, 0x44, 0x01, 0x0C, 0x03, 0x10,
  0x0C, 0x30, 0x08, 0x40, 0x20, 0xC0, 0x61, 0x01, 0x83, 0x01, 0x04, 0x04,
  0x0C, 0x04, 0x10, 0x10, 0x10, 0x20, 0x40, 0x80, 0x40, 0x81, 0x02, 0x01,
  0x06, 0x04, 0x18, 0x04, 0x10, 0x10, 0x40, 0x10, 0x40, 0x41, 0x00, 0x42,
  0x01, 0x08, 0x01, 0x08, 0x04, 0x20, 0x04, 0x60, 0x11, 0x80, 0x11, 0x00,
  0x44, 0x00, 0x4C, 0x01, 0x30, 0x01, 0x20, 0x04, 0x80, 0x04, 0x80, 0x12,
  0x00, 0x14, 0x00, 0x50, 0x00, 0x50, 0x01, 0x40, 0x01, 0xC0, 0x07, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0xC0,
  0x04, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x20, 0x00,
  0x20, 0xC0, 0x00, 0x41, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x98, 0x00, 0x01,
  0x20, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x60, 0x00, 0x0C, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x41, 0x00, 0x01, 0x82, 0x00, 0x02, 0x04, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x40, 0x10, 0x01, 0x80, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x00, 0xC0, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x00, 0x80,
  0x03, 0x80, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x10, 0x40, 0x30, 0x40, 0x20, 0x60, 0x60, 0x20, 0x40, 0x20, 0x80, 0x21,
  0x80, 0x21, 0x00, 0x23, 0x00, 0x32, 0x00, 0x16, 0x00, 0x14, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x00, 0x82, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x00, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x63,
  0x00, 0x10, 0x40, 0x0C, 0x18, 0x02, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x30,
  0x20, 0x04, 0x18, 0x01, 0x84, 0x00, 0x22, 0x00, 0x09, 0x80, 0x03, 0xC0,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x8C, 0x44, 0x21, 0x10, 0x00, 0xF0,
  0x01, 0xFC, 0x41, 0x81, 0x21, 0x80, 0xA1, 0x80, 0x30, 0x80, 0x18, 0xC0,
  0x0C, 0x40, 0x06, 0x60, 0x02, 0x20, 0x01, 0x10, 0x00, 0x98, 0x00, 0xCC,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x04,
  0x20, 0x06, 0x10, 0x03, 0x08, 0x02, 0x84, 0x01, 0xC3, 0x01, 0x40, 0xC1,
  0x20, 0x3F, 0x10, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x0E, 0x00, 0x9D, 0xC0, 0xD8, 0x30, 0x58, 0x0C, 0x38, 0x02,
  0x18, 0x01, 0x0C, 0x00, 0x8C, 0x00, 0x46, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x09, 0x80, 0x04, 0x80, 0x06, 0x40, 0x03, 0x20, 0x01, 0x10, 0x00, 0x98,
  0x00, 0xCC, 0x00, 0x46, 0x00, 0x23, 0x00, 0x21, 0x80, 0x11, 0x40, 0x10,
  0xA0, 0x18, 0x48, 0x18, 0x23, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x70, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x10, 0x3F, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x01, 0xC2, 0x01, 0xFC, 0x40, 0x60, 0x48, 0x18, 0x07,
  0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x61, 0x80, 0x0C,
  0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x84, 0x00, 0x30,
  0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x30, 0x40, 0x06, 0x08, 0x01, 0x81,
  0x00, 0x30, 0x20, 0x0E, 0x04, 0x01, 0x40, 0xC0, 0x48, 0x0C, 0x12, 0x00,
  0xFC, 0x40, 0x00, 0x00, 0x60, 0x0F, 0xE0, 0x60, 0xC3, 0x01, 0x18, 0x04,
  0x40, 0x13, 0x00, 0x48, 0x03, 0x60, 0x09, 0x00, 0x64, 0x03, 0x30, 0x30,
  0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x08, 0x3F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0xC4, 0x06, 0x04, 0x81, 0x80, 0x50, 0x60, 0x0C,
  0x08, 0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x10,
  0x40, 0x02, 0x18, 0x00, 0x43, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x60, 0x80, 0x18, 0x10, 0x03, 0x02,
  0x00, 0xE0, 0x40, 0x14, 0x0C, 0x05, 0x80, 0xC3, 0x20, 0x0F, 0xC4, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x10, 0x0C, 0x03, 0x07, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x38,
  0x04, 0xEE, 0x0D, 0x03, 0x0A, 0x01, 0x0E, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x18, 0x01, 0x18, 0x01, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x30, 0x02,
  0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10,
  0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x07, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x03, 0x0C, 0x06, 0x08, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x08, 0x20, 0x18, 0x60, 0x10, 0xC0, 0x11, 0x80,
  0x11, 0x00, 0x33, 0x00, 0x25, 0x80, 0x28, 0x80, 0x30, 0x80, 0x30, 0x80,
  0x60, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x60, 0xC0, 0x20,
  0x80, 0x20, 0x80, 0x20, 0x80, 0x30, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x38, 0x0E, 0x01, 0x3F, 0x0E, 0xE0,
  0x90, 0x26, 0x0C, 0x28, 0x0B, 0x01, 0x0C, 0x03, 0x80, 0x43, 0x00, 0xC0,
  0x10, 0x80, 0x30, 0x04, 0x60, 0x08, 0x01, 0x18, 0x02, 0x00, 0x44, 0x00,
  0x80, 0x31, 0x00, 0x60, 0x08, 0xC0, 0x18, 0x02, 0x30, 0x04, 0x00, 0x88,
  0x01, 0x00, 0x22, 0x00, 0x40, 0x18, 0x80, 0x30, 0x04, 0x60, 0x08, 0x01,
  0x10, 0x02, 0x00, 0x44, 0x00, 0x80, 0x11, 0x00, 0x20, 0x0C, 0x40, 0x18,
  0x02, 0x30, 0x04, 0x00, 0x88, 0x01, 0x00, 0x22, 0x00, 0x40, 0x18, 0x80,
  0x30, 0x04, 0x00, 0x00, 0x38, 0x04, 0xEE, 0x09, 0x03, 0x0A, 0x01, 0x0E,
  0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x03, 0x10,
  0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x60,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0x80,
  0x08, 0x80, 0x18, 0x80, 0x10, 0x00, 0x70, 0x03, 0xFC, 0x06, 0x04, 0x0C,
  0x02, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x10, 0xC0, 0x20, 0x60, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x09, 0xFC,
  0x01, 0x30, 0x60, 0x16, 0x03, 0x01, 0x40, 0x10, 0x18, 0x01, 0x01, 0x80,
  0x10, 0x30, 0x01, 0x03, 0x00, 0x10, 0x30, 0x01, 0x02, 0x00, 0x10, 0x20,
  0x01, 0x06, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C,
  0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x0C, 0x00, 0x81,
  0xC0, 0x10, 0x14, 0x03, 0x01, 0x20, 0x60, 0x11, 0xF8, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x01, 0xFC, 0x41, 0x81, 0x21, 0x80, 0x51, 0x80, 0x30,
  0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x20, 0x01, 0x10, 0x00,
  0x98, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x32, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x0C, 0x40, 0x06, 0x20, 0x06, 0x10, 0x03, 0x08, 0x03, 0x84, 0x01, 0x43,
  0x01, 0x60, 0xC1, 0x20, 0x3F, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x38, 0x27, 0xC2, 0x60, 0x14,
  0x00, 0xE0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00,
  0xE0, 0x0F, 0x7C, 0x30, 0x10, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x40, 0x60, 0xFF, 0x80, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x03, 0x03, 0xFC, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0xC0, 0x1F, 0x00,
  0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02,
  0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18,
  0x80, 0x30, 0x80, 0x30, 0x80, 0x50, 0x80, 0xD0, 0xC1, 0xA0, 0x7F, 0x20,
  0x80, 0x0E, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x04,
  0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x10, 0x20, 0x40, 0x83, 0x02, 0x08,
  0x08, 0x60, 0x21, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80, 0x14, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x10, 0x07, 0x00, 0x60, 0x0A,
  0x00, 0xC0, 0x34, 0x02, 0x80, 0x48, 0x05, 0x01, 0x90, 0x1A, 0x02, 0x20,
  0x24, 0x04, 0x40, 0xC8, 0x10, 0x81, 0x10, 0x21, 0x02, 0x20, 0xC2, 0x08,
  0x41, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x10, 0x82, 0x10, 0x23, 0x04,
  0x60, 0x44, 0x08, 0x80, 0x98, 0x11, 0x01, 0x20, 0x24, 0x02, 0x40, 0x48,
  0x05, 0x00, 0xA0, 0x0A, 0x01, 0x40, 0x18, 0x02, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x40, 0x18, 0x04, 0x06, 0x00, 0x80,
  0x80, 0x10, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x98,
  0x00, 0x1A, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x03, 0x40,
  0x00, 0x48, 0x00, 0x11, 0x00, 0x06, 0x10, 0x00, 0x82, 0x00, 0x20, 0x40,
  0x0C, 0x0C, 0x01, 0x00, 0x80, 0x40, 0x10, 0x18, 0x02, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x04, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x10, 0x01, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40,
  0x40, 0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00,
  0x01, 0x04, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x44, 0x00, 0x01,
  0x10, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xE0, 0xE0,
  0x60, 0x1F, 0xC0, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 33, 9, 1, -33 },
  { 39, 9, 12, 13, 5, -33 },
  { 53, 20, 33, 20, 1, -33 },
  { 136, 19, 38, 19, 0, -35 },
  { 227, 22, 34, 27, 3, -33 },
  { 321, 19, 33, 20, 0, -33 },
  { 400, 3, 12, 7, 5, -33 },
  { 405, 13, 40, 11, 1, -33 },
  { 470, 12, 40, 11, -3, -33 },
  { 530, 13, 15, 18, 6, -35 },
  { 555, 17, 21, 21, 2, -27 },
  { 600, 6, 11, 8, -2, -5 },
  { 609, 10, 1, 13, 1, -13 },
  { 611, 2, 3, 8, 1, -3 },
  { 612, 19, 33, 14, -2, -33 },
  { 691, 16, 33, 19, 2, -33 },
  { 757, 9, 33, 19, 6, -33 },
  { 795, 19, 33, 19, -1, -33 },
  { 874, 18, 34, 19, 0, -33 },
  { 951, 18, 33, 19, 0, -33 },
  { 1026, 19, 33, 19, 0, -33 },
  { 1105, 17, 33, 19, 2, -33 },
  { 1176, 17, 33, 19, 3, -33 },
  { 1247, 19, 33, 19, 0, -33 },
  { 1326, 18, 33, 19, 0, -33 },
  { 1401, 7, 24, 8, 0, -24 },
  { 1422, 10, 30, 8, -2, -24 },
  { 1460, 17, 19, 21, 2, -26 },
  { 1501, 17, 11, 21, 2, -22 },
  { 1525, 17, 19, 21, 2, -26 },
  { 1566, 13, 33, 13, 2, -33 },
  { 1620, 25, 37, 28, 2, -33 },
  { 1736, 18, 33, 18, -3, -33 },
  { 1811, 19, 33, 20, 1, -33 },
  { 1890, 20, 33, 19, 2, -33 },
  { 1973, 20, 33, 23, 1, -33 },
  { 2056, 19, 33, 18, 1, -33 },
  { 2135, 19, 33, 17, 1, -33 },
  { 2214, 22, 33, 24, 2, -33 },
  { 2305, 23, 33, 24, 1, -33 },
  { 2400, 14, 33, 9, -2, -33 },
  { 2458, 16, 41, 8, -7, -33 },
  { 2540, 21, 33, 19, 1, -33 },
  { 2627, 12, 33, 17, 1, -33 },
  { 2677, 29, 33, 30, 1, -33 },
  { 2797, 24, 33, 24, 1, -33 },
  { 2896, 21, 33, 24, 2, -33 },
  { 2983, 19, 33, 19, 1, -33 },
  { 3062, 21, 41, 24, 2, -33 },
  { 3170, 18, 33, 19, 1, -33 },
  { 3245, 20, 33, 18, -1, -33 },
  { 3328, 16, 33, 16, 4, -33 },
  { 3394, 22, 33, 23, 2, -33 },
  { 3485, 18, 33, 18, 4, -33 },
  { 3560, 30, 33, 31, 4, -33 },
  { 3684, 23, 33, 17, -3, -33 },
  { 3779, 16, 33, 16, 4, -33 },
  { 3845, 21, 33, 17, -1, -33 },
  { 3932, 17, 40, 13, -1, -33 },
  { 4017, 6, 33, 14, 5, -33 },
  { 4042, 17, 40, 13, -3, -33 },
  { 4127, 18, 17, 20, 1, -33 },
  { 4166, 14, 2, 14, -4, 4 },
  { 4170, 4, 7, 10, 7, -35 },
  { 4174, 17, 25, 20, 2, -25 },
  { 4228, 17, 35, 20, 1, -35 },
  { 4303, 14, 25, 15, 2, -25 },
  { 4347, 19, 35, 20, 2, -35 },
  { 4431, 14, 25, 17, 2, -25 },
  { 4475, 21, 46, 10, -6, -35 },
  { 4596, 19, 36, 20, 0, -25 },
  { 4682, 16, 35, 19, 1, -35 },
  { 4752, 8, 33, 8, 1, -33 },
  { 4785, 15, 44, 8, -6, -33 },
  { 4868, 16, 35, 16, 1, -35 },
  { 4938, 8, 35, 8, 1, -35 },
  { 4973, 26, 25, 29, 1, -25 },
  { 5055, 16, 25, 19, 1, -25 },
  { 5105, 16, 25, 19, 2, -25 },
  { 5155, 20, 36, 20, -2, -25 },
  { 5245, 17, 36, 20, 2, -25 },
  { 5322, 13, 25, 13, 1, -25 },
  { 5363, 15, 25, 15, 0, -25 },
  { 5410, 10, 30, 10, 1, -30 },
  { 5448, 16, 24, 19, 2, -24 },
  { 5496, 14, 24, 14, 3, -24 },
  { 5538, 23, 24, 24, 3, -24 },
  { 5607, 19, 24, 15, -2, -24 },
  { 5664, 22, 35, 15, -5, -24 },
  { 5761, 15, 24, 13, -1, -24 },
  { 5806, 16, 40, 14, 1, -33 },
  { 5886, 1, 46, 18, 9, -35 },
  { 5892, 16, 40, 14, -3, -33 },
  { 5972, 17, 4, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_THINITALIC46PT7B_H_
