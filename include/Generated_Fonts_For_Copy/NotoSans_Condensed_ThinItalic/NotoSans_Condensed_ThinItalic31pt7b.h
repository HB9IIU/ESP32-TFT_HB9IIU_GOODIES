#ifndef _NOTOSANS_CONDENSED_THINITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x40, 0x00, 0x00, 0x82, 0x00, 0x65, 0x14, 0x51, 0x4A, 0x28, 0xA2,
  0x01, 0x88, 0x04, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10, 0x08, 0x41, 0xFF,
  0xC1, 0x08, 0x04, 0x20, 0x10, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x22,
  0x0F, 0xFF, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x42,
  0x01, 0x08, 0x00, 0x00, 0x40, 0x02, 0x00, 0x20, 0x07, 0xE0, 0xC8, 0x84,
  0x40, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x02, 0x40, 0x1C, 0x00, 0x20,
  0x01, 0x80, 0x0A, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x48, 0x64, 0xC0, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x80, 0x00, 0x1E, 0x04,
  0x44, 0x11, 0x08, 0x22, 0x10, 0x84, 0x21, 0x10, 0x44, 0x20, 0x90, 0x41,
  0x20, 0x84, 0x89, 0x09, 0x2E, 0x14, 0x8C, 0x4A, 0x1D, 0x24, 0x24, 0x90,
  0x41, 0x20, 0x84, 0x41, 0x08, 0x84, 0x21, 0x08, 0x42, 0x11, 0x04, 0x42,
  0x08, 0x88, 0x1E, 0x00, 0x03, 0xC0, 0x21, 0x01, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x21, 0x00, 0x90, 0x05, 0x00, 0x30, 0x01, 0x80, 0x34, 0x03,
  0x20, 0x90, 0x89, 0x04, 0x48, 0x14, 0x80, 0xA4, 0x06, 0x20, 0x11, 0x01,
  0x84, 0x12, 0x3F, 0x10, 0x69, 0x25, 0x24, 0x01, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x80, 0x08, 0x04, 0x32, 0x05, 0x31, 0xE0, 0xC1, 0x91, 0x08, 0x02, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x32, 0x24, 0x48,
  0x80, 0xFE, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x07, 0xC1, 0x04, 0x20, 0x88, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90,
  0x12, 0x04, 0x40, 0x84, 0x20, 0xF8, 0x00, 0x0C, 0x56, 0xA2, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x00,
  0x03, 0xF0, 0x20, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xE0,
  0x07, 0xE0, 0x81, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x0C, 0x0F, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x0F, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0x50, 0x09, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x22, 0x04, 0x40, 0x84,
  0x08, 0x41, 0x04, 0x20, 0x44, 0x08, 0x40, 0x88, 0x09, 0xFF, 0xE0, 0x08,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x07, 0xF8, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0xF8, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x08, 0x10, 0x7F, 0x00, 0x03, 0xF0, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x46, 0x05, 0x98, 0x60, 0x44, 0x04,
  0xC0, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08,
  0x41, 0x03, 0xE0, 0x7F, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x00, 0x07, 0xE0,
  0x40, 0x82, 0x02, 0x20, 0x11, 0x00, 0x88, 0x08, 0x40, 0x41, 0x04, 0x08,
  0x40, 0x24, 0x01, 0xC0, 0x12, 0x03, 0x08, 0x20, 0x21, 0x01, 0x10, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x84, 0x08, 0x1F, 0x80, 0x07, 0xE0,
  0x82, 0x08, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x31, 0x06, 0x1F, 0xA0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x18, 0x04, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x82, 0x08, 0x41, 0x08, 0x20, 0x00, 0x10, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x08, 0x00, 0x3F, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x41, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x04, 0x81, 0xC2, 0x41, 0x11, 0x41, 0x10, 0xA1, 0x08,
  0x51, 0x04, 0x28, 0x82, 0x18, 0x42, 0x14, 0x21, 0x0A, 0x20, 0x85, 0x10,
  0xC4, 0x84, 0x62, 0x42, 0x5A, 0x20, 0xC6, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x09, 0x00, 0x90, 0x09, 0x01, 0x10, 0x11, 0x02, 0x10, 0x21,
  0x04, 0x10, 0x41, 0x0F, 0xF0, 0x81, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x18, 0x01, 0x0F, 0xE0, 0x40, 0x82, 0x04, 0x20,
  0x11, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02, 0x20, 0x21, 0x06, 0x0F, 0xC0,
  0x41, 0x84, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x02, 0x20,
  0x11, 0x01, 0x08, 0x10, 0x7F, 0x00, 0x03, 0xF8, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x41, 0x82, 0x04, 0x20,
  0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x24, 0x01, 0x20,
  0x11, 0x01, 0x08, 0x30, 0x7E, 0x00, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xF8,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x3F, 0xC2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x00, 0x03, 0xFC, 0x10, 0x10, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x3E, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x88, 0x02, 0x30, 0x08, 0x40, 0x20, 0xFF, 0x00, 0x04, 0x01, 0x04,
  0x01, 0x04, 0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10,
  0x02, 0x10, 0x04, 0x10, 0x04, 0x1F, 0xFC, 0x10, 0x04, 0x20, 0x04, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x10, 0xC0, 0x10, 0x0F, 0x81, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x07, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x03, 0xE0, 0x00, 0x04, 0x06, 0x08, 0x18,
  0x10, 0x20, 0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x20, 0x08, 0x80, 0x13,
  0x00, 0x2C, 0x00, 0x58, 0x00, 0xD0, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x10, 0x40, 0x20, 0x80, 0x81, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x18,
  0x0C, 0x00, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x07, 0xFC, 0x04, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x30, 0xA0,
  0x05, 0x0A, 0x00, 0x50, 0xA0, 0x0A, 0x0A, 0x00, 0xA1, 0x20, 0x12, 0x12,
  0x01, 0x21, 0x20, 0x22, 0x12, 0x02, 0x41, 0x10, 0x44, 0x21, 0x04, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x82, 0x11, 0x08, 0x21, 0x10, 0x84, 0x12, 0x08,
  0x41, 0x20, 0x84, 0x14, 0x10, 0x41, 0x41, 0x0C, 0x08, 0x10, 0x04, 0x01,
  0x83, 0x00, 0x81, 0x80, 0x41, 0x40, 0x20, 0xA0, 0x10, 0x48, 0x10, 0x24,
  0x08, 0x22, 0x04, 0x11, 0x02, 0x08, 0x41, 0x04, 0x21, 0x02, 0x10, 0x82,
  0x08, 0x41, 0x02, 0x20, 0x81, 0x20, 0x40, 0x90, 0x20, 0x48, 0x20, 0x14,
  0x10, 0x0A, 0x08, 0x06, 0x04, 0x01, 0x06, 0x00, 0x80, 0x07, 0xF0, 0x20,
  0x41, 0x00, 0x84, 0x02, 0x20, 0x09, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x22, 0x00, 0x88, 0x04, 0x20, 0x10, 0x40, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x82, 0x08, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x20, 0x22, 0x02, 0x20, 0x42, 0x38, 0x3C, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xF0, 0x20,
  0x41, 0x00, 0x84, 0x02, 0x20, 0x09, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x22, 0x00, 0x88, 0x04, 0x20, 0x10, 0x40, 0x80, 0xFC, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x82,
  0x08, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x22, 0x02,
  0x20, 0xC3, 0xF0, 0x42, 0x04, 0x20, 0x41, 0x04, 0x10, 0x41, 0x08, 0x10,
  0x81, 0x08, 0x08, 0x80, 0x88, 0x08, 0x07, 0xF8, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x7F, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x08, 0x02,
  0x10, 0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x10,
  0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x80, 0x21, 0x00, 0x42, 0x00, 0x82, 0x02, 0x04,
  0x08, 0x07, 0xE0, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x08, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x08,
  0x40, 0x88, 0x08, 0x80, 0x90, 0x09, 0x00, 0xA0, 0x0A, 0x00, 0xC0, 0x04,
  0x00, 0x80, 0x40, 0x18, 0x04, 0x02, 0x80, 0xC0, 0x28, 0x0C, 0x04, 0x80,
  0xC0, 0x48, 0x14, 0x04, 0x81, 0x40, 0x88, 0x24, 0x08, 0x82, 0x41, 0x08,
  0x44, 0x10, 0x84, 0x42, 0x08, 0x44, 0x20, 0x88, 0x42, 0x08, 0x84, 0x40,
  0x90, 0x44, 0x09, 0x04, 0x80, 0xA0, 0x48, 0x0A, 0x04, 0x80, 0xA0, 0x50,
  0x0C, 0x05, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x01, 0x10,
  0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x81, 0x01, 0x02, 0x04, 0x02, 0x10,
  0x04, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x04, 0x81, 0x20, 0x84, 0x21, 0x10,
  0x48, 0x12, 0x05, 0x01, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xE0, 0x00, 0x88,
  0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x22, 0x11, 0x11, 0x11, 0x03, 0xE0,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xE0, 0x00,
  0x03, 0x00, 0x30, 0x04, 0x80, 0x48, 0x08, 0x81, 0x04, 0x10, 0x42, 0x02,
  0x20, 0x24, 0x02, 0x80, 0x10, 0xFF, 0x80, 0x92, 0x26, 0x03, 0x00, 0xCD,
  0x10, 0x52, 0x02, 0x20, 0x24, 0x02, 0x40, 0x24, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x81, 0x84, 0x28, 0x7C, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9C, 0x0A,
  0x21, 0x41, 0x18, 0x11, 0x81, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x24, 0x02, 0x40, 0x46, 0x04, 0x60, 0x89, 0xF0, 0x03,
  0x83, 0x11, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x3E, 0x00, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x62, 0x0C, 0xD0,
  0x82, 0x88, 0x08, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00, 0x90, 0x08, 0x80,
  0x44, 0x02, 0x20, 0x31, 0x01, 0x08, 0x08, 0x40, 0xC1, 0x0A, 0x0F, 0x90,
  0x03, 0x03, 0x21, 0x04, 0x81, 0x20, 0x50, 0x14, 0x09, 0x0C, 0xFC, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x1C,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x24,
  0x03, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x33, 0x42, 0x0A, 0x20, 0x21,
  0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0xC4, 0x04, 0x20, 0x61, 0x03, 0x04, 0x28, 0x3E, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x1F, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x98, 0x0A, 0x21, 0x41, 0x18,
  0x11, 0x01, 0x10, 0x11, 0x02, 0x20, 0x22, 0x02, 0x20, 0x22, 0x04, 0x20,
  0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x88, 0x08, 0x04, 0x10, 0x00, 0x00,
  0x00, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0xE0, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x81, 0x08, 0x21, 0x04, 0x10, 0x81, 0x10, 0x11, 0x01, 0x20, 0x24,
  0x02, 0xC0, 0x32, 0x02, 0x20, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x08, 0x08, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x00, 0x81, 0x83, 0x9B,
  0x11, 0x42, 0x84, 0x60, 0xC1, 0x10, 0x20, 0x44, 0x08, 0x11, 0x02, 0x04,
  0x80, 0x81, 0x20, 0x40, 0x48, 0x10, 0x22, 0x04, 0x08, 0x81, 0x02, 0x40,
  0x40, 0x90, 0x20, 0x24, 0x08, 0x11, 0x02, 0x04, 0x80, 0x81, 0x00, 0x01,
  0x80, 0xA2, 0x14, 0x11, 0x81, 0x10, 0x11, 0x02, 0x10, 0x22, 0x02, 0x20,
  0x22, 0x02, 0x20, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x08, 0x80,
  0x80, 0x03, 0x01, 0x98, 0x41, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E,
  0x00, 0x00, 0xE0, 0x28, 0x82, 0x82, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x22, 0x01, 0x10, 0x10,
  0xC0, 0x86, 0x08, 0x4F, 0x82, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x03, 0x00, 0xCD, 0x10, 0x52, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88,
  0x08, 0x81, 0x84, 0x28, 0x7C, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x01, 0xC2, 0x81, 0x40, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x00, 0x06, 0x06, 0x32, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0xFC, 0x00,
  0x10, 0x41, 0x04, 0x6C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x3C, 0x30, 0x24, 0x04, 0x80, 0x90, 0x12, 0x04, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x12, 0x02, 0x40, 0x48, 0x19, 0x02, 0x20, 0xC3,
  0xE8, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x08, 0x88, 0x44,
  0x24, 0x12, 0x0A, 0x05, 0x03, 0x00, 0x80, 0x81, 0x03, 0x02, 0x06, 0x0C,
  0x14, 0x18, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x42, 0x44, 0x88, 0x91, 0x11,
  0x22, 0x42, 0x84, 0x85, 0x0A, 0x0A, 0x14, 0x18, 0x28, 0x30, 0x20, 0x40,
  0x40, 0x08, 0x10, 0x82, 0x08, 0x40, 0x84, 0x04, 0x80, 0x50, 0x05, 0x00,
  0x20, 0x06, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x21, 0x04, 0x10, 0x40, 0x88,
  0x08, 0x02, 0x03, 0x02, 0x02, 0x02, 0x04, 0x02, 0x04, 0x02, 0x08, 0x02,
  0x08, 0x02, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x90, 0x00, 0x60,
  0x00, 0x0F, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x07, 0xF8, 0x01,
  0xE0, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x03, 0x01, 0x80, 0x08, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x10, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0xC0, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x03, 0x80, 0x00, 0x7C, 0x18, 0x3E,
};

const GFXglyph NotoSans_Condensed_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 22, 6, 1, -22 },
  { 18, 6, 8, 8, 3, -22 },
  { 24, 14, 22, 14, 0, -22 },
  { 63, 13, 26, 13, 0, -24 },
  { 106, 15, 22, 18, 2, -22 },
  { 148, 13, 22, 13, 0, -22 },
  { 184, 3, 8, 5, 3, -22 },
  { 187, 8, 27, 7, 1, -22 },
  { 214, 8, 27, 8, -2, -22 },
  { 241, 9, 9, 12, 4, -23 },
  { 252, 12, 14, 14, 1, -18 },
  { 273, 4, 7, 5, -1, -3 },
  { 277, 7, 1, 9, 1, -9 },
  { 278, 1, 2, 5, 1, -2 },
  { 279, 12, 22, 9, -1, -22 },
  { 312, 11, 22, 13, 1, -22 },
  { 343, 6, 22, 13, 4, -22 },
  { 360, 13, 22, 13, -1, -22 },
  { 396, 12, 22, 13, 0, -22 },
  { 429, 12, 22, 13, 0, -22 },
  { 462, 13, 22, 13, 0, -22 },
  { 498, 12, 22, 13, 1, -22 },
  { 531, 11, 22, 13, 2, -22 },
  { 562, 13, 22, 13, 0, -22 },
  { 598, 12, 22, 13, 0, -22 },
  { 631, 5, 16, 5, 0, -16 },
  { 641, 6, 20, 5, -1, -16 },
  { 656, 12, 14, 14, 1, -18 },
  { 677, 12, 8, 14, 1, -15 },
  { 689, 12, 14, 14, 1, -18 },
  { 710, 9, 22, 9, 1, -22 },
  { 735, 17, 25, 19, 1, -22 },
  { 789, 12, 22, 12, -2, -22 },
  { 822, 13, 22, 14, 1, -22 },
  { 858, 13, 22, 13, 2, -22 },
  { 894, 13, 22, 15, 1, -22 },
  { 930, 13, 22, 12, 0, -22 },
  { 966, 13, 22, 11, 0, -22 },
  { 1002, 14, 22, 16, 2, -22 },
  { 1041, 16, 22, 16, 0, -22 },
  { 1085, 9, 22, 6, -1, -22 },
  { 1110, 11, 27, 5, -5, -22 },
  { 1148, 15, 22, 13, 0, -22 },
  { 1190, 9, 22, 11, 0, -22 },
  { 1215, 20, 22, 20, 0, -22 },
  { 1270, 17, 22, 16, 0, -22 },
  { 1317, 14, 22, 16, 2, -22 },
  { 1356, 12, 22, 13, 1, -22 },
  { 1389, 14, 27, 16, 2, -22 },
  { 1437, 12, 22, 13, 1, -22 },
  { 1470, 13, 22, 12, 0, -22 },
  { 1506, 10, 22, 11, 3, -22 },
  { 1534, 15, 22, 16, 1, -22 },
  { 1576, 12, 22, 12, 3, -22 },
  { 1609, 20, 22, 21, 3, -22 },
  { 1664, 15, 22, 11, -2, -22 },
  { 1706, 10, 22, 11, 3, -22 },
  { 1734, 14, 22, 12, -1, -22 },
  { 1773, 11, 27, 9, 0, -22 },
  { 1811, 4, 22, 10, 3, -22 },
  { 1822, 11, 27, 9, -2, -22 },
  { 1860, 12, 11, 14, 1, -22 },
  { 1877, 9, 1, 9, -2, 3 },
  { 1879, 3, 5, 7, 5, -24 },
  { 1881, 12, 17, 13, 1, -17 },
  { 1907, 12, 24, 13, 0, -24 },
  { 1943, 10, 17, 10, 1, -17 },
  { 1965, 13, 24, 14, 1, -24 },
  { 2004, 10, 17, 12, 1, -17 },
  { 2026, 14, 31, 6, -4, -24 },
  { 2081, 13, 24, 13, 0, -17 },
  { 2120, 12, 24, 13, 0, -24 },
  { 2156, 6, 22, 5, 0, -22 },
  { 2173, 10, 29, 5, -4, -22 },
  { 2210, 12, 24, 11, 0, -24 },
  { 2246, 6, 24, 5, 0, -24 },
  { 2264, 18, 17, 20, 0, -17 },
  { 2303, 12, 17, 13, 0, -17 },
  { 2329, 11, 17, 13, 1, -17 },
  { 2353, 13, 24, 13, -1, -17 },
  { 2392, 12, 24, 14, 1, -17 },
  { 2428, 10, 17, 9, 0, -17 },
  { 2450, 10, 17, 10, 0, -17 },
  { 2472, 6, 20, 7, 1, -20 },
  { 2487, 11, 16, 13, 1, -16 },
  { 2509, 9, 16, 10, 2, -16 },
  { 2527, 15, 16, 16, 2, -16 },
  { 2557, 12, 16, 10, -1, -16 },
  { 2581, 16, 24, 10, -4, -16 },
  { 2629, 11, 16, 9, -1, -16 },
  { 2651, 11, 27, 10, 1, -22 },
  { 2689, 1, 32, 12, 6, -24 },
  { 2693, 11, 27, 10, -2, -22 },
  { 2731, 12, 2, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_THINITALIC31PT7B_H_
