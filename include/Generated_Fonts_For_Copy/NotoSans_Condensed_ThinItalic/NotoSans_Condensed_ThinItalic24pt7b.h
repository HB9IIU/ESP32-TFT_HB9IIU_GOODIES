#ifndef _NOTOSANS_CONDENSED_THINITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x00, 0x08, 0xC0,
  0x4A, 0x52, 0x99, 0x48, 0x02, 0x40, 0x88, 0x11, 0x02, 0x40, 0x88, 0x7F,
  0xC2, 0x20, 0x88, 0x11, 0x02, 0x20, 0x48, 0x77, 0xC2, 0x20, 0x48, 0x11,
  0x02, 0x20, 0x48, 0x00, 0x01, 0x00, 0x80, 0xFC, 0x48, 0x22, 0x09, 0x02,
  0x40, 0x50, 0x0C, 0x01, 0x00, 0xA0, 0x24, 0x09, 0x02, 0x40, 0x90, 0x48,
  0x7C, 0x04, 0x01, 0x00, 0x3C, 0x22, 0x42, 0x44, 0x44, 0x44, 0x44, 0x88,
  0x50, 0x85, 0x28, 0xAD, 0x8A, 0x95, 0x51, 0x25, 0x10, 0x91, 0x11, 0x11,
  0x21, 0x22, 0x22, 0x22, 0x41, 0xC0, 0x07, 0x02, 0x21, 0x08, 0x44, 0x11,
  0x04, 0x80, 0xA0, 0x30, 0x18, 0x09, 0x04, 0x45, 0x0A, 0x82, 0xA0, 0x48,
  0x12, 0x0C, 0x7C, 0x80, 0x55, 0xA0, 0x04, 0x21, 0x04, 0x21, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x20, 0x82, 0x08, 0x00, 0x10, 0x23, 0x41, 0xF3, 0x09, 0x22, 0x00,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x25, 0x28, 0xF8, 0x70, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x00, 0x0F, 0x08, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x05, 0x02,
  0x81, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x12, 0x11, 0x10, 0x70, 0x00, 0x19,
  0xB4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x0F, 0xC0,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x1E, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0xFC, 0x00, 0x00, 0xC0, 0x60, 0x28, 0x0A, 0x04,
  0x82, 0x40, 0x90, 0x44, 0x21, 0x08, 0x44, 0x22, 0x08, 0xFF, 0x80, 0x80,
  0x20, 0x10, 0x04, 0x00, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0xF8, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0xFC, 0x00, 0x0F, 0x88, 0x04, 0x04, 0x04, 0x02, 0x01, 0x31, 0x64, 0xC1,
  0x40, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08, 0x78, 0x00, 0x7F, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x80, 0xC0, 0x00, 0x0F, 0x84, 0x11, 0x04, 0x81, 0x20,
  0x44, 0x21, 0x10, 0x28, 0x1C, 0x08, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48,
  0x11, 0x08, 0x7C, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x12, 0x09, 0x05, 0x02,
  0x81, 0x21, 0x8B, 0x42, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0xF8, 0x00,
  0x11, 0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x08, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x44, 0x21, 0x10, 0x00, 0x80, 0x81, 0x83, 0x06, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x20,
  0x00, 0x7C, 0x04, 0x08, 0x10, 0x20, 0x82, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x00, 0x00, 0x40, 0x80, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x12, 0x00,
  0xA1, 0xE5, 0x11, 0x31, 0x11, 0x88, 0x8C, 0x84, 0x64, 0x25, 0x22, 0x29,
  0x12, 0x47, 0x72, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x0F, 0x80, 0x00,
  0x80, 0x60, 0x18, 0x05, 0x02, 0x40, 0x90, 0x44, 0x11, 0x08, 0x43, 0xF1,
  0x04, 0x41, 0x20, 0x48, 0x14, 0x05, 0x01, 0xC0, 0x40, 0x0F, 0x81, 0x08,
  0x40, 0x88, 0x11, 0x02, 0x20, 0x88, 0x21, 0xE8, 0x23, 0x04, 0x10, 0x82,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x08, 0xFE, 0x00, 0x07, 0xE1, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0x08,
  0x40, 0x88, 0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81,
  0x20, 0x24, 0x04, 0x81, 0x10, 0x42, 0x10, 0xFC, 0x00, 0x0F, 0xC4, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0xFC, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xFE, 0x00, 0x0F, 0xC4, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x3F, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x81, 0x88, 0x24, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x08, 0x40, 0x84, 0x08, 0x3F, 0x80, 0x08, 0x08, 0x80, 0x84, 0x04,
  0x20, 0x21, 0x01, 0x08, 0x10, 0x80, 0x87, 0xFC, 0x20, 0x21, 0x01, 0x08,
  0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x10, 0x80, 0x80, 0x0E,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0xF0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02,
  0x0F, 0x00, 0x08, 0x31, 0x04, 0x10, 0x81, 0x10, 0x11, 0x01, 0x20, 0x24,
  0x02, 0x80, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x41,
  0x04, 0x10, 0x81, 0x00, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0xFE, 0x08, 0x01, 0x08, 0x03, 0x18,
  0x06, 0x18, 0x06, 0x14, 0x0A, 0x14, 0x0A, 0x24, 0x12, 0x24, 0x14, 0x24,
  0x24, 0x24, 0x24, 0x24, 0x44, 0x44, 0x44, 0x44, 0x88, 0x44, 0x88, 0x45,
  0x08, 0x42, 0x08, 0x82, 0x08, 0x08, 0x08, 0xC0, 0x45, 0x04, 0x28, 0x21,
  0x41, 0x0A, 0x08, 0x88, 0x44, 0x44, 0x22, 0x21, 0x11, 0x08, 0x48, 0x82,
  0x84, 0x14, 0x20, 0xA1, 0x03, 0x08, 0x10, 0x80, 0x80, 0x0F, 0xC2, 0x04,
  0x40, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0x0F, 0x82, 0x11,
  0x04, 0x41, 0x10, 0x44, 0x12, 0x04, 0x82, 0x21, 0x0E, 0x82, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0xC2, 0x04, 0x40, 0x90,
  0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28,
  0x05, 0x01, 0x20, 0x22, 0x08, 0x34, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x0F, 0x82, 0x11, 0x04, 0x41, 0x10, 0x44, 0x12, 0x04, 0x82, 0x23, 0x0F,
  0x02, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x04, 0x81, 0x00, 0x0F, 0xC4,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0xFC, 0x00, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x10, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x0A, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x10, 0x7C,
  0x00, 0x80, 0xE0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x84,
  0x22, 0x08, 0x82, 0x40, 0x90, 0x28, 0x06, 0x01, 0x00, 0x40, 0x00, 0x81,
  0x01, 0x81, 0x02, 0x82, 0x82, 0x82, 0x84, 0x82, 0x84, 0x84, 0x88, 0x84,
  0x88, 0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0x90, 0xA0, 0xA0,
  0xA0, 0xA1, 0x40, 0xC1, 0x40, 0xC1, 0x80, 0x80, 0x80, 0x08, 0x21, 0x08,
  0x21, 0x04, 0x40, 0x48, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x01, 0x40, 0x28,
  0x09, 0x02, 0x20, 0x44, 0x10, 0x44, 0x08, 0x81, 0x00, 0x81, 0x81, 0x82,
  0x84, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x0F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0xFF, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x88,
  0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x10, 0x07, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x0F, 0x80, 0x04, 0x06, 0x04, 0x82,
  0x42, 0x11, 0x09, 0x05, 0x01, 0x80, 0x80, 0xFE, 0xC8, 0x80, 0x1E, 0x90,
  0xC8, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0xC7,
  0xA0, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x05, 0xC1, 0x88, 0x41, 0x20,
  0x48, 0x12, 0x04, 0x82, 0x40, 0x90, 0x24, 0x09, 0x04, 0xC2, 0x2F, 0x00,
  0x0E, 0x60, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x83, 0xA3, 0x18, 0x86, 0x41, 0x10,
  0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x18, 0x86, 0x1E, 0x80, 0x0E,
  0x32, 0x21, 0x41, 0x42, 0x84, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C,
  0x00, 0xE0, 0x20, 0x04, 0x01, 0x00, 0x20, 0x1F, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x06, 0x00, 0x07, 0x46, 0x31,
  0x0C, 0x82, 0x20, 0x90, 0x24, 0x09, 0x02, 0x41, 0x10, 0x44, 0x31, 0x0C,
  0x3D, 0x00, 0x80, 0x20, 0x08, 0x04, 0x21, 0x07, 0x80, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0xB8, 0x62, 0x21, 0x20, 0x90, 0x48, 0x24, 0x14, 0x12,
  0x09, 0x04, 0x82, 0x82, 0x41, 0x00, 0x08, 0x00, 0x01, 0x08, 0x84, 0x21,
  0x08, 0x84, 0x21, 0x10, 0x80, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x84, 0x44,
  0x44, 0x24, 0x12, 0x0A, 0x0B, 0x06, 0x82, 0x21, 0x10, 0x88, 0x84, 0x41,
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84,
  0x00, 0x17, 0x38, 0x63, 0x11, 0x08, 0x48, 0x21, 0x20, 0x84, 0x84, 0x12,
  0x10, 0x50, 0x41, 0x41, 0x09, 0x08, 0x24, 0x20, 0xA0, 0x82, 0x82, 0x10,
  0x17, 0x0C, 0x44, 0x24, 0x12, 0x09, 0x04, 0x82, 0x82, 0x41, 0x20, 0x90,
  0x50, 0x48, 0x20, 0x1E, 0x21, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x84, 0x78, 0x0B, 0x81, 0x88, 0x20, 0x88, 0x11, 0x02, 0x20,
  0x44, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x30, 0x85, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1E, 0x90, 0xC8, 0x68, 0x24,
  0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0xC7, 0xA0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x00, 0x16, 0x30, 0x41, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x00, 0x1F, 0x20, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x04, 0x04, 0xF8, 0x21, 0x09, 0xF4, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x42, 0x1C, 0x20, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x09,
  0x04, 0x82, 0x41, 0x21, 0x11, 0x8F, 0x40, 0x81, 0x82, 0x82, 0x84, 0x84,
  0x88, 0x88, 0x90, 0x50, 0x60, 0x60, 0x40, 0x40, 0x82, 0x18, 0x21, 0x86,
  0x18, 0x62, 0x8A, 0x28, 0xA4, 0x92, 0x49, 0x24, 0xA2, 0x8A, 0x28, 0xA3,
  0x04, 0x30, 0x42, 0x00, 0x10, 0x44, 0x21, 0x10, 0x24, 0x0A, 0x03, 0x00,
  0x80, 0x30, 0x14, 0x09, 0x02, 0x21, 0x08, 0x82, 0x00, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x05, 0x00, 0x50,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x0F, 0xC0, 0x07, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x0C, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x07, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x20, 0xC0, 0x70, 0x46, 0x40, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 17, 5, 0, -17 },
  { 12, 5, 6, 7, 2, -17 },
  { 16, 11, 17, 11, 0, -17 },
  { 40, 10, 19, 10, 0, -18 },
  { 64, 12, 17, 14, 1, -17 },
  { 90, 10, 17, 10, 0, -17 },
  { 112, 2, 6, 4, 2, -17 },
  { 114, 6, 21, 6, 1, -17 },
  { 130, 7, 21, 6, -2, -17 },
  { 149, 7, 7, 9, 3, -18 },
  { 156, 9, 11, 11, 1, -14 },
  { 169, 3, 5, 4, -1, -2 },
  { 171, 5, 1, 7, 1, -7 },
  { 172, 2, 2, 4, 0, -2 },
  { 173, 10, 17, 7, -1, -17 },
  { 195, 9, 17, 10, 1, -17 },
  { 215, 5, 17, 10, 3, -17 },
  { 226, 10, 17, 10, -1, -17 },
  { 248, 10, 17, 10, 0, -17 },
  { 270, 10, 17, 10, 0, -17 },
  { 292, 10, 17, 10, 0, -17 },
  { 314, 9, 17, 10, 1, -17 },
  { 334, 9, 17, 10, 1, -17 },
  { 354, 10, 17, 10, 0, -17 },
  { 376, 9, 17, 10, 0, -17 },
  { 396, 4, 13, 4, 0, -13 },
  { 403, 5, 16, 4, -1, -13 },
  { 413, 9, 11, 11, 1, -14 },
  { 426, 9, 5, 11, 1, -11 },
  { 432, 9, 11, 11, 1, -14 },
  { 445, 7, 17, 7, 1, -17 },
  { 460, 13, 19, 15, 1, -17 },
  { 491, 10, 17, 9, -2, -17 },
  { 513, 11, 17, 11, 0, -17 },
  { 537, 11, 17, 10, 1, -17 },
  { 561, 11, 17, 12, 0, -17 },
  { 585, 10, 17, 10, 0, -17 },
  { 607, 10, 17, 9, 0, -17 },
  { 629, 12, 17, 13, 1, -17 },
  { 655, 13, 17, 12, 0, -17 },
  { 683, 7, 17, 5, -1, -17 },
  { 698, 9, 21, 4, -4, -17 },
  { 722, 12, 17, 10, 0, -17 },
  { 748, 7, 17, 9, 0, -17 },
  { 763, 16, 17, 16, 0, -17 },
  { 797, 13, 17, 13, 0, -17 },
  { 825, 11, 17, 13, 1, -17 },
  { 849, 10, 17, 10, 0, -17 },
  { 871, 11, 21, 13, 1, -17 },
  { 900, 10, 17, 10, 0, -17 },
  { 922, 10, 17, 9, 0, -17 },
  { 944, 8, 17, 8, 2, -17 },
  { 961, 11, 17, 12, 1, -17 },
  { 985, 10, 17, 10, 2, -17 },
  { 1007, 16, 17, 16, 2, -17 },
  { 1041, 11, 17, 9, -1, -17 },
  { 1065, 8, 17, 8, 2, -17 },
  { 1082, 11, 17, 9, -1, -17 },
  { 1106, 8, 21, 7, 0, -17 },
  { 1127, 4, 17, 8, 2, -17 },
  { 1136, 9, 21, 7, -2, -17 },
  { 1160, 9, 9, 11, 1, -17 },
  { 1171, 7, 1, 7, -2, 2 },
  { 1172, 3, 3, 5, 3, -18 },
  { 1174, 9, 13, 10, 1, -13 },
  { 1189, 10, 18, 10, 0, -18 },
  { 1212, 7, 13, 8, 1, -13 },
  { 1224, 10, 18, 10, 1, -18 },
  { 1247, 8, 13, 9, 1, -13 },
  { 1260, 11, 24, 5, -3, -18 },
  { 1293, 10, 19, 10, 0, -13 },
  { 1317, 9, 18, 10, 0, -18 },
  { 1338, 5, 17, 4, 0, -17 },
  { 1349, 8, 23, 4, -3, -17 },
  { 1372, 9, 18, 8, 0, -18 },
  { 1393, 5, 18, 4, 0, -18 },
  { 1405, 14, 13, 15, 0, -13 },
  { 1428, 9, 13, 10, 0, -13 },
  { 1443, 8, 13, 10, 1, -13 },
  { 1456, 11, 19, 10, -1, -13 },
  { 1483, 9, 19, 10, 1, -13 },
  { 1505, 7, 13, 7, 0, -13 },
  { 1517, 8, 13, 8, 0, -13 },
  { 1530, 5, 16, 5, 1, -16 },
  { 1540, 9, 13, 10, 1, -13 },
  { 1555, 8, 13, 8, 1, -13 },
  { 1568, 12, 13, 12, 1, -13 },
  { 1588, 10, 13, 8, -1, -13 },
  { 1605, 12, 19, 8, -3, -13 },
  { 1634, 9, 13, 7, -1, -13 },
  { 1649, 8, 21, 8, 1, -17 },
  { 1670, 1, 24, 10, 4, -18 },
  { 1673, 8, 21, 8, -1, -17 },
  { 1694, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_THINITALIC24PT7B_H_
