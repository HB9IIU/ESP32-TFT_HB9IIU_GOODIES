#ifndef _NOTOSANS_CONDENSED_THINITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x41, 0x00, 0x00, 0x00, 0x08, 0x20, 0x22, 0x45, 0x0A, 0x24, 0x48,
  0x91, 0x42, 0x88, 0x00, 0x86, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10,
  0x80, 0x21, 0x00, 0x82, 0x0F, 0xFF, 0x02, 0x10, 0x08, 0x20, 0x10, 0x80,
  0x21, 0x00, 0x42, 0x01, 0x04, 0x02, 0x10, 0x7F, 0xFC, 0x10, 0x40, 0x21,
  0x00, 0x42, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x21, 0x80,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x7E, 0x06, 0x44, 0x21, 0x00, 0x88,
  0x04, 0x20, 0x10, 0x80, 0x42, 0x00, 0x90, 0x02, 0x40, 0x05, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x90, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x04,
  0x20, 0x10, 0x80, 0x44, 0x39, 0x60, 0x0E, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x01, 0x0D, 0x01, 0x08, 0x40, 0x84, 0x20, 0x84, 0x10, 0x42,
  0x08, 0x41, 0x04, 0x41, 0x02, 0x20, 0x82, 0x20, 0x41, 0x10, 0x20, 0x91,
  0x90, 0x49, 0x28, 0x49, 0x0C, 0x29, 0x07, 0x64, 0x82, 0x44, 0x41, 0x02,
  0x41, 0x02, 0x20, 0x81, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x82, 0x10,
  0x81, 0x08, 0x40, 0x88, 0x40, 0x78, 0x00, 0x00, 0xC0, 0x04, 0x80, 0x21,
  0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01, 0x08, 0x04, 0x60, 0x11,
  0x00, 0x48, 0x00, 0xC0, 0x06, 0x00, 0x24, 0x01, 0x10, 0x48, 0x42, 0x40,
  0x89, 0x02, 0x28, 0x05, 0x20, 0x14, 0x80, 0x62, 0x01, 0x88, 0x0E, 0x10,
  0x64, 0x3E, 0x10, 0x25, 0x24, 0x94, 0x80, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x00, 0x04, 0x01, 0x00, 0x43, 0x10, 0x34, 0x03, 0xF0, 0xC0, 0xD0, 0x42,
  0x30, 0x80, 0x10, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x12, 0x24, 0x48, 0x80, 0xFE, 0xC0, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x80, 0x32, 0x04,
  0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x04, 0x30, 0x3C, 0x00, 0x06, 0x14,
  0xD2, 0x28, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x00, 0xE0, 0x0C, 0x60, 0x40,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x18, 0xC0, 0x80, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x30,
  0x0F, 0x00, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x20, 0x20, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x04, 0x80, 0x28, 0x02, 0x40, 0x22,
  0x01, 0x10, 0x10, 0x81, 0x08, 0x08, 0x40, 0x82, 0x08, 0x10, 0x80, 0x84,
  0x08, 0x40, 0x44, 0x02, 0x3F, 0xFE, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFC, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x08, 0x18, 0x3F, 0x80, 0x00, 0x70,
  0x0C, 0x40, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x11, 0xE0, 0xB0, 0x86, 0x02, 0x30, 0x11, 0x00, 0x98, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x21, 0x02, 0x08,
  0x20, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x0C, 0x40, 0x40, 0x82,
  0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x40,
  0x42, 0x00, 0xB0, 0x03, 0x00, 0x32, 0x01, 0x04, 0x08, 0x08, 0x40, 0x21,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x84, 0x02, 0x18, 0x10,
  0x3F, 0x80, 0x00, 0xC0, 0x19, 0x81, 0x02, 0x10, 0x10, 0x80, 0x88, 0x04,
  0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x31, 0x01, 0x88,
  0x14, 0x33, 0x40, 0x62, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0xFC, 0x00, 0x08, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x46, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10,
  0x10, 0x20, 0x20, 0x40, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x00, 0x0E, 0x0C, 0x60, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x30, 0x10, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80, 0x02,
  0x30, 0x00, 0x44, 0x00, 0x09, 0x03, 0xE1, 0x20, 0x84, 0x24, 0x20, 0x85,
  0x04, 0x20, 0xA1, 0x04, 0x14, 0x20, 0x84, 0x88, 0x10, 0xA1, 0x04, 0x14,
  0x20, 0x86, 0x84, 0x10, 0x90, 0x86, 0x12, 0x11, 0x44, 0x41, 0xC7, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x04, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xA0,
  0x05, 0x00, 0x48, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x2F, 0xE1, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02,
  0x40, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x01, 0x07, 0xF0, 0x20, 0x20,
  0x80, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08,
  0x40, 0x42, 0x06, 0x0F, 0xE0, 0x20, 0x60, 0x80, 0x42, 0x01, 0x10, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x80, 0x22, 0x01, 0x08, 0x18,
  0x3F, 0x80, 0x00, 0x38, 0x06, 0x10, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x10, 0x30, 0x20, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x31, 0x00, 0x44, 0x01, 0x08,
  0x06, 0x10, 0x18, 0x20, 0xC0, 0x7E, 0x00, 0x07, 0xFC, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x0F, 0xF8, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xE0,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x30, 0x01, 0x87, 0x06,
  0x01, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7C, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x10, 0x80, 0x10, 0x40, 0x10, 0x20, 0x10, 0x1F, 0xE0, 0x0C, 0x00, 0x84,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40, 0x08,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x08, 0x01, 0x07, 0xFF, 0x82, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10,
  0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20,
  0x07, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x03, 0xE0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x0F, 0x00, 0x0C, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80, 0x82,
  0x02, 0x08, 0x04, 0x30, 0x08, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x90, 0x01,
  0x50, 0x03, 0x20, 0x04, 0x40, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x81,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x08, 0x20, 0x10, 0x40, 0x30,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0x04, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x50, 0xA0,
  0x02, 0x89, 0x00, 0x28, 0x48, 0x01, 0x42, 0x40, 0x12, 0x12, 0x00, 0x90,
  0x90, 0x09, 0x08, 0x80, 0x88, 0x44, 0x04, 0x42, 0x20, 0x42, 0x11, 0x02,
  0x10, 0x88, 0x21, 0x08, 0x41, 0x08, 0x41, 0x10, 0x42, 0x08, 0x82, 0x10,
  0x48, 0x11, 0x02, 0x41, 0x08, 0x14, 0x08, 0x40, 0xA0, 0x42, 0x06, 0x02,
  0x10, 0x30, 0x20, 0x04, 0x00, 0x86, 0x00, 0x43, 0x00, 0x21, 0x40, 0x20,
  0xA0, 0x10, 0x90, 0x08, 0x48, 0x04, 0x22, 0x02, 0x11, 0x02, 0x08, 0x81,
  0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x81, 0x10, 0x80,
  0x88, 0x40, 0x44, 0x20, 0x24, 0x10, 0x0A, 0x10, 0x05, 0x08, 0x02, 0x84,
  0x01, 0x42, 0x00, 0x41, 0x00, 0x20, 0x00, 0x40, 0x06, 0x30, 0x10, 0x10,
  0x40, 0x21, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x04, 0x10,
  0x18, 0x20, 0x60, 0x3F, 0x00, 0x07, 0xE0, 0x40, 0x82, 0x02, 0x10, 0x10,
  0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x88, 0x04, 0x40,
  0x42, 0x1C, 0x1E, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x00, 0x40, 0x06, 0x30,
  0x10, 0x10, 0x40, 0x21, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10,
  0x04, 0x10, 0x18, 0x20, 0x60, 0x3F, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x40, 0x82, 0x02,
  0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x88,
  0x0C, 0x40, 0xC3, 0xF8, 0x10, 0x80, 0x84, 0x08, 0x20, 0x41, 0x02, 0x04,
  0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x22, 0x01, 0x10, 0x08, 0x00, 0x20,
  0x03, 0x1C, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x40, 0x20, 0x7F, 0x80, 0xFF, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x10, 0x03, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80,
  0x20, 0x80, 0x20, 0x80, 0x40, 0x40, 0x80, 0x3F, 0x00, 0x80, 0x0C, 0x00,
  0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x84,
  0x04, 0x20, 0x41, 0x02, 0x08, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x80,
  0x50, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x08, 0x81, 0x10,
  0x42, 0x04, 0x41, 0x08, 0x21, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x44, 0x08, 0x41, 0x10, 0x22, 0x04, 0x80, 0x88, 0x12, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x18, 0x02, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x02, 0x01, 0x81, 0x00, 0x80, 0x80,
  0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x10, 0x00, 0x14, 0x00, 0x0A, 0x00,
  0x09, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x04, 0x10, 0x02, 0x08, 0x02, 0x04,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x00, 0x20, 0x80, 0x38, 0x02,
  0x80, 0x48, 0x04, 0x40, 0x84, 0x10, 0x41, 0x04, 0x20, 0x42, 0x04, 0x40,
  0x24, 0x02, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x07, 0xFE, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0F, 0xE0, 0x00, 0x82, 0x10, 0x84, 0x21, 0x04, 0x21,
  0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x20, 0x84, 0x21, 0x03, 0xF0, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0xFC, 0x00, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x08, 0x80,
  0x44, 0x04, 0x10, 0x60, 0x82, 0x04, 0x20, 0x11, 0x00, 0x90, 0x03, 0x80,
  0x10, 0xFF, 0xC0, 0x91, 0x12, 0x07, 0xC8, 0x41, 0x44, 0x0A, 0x20, 0x22,
  0x01, 0x10, 0x09, 0x00, 0x48, 0x04, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x04, 0x40, 0x22, 0x03, 0x08, 0x28, 0x41, 0x41, 0xF4, 0x00, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x09, 0xF0, 0x50, 0xC3, 0x02, 0x10, 0x11, 0x80, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x30, 0x09, 0x80,
  0x8C, 0x0C, 0x50, 0xC4, 0xFC, 0x00, 0x07, 0xE1, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x07, 0xC8,
  0x10, 0x50, 0x40, 0x60, 0x80, 0x82, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20,
  0x08, 0x40, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x06, 0x10, 0x08,
  0x20, 0x30, 0x20, 0xE0, 0x41, 0x40, 0x7C, 0x80, 0x07, 0xC1, 0x04, 0x40,
  0x88, 0x12, 0x02, 0x40, 0x90, 0x12, 0x0C, 0x5E, 0x14, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x03, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x01, 0xC0,
  0x00, 0x03, 0xE4, 0x10, 0x50, 0x80, 0xC2, 0x03, 0x10, 0x08, 0x40, 0x22,
  0x00, 0x88, 0x02, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x31,
  0x00, 0x84, 0x06, 0x08, 0x38, 0x20, 0xA0, 0x7C, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x81, 0x03, 0xF8, 0x00, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x09, 0xF0, 0x50, 0xC3, 0x02, 0x10, 0x11, 0x80, 0x88, 0x04, 0x40, 0x42,
  0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x08, 0x40, 0x46, 0x02, 0x00, 0x06, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x0F, 0x00, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x18, 0x41, 0x82, 0x08, 0x20, 0x81, 0x08,
  0x08, 0x80, 0x48, 0x02, 0xC0, 0x2E, 0x01, 0x50, 0x0C, 0x40, 0x42, 0x02,
  0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x84, 0x04, 0x00, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x00, 0x09, 0xE3, 0xE0,
  0xA1, 0x41, 0x0C, 0x18, 0x10, 0x81, 0x81, 0x18, 0x10, 0x11, 0x01, 0x01,
  0x10, 0x10, 0x11, 0x01, 0x01, 0x20, 0x20, 0x22, 0x02, 0x02, 0x20, 0x20,
  0x22, 0x02, 0x02, 0x20, 0x20, 0x44, 0x04, 0x04, 0x40, 0x40, 0x44, 0x04,
  0x04, 0x40, 0x40, 0x4C, 0x08, 0x08, 0x09, 0xF0, 0x50, 0xC3, 0x02, 0x10,
  0x11, 0x80, 0x88, 0x04, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x88, 0x08,
  0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x88, 0x08, 0x40, 0x46, 0x02, 0x00,
  0x07, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x08,
  0x41, 0x03, 0xE0, 0x04, 0xF8, 0x0A, 0x18, 0x18, 0x10, 0x30, 0x20, 0xC0,
  0x21, 0x80, 0x42, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10,
  0x80, 0x41, 0x00, 0x86, 0x01, 0x0C, 0x04, 0x18, 0x18, 0x28, 0x60, 0x5F,
  0x81, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x00, 0x07, 0xC8, 0x41, 0x44, 0x06, 0x20, 0x32, 0x01,
  0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x06, 0x40, 0x22, 0x03, 0x08, 0x18, 0x41, 0x41, 0xF2, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x09,
  0xE1, 0x40, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00,
  0x0F, 0xC2, 0x04, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x40, 0x08, 0x83, 0x1F,
  0xC0, 0x08, 0x10, 0x40, 0x87, 0xE2, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x1E, 0x00, 0x10, 0x18, 0x80,
  0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x62, 0x02, 0x10, 0x30, 0x82,
  0x83, 0xE4, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x22,
  0x08, 0x84, 0x21, 0x08, 0x82, 0x20, 0x90, 0x24, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x00, 0x80, 0x80, 0xC0, 0x40, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x28,
  0x24, 0x14, 0x12, 0x12, 0x11, 0x09, 0x08, 0x88, 0x84, 0x44, 0x44, 0x22,
  0x22, 0x12, 0x12, 0x09, 0x09, 0x05, 0x05, 0x02, 0x82, 0x81, 0x81, 0x40,
  0xC0, 0x40, 0x40, 0x20, 0x00, 0x08, 0x08, 0x40, 0x82, 0x04, 0x08, 0x40,
  0x44, 0x02, 0x20, 0x12, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x40, 0x12,
  0x01, 0x10, 0x08, 0x40, 0x82, 0x08, 0x10, 0x40, 0x84, 0x02, 0x00, 0x02,
  0x00, 0x81, 0x00, 0x80, 0x40, 0x40, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20,
  0x04, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xF0, 0x00, 0xF0,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x70, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0xF0, 0x00, 0x7E, 0x0C, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 7, 9, 9, 3, -24 },
  { 27, 15, 24, 15, 0, -24 },
  { 72, 14, 28, 14, 0, -26 },
  { 121, 17, 25, 20, 2, -25 },
  { 175, 14, 25, 15, 0, -25 },
  { 219, 3, 9, 5, 3, -24 },
  { 223, 9, 29, 8, 1, -24 },
  { 256, 9, 29, 8, -2, -24 },
  { 289, 10, 11, 13, 4, -26 },
  { 303, 13, 16, 15, 1, -20 },
  { 329, 4, 7, 6, -1, -3 },
  { 333, 7, 1, 9, 1, -10 },
  { 334, 1, 2, 6, 1, -2 },
  { 335, 15, 24, 10, -2, -24 },
  { 380, 12, 25, 14, 1, -25 },
  { 418, 7, 24, 14, 4, -24 },
  { 439, 14, 25, 14, -1, -25 },
  { 483, 14, 25, 14, 0, -25 },
  { 527, 13, 25, 14, 0, -25 },
  { 568, 14, 24, 14, 0, -24 },
  { 610, 13, 25, 14, 1, -25 },
  { 651, 13, 24, 14, 2, -24 },
  { 690, 14, 25, 14, 0, -25 },
  { 734, 13, 25, 14, 0, -25 },
  { 775, 5, 18, 6, 0, -18 },
  { 787, 8, 22, 6, -2, -18 },
  { 809, 13, 14, 15, 1, -19 },
  { 832, 13, 8, 15, 1, -16 },
  { 845, 13, 14, 15, 1, -19 },
  { 868, 10, 25, 10, 1, -25 },
  { 900, 19, 27, 21, 1, -24 },
  { 965, 13, 24, 13, -2, -24 },
  { 1004, 14, 24, 15, 1, -24 },
  { 1046, 14, 25, 14, 2, -25 },
  { 1090, 15, 24, 17, 1, -24 },
  { 1135, 14, 24, 14, 1, -24 },
  { 1177, 14, 24, 12, 1, -24 },
  { 1219, 16, 25, 18, 2, -25 },
  { 1269, 17, 24, 17, 1, -24 },
  { 1320, 10, 24, 7, -1, -24 },
  { 1350, 12, 30, 6, -5, -24 },
  { 1395, 15, 24, 14, 1, -24 },
  { 1440, 8, 24, 12, 1, -24 },
  { 1464, 21, 24, 22, 1, -24 },
  { 1527, 17, 24, 18, 1, -24 },
  { 1578, 15, 25, 18, 2, -25 },
  { 1625, 13, 24, 14, 1, -24 },
  { 1664, 15, 31, 18, 2, -25 },
  { 1723, 13, 24, 14, 1, -24 },
  { 1762, 15, 25, 13, -1, -25 },
  { 1809, 12, 24, 12, 3, -24 },
  { 1845, 16, 24, 17, 2, -24 },
  { 1893, 13, 24, 14, 3, -24 },
  { 1932, 22, 24, 23, 3, -24 },
  { 1998, 17, 24, 12, -2, -24 },
  { 2049, 12, 24, 12, 3, -24 },
  { 2085, 15, 24, 13, -1, -24 },
  { 2130, 13, 29, 10, -1, -24 },
  { 2178, 5, 24, 11, 3, -24 },
  { 2193, 12, 29, 10, -2, -24 },
  { 2237, 13, 12, 15, 1, -24 },
  { 2257, 10, 1, 10, -3, 3 },
  { 2259, 3, 5, 7, 5, -26 },
  { 2261, 13, 18, 15, 1, -18 },
  { 2291, 13, 26, 15, 0, -26 },
  { 2334, 11, 18, 11, 1, -18 },
  { 2359, 15, 26, 15, 1, -26 },
  { 2408, 11, 18, 13, 1, -18 },
  { 2433, 15, 34, 7, -4, -26 },
  { 2497, 14, 26, 15, 0, -18 },
  { 2543, 13, 26, 14, 0, -26 },
  { 2586, 7, 24, 6, 0, -24 },
  { 2607, 12, 32, 6, -5, -24 },
  { 2655, 13, 26, 12, 0, -26 },
  { 2698, 7, 26, 6, 0, -26 },
  { 2721, 20, 18, 22, 0, -18 },
  { 2766, 13, 18, 14, 0, -18 },
  { 2796, 12, 18, 14, 1, -18 },
  { 2823, 15, 26, 15, -1, -18 },
  { 2872, 13, 26, 15, 1, -18 },
  { 2915, 11, 18, 9, 0, -18 },
  { 2940, 11, 18, 11, 0, -18 },
  { 2965, 7, 22, 7, 1, -22 },
  { 2985, 13, 18, 14, 1, -18 },
  { 3015, 10, 18, 11, 2, -18 },
  { 3038, 17, 18, 18, 2, -18 },
  { 3077, 13, 18, 11, -1, -18 },
  { 3107, 17, 26, 11, -4, -18 },
  { 3163, 12, 18, 10, -1, -18 },
  { 3190, 12, 29, 11, 1, -24 },
  { 3234, 1, 34, 14, 7, -26 },
  { 3239, 12, 29, 11, -2, -24 },
  { 3283, 13, 2, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_THINITALIC34PT7B_H_
