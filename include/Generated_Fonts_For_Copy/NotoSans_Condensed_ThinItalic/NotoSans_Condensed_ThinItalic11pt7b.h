#ifndef _NOTOSANS_CONDENSED_THINITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0xFC, 0x29, 0x5E, 0xA5, 0x72, 0x94, 0x16, 0x62, 0x23,
  0x5E, 0x40, 0xCD, 0xB5, 0xFA, 0xB6, 0xB7, 0x35, 0x52, 0x6B, 0x9F, 0xE0,
  0x25, 0x29, 0x24, 0x88, 0x24, 0x92, 0x49, 0x50, 0xA5, 0xA0, 0x21, 0x3E,
  0x42, 0x00, 0xC0, 0xE0, 0x80, 0x11, 0x22, 0x48, 0x88, 0x35, 0x59, 0x99,
  0x9E, 0x75, 0x24, 0x94, 0x71, 0x11, 0x24, 0x4E, 0x71, 0x17, 0x11, 0x1E,
  0x11, 0x35, 0x5D, 0x22, 0x74, 0x46, 0x11, 0x1E, 0x3A, 0x11, 0xC9, 0x4A,
  0x5C, 0xF1, 0x22, 0x44, 0x88, 0x75, 0x57, 0x59, 0x9E, 0x75, 0x99, 0x71,
  0x1E, 0x40, 0x20, 0x20, 0x00, 0xB0, 0x3A, 0x30, 0x70, 0xFF, 0xC0, 0xE0,
  0x87, 0xC0, 0x71, 0x12, 0x44, 0x08, 0x3D, 0x15, 0xEB, 0xAE, 0xDA, 0xA0,
  0x70, 0x08, 0x8A, 0x53, 0xA5, 0x31, 0x7A, 0x52, 0xE5, 0x46, 0x5E, 0x78,
  0x88, 0x88, 0x8E, 0x72, 0x52, 0x94, 0xC6, 0x5C, 0x7A, 0x10, 0xE4, 0x42,
  0x1C, 0x7A, 0x10, 0x87, 0x42, 0x10, 0x7C, 0x21, 0x0B, 0x4A, 0x5E, 0x45,
  0x14, 0x5E, 0x4A, 0x28, 0xA2, 0x69, 0x25, 0x24, 0x11, 0x11, 0x12, 0x22,
  0x2C, 0x4A, 0x94, 0xC6, 0x52, 0x52, 0x49, 0x25, 0x27, 0x22, 0x85, 0x0B,
  0x36, 0xB5, 0xAD, 0x52, 0x24, 0x96, 0x5A, 0x5A, 0x68, 0xA2, 0x74, 0x63,
  0x18, 0xCA, 0x5C, 0x72, 0x52, 0x97, 0x42, 0x10, 0x74, 0x63, 0x18, 0xCA,
  0x54, 0x41, 0x00, 0x72, 0x52, 0xA6, 0x52, 0x52, 0x7A, 0x10, 0x82, 0x08,
  0x5C, 0xF4, 0x44, 0x88, 0x88, 0x8C, 0x63, 0x29, 0x4A, 0x5C, 0x99, 0x9A,
  0xAC, 0x88, 0x93, 0x26, 0xD5, 0xAD, 0x5B, 0x24, 0x48, 0x24, 0xA2, 0x84,
  0x20, 0xC5, 0x24, 0x9A, 0xAC, 0x88, 0x88, 0x78, 0x84, 0x44, 0x22, 0x1C,
  0x74, 0x44, 0x48, 0x88, 0x8C, 0xAA, 0x95, 0x31, 0x11, 0x12, 0x22, 0x2C,
  0x21, 0x95, 0x10, 0xE0, 0x80, 0x3A, 0x65, 0x29, 0x70, 0x44, 0x75, 0x59,
  0x9E, 0x34, 0x88, 0x8E, 0x08, 0x4E, 0x99, 0x4A, 0x5C, 0x35, 0xBC, 0x8E,
  0x19, 0x0C, 0x42, 0x21, 0x08, 0x42, 0x20, 0x3A, 0x65, 0x29, 0x70, 0x44,
  0xC0, 0x44, 0x75, 0x59, 0x99, 0x45, 0x6A, 0x10, 0x11, 0x12, 0x22, 0x24,
  0xC0, 0x44, 0x56, 0x4A, 0xAA, 0x55, 0x6A, 0x7E, 0xA5, 0x4C, 0xA9, 0x54,
  0x80, 0x75, 0x59, 0x99, 0x35, 0x99, 0x9E, 0x75, 0x59, 0x9E, 0x88, 0x80,
  0x3A, 0x65, 0x29, 0x70, 0x44, 0x20, 0x69, 0x49, 0x00, 0x78, 0x42, 0x2E,
  0x4D, 0x49, 0x30, 0x55, 0x99, 0x9E, 0xB7, 0x49, 0x00, 0xAD, 0x7B, 0x6A,
  0x50, 0x56, 0x44, 0xAA, 0x4A, 0x4C, 0x62, 0x11, 0x08, 0x80, 0x65, 0x29,
  0x80, 0x12, 0x24, 0xC4, 0x44, 0x84, 0xFF, 0xE0, 0x31, 0x11, 0x12, 0x22,
  0x2C, 0xF8,
};

const GFXglyph NotoSans_Condensed_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 2, 3, 3, 1, -8 },
  { 4, 5, 8, 5, 0, -8 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 5, 8, 7, 1, -8 },
  { 19, 4, 8, 5, 0, -8 },
  { 23, 1, 3, 2, 1, -8 },
  { 24, 3, 10, 3, 0, -8 },
  { 28, 3, 10, 3, -1, -8 },
  { 32, 4, 3, 4, 1, -8 },
  { 34, 5, 5, 5, 0, -6 },
  { 38, 1, 2, 2, 0, -1 },
  { 39, 3, 1, 3, 0, -3 },
  { 40, 1, 1, 2, 0, -1 },
  { 41, 4, 8, 3, 0, -8 },
  { 45, 4, 8, 4, 0, -8 },
  { 49, 3, 8, 4, 1, -8 },
  { 52, 4, 8, 4, 0, -8 },
  { 56, 4, 8, 4, 0, -8 },
  { 60, 4, 8, 4, 0, -8 },
  { 64, 4, 8, 4, 0, -8 },
  { 68, 5, 8, 4, 0, -8 },
  { 73, 4, 8, 4, 1, -8 },
  { 77, 4, 8, 4, 0, -8 },
  { 81, 4, 8, 4, 0, -8 },
  { 85, 2, 6, 2, 0, -6 },
  { 87, 3, 7, 2, -1, -6 },
  { 90, 5, 4, 5, 0, -6 },
  { 93, 5, 2, 5, 0, -5 },
  { 95, 5, 4, 5, 0, -6 },
  { 98, 4, 8, 3, 0, -8 },
  { 102, 6, 9, 7, 0, -8 },
  { 109, 5, 8, 4, -1, -8 },
  { 114, 5, 8, 5, 0, -8 },
  { 119, 4, 8, 5, 1, -8 },
  { 123, 5, 8, 5, 0, -8 },
  { 128, 5, 8, 4, 0, -8 },
  { 133, 5, 8, 4, 0, -8 },
  { 138, 5, 8, 6, 1, -8 },
  { 143, 6, 8, 6, 0, -8 },
  { 149, 3, 8, 2, 0, -8 },
  { 152, 4, 10, 2, -2, -8 },
  { 157, 5, 8, 4, 0, -8 },
  { 162, 3, 8, 4, 0, -8 },
  { 165, 7, 8, 7, 0, -8 },
  { 172, 6, 8, 6, 0, -8 },
  { 178, 5, 8, 6, 1, -8 },
  { 183, 5, 8, 5, 0, -8 },
  { 188, 5, 10, 6, 1, -8 },
  { 195, 5, 8, 5, 0, -8 },
  { 200, 5, 8, 4, 0, -8 },
  { 205, 4, 8, 4, 1, -8 },
  { 209, 5, 8, 6, 1, -8 },
  { 214, 4, 8, 4, 1, -8 },
  { 218, 7, 8, 7, 1, -8 },
  { 225, 6, 8, 4, -1, -8 },
  { 231, 4, 8, 4, 1, -8 },
  { 235, 5, 8, 4, 0, -8 },
  { 240, 4, 10, 3, 0, -8 },
  { 245, 2, 8, 3, 1, -8 },
  { 247, 4, 10, 3, -1, -8 },
  { 252, 5, 4, 5, 0, -8 },
  { 255, 3, 1, 3, -1, 1 },
  { 256, 1, 1, 2, 2, -8 },
  { 257, 5, 6, 5, 0, -6 },
  { 261, 4, 8, 5, 0, -8 },
  { 265, 4, 6, 4, 0, -6 },
  { 268, 5, 8, 5, 0, -8 },
  { 273, 4, 6, 4, 0, -6 },
  { 276, 5, 11, 2, -1, -8 },
  { 283, 5, 9, 5, 0, -6 },
  { 289, 4, 8, 5, 0, -8 },
  { 293, 2, 8, 2, 0, -8 },
  { 295, 4, 11, 2, -2, -8 },
  { 301, 4, 8, 4, 0, -8 },
  { 305, 2, 8, 2, 0, -8 },
  { 307, 7, 6, 7, 0, -6 },
  { 313, 4, 6, 5, 0, -6 },
  { 316, 4, 6, 5, 0, -6 },
  { 319, 4, 9, 5, 0, -6 },
  { 324, 5, 9, 5, 0, -6 },
  { 330, 3, 6, 3, 0, -6 },
  { 333, 4, 6, 4, 0, -6 },
  { 336, 3, 7, 2, 0, -7 },
  { 339, 4, 6, 5, 0, -6 },
  { 342, 3, 6, 3, 1, -6 },
  { 345, 5, 6, 6, 1, -6 },
  { 349, 4, 6, 4, 0, -6 },
  { 352, 5, 9, 4, -1, -6 },
  { 358, 3, 6, 3, 0, -6 },
  { 361, 4, 10, 3, 0, -8 },
  { 366, 1, 11, 4, 2, -8 },
  { 368, 4, 10, 3, -1, -8 },
  { 373, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_THINITALIC11PT7B_H_
