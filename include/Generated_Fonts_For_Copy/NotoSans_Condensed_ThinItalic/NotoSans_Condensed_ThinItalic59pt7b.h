#ifndef _NOTOSANS_CONDENSED_THINITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x18,
  0x31, 0x02, 0x30, 0x23, 0x06, 0x20, 0x62, 0x04, 0x20, 0x46, 0x04, 0x60,
  0xC4, 0x08, 0x40, 0x84, 0x08, 0xC0, 0x88, 0x18, 0x81, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0,
  0x60, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x00,
  0x02, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C,
  0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20,
  0x10, 0x03, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0xC0, 0x20, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x71, 0x83, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x00, 0x01, 0x01, 0x00,
  0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00,
  0x02, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x84, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x10, 0x60, 0x00, 0x10, 0x20,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x20, 0x20,
  0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0x40, 0xC0,
  0x80, 0x41, 0x80, 0xE0, 0xC7, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0xC3,
  0x00, 0x18, 0x0C, 0x18, 0x00, 0x80, 0xC0, 0x40, 0x0C, 0x04, 0x02, 0x00,
  0xC0, 0x60, 0x10, 0x06, 0x02, 0x00, 0x80, 0x60, 0x30, 0x04, 0x02, 0x01,
  0x80, 0x20, 0x30, 0x08, 0x03, 0x01, 0x00, 0x40, 0x18, 0x18, 0x06, 0x00,
  0xC1, 0x80, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x20, 0xC0, 0x08, 0x03, 0x04,
  0x00, 0x40, 0x18, 0x60, 0x02, 0x00, 0xC2, 0x07, 0x30, 0x04, 0x30, 0xFD,
  0x80, 0x61, 0x0C, 0x3C, 0x02, 0x18, 0xC1, 0xA0, 0x31, 0x8C, 0x05, 0x01,
  0x88, 0x40, 0x2C, 0x18, 0xC6, 0x01, 0x61, 0x84, 0x20, 0x09, 0xF8, 0x63,
  0x00, 0x43, 0x02, 0x18, 0x02, 0x00, 0x30, 0x80, 0x30, 0x03, 0x04, 0x01,
  0x80, 0x10, 0x60, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x08, 0x18, 0x02, 0x00,
  0xC0, 0x80, 0x10, 0x04, 0x04, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x40, 0x30, 0x10, 0x02, 0x03,
  0x01, 0x80, 0x10, 0x18, 0x08, 0x00, 0xC1, 0x80, 0xC0, 0x06, 0x18, 0x0C,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x18, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x40, 0x18, 0x00, 0x40, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x40,
  0x60, 0x00, 0x40, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63,
  0x00, 0x00, 0x2E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x04,
  0x03, 0x18, 0x06, 0x02, 0x18, 0x06, 0x06, 0x30, 0x02, 0x06, 0x20, 0x03,
  0x04, 0x60, 0x01, 0x0C, 0x60, 0x01, 0x88, 0x40, 0x01, 0x98, 0xC0, 0x00,
  0xB0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0xE0, 0x40, 0x01, 0xA0, 0x60, 0x03, 0x30, 0x70, 0x06, 0x10, 0x38, 0x1C,
  0x10, 0x1F, 0xF0, 0x18, 0x03, 0x00, 0x00, 0x18, 0x8C, 0x62, 0x10, 0x8C,
  0x62, 0x10, 0x8C, 0x42, 0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x30, 0x10, 0x07, 0x04, 0x00, 0x62, 0x00, 0x06,
  0x83, 0xC0, 0x7F, 0x00, 0x18, 0x00, 0x0D, 0x00, 0x04, 0x40, 0x02, 0x08,
  0x03, 0x02, 0x01, 0x80, 0x40, 0x40, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x03,
  0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x06, 0x08, 0x30, 0x41,
  0x82, 0x08, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0x00, 0x0C, 0x1C, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x43, 0x00, 0x02, 0x18, 0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x60,
  0x00, 0x22, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x06,
  0x40, 0x00, 0x36, 0x00, 0x01, 0x30, 0x00, 0x09, 0x80, 0x00, 0xC8, 0x00,
  0x06, 0x40, 0x00, 0x32, 0x00, 0x01, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60,
  0x03, 0x01, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x01, 0xC3, 0x80,
  0x07, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x0D, 0x07, 0x21,
  0x8C, 0x61, 0xB8, 0x24, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x70,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0x03, 0x00, 0x1C,
  0x00, 0xC0, 0x08, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x80, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x32, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x84, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x20, 0x18, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x10, 0x00, 0x80,
  0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x10, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x05, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x80, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x78, 0x00, 0xC7, 0xFC, 0x01, 0x18, 0x0C, 0x02, 0x60,
  0x0C, 0x0D, 0x00, 0x08, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00,
  0x20, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x02,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41,
  0x80, 0x00, 0x83, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x38,
  0x1C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x01, 0x00, 0x02, 0x01, 0x00, 0x06, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x70, 0x00, 0x60,
  0xC0, 0x00, 0x33, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE7,
  0x00, 0x03, 0x83, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x30, 0x00, 0x20, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x30, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x07,
  0x00, 0x30, 0x04, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x20, 0x20, 0x00, 0xC1,
  0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18,
  0x00, 0x38, 0x60, 0x00, 0xA0, 0xC0, 0x07, 0x83, 0x00, 0x34, 0x07, 0x03,
  0x90, 0x0F, 0xF8, 0xC0, 0x02, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x02, 0x03, 0x80, 0x0F,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x03, 0x03, 0x07, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0xC0, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x07, 0xF0, 0x18, 0x60, 0x0F, 0x38,
  0x0C, 0x60, 0x0C, 0x0C, 0x06, 0x30, 0x0C, 0x06, 0x03, 0x10, 0x0C, 0x02,
  0x01, 0x18, 0x06, 0x01, 0x00, 0x8C, 0x06, 0x01, 0x80, 0x44, 0x02, 0x00,
  0xC0, 0x26, 0x03, 0x00, 0x40, 0x33, 0x01, 0x80, 0x20, 0x19, 0x80, 0x80,
  0x30, 0x0C, 0x80, 0xC0, 0x18, 0x04, 0x40, 0x60, 0x08, 0x06, 0x60, 0x20,
  0x0C, 0x03, 0x30, 0x10, 0x06, 0x01, 0x18, 0x08, 0x03, 0x01, 0x8C, 0x0C,
  0x03, 0x80, 0xC6, 0x06, 0x01, 0x80, 0xC3, 0x03, 0x01, 0xC0, 0x61, 0x80,
  0x80, 0xA0, 0x60, 0xC0, 0x60, 0xD8, 0x60, 0x60, 0x38, 0xC4, 0x60, 0x30,
  0x0F, 0xC3, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x13, 0x00, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04,
  0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x81,
  0x00, 0x02, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x08, 0x00, 0x60, 0x10,
  0x00, 0x80, 0x20, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0xFF, 0xFE, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00,
  0x11, 0x80, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xB0, 0x00, 0x01,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0x20, 0x3E,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x04, 0x00,
  0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x08, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x1C, 0x01, 0x80, 0x3C, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x08, 0x00, 0x18,
  0x04, 0x00, 0x04, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10, 0x30, 0x00,
  0x18, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x07, 0x01, 0x00, 0x07, 0x00, 0x80, 0x06, 0x00, 0xC0,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0x80, 0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x10, 0x3E, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x08, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x10, 0x00, 0x04,
  0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x20, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x60,
  0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x08, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x08,
  0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xE0,
  0x10, 0x00, 0x70, 0x04, 0x00, 0x30, 0x01, 0x00, 0x38, 0x00, 0xC3, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x01, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x8C, 0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x80, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x30, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x30, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x03, 0x00, 0x40, 0x00, 0x08, 0x03, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x31, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00, 0x60, 0x01, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x20,
  0x0C, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x02, 0x78, 0x00, 0x00,
  0x49, 0x00, 0x00, 0x1B, 0x30, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x70, 0x40,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80,
  0x10, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x0A, 0x00, 0xB0, 0x00, 0x00, 0x78, 0x02, 0xC0, 0x00,
  0x01, 0x60, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x6C, 0x00, 0x00, 0x24, 0x01,
  0xB0, 0x00, 0x01, 0x90, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x11, 0x00, 0x00,
  0x33, 0x00, 0xC4, 0x00, 0x00, 0x8C, 0x03, 0x10, 0x00, 0x06, 0x20, 0x0C,
  0x40, 0x00, 0x30, 0x80, 0x21, 0x00, 0x00, 0xC6, 0x00, 0x86, 0x00, 0x06,
  0x18, 0x06, 0x18, 0x00, 0x18, 0x40, 0x18, 0x60, 0x00, 0xC1, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x01, 0x06, 0x00, 0x18, 0x30, 0x04, 0x08, 0x00, 0x60,
  0xC0, 0x30, 0x20, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x02, 0x02,
  0x00, 0x60, 0x60, 0x08, 0x08, 0x01, 0x81, 0x80, 0x60, 0x20, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x10, 0x06, 0x03, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x04, 0x03, 0x00, 0x40, 0x30, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x80, 0x20,
  0x0C, 0x01, 0x06, 0x00, 0x80, 0x30, 0x04, 0x10, 0x02, 0x00, 0x80, 0x10,
  0xC0, 0x18, 0x02, 0x00, 0x42, 0x00, 0x60, 0x18, 0x01, 0x18, 0x01, 0x00,
  0x60, 0x04, 0x40, 0x04, 0x01, 0x80, 0x1B, 0x00, 0x30, 0x04, 0x00, 0x68,
  0x00, 0xC0, 0x30, 0x01, 0xE0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0x08, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x03, 0x00, 0xB0, 0x00, 0x08,
  0x02, 0x40, 0x00, 0x20, 0x19, 0x00, 0x01, 0x80, 0x66, 0x00, 0x06, 0x01,
  0x98, 0x00, 0x18, 0x04, 0x20, 0x00, 0x40, 0x10, 0x80, 0x01, 0x00, 0xC3,
  0x00, 0x0C, 0x03, 0x0C, 0x00, 0x30, 0x0C, 0x10, 0x00, 0xC0, 0x20, 0x40,
  0x02, 0x00, 0x81, 0x80, 0x08, 0x06, 0x06, 0x00, 0x60, 0x18, 0x08, 0x01,
  0x80, 0x60, 0x20, 0x04, 0x01, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x0C, 0x02, 0x00, 0x60, 0x20, 0x08,
  0x01, 0x80, 0x80, 0x60, 0x02, 0x06, 0x01, 0x80, 0x08, 0x18, 0x06, 0x00,
  0x30, 0x60, 0x10, 0x00, 0xC1, 0x00, 0x40, 0x01, 0x04, 0x03, 0x00, 0x06,
  0x30, 0x0C, 0x00, 0x18, 0xC0, 0x30, 0x00, 0x63, 0x00, 0x80, 0x00, 0x88,
  0x02, 0x00, 0x03, 0x20, 0x18, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x36, 0x01,
  0x00, 0x00, 0x50, 0x04, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x40, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x02, 0x02, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x04, 0x00, 0x18,
  0x04, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x38, 0x01, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x41, 0xF8, 0x00,
  0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x02, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x01,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x02,
  0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x04, 0x00, 0x30, 0x04, 0x00, 0xE0, 0x0C, 0x0F, 0xC0, 0x0F,
  0xFE, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x20, 0x01, 0x00, 0x20,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x00, 0x80, 0x40,
  0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x80, 0x03, 0x80, 0x70, 0x07, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x10, 0x18, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x08, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x30, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x32, 0x00, 0x00, 0x64, 0x00, 0x01, 0x88,
  0x00, 0x03, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80,
  0x00, 0xC1, 0x00, 0x01, 0x02, 0x00, 0x06, 0x04, 0x00, 0x08, 0x08, 0x00,
  0x30, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80, 0x40, 0x03, 0x00, 0x80, 0x0C,
  0x01, 0x00, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00,
  0x18, 0x06, 0x00, 0x30, 0x08, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x08,
  0x60, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88,
  0x00, 0x01, 0x30, 0x00, 0x02, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x05,
  0x00, 0x01, 0xC0, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x50,
  0x00, 0x32, 0x00, 0x06, 0x80, 0x01, 0x90, 0x00, 0x24, 0x00, 0x08, 0x80,
  0x03, 0x20, 0x00, 0xC4, 0x00, 0x11, 0x00, 0x04, 0x20, 0x01, 0x88, 0x00,
  0x61, 0x00, 0x0C, 0x40, 0x03, 0x08, 0x00, 0x42, 0x00, 0x30, 0x40, 0x06,
  0x10, 0x01, 0x82, 0x00, 0x20, 0x80, 0x08, 0x10, 0x03, 0x04, 0x00, 0xC0,
  0x80, 0x18, 0x20, 0x04, 0x04, 0x01, 0x81, 0x00, 0x60, 0x20, 0x0C, 0x08,
  0x03, 0x01, 0x00, 0x40, 0x40, 0x10, 0x08, 0x06, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x04, 0x06,
  0x00, 0x80, 0x80, 0x20, 0x20, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x20, 0x40,
  0x08, 0x10, 0x01, 0x06, 0x00, 0x41, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00,
  0x43, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0x86, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x26,
  0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x58, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x02, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x01, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x18,
  0x80, 0x00, 0xC4, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x80, 0x06, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x01, 0x00, 0x30, 0x08, 0x01, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x02, 0x06, 0x00, 0x10, 0x60,
  0x00, 0x82, 0x00, 0x04, 0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0D,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xC0, 0xC0, 0xC0, 0x40, 0x40,
  0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10,
  0x10, 0x10, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x0C,
  0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x58, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0x86, 0x10,
  0xC2, 0x18, 0x43, 0x08, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x10, 0x0C, 0x0C,
  0x40, 0x60, 0x1B, 0x03, 0x00, 0x2C, 0x18, 0x00, 0xA0, 0xC0, 0x03, 0x83,
  0x00, 0x0E, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x08,
  0x40, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01,
  0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x10, 0x01, 0xE0, 0x60, 0x0D, 0x01,
  0x80, 0x64, 0x03, 0x83, 0x10, 0x07, 0xF8, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x31, 0xFE, 0x00, 0xCE, 0x0C, 0x02, 0x60, 0x18, 0x0B, 0x00,
  0x30, 0x78, 0x00, 0xC1, 0xE0, 0x03, 0x07, 0x00, 0x04, 0x18, 0x00, 0x10,
  0x60, 0x00, 0x43, 0x80, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80,
  0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00,
  0x84, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00,
  0x30, 0x50, 0x01, 0x81, 0x60, 0x06, 0x0D, 0x80, 0x30, 0x23, 0x83, 0x80,
  0x87, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x0C,
  0x04, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x80, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x03, 0x81, 0x80, 0x07, 0xF8, 0x60, 0x03, 0x83,
  0x10, 0x01, 0x80, 0x64, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x03, 0xC0, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x08, 0x00, 0x04, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x10, 0x00, 0x08, 0x04, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x38, 0x03, 0x00, 0x0A, 0x00, 0x40, 0x06, 0x80, 0x18, 0x03,
  0x60, 0x06, 0x01, 0x98, 0x00, 0xE1, 0xC4, 0x00, 0x1F, 0xE1, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x03, 0x83, 0x00, 0xC0,
  0x20, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00,
  0x62, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0xC2, 0x00, 0x30, 0xC0, 0x0C,
  0x18, 0x07, 0x03, 0x1F, 0x80, 0x7F, 0x80, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x04, 0x06, 0x03, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0xC0, 0x0C, 0x0C, 0x40, 0x0C,
  0x03, 0x20, 0x0C, 0x00, 0x90, 0x0C, 0x00, 0x78, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x10, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x68, 0x02, 0x00, 0x34, 0x01, 0x80, 0x36, 0x00, 0xC0, 0x33, 0x00, 0x30,
  0x71, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x10, 0x03, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x81, 0xC0, 0x0C, 0x7F, 0x80, 0x66, 0x06, 0x02, 0x60, 0x18, 0x16, 0x00,
  0xC1, 0xE0, 0x02, 0x0E, 0x00, 0x10, 0x70, 0x00, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x04,
  0x10, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x82,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x00,
  0x82, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x02, 0x08, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x8E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x60, 0x06,
  0x02, 0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x02, 0x00, 0x60,
  0x30, 0x02, 0x03, 0x00, 0x10, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00,
  0x43, 0x00, 0x02, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x9E, 0x00, 0x0D, 0x90,
  0x00, 0x58, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x10, 0x01, 0x80, 0x80, 0x0C,
  0x06, 0x00, 0x40, 0x30, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x08, 0x01, 0x80, 0x40, 0x04, 0x06, 0x00, 0x20, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x08, 0x00, 0x20, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0xC7, 0xF0, 0x3F, 0xC0, 0x27, 0x06, 0x18, 0x18, 0x09, 0x00, 0xCC, 0x03,
  0x02, 0x80, 0x16, 0x00, 0xC1, 0xE0, 0x07, 0x00, 0x10, 0x70, 0x01, 0x80,
  0x04, 0x18, 0x00, 0x60, 0x03, 0x06, 0x00, 0x10, 0x00, 0xC1, 0x80, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x02, 0x0C, 0x00,
  0x20, 0x00, 0x82, 0x00, 0x08, 0x00, 0x60, 0x80, 0x06, 0x00, 0x18, 0x60,
  0x01, 0x80, 0x04, 0x18, 0x00, 0x60, 0x01, 0x04, 0x00, 0x10, 0x00, 0xC1,
  0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x02,
  0x0C, 0x00, 0x20, 0x00, 0x82, 0x00, 0x08, 0x00, 0x60, 0x80, 0x06, 0x00,
  0x18, 0x60, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x01, 0x06, 0x00, 0x10,
  0x00, 0x41, 0x00, 0x04, 0x00, 0x30, 0x40, 0x03, 0x00, 0x0C, 0x30, 0x00,
  0xC0, 0x02, 0x0C, 0x00, 0x20, 0x00, 0x82, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x18, 0xFF, 0x00, 0x8C, 0x0C, 0x04, 0xC0, 0x30, 0x2C, 0x01,
  0x83, 0xC0, 0x04, 0x1C, 0x00, 0x20, 0xE0, 0x01, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x18,
  0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20, 0x80, 0x01, 0x04,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01,
  0x04, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x10, 0x00, 0x20, 0x00,
  0x0E, 0x00, 0x03, 0xFC, 0x00, 0x30, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x03,
  0x03, 0x00, 0x18, 0x30, 0x00, 0x41, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x06,
  0x06, 0x00, 0x60, 0x18, 0x06, 0x00, 0xE0, 0x60, 0x03, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x31, 0xFE, 0x00, 0x11, 0xC1, 0x80,
  0x09, 0x80, 0x60, 0x05, 0x80, 0x18, 0x06, 0x80, 0x0C, 0x03, 0xC0, 0x06,
  0x01, 0xC0, 0x01, 0x00, 0xE0, 0x00, 0x80, 0x60, 0x00, 0x40, 0x70, 0x00,
  0x20, 0x30, 0x00, 0x10, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x04, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03,
  0x80, 0x06, 0x01, 0x40, 0x06, 0x00, 0xA0, 0x03, 0x00, 0xD8, 0x07, 0x00,
  0x66, 0x07, 0x00, 0x31, 0xFE, 0x00, 0x10, 0x38, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x0C, 0x03, 0x03, 0x10, 0x0C,
  0x03, 0x20, 0x30, 0x02, 0x40, 0xC0, 0x07, 0x83, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0x82, 0x00, 0x01, 0x04, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x40, 0x00, 0x20, 0x80, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0,
  0x01, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x0A, 0x02, 0x00, 0x34, 0x06, 0x00,
  0xD8, 0x0C, 0x03, 0x30, 0x0C, 0x0C, 0x40, 0x0F, 0xF0, 0x80, 0x07, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x01, 0x8F, 0xC0, 0x8C, 0x00, 0x4C, 0x00,
  0x2C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xF8, 0x0E, 0x03, 0x83, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC1, 0x00, 0x30, 0x30, 0x0C,
  0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x3F, 0xF4, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x7E, 0x03, 0x80, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x08, 0x20, 0x00,
  0x41, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x20,
  0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x04, 0x00, 0x08,
  0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x04, 0x00,
  0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x38, 0x30, 0x03, 0xC1, 0x80, 0x16, 0x0C, 0x01, 0xA0, 0x30, 0x39,
  0x00, 0xFF, 0x08, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x18,
  0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x60, 0x40, 0x10, 0x10,
  0x0C, 0x04, 0x02, 0x01, 0x81, 0x80, 0x60, 0x40, 0x18, 0x30, 0x06, 0x08,
  0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01, 0x98, 0x00,
  0x26, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xA0,
  0x01, 0x80, 0x0D, 0x00, 0x1C, 0x00, 0x48, 0x00, 0xA0, 0x06, 0x40, 0x0D,
  0x00, 0x32, 0x00, 0x48, 0x01, 0x10, 0x06, 0x40, 0x18, 0x80, 0x22, 0x00,
  0x84, 0x01, 0x10, 0x0C, 0x20, 0x18, 0x80, 0x61, 0x00, 0x84, 0x02, 0x08,
  0x0C, 0x20, 0x30, 0x40, 0x41, 0x01, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x20,
  0x60, 0x80, 0x83, 0x03, 0x04, 0x04, 0x18, 0x18, 0x60, 0x20, 0x80, 0xC2,
  0x01, 0x0C, 0x06, 0x30, 0x08, 0x40, 0x31, 0x00, 0x46, 0x01, 0x98, 0x02,
  0x20, 0x0C, 0xC0, 0x13, 0x00, 0x64, 0x00, 0x90, 0x03, 0x60, 0x05, 0x80,
  0x1A, 0x00, 0x2C, 0x00, 0xF0, 0x01, 0x40, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x08, 0x02, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x10, 0x18, 0x00, 0x20, 0x60, 0x00, 0x60, 0x80, 0x00,
  0xC3, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x90, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD0,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x60, 0x00, 0x18, 0x40, 0x00, 0x60, 0xC0,
  0x00, 0x81, 0x80, 0x03, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x08, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x20, 0x01, 0x00, 0x01, 0x00, 0x18, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x01, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x05, 0x83, 0x80, 0x38, 0x03, 0x81, 0xA0, 0x03, 0xFC, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 42, 12, 1, -42 },
  { 59, 12, 15, 16, 6, -42 },
  { 82, 26, 42, 26, 1, -42 },
  { 219, 24, 48, 24, 0, -45 },
  { 363, 29, 44, 35, 3, -43 },
  { 523, 24, 44, 25, 0, -43 },
  { 655, 5, 15, 9, 6, -42 },
  { 665, 16, 51, 14, 2, -42 },
  { 767, 16, 51, 14, -4, -42 },
  { 869, 18, 19, 22, 7, -45 },
  { 912, 22, 27, 27, 3, -34 },
  { 987, 7, 14, 10, -2, -6 },
  { 1000, 13, 2, 16, 2, -17 },
  { 1004, 3, 4, 10, 1, -4 },
  { 1006, 25, 42, 17, -3, -42 },
  { 1138, 21, 44, 24, 2, -43 },
  { 1254, 11, 42, 24, 8, -42 },
  { 1312, 24, 43, 24, -1, -43 },
  { 1441, 25, 44, 24, -1, -43 },
  { 1579, 24, 43, 24, -1, -43 },
  { 1708, 24, 43, 24, 0, -42 },
  { 1837, 23, 44, 24, 2, -43 },
  { 1964, 22, 42, 24, 4, -42 },
  { 2080, 24, 44, 24, 0, -43 },
  { 2212, 22, 44, 24, 1, -43 },
  { 2333, 8, 31, 10, 1, -31 },
  { 2364, 13, 39, 10, -3, -31 },
  { 2428, 22, 24, 27, 3, -33 },
  { 2494, 22, 14, 27, 3, -28 },
  { 2533, 22, 24, 27, 3, -33 },
  { 2599, 17, 43, 17, 2, -43 },
  { 2691, 33, 47, 36, 2, -42 },
  { 2885, 23, 42, 23, -4, -42 },
  { 3006, 25, 42, 26, 1, -42 },
  { 3138, 25, 44, 24, 3, -43 },
  { 3276, 26, 42, 29, 1, -42 },
  { 3413, 25, 42, 23, 1, -42 },
  { 3545, 25, 42, 21, 1, -42 },
  { 3677, 28, 44, 31, 3, -43 },
  { 3831, 30, 42, 30, 1, -42 },
  { 3989, 17, 42, 12, -2, -42 },
  { 4079, 21, 52, 10, -9, -42 },
  { 4216, 27, 42, 24, 1, -42 },
  { 4358, 15, 42, 21, 1, -42 },
  { 4437, 38, 42, 39, 1, -42 },
  { 4637, 30, 42, 31, 1, -42 },
  { 4795, 27, 44, 31, 3, -43 },
  { 4944, 24, 42, 24, 1, -42 },
  { 5070, 27, 53, 31, 3, -43 },
  { 5249, 24, 42, 25, 1, -42 },
  { 5375, 25, 44, 23, -1, -43 },
  { 5513, 20, 42, 21, 5, -42 },
  { 5618, 28, 43, 30, 3, -42 },
  { 5769, 23, 42, 24, 5, -42 },
  { 5890, 37, 42, 39, 6, -42 },
  { 6085, 28, 42, 21, -3, -42 },
  { 6232, 21, 42, 21, 5, -42 },
  { 6343, 27, 42, 22, -2, -42 },
  { 6485, 21, 51, 17, -1, -42 },
  { 6619, 8, 42, 19, 6, -42 },
  { 6661, 21, 51, 17, -4, -42 },
  { 6795, 23, 22, 26, 2, -42 },
  { 6859, 18, 1, 17, -5, 6 },
  { 6862, 5, 9, 12, 9, -45 },
  { 6868, 22, 33, 25, 2, -32 },
  { 6959, 22, 46, 25, 1, -45 },
  { 7086, 18, 33, 19, 2, -32 },
  { 7161, 26, 46, 26, 2, -45 },
  { 7311, 19, 33, 22, 2, -32 },
  { 7390, 28, 59, 12, -8, -45 },
  { 7597, 25, 46, 26, 0, -32 },
  { 7741, 21, 45, 25, 1, -45 },
  { 7860, 11, 42, 10, 1, -42 },
  { 7918, 20, 56, 10, -8, -42 },
  { 8058, 21, 45, 20, 1, -45 },
  { 8177, 11, 45, 10, 1, -45 },
  { 8239, 34, 32, 37, 1, -32 },
  { 8375, 21, 32, 25, 1, -32 },
  { 8459, 21, 33, 25, 2, -32 },
  { 8546, 25, 46, 25, -2, -32 },
  { 8690, 23, 46, 26, 2, -32 },
  { 8823, 17, 32, 16, 1, -32 },
  { 8891, 19, 33, 19, 0, -32 },
  { 8970, 12, 40, 13, 2, -39 },
  { 9030, 21, 32, 25, 2, -31 },
  { 9114, 18, 31, 18, 3, -31 },
  { 9184, 29, 31, 31, 4, -31 },
  { 9297, 23, 31, 20, -2, -31 },
  { 9387, 29, 45, 19, -7, -31 },
  { 9551, 21, 31, 17, -2, -31 },
  { 9633, 20, 51, 19, 2, -42 },
  { 9761, 2, 59, 24, 11, -45 },
  { 9776, 21, 51, 19, -4, -42 },
  { 9910, 22, 5, 27, 3, -23 },
};

const GFXfont NotoSans_Condensed_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_THINITALIC59PT7B_H_
