#ifndef _NOTOSANS_CONDENSED_THINITALIC52PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xC0, 0x00,
  0x10, 0x66, 0x08, 0xC1, 0x10, 0x62, 0x0C, 0x41, 0x18, 0x23, 0x04, 0x41,
  0x88, 0x21, 0x04, 0x60, 0x88, 0x30, 0x00, 0x08, 0x08, 0x00, 0x30, 0x10,
  0x00, 0x60, 0x60, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x06, 0x06, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x01,
  0x01, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x20, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x0C,
  0x00, 0x10, 0x18, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x01, 0x80,
  0x02, 0x02, 0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x18, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x40, 0x01, 0x81, 0x80, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x18,
  0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x03, 0x03,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x71, 0x1C, 0x06, 0x18, 0x20,
  0x60, 0xC0, 0x02, 0x04, 0x00, 0x30, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x80, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x98, 0x00, 0x04, 0x60, 0x00, 0x21, 0x00, 0x03,
  0x0C, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40,
  0x03, 0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x04, 0x18, 0x20, 0x63,
  0x81, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0xC0, 0xC3, 0x00, 0x20, 0x20, 0x40, 0x18, 0x18, 0x10, 0x04,
  0x04, 0x04, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x40, 0x60, 0x10,
  0x30, 0x18, 0x04, 0x08, 0x04, 0x03, 0x06, 0x01, 0x00, 0xC1, 0x00, 0x40,
  0x20, 0x80, 0x30, 0x08, 0x60, 0x0C, 0x02, 0x10, 0x03, 0x01, 0x8C, 0x38,
  0x80, 0x42, 0x1F, 0x20, 0x11, 0x88, 0x68, 0x0C, 0x46, 0x0B, 0x02, 0x33,
  0x02, 0xC1, 0x98, 0x80, 0xD0, 0xC4, 0x60, 0x27, 0xE3, 0x10, 0x08, 0x60,
  0x84, 0x02, 0x00, 0x63, 0x00, 0x80, 0x10, 0xC0, 0x20, 0x0C, 0x20, 0x08,
  0x02, 0x08, 0x06, 0x01, 0x02, 0x01, 0x80, 0xC0, 0x80, 0x40, 0x20, 0x60,
  0x10, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0x80,
  0x60, 0x40, 0x40, 0x08, 0x30, 0x30, 0x03, 0x18, 0x08, 0x00, 0x7C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x0C, 0x30, 0x00,
  0xC0, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00, 0x10, 0x08,
  0x01, 0x80, 0x40, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x08,
  0x10, 0x00, 0x41, 0x80, 0x02, 0x18, 0x00, 0x19, 0x80, 0x00, 0x58, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x33, 0x00, 0x03, 0x08,
  0x00, 0x30, 0x60, 0x63, 0x03, 0x03, 0x30, 0x08, 0x11, 0x00, 0x61, 0x98,
  0x01, 0x08, 0x80, 0x0C, 0xC4, 0x00, 0x64, 0x60, 0x01, 0x63, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x10, 0x01, 0x20, 0xC0,
  0x11, 0x83, 0x03, 0x04, 0x0F, 0xF0, 0x30, 0x08, 0x00, 0x00, 0x13, 0x32,
  0x22, 0x66, 0x44, 0x4C, 0x80, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x80, 0x80, 0xE0, 0x80, 0x30,
  0x80, 0x0D, 0x03, 0x03, 0xFC, 0x01, 0x00, 0x06, 0x80, 0x0C, 0x80, 0x18,
  0x40, 0x20, 0x40, 0x40, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x04, 0x30, 0xC2,
  0x18, 0x43, 0x08, 0x61, 0x0C, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x30,
  0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x60, 0x03, 0x08, 0x00, 0x61, 0x00,
  0x0C, 0x60, 0x01, 0x88, 0x00, 0x31, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00,
  0x44, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x80, 0x01,
  0x10, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C,
  0x20, 0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x18, 0x03, 0x03, 0x00, 0xC0,
  0x20, 0x30, 0x02, 0x0C, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x68, 0x66, 0x31, 0x98, 0x48, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0x00, 0x38, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x0E, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x20, 0x01, 0x80, 0xE0, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x58, 0x00, 0x03, 0x60, 0x00, 0x19, 0x00, 0x00, 0x44, 0x00,
  0x02, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x42, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x41, 0x80, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40,
  0x02, 0x01, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x80, 0x18,
  0x02, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x60, 0x18, 0x01, 0x00, 0xC0, 0x04,
  0x02, 0x00, 0x10, 0x10, 0x00, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xF8, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFF, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x20, 0x03, 0x01, 0x80, 0x70, 0x07, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x0F, 0x00, 0x23, 0xFC, 0x06, 0xE0, 0x60, 0x78,
  0x03, 0x05, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x20, 0xC0, 0x06,
  0x0C, 0x00, 0x40, 0x40, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x70, 0x01, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x18, 0x01, 0x00, 0x60,
  0x10, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00,
  0x08, 0x10, 0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x30, 0x03, 0x01,
  0x80, 0x10, 0x06, 0x01, 0x00, 0x10, 0x30, 0x00, 0xC3, 0x00, 0x03, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x38, 0xC0, 0x03, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0x00, 0x30, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x30,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x10, 0xC0, 0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x01,
  0x80, 0xC0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xE0, 0x07, 0x02, 0x01, 0x80, 0x20, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x00,
  0x08, 0x60, 0x01, 0x08, 0x00, 0x23, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00,
  0x62, 0x00, 0x1C, 0x40, 0x03, 0x0C, 0x00, 0xE0, 0x80, 0x34, 0x18, 0x1D,
  0x81, 0xFE, 0x20, 0x02, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x1C, 0x01,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x18, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x83, 0x06, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20,
  0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x60, 0x70,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x60, 0x11, 0x80, 0x3F, 0x81,
  0x10, 0x0C, 0x08, 0x11, 0x00, 0x81, 0x81, 0x30, 0x10, 0x10, 0x12, 0x03,
  0x01, 0x01, 0x60, 0x20, 0x10, 0x16, 0x06, 0x03, 0x01, 0x40, 0x40, 0x20,
  0x34, 0x0C, 0x02, 0x03, 0x40, 0x80, 0x60, 0x2C, 0x08, 0x06, 0x02, 0xC1,
  0x80, 0x40, 0x68, 0x18, 0x04, 0x04, 0x81, 0x80, 0xC0, 0x48, 0x18, 0x0C,
  0x0C, 0x81, 0x81, 0x40, 0x88, 0x18, 0x14, 0x18, 0x80, 0x82, 0x43, 0x08,
  0x0C, 0x66, 0x60, 0x80, 0x7C, 0x3C, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0x60, 0x00, 0x32,
  0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0xC2, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x30, 0x20, 0x02,
  0x02, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x20, 0x1F, 0xFE, 0x03, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03,
  0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x06, 0x03, 0xC0,
  0x18, 0x01, 0x80, 0x40, 0x06, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00,
  0x81, 0x80, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x40, 0x06, 0x03,
  0x00, 0x30, 0x0C, 0x07, 0x80, 0x3F, 0xF0, 0x00, 0x80, 0x70, 0x02, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x01, 0x00, 0x06, 0x04, 0x00, 0x18,
  0x10, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20,
  0x00, 0x40, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40, 0x01,
  0x81, 0x00, 0x0C, 0x0C, 0x00, 0xE0, 0x30, 0x1E, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0xC0, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0x03, 0xC0, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xC0,
  0x10, 0x00, 0xC0, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02,
  0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08, 0x30, 0x00, 0x10, 0x40,
  0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x21, 0x80, 0x00,
  0x43, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x18,
  0x60, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x82, 0x00, 0x06, 0x0C,
  0x00, 0x08, 0x18, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x40, 0x03, 0x00, 0x80,
  0x0C, 0x03, 0x00, 0x70, 0x06, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0x20,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x7F, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10,
  0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x40, 0x40, 0x00, 0x60, 0x30, 0x00, 0x30, 0x08, 0x00, 0x10,
  0x06, 0x00, 0x08, 0x01, 0xC0, 0x1C, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0x40, 0x20, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x20, 0x00, 0x10, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x20,
  0x10, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC6, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x80, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x18,
  0x01, 0x00, 0x30, 0x01, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80,
  0x02, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x04, 0x30, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x09, 0xE0, 0x00, 0x0B, 0x20, 0x00, 0x0E, 0x20, 0x00,
  0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x10, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x0C, 0x00,
  0x20, 0x04, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x06, 0x00,
  0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x50, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x00, 0xF0, 0x14, 0x00, 0x00,
  0x50, 0x0A, 0x00, 0x00, 0x68, 0x0D, 0x00, 0x00, 0x24, 0x06, 0x80, 0x00,
  0x36, 0x02, 0x60, 0x00, 0x13, 0x01, 0x30, 0x00, 0x19, 0x01, 0x98, 0x00,
  0x08, 0x80, 0xCC, 0x00, 0x0C, 0x40, 0x42, 0x00, 0x04, 0x60, 0x21, 0x00,
  0x06, 0x20, 0x10, 0x80, 0x02, 0x10, 0x18, 0x40, 0x03, 0x08, 0x0C, 0x20,
  0x01, 0x0C, 0x04, 0x10, 0x01, 0x86, 0x02, 0x08, 0x00, 0x82, 0x01, 0x04,
  0x00, 0xC1, 0x01, 0x83, 0x00, 0x40, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x40,
  0xC0, 0x20, 0x60, 0x20, 0x20, 0x30, 0x20, 0x30, 0x10, 0x10, 0x10, 0x18,
  0x08, 0x10, 0x08, 0x08, 0x04, 0x18, 0x0C, 0x04, 0x02, 0x08, 0x04, 0x02,
  0x01, 0x0C, 0x02, 0x03, 0x00, 0x84, 0x01, 0x01, 0x80, 0x46, 0x01, 0x80,
  0x80, 0x32, 0x00, 0xC0, 0x40, 0x1B, 0x00, 0x40, 0x20, 0x0D, 0x00, 0x20,
  0x30, 0x03, 0x80, 0x10, 0x18, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x38, 0x00, 0x08, 0x07, 0x00, 0x01, 0x00,
  0xA0, 0x00, 0x20, 0x14, 0x00, 0x0C, 0x02, 0xC0, 0x01, 0x80, 0xC8, 0x00,
  0x20, 0x19, 0x00, 0x04, 0x02, 0x20, 0x01, 0x80, 0x46, 0x00, 0x30, 0x18,
  0x40, 0x04, 0x03, 0x08, 0x00, 0x80, 0x41, 0x00, 0x10, 0x08, 0x30, 0x06,
  0x01, 0x02, 0x00, 0xC0, 0x60, 0x40, 0x10, 0x0C, 0x0C, 0x02, 0x01, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x18, 0x04, 0x02, 0x03, 0x01, 0x80, 0x60, 0x40,
  0x30, 0x0C, 0x08, 0x04, 0x00, 0x81, 0x00, 0x80, 0x10, 0x60, 0x30, 0x03,
  0x08, 0x06, 0x00, 0x61, 0x00, 0x80, 0x04, 0x20, 0x10, 0x00, 0x8C, 0x02,
  0x00, 0x19, 0x80, 0xC0, 0x03, 0x20, 0x18, 0x00, 0x24, 0x02, 0x00, 0x04,
  0x80, 0x40, 0x00, 0xF0, 0x08, 0x00, 0x1E, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x08, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x40, 0x00, 0x81,
  0x80, 0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x04, 0x40,
  0x00, 0x09, 0x80, 0x00, 0x13, 0x00, 0x00, 0x24, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x03,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x00,
  0x30, 0x03, 0x80, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x0C, 0x0E, 0x00, 0x60, 0x18, 0x02, 0x00, 0x60, 0x10, 0x01,
  0x80, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x02, 0x00, 0x08, 0x10,
  0x00, 0x41, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x08,
  0x10, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x40, 0x06, 0x02, 0x00,
  0xE0, 0x10, 0x3C, 0x01, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0xC0, 0x0C, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x40, 0x00, 0x81, 0x80, 0x01, 0x06, 0x00, 0x03,
  0x08, 0x00, 0x06, 0x30, 0x00, 0x04, 0x40, 0x00, 0x09, 0x80, 0x00, 0x13,
  0x00, 0x00, 0x24, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x40,
  0x00, 0x06, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x03,
  0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x80,
  0x80, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x0E, 0x00, 0x60,
  0x18, 0x02, 0x00, 0x60, 0x10, 0x01, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x60, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x40, 0x01, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x0C, 0x0C,
  0x00, 0xC0, 0x40, 0x0C, 0x02, 0x01, 0xC0, 0x1F, 0xF8, 0x01, 0x81, 0x00,
  0x0C, 0x08, 0x00, 0x40, 0x60, 0x02, 0x01, 0x00, 0x10, 0x08, 0x01, 0x80,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x30, 0x02, 0x01,
  0x80, 0x18, 0x08, 0x00, 0xC0, 0x40, 0x02, 0x02, 0x00, 0x10, 0x30, 0x00,
  0x81, 0x80, 0x06, 0x08, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xE0, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0xE0, 0x1C,
  0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x40,
  0x40, 0x00, 0x20, 0x60, 0x00, 0x10, 0x30, 0x00, 0x18, 0x10, 0x00, 0x0C,
  0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0x40, 0x00, 0x20, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x10, 0x00, 0x08, 0x08, 0x00, 0x04, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x10, 0x10,
  0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x02, 0x03,
  0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x80,
  0x0C, 0x00, 0x80, 0x03, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80,
  0x00, 0xC8, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x03, 0x08,
  0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0xC0,
  0xC0, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x0C, 0x06, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x08,
  0x00, 0x41, 0x80, 0x04, 0x10, 0x00, 0x43, 0x00, 0x04, 0x20, 0x00, 0x46,
  0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0x58, 0x00, 0x05,
  0x00, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x50, 0x00,
  0x30, 0x00, 0x68, 0x00, 0x28, 0x00, 0x24, 0x00, 0x14, 0x00, 0x32, 0x00,
  0x1A, 0x00, 0x19, 0x00, 0x09, 0x00, 0x08, 0x80, 0x0C, 0x80, 0x0C, 0x40,
  0x04, 0x40, 0x04, 0x20, 0x02, 0x20, 0x06, 0x10, 0x03, 0x10, 0x02, 0x08,
  0x01, 0x08, 0x01, 0x04, 0x01, 0x84, 0x01, 0x82, 0x00, 0x82, 0x00, 0x81,
  0x00, 0xC1, 0x00, 0xC0, 0x80, 0x40, 0x80, 0x40, 0x40, 0x20, 0x40, 0x60,
  0x20, 0x30, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x18, 0x08, 0x18,
  0x04, 0x08, 0x04, 0x08, 0x02, 0x04, 0x02, 0x0C, 0x01, 0x06, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x82, 0x00, 0x43, 0x00, 0x43, 0x00, 0x21, 0x00, 0x21,
  0x00, 0x11, 0x80, 0x11, 0x80, 0x08, 0x80, 0x08, 0x80, 0x04, 0x40, 0x04,
  0xC0, 0x02, 0x60, 0x02, 0x40, 0x01, 0x20, 0x01, 0x20, 0x00, 0xB0, 0x00,
  0xB0, 0x00, 0x50, 0x00, 0x50, 0x00, 0x28, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x30, 0x00, 0x10, 0x30, 0x00,
  0x08, 0x10, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x60,
  0x00, 0x01, 0x90, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x60,
  0x10, 0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x10, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x18, 0x00, 0x40, 0x08, 0x00, 0x20, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00,
  0x86, 0x00, 0x30, 0xC0, 0x04, 0x08, 0x01, 0x81, 0x00, 0x20, 0x20, 0x0C,
  0x04, 0x03, 0x00, 0x80, 0x40, 0x18, 0x18, 0x03, 0x02, 0x00, 0x20, 0xC0,
  0x04, 0x10, 0x00, 0x86, 0x00, 0x11, 0x80, 0x03, 0x20, 0x00, 0x6C, 0x00,
  0x05, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81, 0x03, 0x06, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81,
  0x03, 0x06, 0x04, 0x08, 0x10, 0x20, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x68, 0x00, 0x04, 0xC0, 0x00, 0xC4,
  0x00, 0x08, 0x40, 0x01, 0x86, 0x00, 0x30, 0x20, 0x02, 0x03, 0x00, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x81, 0x80, 0x0C, 0x30,
  0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x30,
  0xFF, 0xFE, 0x84, 0x30, 0x82, 0x10, 0x43, 0x00, 0x7C, 0x00, 0x3D, 0xC4,
  0x0C, 0x0C, 0x83, 0x00, 0xD0, 0xC0, 0x0E, 0x10, 0x01, 0x86, 0x00, 0x30,
  0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0x44,
  0x00, 0x18, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x01, 0x10,
  0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20,
  0x03, 0x86, 0x00, 0x70, 0xC0, 0x14, 0x0C, 0x04, 0x81, 0x81, 0x90, 0x1F,
  0xC2, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x1F,
  0x00, 0x67, 0xB8, 0x04, 0xC0, 0xC0, 0x58, 0x06, 0x05, 0x00, 0x20, 0xF0,
  0x02, 0x0E, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x18,
  0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x63,
  0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0xC2, 0x00, 0x08,
  0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x06, 0x00, 0x30, 0xF0, 0x06,
  0x09, 0x00, 0xC0, 0x98, 0x18, 0x08, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0xE7, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x20, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x7C, 0x30, 0x07, 0xBC, 0xC0,
  0x30, 0x12, 0x01, 0x80, 0x68, 0x0C, 0x00, 0xA0, 0x20, 0x03, 0x81, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00,
  0xC0, 0x80, 0x07, 0x02, 0x00, 0x18, 0x08, 0x00, 0xE0, 0x30, 0x06, 0x80,
  0xC0, 0x16, 0x01, 0x80, 0xD0, 0x06, 0x0E, 0x40, 0x0F, 0xE1, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xEE, 0x03, 0x03, 0x06, 0x01, 0x0C, 0x01,
  0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x03, 0x20, 0x02, 0x60, 0x04,
  0x40, 0x18, 0x40, 0x70, 0x4F, 0xC0, 0xFE, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x10, 0x1F, 0xF0, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xEF, 0x30, 0x0C, 0x04, 0x80, 0x60, 0x1A, 0x03,
  0x00, 0x28, 0x08, 0x00, 0xE0, 0x60, 0x03, 0x81, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x20, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x08, 0x10, 0x00, 0x20,
  0x40, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x40, 0x80,
  0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x01, 0xC0, 0x80, 0x06,
  0x02, 0x00, 0x38, 0x0C, 0x01, 0xA0, 0x30, 0x05, 0x80, 0x40, 0x34, 0x01,
  0x83, 0x90, 0x03, 0xF8, 0x40, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x21, 0xF0, 0x0C, 0xF7, 0x01,
  0x30, 0x30, 0x2C, 0x02, 0x07, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x01, 0x86,
  0x00, 0x20, 0xC0, 0x04, 0x10, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x40,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x03, 0x08, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x01, 0x04, 0x00,
  0x20, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x02, 0x0C,
  0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x80, 0x30,
  0x20, 0x04, 0x0C, 0x00, 0x83, 0x00, 0x10, 0xC0, 0x06, 0x30, 0x00, 0xC4,
  0x00, 0x11, 0x80, 0x02, 0x58, 0x00, 0x5B, 0x00, 0x1E, 0x20, 0x03, 0x84,
  0x00, 0x60, 0xC0, 0x08, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x20, 0x02,
  0x04, 0x00, 0x40, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00,
  0x02, 0x1E, 0x03, 0xE0, 0x11, 0xDE, 0x1D, 0xE0, 0x48, 0x09, 0x80, 0x81,
  0x40, 0x24, 0x03, 0x06, 0x00, 0xE0, 0x04, 0x38, 0x03, 0x80, 0x10, 0xC0,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x20, 0x02,
  0x00, 0x21, 0x80, 0x08, 0x00, 0x86, 0x00, 0x60, 0x02, 0x10, 0x01, 0x80,
  0x18, 0x40, 0x04, 0x00, 0x41, 0x00, 0x10, 0x01, 0x0C, 0x00, 0x40, 0x04,
  0x30, 0x03, 0x00, 0x30, 0x80, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x02, 0x08,
  0x00, 0x80, 0x08, 0x60, 0x06, 0x00, 0x21, 0x00, 0x18, 0x01, 0x84, 0x00,
  0x40, 0x06, 0x10, 0x01, 0x00, 0x10, 0xC0, 0x04, 0x00, 0x43, 0x00, 0x30,
  0x01, 0x08, 0x00, 0xC0, 0x0C, 0x20, 0x02, 0x00, 0x20, 0x02, 0x1F, 0x00,
  0x8F, 0x70, 0x13, 0x03, 0x02, 0xC0, 0x20, 0x70, 0x06, 0x1C, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x30,
  0x01, 0x84, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x86, 0x00, 0x30, 0x80,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00,
  0x10, 0x40, 0x02, 0x00, 0x00, 0x7C, 0x00, 0x7B, 0xC0, 0x30, 0x18, 0x18,
  0x06, 0x0C, 0x00, 0x82, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x01, 0x30, 0x00,
  0x48, 0x00, 0x16, 0x00, 0x05, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x3C,
  0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x63, 0x00, 0x10, 0x40, 0x08,
  0x18, 0x06, 0x03, 0x07, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x43,
  0xE0, 0x01, 0x1E, 0xE0, 0x02, 0x60, 0x60, 0x05, 0x80, 0x60, 0x0A, 0x00,
  0x40, 0x3C, 0x00, 0x80, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40,
  0x40, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08,
  0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x30, 0x1E, 0x00, 0xC0, 0x34, 0x03,
  0x00, 0x4C, 0x0C, 0x00, 0x8F, 0xF0, 0x01, 0x02, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0xE3, 0x03, 0x01,
  0x20, 0x60, 0x1A, 0x0C, 0x00, 0xA0, 0x80, 0x0E, 0x18, 0x00, 0xE1, 0x00,
  0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x40,
  0x00, 0x84, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x08,
  0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x07, 0x08, 0x00, 0x60,
  0xC0, 0x0E, 0x0C, 0x00, 0xA0, 0xC0, 0x1E, 0x04, 0x03, 0x40, 0x60, 0x64,
  0x03, 0xF8, 0x40, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x02, 0x1E, 0x08,
  0xF4, 0x13, 0x00, 0x2C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xEF, 0xC1, 0x80, 0x41, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x30, 0x18, 0x1F,
  0xF8, 0x00, 0x40, 0x00, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x81, 0xFF, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x0F, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01,
  0x04, 0x00, 0x21, 0x80, 0x0C, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04,
  0x30, 0x01, 0x86, 0x00, 0x30, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10,
  0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0xC3,
  0x00, 0x18, 0x40, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x05, 0x04,
  0x01, 0xE0, 0xC0, 0x68, 0x0C, 0x19, 0x01, 0xFE, 0x20, 0x06, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08,
  0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x40,
  0x40, 0xC0, 0x40, 0x80, 0x41, 0x80, 0x41, 0x00, 0x43, 0x00, 0x42, 0x00,
  0x46, 0x00, 0x44, 0x00, 0x4C, 0x00, 0x48, 0x00, 0x58, 0x00, 0x50, 0x00,
  0x50, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x28, 0x01, 0xC0, 0x1A, 0x00, 0x50, 0x04, 0x80, 0x14, 0x01, 0x20, 0x09,
  0x00, 0xCC, 0x02, 0x40, 0x23, 0x01, 0x10, 0x18, 0xC0, 0x44, 0x04, 0x30,
  0x31, 0x01, 0x0C, 0x08, 0x40, 0x83, 0x06, 0x10, 0x20, 0xC1, 0x04, 0x18,
  0x30, 0x41, 0x04, 0x0C, 0x20, 0x43, 0x03, 0x08, 0x10, 0x80, 0xC6, 0x04,
  0x20, 0x31, 0x01, 0x18, 0x0C, 0xC0, 0x44, 0x03, 0x20, 0x13, 0x00, 0xD8,
  0x04, 0x80, 0x34, 0x01, 0x20, 0x0D, 0x00, 0x50, 0x03, 0x80, 0x14, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x18, 0x08, 0x01, 0x80, 0x40, 0x18, 0x03, 0x00, 0x80, 0x08, 0x08, 0x00,
  0x40, 0xC0, 0x02, 0x04, 0x00, 0x18, 0x40, 0x00, 0x46, 0x00, 0x02, 0x60,
  0x00, 0x1A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0x82, 0x00,
  0x0C, 0x10, 0x00, 0xC0, 0xC0, 0x04, 0x02, 0x00, 0x60, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x06, 0x03, 0x00, 0x10, 0x30, 0x00, 0x80, 0x00, 0x20, 0x00,
  0xC0, 0x08, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x20,
  0x02, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0x40, 0x00, 0x80, 0x30, 0x00,
  0x30, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x01, 0x60,
  0x60, 0x38, 0x03, 0xFE, 0x80, 0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 37, 11, 1, -37 },
  { 48, 11, 13, 14, 5, -37 },
  { 66, 23, 37, 23, 1, -37 },
  { 173, 21, 42, 21, 0, -39 },
  { 284, 26, 39, 31, 3, -38 },
  { 411, 21, 39, 22, 0, -38 },
  { 514, 4, 13, 8, 5, -37 },
  { 521, 15, 45, 13, 1, -37 },
  { 606, 14, 45, 13, -3, -37 },
  { 685, 16, 16, 20, 6, -39 },
  { 717, 20, 24, 23, 2, -30 },
  { 777, 6, 12, 9, -2, -5 },
  { 786, 12, 2, 14, 1, -15 },
  { 789, 3, 3, 9, 1, -3 },
  { 791, 21, 37, 15, -2, -37 },
  { 889, 19, 39, 21, 2, -38 },
  { 982, 10, 37, 21, 7, -37 },
  { 1029, 21, 38, 21, -1, -38 },
  { 1129, 22, 39, 21, -1, -38 },
  { 1237, 22, 38, 21, -1, -38 },
  { 1342, 21, 38, 21, 0, -37 },
  { 1442, 20, 39, 21, 2, -38 },
  { 1540, 20, 37, 21, 3, -37 },
  { 1633, 21, 39, 21, 0, -38 },
  { 1736, 19, 39, 21, 1, -38 },
  { 1829, 7, 28, 9, 1, -28 },
  { 1854, 10, 35, 9, -2, -28 },
  { 1898, 20, 21, 23, 2, -29 },
  { 1951, 20, 12, 23, 2, -24 },
  { 1981, 20, 21, 23, 2, -29 },
  { 2034, 15, 38, 15, 2, -38 },
  { 2106, 28, 42, 32, 2, -37 },
  { 2253, 20, 37, 20, -3, -37 },
  { 2346, 22, 37, 23, 1, -37 },
  { 2448, 22, 39, 22, 3, -38 },
  { 2556, 23, 37, 26, 1, -37 },
  { 2663, 22, 37, 21, 1, -37 },
  { 2765, 22, 37, 19, 1, -37 },
  { 2867, 25, 39, 27, 3, -38 },
  { 2989, 26, 37, 27, 1, -37 },
  { 3110, 16, 37, 10, -2, -37 },
  { 3184, 18, 46, 9, -8, -37 },
  { 3288, 24, 37, 21, 1, -37 },
  { 3399, 13, 37, 19, 1, -37 },
  { 3460, 33, 37, 34, 1, -37 },
  { 3613, 27, 37, 27, 1, -37 },
  { 3738, 23, 39, 27, 3, -38 },
  { 3851, 21, 37, 22, 1, -37 },
  { 3949, 23, 47, 27, 3, -38 },
  { 4085, 21, 37, 22, 1, -37 },
  { 4183, 22, 39, 20, -1, -38 },
  { 4291, 17, 37, 18, 5, -37 },
  { 4370, 25, 38, 26, 2, -37 },
  { 4489, 20, 37, 21, 5, -37 },
  { 4582, 33, 37, 35, 5, -37 },
  { 4735, 25, 37, 19, -3, -37 },
  { 4851, 19, 37, 18, 4, -37 },
  { 4939, 24, 37, 20, -2, -37 },
  { 5050, 19, 45, 15, -1, -37 },
  { 5157, 7, 37, 16, 5, -37 },
  { 5190, 18, 45, 15, -3, -37 },
  { 5292, 20, 19, 23, 2, -37 },
  { 5340, 15, 1, 15, -4, 5 },
  { 5342, 5, 8, 11, 8, -40 },
  { 5347, 19, 29, 22, 2, -28 },
  { 5416, 20, 41, 22, 1, -40 },
  { 5519, 16, 29, 17, 2, -28 },
  { 5577, 22, 41, 23, 2, -40 },
  { 5690, 16, 29, 20, 2, -28 },
  { 5748, 24, 52, 11, -7, -40 },
  { 5904, 22, 40, 23, 0, -28 },
  { 6014, 19, 40, 22, 1, -40 },
  { 6109, 9, 37, 9, 1, -37 },
  { 6151, 17, 49, 9, -7, -37 },
  { 6256, 19, 40, 18, 1, -40 },
  { 6351, 9, 40, 9, 1, -40 },
  { 6396, 30, 28, 33, 1, -28 },
  { 6501, 19, 28, 22, 1, -28 },
  { 6568, 18, 29, 22, 2, -28 },
  { 6634, 23, 40, 22, -2, -28 },
  { 6749, 20, 40, 23, 2, -28 },
  { 6849, 15, 28, 14, 1, -28 },
  { 6902, 17, 29, 17, 0, -28 },
  { 6964, 11, 35, 11, 1, -34 },
  { 7013, 19, 28, 22, 2, -27 },
  { 7080, 16, 27, 16, 3, -27 },
  { 7134, 26, 27, 27, 3, -27 },
  { 7222, 21, 27, 17, -2, -27 },
  { 7293, 26, 40, 17, -6, -27 },
  { 7423, 17, 27, 15, -1, -27 },
  { 7481, 17, 45, 16, 2, -37 },
  { 7577, 1, 53, 21, 10, -40 },
  { 7584, 18, 45, 16, -3, -37 },
  { 7686, 20, 5, 23, 2, -21 },
};

const GFXfont NotoSans_Condensed_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_THINITALIC52PT7B_H_
