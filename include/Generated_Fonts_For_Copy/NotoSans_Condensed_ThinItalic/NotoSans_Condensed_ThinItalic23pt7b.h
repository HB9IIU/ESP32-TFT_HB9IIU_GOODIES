#ifndef _NOTOSANS_CONDENSED_THINITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x00, 0x18, 0x4A,
  0x55, 0x29, 0x48, 0x04, 0x41, 0x10, 0x48, 0x22, 0x3F, 0xC2, 0x41, 0x10,
  0x44, 0x12, 0x04, 0x8F, 0xF8, 0x88, 0x24, 0x11, 0x04, 0x41, 0x20, 0x02,
  0x03, 0x86, 0xA4, 0x42, 0x41, 0x20, 0x90, 0x28, 0x08, 0x02, 0x02, 0x81,
  0x20, 0x90, 0x88, 0x49, 0xF8, 0x10, 0x08, 0x00, 0x18, 0x02, 0x42, 0x44,
  0x44, 0x48, 0x44, 0x88, 0x50, 0x89, 0x08, 0xA6, 0x8A, 0x99, 0x51, 0x65,
  0x10, 0xA1, 0x12, 0x21, 0x22, 0x22, 0x22, 0x24, 0x43, 0xC0, 0x06, 0x04,
  0x84, 0x42, 0x21, 0x10, 0x88, 0x48, 0x18, 0x18, 0x14, 0x11, 0x28, 0x98,
  0x34, 0x1A, 0x09, 0x0A, 0x79, 0x00, 0x56, 0xA0, 0x0C, 0x21, 0x08, 0x21,
  0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x41, 0x04, 0x00, 0x11, 0x21, 0x59, 0x45, 0x11, 0x02, 0x00,
  0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x29, 0x28, 0xF8, 0xC0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0E, 0x11,
  0x21, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84,
  0x84, 0x88, 0x70, 0x35, 0x91, 0x22, 0x22, 0x24, 0x44, 0x44, 0x88, 0x07,
  0x02, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x00, 0x0F, 0x08, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x1C, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0xFC, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x50, 0x50, 0x28,
  0x24, 0x22, 0x21, 0x11, 0x10, 0x90, 0x4F, 0xF8, 0x10, 0x10, 0x08, 0x04,
  0x00, 0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x00, 0xF0, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x09, 0xF8, 0x07, 0x84, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x78, 0xC2, 0x41, 0x20, 0x90, 0x48, 0x24, 0x12, 0x09,
  0x08, 0x78, 0x00, 0x7F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x07, 0x0C, 0x44,
  0x24, 0x12, 0x09, 0x04, 0x44, 0x14, 0x0C, 0x19, 0x10, 0x90, 0x28, 0x14,
  0x0A, 0x05, 0x04, 0x7C, 0x00, 0x06, 0x0C, 0x84, 0x24, 0x12, 0x0A, 0x05,
  0x02, 0x81, 0x21, 0x91, 0x47, 0x40, 0x20, 0x10, 0x10, 0x10, 0x08, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x84, 0x42, 0x00, 0x01, 0x83, 0x06, 0x0C, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x30, 0x60, 0x40, 0x40, 0x00,
  0x39, 0x10, 0x41, 0x04, 0x10, 0x84, 0x10, 0x84, 0x10, 0x80, 0x00, 0x00,
  0x80, 0x07, 0xE0, 0x81, 0x10, 0x12, 0x01, 0x43, 0x94, 0x49, 0x48, 0x98,
  0x89, 0x91, 0x19, 0x11, 0x91, 0x19, 0x12, 0x93, 0x48, 0xC8, 0x80, 0x08,
  0x00, 0x40, 0x03, 0xE0, 0x01, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24,
  0x22, 0x11, 0x0F, 0x88, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x1F, 0x84,
  0x11, 0x04, 0x41, 0x10, 0x48, 0x22, 0x10, 0xF8, 0x21, 0x08, 0x24, 0x09,
  0x02, 0x40, 0x90, 0x44, 0x23, 0xF0, 0x03, 0x83, 0x11, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x3E, 0x00, 0x1F, 0x82, 0x08, 0x40, 0x88, 0x11, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x20, 0x44, 0x09, 0x01, 0x20, 0x44, 0x08, 0x82, 0x20,
  0x87, 0xE0, 0x1F, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0xFC,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x03, 0xF8, 0x1F, 0xC4,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x3F, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x03, 0xC1, 0x84, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x7A, 0x01, 0x40, 0x48, 0x09,
  0x01, 0x20, 0x22, 0x04, 0x3F, 0x00, 0x10, 0x11, 0x01, 0x10, 0x11, 0x02,
  0x10, 0x22, 0x02, 0x20, 0x23, 0xFC, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04,
  0x40, 0x84, 0x08, 0x80, 0x88, 0x08, 0x1E, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x78, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x86, 0x00, 0x10, 0x62, 0x08, 0x42, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x01,
  0xC0, 0x24, 0x04, 0x81, 0x10, 0x21, 0x04, 0x20, 0x84, 0x20, 0x44, 0x08,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x3F,
  0x08, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x51, 0x80, 0xC5, 0x02, 0x89,
  0x09, 0x12, 0x12, 0x24, 0x48, 0x48, 0x91, 0x12, 0x22, 0x24, 0x44, 0x50,
  0x88, 0xA2, 0x21, 0x84, 0x41, 0x08, 0x08, 0x11, 0x81, 0x18, 0x11, 0x41,
  0x14, 0x22, 0x42, 0x24, 0x22, 0x22, 0x22, 0x22, 0x24, 0x41, 0x44, 0x14,
  0x41, 0x44, 0x18, 0x80, 0x88, 0x08, 0x07, 0x01, 0x18, 0x41, 0x10, 0x12,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09,
  0x01, 0x20, 0x42, 0x10, 0x3C, 0x00, 0x1F, 0x84, 0x11, 0x04, 0x41, 0x10,
  0x48, 0x12, 0x08, 0x84, 0x3E, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x07, 0x01, 0x18, 0x41, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x42, 0x10,
  0x34, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x1F, 0x84, 0x11, 0x04, 0x41,
  0x10, 0x48, 0x22, 0x08, 0x84, 0x3E, 0x09, 0x04, 0x41, 0x08, 0x42, 0x10,
  0x88, 0x22, 0x04, 0x07, 0x0C, 0x48, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x08, 0x04, 0xFC, 0x00, 0xFF,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x20, 0x24, 0x04, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90,
  0x12, 0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x02, 0x20, 0x83,
  0xE0, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x08, 0x88, 0x44,
  0x24, 0x12, 0x0A, 0x05, 0x03, 0x00, 0x80, 0x81, 0x03, 0x02, 0x0A, 0x0C,
  0x14, 0x28, 0x48, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44, 0x88, 0x91, 0x21,
  0x22, 0x42, 0x44, 0x85, 0x0A, 0x0A, 0x14, 0x18, 0x30, 0x30, 0x60, 0x40,
  0x80, 0x08, 0x61, 0x08, 0x22, 0x04, 0x40, 0x90, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x40, 0x48, 0x11, 0x02, 0x20, 0x84, 0x20, 0x84, 0x08, 0x81,
  0x82, 0x84, 0x84, 0x48, 0x48, 0x50, 0x50, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x0F, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x07,
  0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x88, 0x44, 0x44,
  0x44, 0x22, 0x22, 0x22, 0x21, 0x0F, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0xF0, 0x0C, 0x0A, 0x04, 0x84, 0x42, 0x22, 0x09, 0x05, 0x01, 0xFE, 0x89,
  0x10, 0x1F, 0x21, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C,
  0x74, 0x08, 0x08, 0x04, 0x02, 0x01, 0x20, 0xE8, 0x42, 0x41, 0x20, 0x90,
  0x50, 0x28, 0x14, 0x0A, 0x09, 0x05, 0x84, 0xBC, 0x00, 0x1E, 0x41, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0xC0, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x0C, 0x84, 0xA2, 0x11, 0x04, 0x41, 0x20, 0x48, 0x12, 0x08, 0x82,
  0x20, 0x88, 0x62, 0x28, 0x74, 0x00, 0x1E, 0x45, 0x0A, 0x18, 0x5F, 0x20,
  0x40, 0x81, 0x02, 0x03, 0xC0, 0x00, 0xE0, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x03, 0xE0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x06, 0x00, 0x0F, 0x44, 0x22, 0x08, 0x82, 0x40, 0x90, 0x24, 0x11, 0x04,
  0x41, 0x10, 0xC4, 0x50, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x88, 0x1C,
  0x00, 0x08, 0x08, 0x04, 0x02, 0x01, 0x20, 0xE8, 0x42, 0x41, 0x20, 0x90,
  0x88, 0x48, 0x24, 0x12, 0x09, 0x09, 0x04, 0x82, 0x00, 0x18, 0x00, 0x01,
  0x10, 0x84, 0x22, 0x10, 0x84, 0x22, 0x10, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x08, 0x04, 0x02, 0x01, 0x08, 0x88,
  0x88, 0x44, 0x24, 0x14, 0x16, 0x0D, 0x04, 0x82, 0x21, 0x11, 0x08, 0x84,
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x80,
  0x2F, 0x78, 0x42, 0x12, 0x08, 0x48, 0x41, 0x21, 0x09, 0x04, 0x24, 0x10,
  0x90, 0x82, 0x42, 0x09, 0x08, 0x48, 0x21, 0x20, 0x84, 0x2F, 0x08, 0x48,
  0x24, 0x12, 0x12, 0x09, 0x04, 0x82, 0x41, 0x21, 0x20, 0x90, 0x40, 0x1E,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x78, 0x0F,
  0x82, 0x11, 0x84, 0x41, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x88, 0x26,
  0x11, 0x78, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x90, 0x90,
  0x48, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x43, 0x21, 0x0F, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x00, 0x2E, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x00, 0x3E, 0x41, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x08, 0x17, 0xC0, 0x21, 0x0B, 0xA4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x43,
  0x80, 0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C,
  0xF4, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA0, 0xC1, 0x02, 0x00,
  0x82, 0x18, 0x62, 0x86, 0x28, 0xA2, 0x8A, 0x49, 0x24, 0x92, 0x8A, 0x28,
  0xA3, 0x0C, 0x30, 0x42, 0x08, 0x20, 0x10, 0x88, 0x84, 0x41, 0x40, 0xC0,
  0x40, 0x20, 0x28, 0x24, 0x12, 0x10, 0x90, 0x40, 0x08, 0x10, 0x42, 0x04,
  0x20, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x0E, 0x00, 0x1F,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x07,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x0C, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x04, 0x30, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x86, 0x00, 0x78, 0xC3, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 5, 6, 6, 2, -16 },
  { 15, 10, 16, 10, 0, -16 },
  { 35, 9, 18, 9, 0, -17 },
  { 56, 12, 17, 14, 1, -17 },
  { 82, 9, 17, 10, 0, -17 },
  { 102, 2, 6, 4, 2, -16 },
  { 104, 6, 20, 6, 1, -16 },
  { 119, 7, 20, 6, -2, -16 },
  { 137, 7, 7, 9, 3, -17 },
  { 144, 9, 10, 10, 1, -13 },
  { 156, 3, 5, 4, -1, -2 },
  { 158, 5, 1, 6, 1, -7 },
  { 159, 2, 1, 4, 0, -1 },
  { 160, 9, 16, 7, -1, -16 },
  { 178, 8, 17, 9, 1, -17 },
  { 195, 4, 16, 9, 3, -16 },
  { 203, 10, 17, 9, -1, -17 },
  { 225, 9, 17, 9, 0, -17 },
  { 245, 9, 17, 9, 0, -17 },
  { 265, 9, 16, 9, 0, -16 },
  { 283, 9, 17, 9, 1, -17 },
  { 303, 9, 16, 9, 1, -16 },
  { 321, 9, 17, 9, 0, -17 },
  { 341, 9, 17, 9, 0, -17 },
  { 361, 4, 12, 4, 0, -12 },
  { 367, 5, 15, 4, -1, -12 },
  { 377, 9, 10, 10, 1, -13 },
  { 389, 9, 6, 10, 1, -11 },
  { 396, 9, 10, 10, 1, -13 },
  { 408, 6, 17, 7, 1, -17 },
  { 421, 12, 18, 14, 1, -16 },
  { 448, 9, 16, 9, -1, -16 },
  { 466, 10, 16, 10, 0, -16 },
  { 486, 10, 17, 10, 1, -17 },
  { 508, 11, 16, 11, 0, -16 },
  { 530, 10, 16, 9, 0, -16 },
  { 550, 10, 16, 8, 0, -16 },
  { 570, 11, 17, 12, 1, -17 },
  { 594, 12, 16, 12, 0, -16 },
  { 618, 7, 16, 5, -1, -16 },
  { 632, 7, 20, 4, -3, -16 },
  { 650, 11, 16, 9, 0, -16 },
  { 672, 6, 16, 8, 0, -16 },
  { 684, 15, 16, 15, 0, -16 },
  { 714, 12, 16, 12, 0, -16 },
  { 738, 11, 17, 12, 1, -17 },
  { 762, 10, 16, 10, 0, -16 },
  { 782, 11, 21, 12, 1, -17 },
  { 811, 10, 16, 10, 0, -16 },
  { 831, 9, 17, 9, 0, -17 },
  { 851, 8, 16, 8, 2, -16 },
  { 867, 11, 16, 12, 1, -16 },
  { 889, 9, 16, 9, 2, -16 },
  { 907, 15, 16, 15, 2, -16 },
  { 937, 11, 16, 8, -1, -16 },
  { 959, 8, 16, 8, 2, -16 },
  { 975, 11, 16, 9, -1, -16 },
  { 997, 8, 20, 7, 0, -16 },
  { 1017, 4, 16, 7, 2, -16 },
  { 1025, 8, 20, 7, -1, -16 },
  { 1045, 9, 8, 10, 1, -16 },
  { 1054, 7, 1, 7, -2, 2 },
  { 1055, 3, 4, 5, 3, -18 },
  { 1057, 8, 12, 10, 1, -12 },
  { 1069, 9, 17, 10, 0, -17 },
  { 1089, 7, 12, 7, 1, -12 },
  { 1100, 10, 17, 10, 1, -17 },
  { 1122, 7, 12, 9, 1, -12 },
  { 1133, 11, 24, 5, -3, -18 },
  { 1166, 10, 18, 10, 0, -12 },
  { 1189, 9, 17, 10, 0, -17 },
  { 1209, 5, 16, 4, 0, -16 },
  { 1219, 8, 22, 4, -3, -16 },
  { 1241, 9, 17, 8, 0, -17 },
  { 1261, 5, 17, 4, 0, -17 },
  { 1272, 14, 12, 15, 0, -12 },
  { 1293, 9, 12, 10, 0, -12 },
  { 1307, 8, 12, 10, 1, -12 },
  { 1319, 10, 17, 10, -1, -12 },
  { 1341, 9, 17, 10, 1, -12 },
  { 1361, 7, 12, 6, 0, -12 },
  { 1372, 7, 12, 7, 0, -12 },
  { 1383, 5, 15, 5, 1, -15 },
  { 1393, 8, 12, 10, 1, -12 },
  { 1405, 7, 12, 7, 1, -12 },
  { 1416, 12, 12, 12, 1, -12 },
  { 1434, 9, 12, 8, -1, -12 },
  { 1448, 12, 18, 8, -3, -12 },
  { 1475, 8, 12, 7, -1, -12 },
  { 1487, 8, 20, 7, 1, -16 },
  { 1507, 1, 24, 9, 4, -18 },
  { 1510, 7, 20, 7, -1, -16 },
  { 1528, 9, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_THINITALIC23PT7B_H_
