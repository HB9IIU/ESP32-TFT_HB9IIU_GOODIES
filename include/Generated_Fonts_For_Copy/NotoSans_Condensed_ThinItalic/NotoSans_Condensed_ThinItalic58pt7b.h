#ifndef _NOTOSANS_CONDENSED_THINITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x10, 0x26,
  0x0C, 0xC1, 0x90, 0x32, 0x04, 0x40, 0x98, 0x32, 0x06, 0x40, 0x88, 0x11,
  0x02, 0x60, 0xC8, 0x11, 0x02, 0x20, 0x40, 0x00, 0x06, 0x03, 0x00, 0x02,
  0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x40, 0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x08, 0x00,
  0x18, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x20, 0x10, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01,
  0x80, 0x01, 0x00, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x80, 0x60, 0x00, 0x40,
  0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x08, 0x00, 0x18,
  0x04, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x00, 0x02, 0x01, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x39,
  0x9F, 0x00, 0xE1, 0x82, 0x01, 0x81, 0x00, 0x01, 0x81, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02,
  0x00, 0x02, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x01, 0x84,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x20, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0xC1,
  0x80, 0xE0, 0xC7, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x03, 0x01, 0x82, 0x00, 0x30,
  0x18, 0x18, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x0C, 0x06, 0x00, 0x80, 0x60,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x01, 0x00, 0x60,
  0x20, 0x08, 0x03, 0x03, 0x00, 0xC0, 0x18, 0x30, 0x06, 0x00, 0x81, 0x00,
  0x30, 0x04, 0x18, 0x01, 0x00, 0x60, 0x80, 0x08, 0x03, 0x0C, 0x00, 0x40,
  0x10, 0x40, 0x06, 0x01, 0x86, 0x1F, 0x30, 0x0C, 0x61, 0x8D, 0x80, 0x42,
  0x18, 0x2C, 0x06, 0x31, 0x81, 0xA0, 0x21, 0x18, 0x0D, 0x03, 0x18, 0xC0,
  0x6C, 0x30, 0x84, 0x03, 0x3F, 0x0C, 0x60, 0x18, 0xF0, 0xC2, 0x00, 0xC0,
  0x06, 0x10, 0x06, 0x00, 0x61, 0x80, 0x20, 0x02, 0x0C, 0x01, 0x00, 0x30,
  0x40, 0x08, 0x01, 0x02, 0x00, 0xC0, 0x18, 0x10, 0x06, 0x01, 0x81, 0x80,
  0x20, 0x0C, 0x0C, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x0C, 0x02, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x06, 0x01, 0x00,
  0x10, 0x20, 0x18, 0x00, 0xC3, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x80,
  0x80, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x10, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x10, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x10, 0x30, 0x00, 0x20, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0xE6, 0x00, 0x03, 0x86, 0x00, 0x0C, 0x0C,
  0x02, 0x10, 0x08, 0x0C, 0x60, 0x18, 0x19, 0x80, 0x30, 0x22, 0x00, 0x20,
  0xCC, 0x00, 0x61, 0x18, 0x00, 0x46, 0x20, 0x00, 0xC8, 0xC0, 0x01, 0xB1,
  0x80, 0x01, 0x43, 0x00, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x08,
  0x00, 0x2C, 0x18, 0x00, 0xC8, 0x30, 0x07, 0x18, 0x38, 0x18, 0x10, 0x3F,
  0xE0, 0x30, 0x04, 0x00, 0x00, 0x13, 0x32, 0x22, 0x64, 0x44, 0x4C, 0x88,
  0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x08,
  0x04, 0x07, 0x06, 0x00, 0xC2, 0x00, 0x19, 0x01, 0x02, 0x9F, 0x80, 0xF0,
  0x00, 0xE0, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0xC1, 0x00, 0xC0, 0x80, 0x80,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x0C, 0x30,
  0x60, 0x83, 0x06, 0x08, 0x30, 0x41, 0x82, 0x08, 0x00, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xEF, 0x00, 0x18, 0x18,
  0x01, 0x80, 0x60, 0x18, 0x01, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x00, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x04, 0x40, 0x00, 0x66, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x02, 0x10, 0x00, 0x30, 0x80, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x20, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x06,
  0x00, 0x30, 0x60, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x78,
  0x1B, 0x06, 0x63, 0x88, 0xC1, 0x30, 0x64, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0xF0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x78, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x80, 0x03, 0x00,
  0xE0, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08,
  0x00, 0x0C, 0x08, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10,
  0x00, 0x20, 0x10, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x30,
  0x01, 0x80, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x30, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x1F, 0xFE, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x20, 0x01, 0x80, 0x60, 0x0E, 0x00, 0x7F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3E, 0x70, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC3, 0xF8, 0x03, 0x38, 0x70, 0x09, 0x80, 0x60, 0x6C,
  0x00, 0xC1, 0xE0, 0x01, 0x07, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0x40, 0x01, 0x01, 0x00, 0x0C,
  0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x38, 0x38, 0x00, 0x3F, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x06, 0x01,
  0x80, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x02, 0x03, 0x00, 0x02, 0x03, 0x00, 0x06, 0x01, 0x00, 0x06, 0x01,
  0x00, 0x0C, 0x01, 0x80, 0x08, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE6, 0x00, 0x01, 0x83, 0x00, 0x07, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0x40, 0x30, 0x00, 0x60, 0x20, 0x00, 0x20, 0x60, 0x00, 0x20, 0x40,
  0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x60,
  0x00, 0x40, 0x20, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF7, 0x80, 0x0E,
  0x03, 0x00, 0x60, 0x04, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x60, 0x00,
  0x81, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC2,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0E,
  0x18, 0x00, 0x38, 0x20, 0x01, 0x40, 0xC0, 0x0D, 0x01, 0x80, 0xEC, 0x03,
  0xFE, 0x30, 0x03, 0xE0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x80, 0xC0, 0x03, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x03, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0xC0, 0xC0, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xDE, 0x02, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x38, 0x03, 0x0C, 0x00, 0xFF, 0x03,
  0x08, 0x03, 0x83, 0x03, 0x18, 0x06, 0x02, 0x03, 0x10, 0x04, 0x02, 0x03,
  0x30, 0x0C, 0x06, 0x03, 0x30, 0x18, 0x06, 0x03, 0x20, 0x10, 0x04, 0x03,
  0x20, 0x30, 0x04, 0x02, 0x60, 0x20, 0x0C, 0x02, 0x60, 0x60, 0x0C, 0x06,
  0x40, 0x60, 0x08, 0x06, 0x40, 0x40, 0x18, 0x06, 0xC0, 0x40, 0x18, 0x04,
  0xC0, 0xC0, 0x18, 0x0C, 0xC0, 0xC0, 0x30, 0x0C, 0xC0, 0xC0, 0x30, 0x18,
  0xC0, 0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x50, 0x30, 0xC0, 0xC0, 0xD0, 0x30,
  0xC0, 0x40, 0x90, 0x60, 0xC0, 0x61, 0x98, 0xC0, 0xC0, 0x3F, 0x0F, 0x80,
  0xC0, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x20, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x13, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x0C,
  0x04, 0x00, 0x10, 0x08, 0x00, 0x60, 0x10, 0x00, 0x80, 0x20, 0x03, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x10, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80,
  0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0x01, 0x03, 0x00, 0x01, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x70, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0C, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x08, 0x00, 0x30, 0x08, 0x00,
  0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x40, 0x07, 0x00, 0xC0, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x07,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x30,
  0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x80, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x20, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x20, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x03, 0x00, 0x40, 0x01, 0x80, 0x10, 0x01, 0xC0, 0x04, 0x00,
  0xE0, 0x03, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08,
  0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x0F,
  0x00, 0x70, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x20, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x20, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x04, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x04, 0x01, 0x00, 0x00, 0x20, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0x40, 0x01, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0x20, 0x18,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x8E, 0x00, 0x00, 0x11, 0xC0, 0x00, 0x06, 0x78, 0x00, 0x00, 0xD9,
  0x00, 0x00, 0x1E, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x03,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x1E, 0x01, 0x40, 0x00, 0x00, 0xF0, 0x0A, 0x00,
  0x00, 0x0D, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x36, 0x00, 0x00, 0x26, 0x01, 0x30, 0x00, 0x03, 0x20, 0x09, 0x80, 0x00,
  0x11, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x06, 0x20, 0x00, 0x08, 0xC0, 0x31,
  0x00, 0x00, 0xC6, 0x01, 0x08, 0x00, 0x04, 0x20, 0x08, 0x40, 0x00, 0x61,
  0x00, 0xC2, 0x00, 0x02, 0x18, 0x06, 0x10, 0x00, 0x30, 0xC0, 0x30, 0xC0,
  0x01, 0x06, 0x01, 0x06, 0x00, 0x18, 0x20, 0x18, 0x30, 0x00, 0x81, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x20, 0x20, 0x06,
  0x04, 0x01, 0x01, 0x00, 0x20, 0x20, 0x18, 0x08, 0x03, 0x01, 0x00, 0xC0,
  0x40, 0x10, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x01, 0x00, 0xC0, 0xC0, 0x20, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x60, 0x18, 0x06, 0x01, 0x86, 0x00, 0xC0, 0x20, 0x0C, 0x30, 0x04, 0x01,
  0x00, 0x23, 0x00, 0x20, 0x18, 0x01, 0x18, 0x03, 0x00, 0xC0, 0x09, 0x80,
  0x18, 0x04, 0x00, 0x4C, 0x00, 0x80, 0x20, 0x02, 0xC0, 0x04, 0x03, 0x00,
  0x14, 0x00, 0x20, 0x18, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x80, 0x28, 0x00, 0x02, 0x00, 0xB0, 0x00, 0x18, 0x06, 0xC0, 0x00, 0x60,
  0x19, 0x00, 0x01, 0x00, 0x64, 0x00, 0x04, 0x01, 0x18, 0x00, 0x30, 0x04,
  0x60, 0x00, 0xC0, 0x30, 0x80, 0x03, 0x00, 0xC2, 0x00, 0x08, 0x03, 0x0C,
  0x00, 0x20, 0x08, 0x30, 0x01, 0x80, 0x20, 0x40, 0x06, 0x01, 0x81, 0x80,
  0x18, 0x06, 0x06, 0x00, 0x40, 0x10, 0x18, 0x01, 0x00, 0x40, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x10, 0x18, 0x02, 0x00, 0x60, 0x60, 0x18, 0x01, 0x81, 0x80, 0x60,
  0x02, 0x04, 0x01, 0x80, 0x08, 0x10, 0x04, 0x00, 0x30, 0xC0, 0x10, 0x00,
  0xC3, 0x00, 0xC0, 0x01, 0x0C, 0x03, 0x00, 0x04, 0x20, 0x0C, 0x00, 0x18,
  0x80, 0x20, 0x00, 0x66, 0x00, 0x80, 0x00, 0x98, 0x06, 0x00, 0x02, 0x40,
  0x18, 0x00, 0x0D, 0x00, 0x40, 0x00, 0x34, 0x01, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x08, 0x08, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xC0,
  0x78, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x06, 0x01, 0x80,
  0x02, 0x01, 0x80, 0x02, 0x01, 0x80, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x04, 0x00,
  0x18, 0x04, 0x00, 0x18, 0x04, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x0C, 0x0F,
  0x80, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x08, 0x08, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0x80, 0xF0, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x08,
  0x00, 0x60, 0x30, 0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x00,
  0x02, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x30, 0x00,
  0x60, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x20, 0x03, 0x00, 0xC0, 0x3C, 0x01,
  0xFF, 0xE0, 0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x04, 0x00, 0x30,
  0x08, 0x00, 0x60, 0x18, 0x00, 0x80, 0x30, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x03, 0x00, 0x40, 0x02,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x20, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x9F, 0x80, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x04, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x26, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x88, 0x00, 0x06, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x03,
  0x02, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10, 0x00, 0xC0,
  0x20, 0x01, 0x00, 0x40, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x03, 0x00, 0x18, 0x04, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x23, 0x00, 0x00, 0x44, 0x00, 0x00, 0x98, 0x00, 0x01, 0x20, 0x00,
  0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01,
  0xA0, 0x00, 0x38, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0xC8, 0x00, 0x1A,
  0x00, 0x06, 0x40, 0x00, 0xD0, 0x00, 0x22, 0x00, 0x04, 0x80, 0x03, 0x10,
  0x00, 0x64, 0x00, 0x10, 0x80, 0x02, 0x20, 0x01, 0x84, 0x00, 0x31, 0x00,
  0x0C, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x18, 0x40, 0x06, 0x08, 0x00,
  0xC2, 0x00, 0x20, 0x40, 0x04, 0x10, 0x03, 0x02, 0x00, 0x60, 0x80, 0x10,
  0x10, 0x02, 0x04, 0x01, 0x80, 0x80, 0x30, 0x20, 0x0C, 0x04, 0x01, 0x83,
  0x00, 0x40, 0x20, 0x08, 0x18, 0x06, 0x01, 0x00, 0xC0, 0xC0, 0x20, 0x08,
  0x04, 0x06, 0x03, 0x00, 0x40, 0x60, 0x30, 0x18, 0x02, 0x02, 0x01, 0x80,
  0x80, 0x10, 0x30, 0x0C, 0x0C, 0x00, 0x81, 0x80, 0x60, 0x40, 0x04, 0x08,
  0x03, 0x06, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x01, 0x04, 0x00, 0xC3, 0x00,
  0x08, 0x60, 0x06, 0x18, 0x00, 0x43, 0x00, 0x30, 0x80, 0x02, 0x10, 0x01,
  0x8C, 0x00, 0x11, 0x80, 0x0C, 0x40, 0x00, 0x88, 0x00, 0x66, 0x00, 0x04,
  0xC0, 0x03, 0x30, 0x00, 0x24, 0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0xD8,
  0x00, 0x0B, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x08, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00,
  0x0C, 0x00, 0x40, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x44, 0x00, 0x0C, 0x40,
  0x00, 0x84, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x02,
  0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x18, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x06, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x98, 0x00, 0x1B, 0x00, 0x01, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x07,
  0xFE, 0x00, 0x00, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60,
  0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18,
  0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06,
  0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x23, 0x00, 0x01, 0x84,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x80, 0x80, 0x04, 0x03, 0x00,
  0x30, 0x04, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x30, 0x00, 0x80, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x00,
  0x98, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0x80, 0xC1, 0x82, 0x0C,
  0x10, 0x60, 0x83, 0x04, 0x00, 0x3F, 0x04, 0x03, 0xCE, 0x30, 0x18, 0x0C,
  0x80, 0xC0, 0x1A, 0x06, 0x00, 0x28, 0x10, 0x00, 0xE0, 0xC0, 0x03, 0x86,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x20, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x06, 0x10, 0x00, 0x18,
  0x40, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03,
  0x83, 0x00, 0x1E, 0x04, 0x00, 0x50, 0x18, 0x03, 0x40, 0x60, 0x19, 0x00,
  0xC1, 0xCC, 0x01, 0xFE, 0x30, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x3F, 0x00, 0x33,
  0xCF, 0x00, 0x9C, 0x0C, 0x02, 0xC0, 0x18, 0x1A, 0x00, 0x20, 0x78, 0x00,
  0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x08, 0x60,
  0x00, 0x61, 0xC0, 0x01, 0x07, 0x00, 0x0C, 0x14, 0x00, 0x60, 0x50, 0x03,
  0x03, 0x60, 0x1C, 0x08, 0xC0, 0xC0, 0x21, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x3C, 0x70, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x02, 0x00, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x01, 0xF8, 0x20, 0x03, 0xCF, 0x30, 0x03,
  0x00, 0x98, 0x03, 0x00, 0x6C, 0x03, 0x00, 0x14, 0x01, 0x00, 0x0E, 0x01,
  0x80, 0x07, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x40, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x0C, 0x00, 0x04, 0x04, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x1A, 0x00, 0x80, 0x0F, 0x00, 0x60, 0x0D, 0x80, 0x30, 0x0C, 0x80, 0x0C,
  0x1C, 0x40, 0x03, 0xFC, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x1E, 0x70, 0x06, 0x03, 0x01, 0x80, 0x20, 0x60, 0x04, 0x08, 0x00, 0xC3,
  0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x10,
  0x01, 0x86, 0x00, 0x60, 0xC0, 0x38, 0x18, 0x3C, 0x03, 0xFE, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x30, 0x18, 0x03, 0xFE, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0x00, 0x3C, 0xF1, 0x00,
  0x60, 0x13, 0x00, 0xC0, 0x1B, 0x01, 0x80, 0x0A, 0x01, 0x00, 0x0E, 0x03,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x04, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18,
  0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30,
  0x00, 0x70, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x01, 0xA0, 0x10,
  0x01, 0xE0, 0x18, 0x03, 0x60, 0x18, 0x06, 0x40, 0x0C, 0x1C, 0x40, 0x07,
  0xF8, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x80,
  0x18, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x87, 0xE0, 0x0C, 0xF3, 0xC0,
  0x4C, 0x06, 0x02, 0xC0, 0x18, 0x3C, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00,
  0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x02, 0x0C,
  0x00, 0x30, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x02,
  0x08, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00, 0x41, 0x80,
  0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00, 0x41,
  0x80, 0x06, 0x08, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00,
  0x41, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x40, 0x0C, 0x02, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x40, 0x08, 0x06, 0x00, 0x40, 0x60, 0x02, 0x06, 0x00,
  0x30, 0x60, 0x01, 0x86, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x06, 0x38,
  0x00, 0x33, 0xC0, 0x01, 0xB6, 0x00, 0x0B, 0x10, 0x00, 0x70, 0xC0, 0x07,
  0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0x80, 0x08, 0x06, 0x00, 0x40, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0xC0,
  0x04, 0x06, 0x00, 0x20, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x00, 0x03,
  0x0F, 0x80, 0x7E, 0x00, 0x8E, 0x38, 0x71, 0xC0, 0x26, 0x06, 0x30, 0x18,
  0x0B, 0x00, 0xD8, 0x02, 0x07, 0x80, 0x3C, 0x00, 0x81, 0xC0, 0x0E, 0x00,
  0x30, 0x60, 0x03, 0x80, 0x08, 0x18, 0x00, 0xC0, 0x02, 0x06, 0x00, 0x30,
  0x00, 0x83, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x00, 0x18, 0x30, 0x00,
  0x80, 0x06, 0x08, 0x00, 0x60, 0x01, 0x06, 0x00, 0x18, 0x00, 0x41, 0x80,
  0x04, 0x00, 0x30, 0x60, 0x01, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0x02, 0x04,
  0x00, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x00, 0x18,
  0x30, 0x00, 0x80, 0x06, 0x08, 0x00, 0x60, 0x01, 0x02, 0x00, 0x18, 0x00,
  0x41, 0x80, 0x04, 0x00, 0x30, 0x60, 0x01, 0x00, 0x0C, 0x18, 0x00, 0x40,
  0x03, 0x04, 0x00, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x00, 0x20, 0xC0, 0x02,
  0x00, 0x18, 0x30, 0x00, 0x80, 0x06, 0x08, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x0F, 0xC0, 0x11, 0xE7, 0x80, 0x98, 0x0C, 0x05, 0x80, 0x30, 0x78, 0x01,
  0x83, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60,
  0x00, 0x83, 0x00, 0x04, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00,
  0x10, 0x60, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x03, 0x0C,
  0x00, 0x10, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x03,
  0x0C, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0x3C, 0x01, 0x80, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x30, 0x40, 0x03,
  0x0C, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x13, 0x00, 0x01, 0x30, 0x00,
  0x13, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C,
  0x00, 0x10, 0x40, 0x03, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x83, 0x80,
  0x1F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x61, 0xF8, 0x00, 0x21, 0xCF, 0x00,
  0x13, 0x81, 0x80, 0x0B, 0x00, 0x60, 0x0D, 0x80, 0x10, 0x07, 0x80, 0x0C,
  0x02, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x10, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x08, 0x07,
  0x00, 0x0C, 0x02, 0x80, 0x0C, 0x01, 0x40, 0x0C, 0x01, 0xB0, 0x0C, 0x00,
  0xCC, 0x0C, 0x00, 0x63, 0xFC, 0x00, 0x20, 0x60, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x04, 0x03, 0xCF, 0x10, 0x18, 0x0C, 0xC0, 0xC0, 0x1B, 0x06, 0x00,
  0x28, 0x10, 0x00, 0xE0, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x18,
  0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80,
  0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x1A, 0x04, 0x00,
  0x78, 0x18, 0x03, 0x60, 0x60, 0x19, 0x00, 0xC1, 0xC4, 0x01, 0xFE, 0x30,
  0x01, 0x80, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x02, 0x0F, 0x81, 0x1E, 0x40, 0x98, 0x00, 0x58, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x78, 0xF0, 0x30, 0x04, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x80, 0x18, 0x30, 0x1C, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0xFF, 0x7F, 0xF0, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0F, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x08, 0x20,
  0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18,
  0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00,
  0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x04,
  0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x03,
  0x04, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x07, 0x06, 0x00, 0x38, 0x30, 0x03, 0xC1, 0x80, 0x34, 0x0C, 0x03, 0x20,
  0x30, 0x31, 0x00, 0xFF, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x61,
  0x00, 0x18, 0x40, 0x0C, 0x10, 0x03, 0x04, 0x01, 0x81, 0x00, 0x60, 0x40,
  0x10, 0x10, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x40, 0x40, 0x18, 0x30,
  0x06, 0x08, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01,
  0x98, 0x00, 0x64, 0x00, 0x1B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0A, 0x00, 0x18,
  0x00, 0xD0, 0x00, 0xC0, 0x06, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x50, 0x03,
  0x20, 0x06, 0x80, 0x11, 0x00, 0x24, 0x01, 0x88, 0x03, 0x20, 0x08, 0x40,
  0x11, 0x00, 0xC2, 0x01, 0x88, 0x06, 0x10, 0x08, 0x40, 0x20, 0x80, 0x42,
  0x03, 0x04, 0x06, 0x10, 0x10, 0x20, 0x20, 0x81, 0x81, 0x03, 0x04, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0x41, 0x81, 0x06, 0x02, 0x08, 0x08, 0x20, 0x10,
  0xC0, 0x43, 0x00, 0x86, 0x02, 0x10, 0x04, 0x20, 0x10, 0x80, 0x23, 0x00,
  0x8C, 0x01, 0x10, 0x04, 0x40, 0x09, 0x80, 0x26, 0x00, 0x48, 0x01, 0x20,
  0x02, 0xC0, 0x0B, 0x00, 0x14, 0x00, 0x58, 0x00, 0xA0, 0x02, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x08,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x20, 0x60, 0x00, 0x40,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x20, 0x00, 0x04, 0x60, 0x00, 0x18, 0x40, 0x00,
  0x60, 0x80, 0x00, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x10,
  0x04, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x10, 0x08, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x18, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xFE,
  0x00, 0x70, 0x1C, 0x07, 0x00, 0x3F, 0xE8, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 41, 12, 1, -41 },
  { 58, 11, 15, 16, 6, -41 },
  { 79, 25, 41, 26, 1, -41 },
  { 208, 24, 47, 23, 0, -44 },
  { 349, 29, 43, 34, 3, -42 },
  { 505, 23, 43, 25, 0, -42 },
  { 629, 4, 15, 9, 6, -41 },
  { 637, 15, 50, 14, 2, -41 },
  { 731, 16, 50, 14, -4, -41 },
  { 831, 17, 18, 22, 7, -44 },
  { 870, 22, 27, 26, 2, -34 },
  { 945, 7, 13, 10, -2, -6 },
  { 957, 12, 1, 16, 2, -16 },
  { 959, 3, 4, 10, 1, -4 },
  { 961, 24, 41, 17, -3, -41 },
  { 1084, 21, 43, 23, 2, -42 },
  { 1197, 11, 41, 23, 8, -41 },
  { 1254, 24, 42, 23, -1, -42 },
  { 1380, 24, 43, 23, -1, -42 },
  { 1509, 24, 42, 23, -1, -42 },
  { 1635, 23, 42, 23, 0, -41 },
  { 1756, 22, 43, 23, 2, -42 },
  { 1875, 22, 41, 23, 3, -41 },
  { 1988, 24, 43, 23, 0, -42 },
  { 2117, 22, 43, 23, 1, -42 },
  { 2236, 8, 31, 10, 1, -31 },
  { 2267, 12, 38, 10, -3, -31 },
  { 2324, 22, 25, 26, 2, -33 },
  { 2393, 22, 13, 26, 2, -27 },
  { 2429, 22, 25, 26, 2, -33 },
  { 2498, 17, 42, 17, 2, -42 },
  { 2588, 32, 46, 35, 2, -41 },
  { 2772, 23, 42, 23, -4, -42 },
  { 2893, 24, 41, 26, 1, -41 },
  { 3016, 25, 43, 24, 3, -42 },
  { 3151, 26, 41, 28, 1, -41 },
  { 3285, 24, 41, 23, 1, -41 },
  { 3408, 24, 41, 21, 1, -41 },
  { 3531, 28, 43, 30, 3, -42 },
  { 3682, 29, 41, 30, 1, -41 },
  { 3831, 17, 41, 12, -2, -41 },
  { 3919, 20, 51, 10, -9, -41 },
  { 4047, 27, 41, 23, 1, -41 },
  { 4186, 15, 41, 21, 1, -41 },
  { 4263, 37, 41, 38, 1, -41 },
  { 4453, 30, 41, 30, 1, -41 },
  { 4607, 26, 43, 31, 3, -42 },
  { 4747, 24, 41, 24, 1, -41 },
  { 4870, 26, 52, 31, 3, -42 },
  { 5039, 23, 41, 24, 1, -41 },
  { 5157, 25, 43, 23, -1, -42 },
  { 5292, 20, 41, 20, 5, -41 },
  { 5395, 27, 42, 29, 3, -41 },
  { 5537, 23, 41, 23, 5, -41 },
  { 5655, 37, 41, 39, 6, -41 },
  { 5845, 28, 41, 21, -3, -41 },
  { 5989, 20, 41, 20, 5, -41 },
  { 6092, 27, 41, 22, -2, -41 },
  { 6231, 21, 50, 16, -1, -41 },
  { 6363, 8, 41, 18, 6, -41 },
  { 6404, 21, 50, 16, -4, -41 },
  { 6536, 22, 21, 25, 2, -41 },
  { 6594, 17, 1, 17, -5, 6 },
  { 6597, 6, 9, 12, 8, -44 },
  { 6604, 22, 32, 25, 2, -31 },
  { 6692, 22, 45, 25, 1, -44 },
  { 6816, 18, 32, 19, 2, -31 },
  { 6888, 25, 45, 25, 2, -44 },
  { 7029, 19, 32, 22, 2, -31 },
  { 7105, 27, 58, 12, -8, -44 },
  { 7301, 24, 45, 25, 0, -31 },
  { 7436, 21, 44, 24, 1, -44 },
  { 7552, 10, 41, 10, 1, -41 },
  { 7604, 20, 55, 10, -8, -41 },
  { 7742, 21, 44, 20, 1, -44 },
  { 7858, 11, 44, 10, 1, -44 },
  { 7919, 34, 31, 37, 1, -31 },
  { 8051, 21, 31, 24, 1, -31 },
  { 8133, 20, 32, 24, 2, -31 },
  { 8213, 25, 44, 25, -2, -31 },
  { 8351, 22, 45, 25, 2, -31 },
  { 8475, 17, 31, 16, 1, -31 },
  { 8541, 18, 32, 19, 0, -31 },
  { 8613, 12, 39, 13, 2, -38 },
  { 8672, 21, 32, 24, 2, -31 },
  { 8756, 18, 31, 18, 3, -31 },
  { 8826, 29, 31, 30, 3, -31 },
  { 8939, 23, 31, 19, -2, -31 },
  { 9029, 29, 45, 19, -7, -31 },
  { 9193, 20, 31, 17, -2, -31 },
  { 9271, 20, 50, 18, 2, -41 },
  { 9396, 2, 58, 23, 11, -44 },
  { 9411, 20, 50, 18, -4, -41 },
  { 9536, 21, 5, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_THINITALIC58PT7B_H_
