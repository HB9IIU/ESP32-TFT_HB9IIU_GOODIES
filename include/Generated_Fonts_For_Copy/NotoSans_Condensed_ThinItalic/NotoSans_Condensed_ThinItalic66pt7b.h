#ifndef _NOTOSANS_CONDENSED_THINITALIC66PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0x00, 0x70, 0x01, 0x80, 0x00, 0x18, 0x18, 0x80, 0x8C, 0x0C, 0x60,
  0x63, 0x03, 0x10, 0x18, 0x80, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x10,
  0x80, 0x8C, 0x0C, 0x60, 0x62, 0x02, 0x10, 0x10, 0x80, 0x80, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x01,
  0x00, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x04, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x02,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x04,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x08,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xE3, 0x0F, 0x00, 0xE0, 0xC0, 0x80, 0x70, 0x30, 0x00, 0x18, 0x08,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20,
  0x10, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x34, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x80, 0x00,
  0x02, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x04, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x01, 0x03, 0x00,
  0x80, 0xC3, 0x80, 0x3F, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0C, 0x03, 0x0C, 0x00, 0x08, 0x06, 0x06, 0x00,
  0x18, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x02, 0x00, 0x30, 0x18, 0x02, 0x00,
  0x60, 0x18, 0x02, 0x00, 0x60, 0x30, 0x02, 0x00, 0xC0, 0x30, 0x02, 0x00,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x60, 0x06, 0x03,
  0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x06, 0x06, 0x00, 0x40, 0x04, 0x0C,
  0x00, 0xC0, 0x0C, 0x08, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x0C, 0x10,
  0x00, 0xC0, 0x08, 0x30, 0x38, 0xC0, 0x18, 0x60, 0xFE, 0xC0, 0x18, 0x61,
  0x86, 0xC0, 0x30, 0xC3, 0x03, 0xC0, 0x30, 0xC6, 0x03, 0xC0, 0x21, 0x84,
  0x03, 0xC0, 0x61, 0x0C, 0x03, 0xC0, 0xC3, 0x08, 0x03, 0x61, 0x86, 0x18,
  0x03, 0x3F, 0x06, 0x18, 0x03, 0x1C, 0x0C, 0x10, 0x03, 0x00, 0x0C, 0x30,
  0x03, 0x00, 0x18, 0x30, 0x03, 0x00, 0x10, 0x30, 0x03, 0x00, 0x30, 0x20,
  0x02, 0x00, 0x60, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00, 0xC0, 0x60,
  0x06, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x40,
  0x0C, 0x03, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x40, 0x18, 0x06, 0x00, 0x40,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x18, 0x00, 0x60,
  0x60, 0x18, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x10, 0x00, 0x30, 0x02, 0x00, 0x04, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x07, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0x81, 0x80, 0x10,
  0x60, 0x30, 0x04, 0x18, 0x02, 0x01, 0x86, 0x00, 0x60, 0x30, 0xC0, 0x0C,
  0x04, 0x30, 0x00, 0xC1, 0x84, 0x00, 0x18, 0x31, 0x80, 0x01, 0x0C, 0x30,
  0x00, 0x31, 0x86, 0x00, 0x06, 0x60, 0x80, 0x00, 0x6C, 0x30, 0x00, 0x0F,
  0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x01, 0x80,
  0x01, 0xA0, 0x30, 0x00, 0x66, 0x06, 0x00, 0x18, 0xC0, 0x60, 0x06, 0x0C,
  0x07, 0x03, 0x81, 0x80, 0x7F, 0xE0, 0x10, 0x03, 0xC0, 0x01, 0x00, 0x18,
  0x8C, 0x63, 0x10, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x10, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x01, 0x80, 0x40, 0x18, 0x08, 0x00, 0xC3, 0x00, 0x0E,
  0x40, 0x20, 0x68, 0xFC, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x12, 0x00, 0x0C,
  0x40, 0x03, 0x04, 0x00, 0xC0, 0x80, 0x30, 0x08, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x67, 0xE6,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x1C,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x10, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x20, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x38, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xB0, 0x72,
  0x0E, 0x61, 0x86, 0x70, 0x6E, 0x04, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01, 0x80, 0x08,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x10,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xC8, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x33, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x78,
  0x08, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x7C, 0x00, 0x10, 0xFF, 0xC0, 0x04,
  0x70, 0x38, 0x03, 0x30, 0x03, 0x00, 0xD8, 0x00, 0x60, 0x2C, 0x00, 0x18,
  0x0E, 0x00, 0x02, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40,
  0x00, 0x0C, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x10, 0x06, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x04, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x38, 0x00, 0x30, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x38,
  0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x0E, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x38, 0x20, 0x00, 0x1C, 0x18, 0x00, 0x1E, 0x0C,
  0x00, 0x1A, 0x03, 0x00, 0x19, 0x01, 0xC0, 0x1D, 0x80, 0x70, 0x38, 0xC0,
  0x1F, 0xF8, 0x40, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x02, 0x03, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x3C, 0x0E, 0x02, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x01, 0x83, 0x00, 0x03, 0xC0, 0x0C, 0x18, 0x00, 0xFF,
  0xC0, 0x61, 0x80, 0x0E, 0x0C, 0x03, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x60,
  0x0C, 0x03, 0x00, 0xC6, 0x00, 0xC0, 0x10, 0x06, 0x30, 0x0C, 0x01, 0x80,
  0x21, 0x00, 0x60, 0x0C, 0x01, 0x18, 0x06, 0x00, 0x60, 0x18, 0xC0, 0x30,
  0x02, 0x00, 0xC6, 0x03, 0x00, 0x30, 0x06, 0x20, 0x18, 0x01, 0x80, 0x33,
  0x00, 0xC0, 0x0C, 0x01, 0x18, 0x04, 0x00, 0x40, 0x18, 0xC0, 0x60, 0x06,
  0x00, 0xC6, 0x03, 0x00, 0x30, 0x06, 0x20, 0x18, 0x01, 0x80, 0x61, 0x00,
  0xC0, 0x18, 0x03, 0x18, 0x06, 0x00, 0xC0, 0x18, 0xC0, 0x20, 0x0E, 0x01,
  0x86, 0x01, 0x00, 0x70, 0x0C, 0x30, 0x0C, 0x06, 0x80, 0xC1, 0x80, 0x60,
  0x24, 0x0C, 0x0C, 0x03, 0x03, 0x20, 0xE0, 0x60, 0x0C, 0x31, 0x8E, 0x03,
  0x00, 0x7F, 0x07, 0xE0, 0x18, 0x00, 0x40, 0x08, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x03,
  0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x10, 0x00,
  0x0C, 0x04, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x40, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x08, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x20, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x60, 0x07, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x40,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x02,
  0x00, 0x00, 0xE0, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x40, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x02, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x40,
  0x0F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x40, 0x07, 0xFF, 0xF8, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xF0, 0x40, 0x00, 0x40, 0x30, 0x40, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x3F,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0xC3, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x60, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x04, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x03,
  0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x01, 0x9B, 0x00,
  0x00, 0x03, 0x66, 0x00, 0x00, 0x07, 0x84, 0x00, 0x00, 0x0A, 0x0C, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0xF0, 0x00, 0x00, 0x0D, 0x00,
  0x12, 0x00, 0x00, 0x03, 0x60, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0xC8,
  0x00, 0x00, 0x19, 0x80, 0x19, 0x00, 0x00, 0x03, 0x30, 0x03, 0x30, 0x00,
  0x00, 0xC4, 0x00, 0x46, 0x00, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x00, 0x06,
  0x30, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0,
  0x0C, 0x60, 0x00, 0x06, 0x10, 0x01, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x60,
  0x80, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x00, 0x0C, 0x18, 0x01, 0x82, 0x00,
  0x01, 0x82, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x0C, 0x0C, 0x00, 0x0C,
  0x18, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x20,
  0x06, 0x01, 0x80, 0x18, 0x04, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x18, 0x03, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x20, 0x04, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x83, 0x00, 0x30, 0x03, 0x00, 0x30, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC3, 0x00, 0x10, 0x01, 0x00, 0x18, 0xC0,
  0x06, 0x00, 0x60, 0x01, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x26, 0x00, 0x18,
  0x01, 0x80, 0x04, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x40, 0x04,
  0x00, 0x1E, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x78, 0x00,
  0x01, 0x80, 0x1A, 0x00, 0x00, 0x60, 0x04, 0xC0, 0x00, 0x18, 0x03, 0x30,
  0x00, 0x06, 0x00, 0xCC, 0x00, 0x01, 0x00, 0x31, 0x00, 0x00, 0xC0, 0x0C,
  0x60, 0x00, 0x30, 0x02, 0x18, 0x00, 0x0C, 0x01, 0x86, 0x00, 0x02, 0x00,
  0x60, 0xC0, 0x01, 0x80, 0x18, 0x30, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x18,
  0x01, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x60, 0x01, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x0C, 0x06, 0x00, 0x30, 0x02, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x18, 0x01, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x40, 0x0C, 0x00, 0x20, 0x30, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x80, 0x03, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x80, 0x18, 0x00, 0x10, 0x60,
  0x06, 0x00, 0x06, 0x18, 0x01, 0x80, 0x01, 0x86, 0x00, 0xC0, 0x00, 0x61,
  0x80, 0x30, 0x00, 0x08, 0x40, 0x0C, 0x00, 0x03, 0x30, 0x03, 0x00, 0x00,
  0xCC, 0x00, 0x80, 0x00, 0x33, 0x00, 0x60, 0x00, 0x04, 0xC0, 0x18, 0x00,
  0x01, 0xA0, 0x06, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x40,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00,
  0xE0, 0x06, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x10, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x70,
  0x04, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x30, 0x03, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x18,
  0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0E, 0x00, 0xF0, 0x03, 0x80, 0x02, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x10, 0x00, 0x18, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00,
  0xC0, 0x10, 0x00, 0x20, 0x04, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x40,
  0x03, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00,
  0x40, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x26, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x30, 0x00, 0x02, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x40, 0x00, 0x19, 0x80, 0x00, 0x68, 0x00, 0x06, 0x30,
  0x00, 0x0D, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x20, 0x00, 0x10, 0xC0, 0x00,
  0x64, 0x00, 0x06, 0x18, 0x00, 0x08, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x10,
  0x00, 0x30, 0x60, 0x00, 0x62, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x40, 0x01,
  0x81, 0x80, 0x03, 0x08, 0x00, 0x30, 0x30, 0x00, 0x41, 0x00, 0x04, 0x06,
  0x00, 0x18, 0x20, 0x01, 0x80, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x10, 0x01, 0x80, 0x60, 0x06, 0x02,
  0x00, 0x20, 0x0C, 0x00, 0xC0, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x20, 0x0C, 0x00,
  0xC0, 0x30, 0x04, 0x03, 0x00, 0x18, 0x06, 0x00, 0x80, 0x60, 0x03, 0x00,
  0x80, 0x10, 0x08, 0x00, 0x60, 0x30, 0x02, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x40, 0x60, 0x00, 0x81, 0x80, 0x08, 0x18, 0x00, 0x10, 0x30, 0x01, 0x03,
  0x00, 0x02, 0x0C, 0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x04, 0x18, 0x00,
  0x08, 0x20, 0x00, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x21,
  0x80, 0x02, 0x18, 0x00, 0x04, 0x60, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00,
  0x08, 0xC0, 0x00, 0x13, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x26,
  0x00, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0x60, 0x00, 0x16, 0x00, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x01, 0x00, 0x18, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x20, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0x06, 0x18, 0x20, 0xC1, 0x82, 0x0C, 0x10,
  0x00, 0x1F, 0xE0, 0x80, 0x1C, 0x38, 0xC0, 0x38, 0x06, 0x60, 0x38, 0x01,
  0x30, 0x18, 0x00, 0xD0, 0x18, 0x00, 0x28, 0x18, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02, 0x0C,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x1C, 0x04, 0x00, 0x0A, 0x03, 0x00, 0x0F, 0x01, 0x80, 0x0D,
  0x80, 0x40, 0x0C, 0xC0, 0x30, 0x0E, 0x40, 0x0E, 0x0C, 0x20, 0x03, 0xFC,
  0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x07, 0xF0, 0x01, 0x8E, 0x1C, 0x00, 0x8C,
  0x03, 0x00, 0x4C, 0x00, 0xC0, 0x6C, 0x00, 0x60, 0x3C, 0x00, 0x18, 0x1E,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x0F, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x07, 0x80,
  0x03, 0x02, 0xC0, 0x03, 0x01, 0x20, 0x03, 0x01, 0x98, 0x03, 0x00, 0xC7,
  0x07, 0x00, 0x41, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x01, 0xC1, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x30, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x03, 0xFC, 0x18, 0x00, 0x38, 0x70, 0x80, 0x07, 0x00,
  0xCC, 0x00, 0x70, 0x03, 0x60, 0x07, 0x00, 0x0B, 0x00, 0x30, 0x00, 0x50,
  0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x07, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x3C, 0x00, 0x80, 0x01, 0xE0, 0x06,
  0x00, 0x1A, 0x00, 0x30, 0x01, 0x90, 0x01, 0x80, 0x1D, 0x80, 0x06, 0x01,
  0xCC, 0x00, 0x1C, 0x3C, 0x60, 0x00, 0x7F, 0x82, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xC3, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x30,
  0x18, 0x01, 0x81, 0x80, 0x04, 0x18, 0x00, 0x20, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0x61, 0xFC, 0x03, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x00, 0xF0, 0x38, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x30, 0x00, 0xE1, 0xC2, 0x00,
  0x38, 0x06, 0x20, 0x07, 0x00, 0x36, 0x00, 0xE0, 0x01, 0x60, 0x0C, 0x00,
  0x14, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x70, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0xC0, 0x10, 0x00, 0x3C, 0x01, 0x80, 0x06,
  0x80, 0x18, 0x00, 0xC8, 0x01, 0x80, 0x1D, 0x80, 0x0C, 0x03, 0x98, 0x00,
  0x70, 0xF1, 0x80, 0x03, 0xFC, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x87, 0xF8, 0x01, 0x8E, 0x1C, 0x01, 0x38, 0x06, 0x01, 0x30, 0x03,
  0x03, 0x60, 0x03, 0x03, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08,
  0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x10, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x01, 0x00, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C,
  0xD0, 0x00, 0x09, 0x98, 0x00, 0x1B, 0x18, 0x00, 0x1E, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x87, 0xF0, 0x0F, 0xF0, 0x04, 0x70, 0xE0, 0xF1, 0xE0, 0x13, 0x00, 0xC6,
  0x01, 0xC0, 0x58, 0x01, 0x30, 0x03, 0x03, 0x40, 0x07, 0x80, 0x0C, 0x0F,
  0x00, 0x1E, 0x00, 0x10, 0x38, 0x00, 0x70, 0x00, 0x40, 0xC0, 0x01, 0xC0,
  0x03, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x60,
  0x00, 0x40, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x30, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x01, 0x83, 0x00,
  0x02, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x20, 0x00, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0x80, 0x03, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x00, 0x81, 0x00, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0x00, 0x60, 0xC0, 0x01,
  0x80, 0x01, 0x02, 0x00, 0x06, 0x00, 0x04, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x40, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x10, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x01, 0x83,
  0x00, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x87,
  0xF8, 0x01, 0x0E, 0x1C, 0x01, 0x38, 0x06, 0x01, 0x30, 0x03, 0x03, 0x60,
  0x03, 0x03, 0xC0, 0x03, 0x02, 0x80, 0x03, 0x03, 0x80, 0x03, 0x07, 0x00,
  0x03, 0x07, 0x00, 0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x10, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xF0,
  0xF0, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x04,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x26, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x90, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00,
  0xC2, 0x00, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x3F, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x02, 0x1E, 0x38, 0x00, 0x23,
  0x80, 0xC0, 0x02, 0x60, 0x06, 0x00, 0x6C, 0x00, 0x60, 0x06, 0xC0, 0x03,
  0x00, 0x78, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30, 0x0E,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x10, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60,
  0x0F, 0x00, 0x0C, 0x00, 0x90, 0x01, 0x80, 0x19, 0x80, 0x30, 0x01, 0x8E,
  0x0E, 0x00, 0x18, 0x7F, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0xC0, 0x0E, 0x1C, 0x20, 0x0E, 0x01, 0x88, 0x07, 0x00, 0x36, 0x01,
  0x80, 0x0D, 0x80, 0xC0, 0x01, 0x40, 0x60, 0x00, 0x70, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x0C, 0x00,
  0x07, 0x03, 0x00, 0x03, 0xC0, 0x40, 0x00, 0xF0, 0x18, 0x00, 0x68, 0x06,
  0x00, 0x3A, 0x01, 0x80, 0x1D, 0x80, 0x30, 0x0E, 0x60, 0x07, 0x07, 0x18,
  0x00, 0xFF, 0x04, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x87, 0xF0, 0x10, 0xE2, 0x01, 0x38,
  0x00, 0x13, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x02, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xE1, 0xF0, 0x1C, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x07, 0x03, 0xC0, 0x78, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x84, 0x07, 0xF0, 0x07, 0x00, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x04,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C,
  0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18,
  0x00, 0x08, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x10, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0x40,
  0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0xC0,
  0x03, 0xC0, 0x40, 0x06, 0xC0, 0x60, 0x0C, 0x80, 0x30, 0x38, 0x80, 0x1F,
  0xE1, 0x80, 0x07, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x06, 0x80, 0x00,
  0x68, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x10, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0xC0,
  0x0C, 0x0C, 0x00, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x04,
  0x03, 0x00, 0x40, 0x60, 0x04, 0x06, 0x00, 0x40, 0xC0, 0x04, 0x0C, 0x00,
  0x41, 0x80, 0x04, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xB0, 0x00, 0x70, 0x00, 0xD8, 0x00, 0x78,
  0x00, 0x4C, 0x00, 0x3C, 0x00, 0x66, 0x00, 0x16, 0x00, 0x33, 0x00, 0x1B,
  0x00, 0x31, 0x80, 0x09, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x08, 0x60, 0x04,
  0x60, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x03, 0x18, 0x06, 0x0C, 0x03,
  0x0C, 0x03, 0x06, 0x01, 0x86, 0x01, 0x03, 0x00, 0x83, 0x01, 0x81, 0x80,
  0xC1, 0x80, 0x80, 0xC0, 0x40, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x30, 0x20, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x10, 0x06,
  0x18, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x0C, 0x01, 0x84, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x62, 0x00, 0x33, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x19, 0x00, 0x0D, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0xC0,
  0x03, 0x40, 0x01, 0x40, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x10, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x10, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0x20, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x9F, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x01, 0xE1, 0xE8, 0x00,
  0x3F, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 47, 13, 1, -47 },
  { 78, 13, 17, 18, 7, -47 },
  { 106, 29, 47, 29, 1, -47 },
  { 277, 26, 54, 27, 1, -50 },
  { 453, 32, 49, 39, 4, -48 },
  { 649, 27, 49, 28, 0, -48 },
  { 815, 5, 17, 10, 7, -47 },
  { 826, 18, 57, 16, 2, -47 },
  { 955, 18, 57, 16, -4, -47 },
  { 1084, 19, 21, 25, 8, -50 },
  { 1134, 25, 30, 30, 3, -38 },
  { 1228, 8, 14, 11, -3, -6 },
  { 1242, 14, 2, 18, 2, -19 },
  { 1246, 4, 4, 11, 1, -4 },
  { 1248, 27, 47, 20, -3, -47 },
  { 1407, 24, 49, 27, 2, -48 },
  { 1554, 12, 47, 27, 9, -47 },
  { 1625, 27, 48, 27, -1, -48 },
  { 1787, 27, 49, 27, -1, -48 },
  { 1953, 27, 48, 27, -1, -48 },
  { 2115, 28, 48, 27, -1, -47 },
  { 2283, 26, 49, 27, 2, -48 },
  { 2443, 25, 47, 27, 4, -47 },
  { 2590, 27, 49, 27, 0, -48 },
  { 2756, 25, 49, 27, 1, -48 },
  { 2910, 10, 35, 11, 1, -35 },
  { 2954, 14, 43, 11, -3, -35 },
  { 3030, 25, 27, 30, 3, -37 },
  { 3115, 25, 16, 30, 3, -31 },
  { 3165, 25, 27, 30, 3, -37 },
  { 3250, 19, 48, 19, 2, -48 },
  { 3364, 37, 53, 40, 2, -47 },
  { 3610, 26, 47, 26, -4, -47 },
  { 3763, 28, 47, 29, 1, -47 },
  { 3928, 29, 49, 27, 3, -48 },
  { 4106, 30, 47, 32, 1, -47 },
  { 4283, 28, 47, 26, 1, -47 },
  { 4448, 28, 47, 24, 1, -47 },
  { 4613, 32, 49, 35, 3, -48 },
  { 4809, 33, 47, 34, 1, -47 },
  { 5003, 20, 47, 13, -3, -47 },
  { 5121, 23, 58, 12, -10, -47 },
  { 5288, 31, 47, 27, 1, -47 },
  { 5471, 17, 47, 24, 1, -47 },
  { 5571, 43, 47, 43, 1, -47 },
  { 5824, 34, 47, 35, 1, -47 },
  { 6024, 30, 49, 35, 3, -48 },
  { 6208, 27, 47, 27, 1, -47 },
  { 6367, 30, 59, 35, 3, -48 },
  { 6589, 27, 47, 28, 1, -47 },
  { 6748, 28, 49, 26, -1, -48 },
  { 6920, 23, 47, 23, 6, -47 },
  { 7056, 31, 48, 33, 3, -47 },
  { 7242, 26, 47, 26, 6, -47 },
  { 7395, 43, 47, 44, 6, -47 },
  { 7648, 32, 47, 24, -4, -47 },
  { 7836, 23, 47, 23, 6, -47 },
  { 7972, 30, 47, 25, -2, -47 },
  { 8149, 24, 57, 19, -1, -47 },
  { 8320, 9, 47, 21, 7, -47 },
  { 8373, 23, 57, 19, -4, -47 },
  { 8537, 26, 24, 29, 2, -47 },
  { 8615, 19, 2, 19, -5, 6 },
  { 8620, 6, 10, 14, 10, -50 },
  { 8628, 25, 36, 28, 2, -35 },
  { 8741, 25, 51, 28, 1, -50 },
  { 8901, 21, 36, 21, 2, -35 },
  { 8996, 29, 51, 29, 2, -50 },
  { 9181, 21, 36, 25, 2, -35 },
  { 9276, 31, 66, 14, -9, -50 },
  { 9532, 28, 51, 29, 0, -35 },
  { 9711, 24, 50, 27, 1, -50 },
  { 9861, 12, 47, 11, 1, -47 },
  { 9932, 22, 63, 12, -9, -47 },
  { 10106, 24, 50, 22, 1, -50 },
  { 10256, 12, 50, 11, 1, -50 },
  { 10331, 38, 35, 42, 1, -35 },
  { 10498, 24, 35, 27, 1, -35 },
  { 10603, 23, 36, 28, 2, -35 },
  { 10707, 28, 50, 28, -2, -35 },
  { 10882, 26, 50, 29, 2, -35 },
  { 11045, 20, 35, 18, 1, -35 },
  { 11133, 22, 36, 21, -1, -35 },
  { 11232, 14, 44, 14, 2, -43 },
  { 11309, 24, 36, 27, 2, -35 },
  { 11417, 20, 35, 21, 4, -35 },
  { 11505, 33, 35, 34, 4, -35 },
  { 11650, 27, 35, 22, -3, -35 },
  { 11769, 33, 51, 22, -8, -35 },
  { 11980, 23, 35, 19, -2, -35 },
  { 12081, 23, 57, 21, 2, -47 },
  { 12245, 1, 66, 26, 13, -50 },
  { 12254, 23, 57, 21, -4, -47 },
  { 12418, 25, 5, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_THINITALIC66PT7B_H_
