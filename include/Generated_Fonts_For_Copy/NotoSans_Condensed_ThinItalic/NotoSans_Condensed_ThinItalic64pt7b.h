#ifndef _NOTOSANS_CONDENSED_THINITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x08, 0x18,
  0xC0, 0xC6, 0x06, 0x30, 0x21, 0x01, 0x08, 0x18, 0xC0, 0xC6, 0x06, 0x20,
  0x21, 0x01, 0x08, 0x18, 0xC0, 0xC6, 0x04, 0x20, 0x21, 0x01, 0x08, 0x18,
  0xC0, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x0C, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x10, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x04,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x20, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0x1F, 0x00, 0xE0, 0x81, 0x80,
  0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00,
  0x30, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x20, 0x00, 0x03, 0x10, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x63, 0x80, 0x00, 0x20, 0xC0, 0x00,
  0x10, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00,
  0x02, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x30, 0x10, 0x18, 0x70,
  0x0F, 0x8D, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x18, 0x07, 0x38, 0x00,
  0x30, 0x18, 0x30, 0x00, 0xC0, 0x60, 0x20, 0x01, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0xC0, 0x08, 0x04, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x40, 0x0C, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x03,
  0x00, 0x20, 0x30, 0x06, 0x00, 0xC0, 0x40, 0x08, 0x01, 0x81, 0x80, 0x30,
  0x03, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x08, 0x30, 0x01, 0x80,
  0x30, 0x60, 0x03, 0x00, 0x61, 0x83, 0xC4, 0x00, 0xC2, 0x0F, 0xE8, 0x03,
  0x0C, 0x30, 0xD0, 0x06, 0x10, 0xC0, 0xE0, 0x18, 0x63, 0x01, 0xE0, 0x31,
  0x86, 0x03, 0xC0, 0xC3, 0x18, 0x07, 0x83, 0x0C, 0x30, 0x0D, 0xCE, 0x10,
  0xC0, 0x19, 0xF0, 0x61, 0x80, 0x30, 0x00, 0x82, 0x00, 0x60, 0x03, 0x0C,
  0x00, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x18, 0x30, 0x02, 0x00, 0x60, 0x60,
  0x0C, 0x00, 0xC0, 0x80, 0x18, 0x03, 0x03, 0x00, 0x30, 0x04, 0x06, 0x00,
  0x60, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x80, 0x40,
  0x20, 0x03, 0x01, 0x80, 0xC0, 0x02, 0x06, 0x03, 0x00, 0x06, 0x18, 0x06,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x20, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x5C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x01, 0xC4, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x0C,
  0x30, 0x0C, 0x02, 0x18, 0x03, 0x01, 0x86, 0x00, 0x40, 0x63, 0x00, 0x18,
  0x10, 0xC0, 0x06, 0x0C, 0x60, 0x00, 0xC3, 0x18, 0x00, 0x31, 0x84, 0x00,
  0x04, 0x61, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x68, 0x30, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x78, 0x18, 0x00, 0x36,
  0x06, 0x00, 0x18, 0x80, 0xC0, 0x1C, 0x30, 0x1C, 0x0E, 0x04, 0x03, 0xFE,
  0x01, 0x80, 0x3C, 0x00, 0x00, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x08,
  0xC6, 0x21, 0x08, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x08,
  0x06, 0x01, 0xC0, 0x80, 0x0C, 0x10, 0x00, 0xE2, 0x00, 0x06, 0x43, 0xE0,
  0x3F, 0xC0, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x66, 0x00, 0x18, 0x40, 0x06,
  0x0C, 0x01, 0x80, 0x80, 0xC0, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFC, 0x6F, 0xB0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0xC0, 0x00,
  0x21, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x46,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x62, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x03, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x38, 0x01, 0x80, 0xE0, 0x01, 0x83, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x3B, 0x07, 0x30, 0xC2,
  0x38, 0x67, 0x06, 0xC0, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xC7, 0x80, 0x07, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xE1,
  0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x40, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x02, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0x80, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x0F, 0xC0, 0x02, 0x1F, 0xF8, 0x03, 0x38, 0x0E, 0x01,
  0xB0, 0x03, 0x80, 0xB0, 0x00, 0xC0, 0x50, 0x00, 0x30, 0x70, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x01,
  0xC1, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x87, 0x80, 0x03, 0x80,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x08,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x04,
  0x01, 0xC0, 0x06, 0x01, 0x80, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x07, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x08, 0x00, 0x0E, 0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x16,
  0x06, 0x00, 0x74, 0x07, 0x00, 0xE4, 0x03, 0xCF, 0x8C, 0x00, 0xFE, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x81, 0xC0,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xF1, 0xE0, 0x10, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x60, 0x00, 0xF0, 0x02, 0x06, 0x00, 0x3F, 0xE0, 0x20, 0xC0, 0x0E,
  0x04, 0x03, 0x0C, 0x01, 0x80, 0xC0, 0x21, 0x80, 0x30, 0x0C, 0x02, 0x18,
  0x03, 0x00, 0xC0, 0x21, 0x00, 0x60, 0x08, 0x02, 0x30, 0x0C, 0x01, 0x80,
  0x63, 0x00, 0xC0, 0x18, 0x06, 0x30, 0x18, 0x01, 0x80, 0x62, 0x01, 0x80,
  0x10, 0x06, 0x60, 0x10, 0x03, 0x00, 0x46, 0x03, 0x00, 0x30, 0x0C, 0x60,
  0x30, 0x03, 0x00, 0xC6, 0x03, 0x00, 0x60, 0x0C, 0x40, 0x20, 0x06, 0x00,
  0x8C, 0x06, 0x00, 0x60, 0x18, 0xC0, 0x60, 0x0E, 0x01, 0x8C, 0x06, 0x00,
  0xC0, 0x30, 0xC0, 0x60, 0x0C, 0x03, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0xC0,
  0x60, 0x34, 0x06, 0x0C, 0x03, 0x02, 0x60, 0xC0, 0xC0, 0x30, 0x66, 0x18,
  0x0C, 0x01, 0xFC, 0x3F, 0x00, 0xC0, 0x0F, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x02,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x00, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0C, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x04, 0x03, 0x00, 0x02,
  0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x08,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x1C,
  0x01, 0x00, 0x07, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x30, 0x03, 0x80, 0x04, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x10, 0x00,
  0x04, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x20, 0x01, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x0E, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x18, 0x03, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x07,
  0x00, 0x18, 0x00, 0xF0, 0x00, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x04, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x10, 0x02,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x40,
  0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x19, 0xE0, 0x00,
  0x00, 0x6C, 0x80, 0x00, 0x01, 0xB3, 0x00, 0x00, 0x05, 0x8C, 0x00, 0x00,
  0x3C, 0x10, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x40, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x05, 0x80, 0x00, 0x00, 0xD0, 0x02,
  0xC0, 0x00, 0x00, 0x68, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x6C, 0x00, 0x00, 0x19,
  0x00, 0x22, 0x00, 0x00, 0x19, 0x80, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x18,
  0x80, 0x00, 0x0C, 0x60, 0x0C, 0x40, 0x00, 0x06, 0x30, 0x04, 0x20, 0x00,
  0x06, 0x10, 0x02, 0x18, 0x00, 0x03, 0x18, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x01, 0x82, 0x00, 0x41,
  0x80, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x18, 0x10, 0x00, 0x60, 0x60, 0x0C, 0x08, 0x00, 0x30, 0x20,
  0x04, 0x04, 0x00, 0x30, 0x30, 0x06, 0x02, 0x00, 0x10, 0x18, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x00, 0x80, 0x60, 0x0C,
  0x02, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x01, 0x00, 0x20, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x06, 0x00, 0x41, 0x80,
  0x18, 0x03, 0x00, 0x20, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0xC0, 0x04, 0x00,
  0x80, 0x0C, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x60, 0x03, 0x00, 0x60, 0x03,
  0x30, 0x01, 0x80, 0x30, 0x01, 0xB0, 0x00, 0xC0, 0x18, 0x00, 0xD8, 0x00,
  0x40, 0x08, 0x00, 0x78, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x20, 0x07, 0x80,
  0x00, 0x30, 0x02, 0xC0, 0x00, 0x18, 0x03, 0x20, 0x00, 0x0C, 0x01, 0x90,
  0x00, 0x06, 0x00, 0xCC, 0x00, 0x02, 0x00, 0x66, 0x00, 0x03, 0x00, 0x21,
  0x00, 0x01, 0x80, 0x30, 0x80, 0x00, 0xC0, 0x18, 0x60, 0x00, 0x60, 0x0C,
  0x30, 0x00, 0x20, 0x04, 0x08, 0x00, 0x30, 0x02, 0x06, 0x00, 0x18, 0x03,
  0x03, 0x00, 0x0C, 0x01, 0x81, 0x80, 0x04, 0x00, 0xC0, 0x40, 0x02, 0x00,
  0x40, 0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x60, 0x04, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x0C, 0x04,
  0x00, 0x80, 0x06, 0x06, 0x00, 0x40, 0x03, 0x03, 0x00, 0x60, 0x00, 0x81,
  0x80, 0x30, 0x00, 0x60, 0x80, 0x18, 0x00, 0x30, 0x40, 0x08, 0x00, 0x18,
  0x60, 0x0C, 0x00, 0x04, 0x30, 0x06, 0x00, 0x03, 0x18, 0x03, 0x00, 0x01,
  0x88, 0x01, 0x80, 0x00, 0xC4, 0x00, 0x80, 0x00, 0x26, 0x00, 0xC0, 0x00,
  0x1B, 0x00, 0x60, 0x00, 0x0D, 0x80, 0x30, 0x00, 0x06, 0x80, 0x18, 0x00,
  0x01, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x10,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x18, 0x01, 0xC0,
  0x04, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x00,
  0xE0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x08, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x07, 0xFF, 0xC0,
  0x03, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x03,
  0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x04, 0x01, 0x80, 0x01,
  0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xE0, 0xFC, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x40, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x10, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x18, 0x00, 0x40, 0x08, 0x00, 0x20, 0x0C,
  0x00, 0x10, 0x06, 0x00, 0x08, 0x06, 0x00, 0x04, 0x03, 0x00, 0x02, 0x03,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x40, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x60, 0x00, 0x33, 0x00,
  0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x23, 0x00, 0x06,
  0x18, 0x00, 0x31, 0x80, 0x02, 0x0C, 0x00, 0x10, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x01, 0x81, 0x80, 0x04, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x60, 0x02, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x18, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x00, 0x40, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x04, 0x00, 0xC0, 0x20, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x01, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x06, 0x04, 0x00, 0x40,
  0xC0, 0x03, 0x06, 0x00, 0x20, 0x40, 0x01, 0x83, 0x00, 0x10, 0x60, 0x00,
  0xC3, 0x00, 0x08, 0x30, 0x00, 0x61, 0x80, 0x04, 0x30, 0x00, 0x30, 0x80,
  0x02, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x8C,
  0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x03, 0x30, 0x00, 0x26, 0x00, 0x01,
  0xB0, 0x00, 0x13, 0x00, 0x00, 0xD8, 0x00, 0x09, 0x00, 0x00, 0x68, 0x00,
  0x05, 0x80, 0x00, 0x3C, 0x00, 0x02, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x08, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x10, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x41,
  0x80, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x40,
  0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x20,
  0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x06,
  0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xC1, 0x81, 0x03,
  0x02, 0x06, 0x04, 0x04, 0x0C, 0x00, 0x1F, 0xC1, 0x00, 0x78, 0xE1, 0x00,
  0xE0, 0x33, 0x01, 0x80, 0x1B, 0x03, 0x00, 0x0A, 0x03, 0x00, 0x0A, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xE0, 0x40, 0x01, 0xE0, 0x40, 0x01, 0x40, 0x60, 0x03, 0x40, 0x60,
  0x06, 0x40, 0x30, 0x0C, 0xC0, 0x18, 0x38, 0xC0, 0x0F, 0xF0, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x87, 0xF0, 0x01, 0x0E, 0x3C, 0x01, 0x38, 0x0E, 0x03, 0x70, 0x06, 0x03,
  0x60, 0x03, 0x02, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x07, 0x80, 0x03, 0x07,
  0x00, 0x01, 0x07, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x10,
  0x00, 0x06, 0x10, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x08, 0x30, 0x00, 0x18, 0x70, 0x00, 0x10, 0x70, 0x00, 0x30, 0x70,
  0x00, 0x60, 0x58, 0x00, 0x60, 0x58, 0x00, 0xC0, 0xCC, 0x01, 0x80, 0xC6,
  0x07, 0x00, 0x83, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xF0, 0x07,
  0x87, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x18, 0x00, 0x78, 0xF1, 0x00,
  0x0E, 0x03, 0x90, 0x01, 0x80, 0x1B, 0x00, 0x30, 0x00, 0xB0, 0x07, 0x00,
  0x0F, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x0C,
  0x00, 0x0E, 0x00, 0x40, 0x01, 0xE0, 0x04, 0x00, 0x1E, 0x00, 0x60, 0x03,
  0x60, 0x06, 0x00, 0x64, 0x00, 0x30, 0x0C, 0x40, 0x01, 0x83, 0x8C, 0x00,
  0x0F, 0xF0, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xC7,
  0x00, 0x38, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x80, 0x1C, 0x0C, 0x07,
  0x80, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x20, 0x1C, 0x07, 0x00, 0x7F, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x60, 0x03,
  0xC7, 0x8C, 0x00, 0xE0, 0x31, 0x00, 0x30, 0x03, 0x20, 0x0C, 0x00, 0x2C,
  0x03, 0x80, 0x07, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x08,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0xE0, 0x08, 0x00, 0x3C, 0x01, 0x00, 0x0F, 0x80, 0x30, 0x01, 0xB0,
  0x06, 0x00, 0x64, 0x00, 0x60, 0x18, 0x80, 0x06, 0x0E, 0x30, 0x00, 0x7F,
  0x86, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x80, 0x07, 0x83, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC3, 0xF8, 0x01, 0x1E, 0x3C, 0x02, 0x60, 0x18, 0x0D, 0x80, 0x18,
  0x1E, 0x00, 0x30, 0x2C, 0x00, 0x60, 0x70, 0x00, 0xC1, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00,
  0x04, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00,
  0x81, 0x00, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x20, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x08, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0xC0, 0x00, 0x20, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x21, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x01, 0x00, 0x0C,
  0x02, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x40, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x08,
  0x18, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8E,
  0x00, 0x02, 0x3C, 0x00, 0x04, 0xD8, 0x00, 0x1B, 0x10, 0x00, 0x3C, 0x30,
  0x00, 0x50, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x80, 0x80, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x10, 0x04, 0x00, 0x30, 0x08, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x0F,
  0xF0, 0x1F, 0xC0, 0x08, 0xE1, 0xC3, 0xC7, 0x80, 0x4C, 0x06, 0x38, 0x0C,
  0x06, 0xC0, 0x1B, 0x00, 0x30, 0x3C, 0x00, 0xD0, 0x01, 0x81, 0x40, 0x07,
  0x80, 0x0C, 0x0E, 0x00, 0x38, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0x03, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x04,
  0x08, 0x00, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x00, 0x81, 0x00, 0x02, 0x00, 0x04, 0x18, 0x00,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x40, 0x00, 0x81, 0x00, 0x02, 0x00, 0x04, 0x18, 0x00, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x01, 0x07, 0xF0, 0x02, 0x3C, 0x78, 0x04, 0xC0, 0x30, 0x1B, 0x00, 0x30,
  0x3C, 0x00, 0x60, 0x50, 0x00, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x07,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00, 0x20, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01,
  0x02, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x40, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x10, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x01, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0xE0, 0x0C,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x01, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00, 0x4C,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x43, 0x00, 0x01, 0x82, 0x00, 0x02, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0xFE, 0x00, 0x04,
  0x38, 0xF0, 0x00, 0x9C, 0x07, 0x00, 0x33, 0x00, 0x60, 0x06, 0xC0, 0x06,
  0x00, 0xB0, 0x00, 0xC0, 0x16, 0x00, 0x18, 0x03, 0x80, 0x01, 0x00, 0xE0,
  0x00, 0x20, 0x1C, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x10,
  0x1C, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x38,
  0x00, 0x08, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x1E, 0x00, 0x18,
  0x02, 0xC0, 0x06, 0x00, 0xCC, 0x03, 0x80, 0x18, 0xC0, 0xE0, 0x03, 0x0F,
  0xF0, 0x00, 0x60, 0x78, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0x80, 0x3C, 0x78, 0xC0,
  0x30, 0x0C, 0x40, 0x30, 0x03, 0x20, 0x30, 0x00, 0xB0, 0x38, 0x00, 0x78,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x82, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x70, 0x30, 0x00, 0x38, 0x08, 0x00, 0x3C, 0x04, 0x00, 0x1E, 0x03,
  0x00, 0x1B, 0x01, 0x80, 0x19, 0x00, 0x60, 0x19, 0x80, 0x38, 0x38, 0xC0,
  0x07, 0xF8, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x07, 0xE0, 0x23, 0xC4, 0x04, 0xE0, 0x01, 0xB0,
  0x00, 0x34, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0x83, 0xC0, 0x70, 0x02, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x10, 0x00, 0xC0,
  0xF0, 0x1C, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x3F, 0xF9, 0xFF,
  0xC1, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0xF0, 0x07, 0x00, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x00, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x38, 0x18, 0x00, 0xD0, 0x30, 0x03, 0x20, 0x30,
  0x0E, 0xC0, 0x70, 0x31, 0x80, 0x7F, 0xC2, 0x00, 0x1C, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x19, 0x00,
  0x03, 0x20, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x60, 0x60, 0x04, 0x08,
  0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0x43, 0x00, 0x08, 0xC0,
  0x01, 0x18, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x06, 0x80, 0x03, 0x80, 0x06, 0x80, 0x03, 0x80, 0x04,
  0x80, 0x07, 0x80, 0x0C, 0x80, 0x07, 0x80, 0x0C, 0xC0, 0x05, 0x80, 0x18,
  0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x09, 0x80, 0x10, 0xC0, 0x18, 0x80, 0x30,
  0xC0, 0x10, 0x80, 0x20, 0xC0, 0x30, 0x80, 0x60, 0xC0, 0x30, 0x80, 0x60,
  0xC0, 0x60, 0x80, 0x40, 0xC0, 0x60, 0x80, 0xC0, 0xC0, 0x40, 0x80, 0x80,
  0xC0, 0xC0, 0x81, 0x80, 0xC0, 0x80, 0x81, 0x80, 0xC1, 0x80, 0x83, 0x00,
  0xC1, 0x00, 0x83, 0x00, 0xC3, 0x00, 0x82, 0x00, 0xC3, 0x00, 0x86, 0x00,
  0xC6, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x8C, 0x00,
  0xCC, 0x00, 0x88, 0x00, 0xC8, 0x00, 0x98, 0x00, 0xD8, 0x00, 0x90, 0x00,
  0xD0, 0x00, 0xB0, 0x00, 0xF0, 0x00, 0xB0, 0x00, 0xF0, 0x00, 0xA0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x08, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x10, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x08, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x06, 0x01, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x70, 0xF0, 0x01, 0xC0, 0x1C,
  0x07, 0x80, 0x0F, 0xFC, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 46, 13, 1, -46 },
  { 70, 13, 17, 17, 6, -46 },
  { 98, 28, 46, 28, 1, -46 },
  { 259, 25, 53, 26, 1, -49 },
  { 425, 31, 47, 38, 4, -46 },
  { 608, 26, 47, 28, 0, -46 },
  { 761, 5, 17, 10, 6, -46 },
  { 772, 17, 56, 15, 2, -46 },
  { 891, 17, 56, 15, -4, -46 },
  { 1010, 19, 20, 24, 8, -48 },
  { 1058, 24, 29, 29, 3, -37 },
  { 1145, 8, 14, 11, -3, -6 },
  { 1159, 14, 1, 18, 2, -18 },
  { 1161, 3, 4, 11, 1, -4 },
  { 1163, 27, 46, 19, -3, -46 },
  { 1319, 23, 47, 26, 2, -46 },
  { 1455, 12, 46, 26, 8, -46 },
  { 1524, 26, 46, 26, -1, -46 },
  { 1674, 27, 47, 26, -1, -46 },
  { 1833, 26, 46, 26, -1, -46 },
  { 1983, 27, 47, 26, -1, -46 },
  { 2142, 25, 47, 26, 2, -46 },
  { 2289, 24, 46, 26, 4, -46 },
  { 2427, 26, 47, 26, 0, -46 },
  { 2580, 24, 47, 26, 1, -46 },
  { 2721, 9, 34, 11, 1, -34 },
  { 2760, 13, 42, 11, -3, -34 },
  { 2829, 24, 27, 29, 3, -36 },
  { 2910, 24, 15, 29, 3, -30 },
  { 2955, 24, 27, 29, 3, -36 },
  { 3036, 19, 46, 19, 2, -46 },
  { 3146, 36, 52, 39, 2, -46 },
  { 3380, 25, 46, 25, -4, -46 },
  { 3524, 27, 46, 28, 1, -46 },
  { 3680, 28, 47, 27, 3, -46 },
  { 3845, 29, 46, 31, 1, -46 },
  { 4012, 27, 46, 25, 1, -46 },
  { 4168, 27, 46, 23, 1, -46 },
  { 4324, 31, 47, 33, 3, -46 },
  { 4507, 32, 46, 33, 1, -46 },
  { 4691, 19, 46, 13, -2, -46 },
  { 4801, 22, 57, 11, -10, -46 },
  { 4958, 30, 46, 26, 1, -46 },
  { 5131, 17, 46, 23, 1, -46 },
  { 5229, 41, 46, 42, 1, -46 },
  { 5465, 33, 46, 34, 1, -46 },
  { 5655, 29, 47, 34, 3, -46 },
  { 5826, 26, 46, 27, 1, -46 },
  { 5976, 29, 57, 34, 3, -46 },
  { 6183, 26, 46, 27, 1, -46 },
  { 6333, 27, 47, 25, -1, -46 },
  { 6492, 22, 46, 22, 6, -46 },
  { 6619, 30, 47, 32, 3, -46 },
  { 6796, 25, 46, 26, 6, -46 },
  { 6940, 41, 46, 43, 6, -46 },
  { 7176, 32, 46, 23, -4, -46 },
  { 7360, 23, 46, 22, 5, -46 },
  { 7493, 29, 46, 24, -2, -46 },
  { 7660, 23, 56, 18, -1, -46 },
  { 7821, 8, 46, 20, 7, -46 },
  { 7867, 23, 56, 18, -4, -46 },
  { 8028, 25, 24, 28, 2, -46 },
  { 8103, 19, 2, 19, -5, 6 },
  { 8108, 7, 10, 14, 9, -49 },
  { 8117, 24, 35, 27, 2, -34 },
  { 8222, 24, 50, 28, 1, -49 },
  { 8372, 20, 35, 21, 2, -34 },
  { 8460, 28, 50, 28, 2, -49 },
  { 8635, 21, 35, 24, 2, -34 },
  { 8727, 29, 64, 13, -8, -49 },
  { 8959, 27, 49, 28, 0, -34 },
  { 9125, 23, 49, 27, 1, -49 },
  { 9266, 12, 46, 11, 1, -46 },
  { 9335, 22, 61, 11, -9, -46 },
  { 9503, 23, 49, 22, 1, -49 },
  { 9644, 12, 49, 11, 1, -49 },
  { 9718, 37, 34, 41, 1, -34 },
  { 9876, 23, 34, 27, 1, -34 },
  { 9974, 23, 35, 27, 2, -34 },
  { 10075, 27, 49, 28, -2, -34 },
  { 10241, 25, 49, 28, 2, -34 },
  { 10395, 19, 34, 18, 1, -34 },
  { 10476, 21, 35, 20, -1, -34 },
  { 10568, 13, 43, 14, 2, -42 },
  { 10638, 23, 35, 27, 2, -34 },
  { 10739, 19, 34, 20, 4, -34 },
  { 10820, 32, 34, 33, 4, -34 },
  { 10956, 26, 34, 21, -3, -34 },
  { 11067, 31, 50, 21, -7, -34 },
  { 11261, 22, 34, 19, -2, -34 },
  { 11355, 22, 56, 20, 2, -46 },
  { 11509, 2, 65, 26, 12, -49 },
  { 11526, 22, 56, 20, -4, -46 },
  { 11680, 24, 5, 29, 3, -25 },
};

const GFXfont NotoSans_Condensed_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_THINITALIC64PT7B_H_
