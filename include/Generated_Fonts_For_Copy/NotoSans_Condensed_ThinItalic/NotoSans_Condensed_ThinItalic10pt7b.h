#ifndef _NOTOSANS_CONDENSED_THINITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xF0, 0x31, 0x96, 0xAF, 0x52, 0x80, 0x23, 0x64, 0x25,
  0x5E, 0x40, 0xDD, 0xEF, 0x7B, 0xB0, 0x75, 0x24, 0xBA, 0xF0, 0xC0, 0x29,
  0x49, 0x24, 0x80, 0x24, 0x92, 0x52, 0x80, 0x5D, 0x50, 0x22, 0xF2, 0x20,
  0xC0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x75, 0x99, 0x9A, 0xE0, 0x75,
  0x68, 0x71, 0x12, 0x44, 0xE0, 0x71, 0x16, 0x11, 0xE0, 0x13, 0x55, 0xA7,
  0x20, 0x74, 0x43, 0x11, 0xE0, 0x34, 0xAD, 0x99, 0xE0, 0xE5, 0x29, 0x20,
  0x75, 0x56, 0x99, 0xE0, 0x79, 0x99, 0x72, 0xE0, 0x40, 0x80, 0x40, 0xA0,
  0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0x64, 0xA8, 0x20, 0x3D,
  0x1B, 0xED, 0xD6, 0xE8, 0x1C, 0x11, 0x33, 0x55, 0x90, 0x75, 0x57, 0x99,
  0xE0, 0x78, 0x88, 0x88, 0xC0, 0x7A, 0x52, 0x98, 0xCB, 0x80, 0x74, 0x46,
  0x88, 0xE0, 0x74, 0x46, 0x88, 0x80, 0x3A, 0x21, 0x38, 0xC5, 0xC0, 0x4A,
  0x52, 0xF8, 0xCA, 0x40, 0x69, 0x29, 0x20, 0x11, 0x11, 0x22, 0x22, 0xC0,
  0x4A, 0x98, 0x8A, 0x52, 0x40, 0x49, 0x29, 0x38, 0x46, 0x89, 0x32, 0x6B,
  0x56, 0xA9, 0x00, 0x4A, 0x5A, 0xD9, 0x4A, 0x40, 0x3A, 0x63, 0x18, 0xC5,
  0xC0, 0x75, 0x57, 0x88, 0x80, 0x3A, 0x63, 0x18, 0xC5, 0x44, 0x20, 0x75,
  0x56, 0xAA, 0x90, 0x74, 0x42, 0x21, 0xE0, 0xE9, 0x49, 0x20, 0x4A, 0x53,
  0x18, 0xCB, 0xC0, 0x9A, 0xAC, 0xC8, 0x80, 0xA6, 0x9A, 0x76, 0x92, 0x49,
  0x00, 0x29, 0x44, 0x42, 0x2A, 0x40, 0xB7, 0x49, 0x20, 0x71, 0x24, 0x48,
  0xE0, 0x69, 0x29, 0x24, 0xC0, 0xFE, 0x31, 0x11, 0x22, 0x22, 0xC0, 0x25,
  0x59, 0xE0, 0xC0, 0x79, 0x99, 0xE0, 0x44, 0x65, 0x59, 0x9E, 0x72, 0x4E,
  0x08, 0x4A, 0xA9, 0x4A, 0x5C, 0x79, 0xE8, 0xE0, 0x12, 0x22, 0x24, 0x44,
  0x48, 0x79, 0x99, 0xE2, 0xE0, 0x44, 0x65, 0x59, 0x9A, 0x45, 0xA8, 0x20,
  0x94, 0x92, 0x80, 0x44, 0x56, 0xAC, 0xAA, 0x55, 0xAA, 0x7D, 0x59, 0x69,
  0xA4, 0x75, 0x99, 0xA0, 0x79, 0x99, 0xE0, 0x75, 0x99, 0xE8, 0x80, 0x79,
  0x99, 0xE2, 0x20, 0x6A, 0x48, 0xF1, 0x1E, 0x56, 0xA8, 0x59, 0x99, 0xE0,
  0xBA, 0x48, 0xCD, 0xA9, 0x4A, 0x00, 0x74, 0x4A, 0xA0, 0x4A, 0x94, 0x42,
  0x23, 0x00, 0x69, 0x4C, 0x32, 0x44, 0xC4, 0x88, 0x40, 0xFF, 0xC0, 0x31,
  0x12, 0x32, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 4, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 4, 7, 4, 0, -7 },
  { 22, 1, 2, 2, 1, -7 },
  { 23, 3, 9, 2, 0, -7 },
  { 27, 3, 9, 2, -1, -7 },
  { 31, 3, 4, 4, 1, -8 },
  { 33, 4, 5, 5, 0, -6 },
  { 36, 1, 2, 2, 0, -1 },
  { 37, 2, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 0, -1 },
  { 39, 4, 7, 3, 0, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 2, 7, 4, 1, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 7, 4, 0, -7 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 4, 7, 4, 0, -7 },
  { 65, 4, 7, 4, 0, -7 },
  { 69, 3, 7, 4, 1, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 4, 7, 4, 0, -7 },
  { 80, 2, 5, 2, 0, -5 },
  { 82, 2, 6, 2, 0, -5 },
  { 84, 4, 5, 5, 0, -6 },
  { 87, 4, 3, 5, 0, -5 },
  { 89, 4, 5, 5, 0, -6 },
  { 92, 3, 7, 3, 0, -7 },
  { 95, 6, 8, 6, 0, -7 },
  { 101, 4, 7, 4, -1, -7 },
  { 105, 4, 7, 4, 0, -7 },
  { 109, 4, 7, 4, 1, -7 },
  { 113, 5, 7, 5, 0, -7 },
  { 118, 4, 7, 4, 0, -7 },
  { 122, 4, 7, 4, 0, -7 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 5, 7, 5, 0, -7 },
  { 136, 3, 7, 2, 0, -7 },
  { 139, 4, 9, 2, -2, -7 },
  { 144, 5, 7, 4, 0, -7 },
  { 149, 3, 7, 4, 0, -7 },
  { 152, 7, 7, 7, 0, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 5, 7, 5, 0, -7 },
  { 169, 4, 7, 4, 0, -7 },
  { 173, 5, 9, 5, 0, -7 },
  { 179, 4, 7, 4, 0, -7 },
  { 183, 4, 7, 4, 0, -7 },
  { 187, 3, 7, 4, 1, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 4, 7, 4, 1, -7 },
  { 199, 6, 7, 7, 1, -7 },
  { 205, 5, 7, 4, -1, -7 },
  { 210, 3, 7, 3, 1, -7 },
  { 213, 4, 7, 4, 0, -7 },
  { 217, 3, 9, 3, 0, -7 },
  { 221, 1, 7, 3, 1, -7 },
  { 222, 4, 9, 3, -1, -7 },
  { 227, 4, 4, 4, 0, -7 },
  { 229, 3, 1, 3, -1, 1 },
  { 230, 1, 2, 2, 1, -8 },
  { 231, 4, 5, 4, 0, -5 },
  { 234, 4, 8, 4, 0, -8 },
  { 238, 3, 5, 3, 0, -5 },
  { 240, 5, 8, 4, 0, -8 },
  { 245, 4, 5, 4, 0, -5 },
  { 248, 4, 10, 2, -1, -8 },
  { 253, 4, 7, 4, 0, -5 },
  { 257, 4, 8, 4, 0, -8 },
  { 261, 2, 7, 2, 0, -7 },
  { 263, 3, 9, 2, -1, -7 },
  { 267, 4, 8, 3, 0, -8 },
  { 271, 2, 8, 2, 0, -8 },
  { 273, 6, 5, 6, 0, -5 },
  { 277, 4, 5, 4, 0, -5 },
  { 280, 4, 5, 4, 0, -5 },
  { 283, 4, 7, 4, 0, -5 },
  { 287, 4, 7, 4, 0, -5 },
  { 291, 3, 5, 3, 0, -5 },
  { 293, 3, 5, 3, 0, -5 },
  { 295, 2, 7, 2, 0, -7 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 3, 5, 3, 1, -5 },
  { 302, 5, 5, 5, 1, -5 },
  { 306, 4, 5, 3, 0, -5 },
  { 309, 5, 7, 3, -1, -5 },
  { 314, 3, 5, 3, 0, -5 },
  { 316, 4, 9, 3, 0, -7 },
  { 321, 1, 10, 4, 2, -8 },
  { 323, 4, 9, 3, -1, -7 },
  { 328, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_THINITALIC10PT7B_H_
