#ifndef _NOTOSANS_CONDENSED_THINITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x30, 0x66, 0x08, 0x81,
  0x10, 0x26, 0x0C, 0xC1, 0x90, 0x22, 0x04, 0x40, 0x88, 0x33, 0x04, 0x40,
  0x88, 0x11, 0x06, 0x00, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x04, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x08, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10, 0x00, 0x20,
  0x10, 0x00, 0x20, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x60, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x00, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00, 0x06, 0x03, 0x00, 0xFF, 0xFF,
  0xF8, 0x04, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x10, 0x00, 0x20, 0x10, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x70, 0x83, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x01,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x06, 0x18, 0x00, 0x04, 0x30, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x26, 0x00, 0x00, 0x46, 0x00, 0x01, 0x86,
  0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x60, 0x60, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x02, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x60, 0x30, 0x21, 0x80, 0x3F, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x0C,
  0x06, 0x18, 0x00, 0x80, 0xC0, 0x80, 0x18, 0x08, 0x08, 0x01, 0x01, 0x80,
  0x80, 0x30, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40, 0x30, 0x08, 0x0C,
  0x02, 0x00, 0x80, 0x80, 0x60, 0x08, 0x18, 0x06, 0x01, 0x81, 0x00, 0x60,
  0x18, 0x30, 0x04, 0x01, 0x82, 0x00, 0x40, 0x10, 0x60, 0x0C, 0x01, 0x0C,
  0x00, 0xC0, 0x30, 0x80, 0x0C, 0x03, 0x18, 0x7C, 0xC0, 0x21, 0x0C, 0x6C,
  0x06, 0x31, 0x82, 0xC0, 0x42, 0x30, 0x3C, 0x0C, 0x62, 0x03, 0x41, 0x8C,
  0x60, 0x36, 0x30, 0x84, 0x03, 0x3E, 0x18, 0xC0, 0x30, 0x81, 0x0C, 0x03,
  0x00, 0x30, 0x80, 0x20, 0x02, 0x18, 0x02, 0x00, 0x61, 0x80, 0x20, 0x0C,
  0x18, 0x06, 0x00, 0x81, 0x00, 0x60, 0x18, 0x10, 0x04, 0x01, 0x01, 0x00,
  0x40, 0x30, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x0C,
  0x01, 0x01, 0x80, 0x80, 0x10, 0x10, 0x18, 0x01, 0x03, 0x01, 0x00, 0x18,
  0x60, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x61, 0x80, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x08,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x02, 0x00, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x60, 0x00, 0x21, 0x80, 0x00, 0x46, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x32, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x04, 0x01, 0x0C, 0x0C, 0x04, 0x30, 0x18, 0x08, 0xC0,
  0x10, 0x31, 0x80, 0x30, 0x46, 0x00, 0x21, 0x8C, 0x00, 0x62, 0x10, 0x00,
  0xCC, 0x20, 0x00, 0x90, 0xC0, 0x01, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x0E, 0x04, 0x00, 0x34, 0x0C, 0x00, 0xCC, 0x18, 0x03, 0x08,
  0x1C, 0x1C, 0x10, 0x1F, 0xF0, 0x30, 0x02, 0x00, 0x00, 0x33, 0x22, 0x66,
  0x44, 0x44, 0xC8, 0x88, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x18, 0x80, 0x07, 0x0F,
  0x01, 0xF0, 0x03, 0x80, 0x04, 0x80, 0x08, 0x40, 0x10, 0x40, 0x60, 0x20,
  0xC0, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x20, 0x81,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x5F, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xF8, 0x00, 0x60, 0xC0, 0x0C, 0x06,
  0x01, 0x80, 0x20, 0x30, 0x03, 0x02, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00,
  0x10, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00,
  0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60,
  0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x64,
  0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08,
  0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03,
  0x08, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x04, 0x01,
  0x80, 0x60, 0x30, 0x03, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x3C, 0x0D, 0x03, 0x21, 0xCC, 0x61, 0xB8, 0x22, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0,
  0x01, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xC0,
  0x60, 0x0E, 0x00, 0x60, 0x08, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x70, 0x07, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x18,
  0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x00, 0x03, 0x02, 0x00, 0x04, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0x80, 0x40, 0x03, 0x00, 0x80,
  0x0C, 0x03, 0x00, 0x10, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x02, 0x01, 0x00,
  0x04, 0x06, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xA0, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x10, 0x01,
  0xC0, 0x30, 0x0E, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xC0, 0x07, 0x02, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x8F, 0xF0, 0x09, 0xC0, 0xC0,
  0x58, 0x03, 0x07, 0x80, 0x08, 0x28, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00,
  0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x10, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x06, 0x04, 0x00, 0x60, 0x30,
  0x02, 0x00, 0x80, 0x30, 0x07, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0x40, 0x08, 0x00,
  0xC0, 0x30, 0x00, 0x80, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x20, 0x30, 0x00, 0xC0,
  0x20, 0x01, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00,
  0xC3, 0x80, 0x00, 0x8C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0xE0, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x30, 0x01,
  0x80, 0xC0, 0x01, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x08, 0x00, 0x04,
  0x30, 0x00, 0x08, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x82, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x0E, 0x07, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x40, 0x30, 0x03,
  0x01, 0x80, 0x08, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x40, 0x00, 0x62, 0x00, 0x03, 0x10, 0x00, 0x18, 0x80, 0x01, 0x84, 0x00,
  0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x04, 0x00, 0x78, 0x30, 0x06, 0x80,
  0xC0, 0xE4, 0x03, 0xFC, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x10, 0x38, 0x00, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x02, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0xC0, 0xC0, 0x00, 0x20, 0x03, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x07,
  0xF8, 0x1C, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x01, 0x80, 0x30, 0x80, 0x1F, 0xE0, 0x63, 0x00, 0x60,
  0xC0, 0xC6, 0x01, 0x81, 0x81, 0x88, 0x06, 0x02, 0x03, 0x30, 0x18, 0x0C,
  0x06, 0x40, 0x20, 0x18, 0x0C, 0x80, 0xC0, 0x20, 0x13, 0x01, 0x00, 0x40,
  0x26, 0x06, 0x01, 0x80, 0x48, 0x08, 0x03, 0x01, 0x90, 0x10, 0x04, 0x03,
  0x60, 0x60, 0x08, 0x04, 0xC0, 0xC0, 0x30, 0x19, 0x81, 0x80, 0x60, 0x33,
  0x02, 0x00, 0xC0, 0x46, 0x04, 0x03, 0x01, 0x88, 0x08, 0x06, 0x02, 0x10,
  0x18, 0x14, 0x0C, 0x20, 0x30, 0x68, 0x30, 0x40, 0x21, 0x98, 0xC0, 0x80,
  0x7E, 0x1F, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00,
  0x1A, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0x82, 0x00,
  0x06, 0x08, 0x00, 0x10, 0x20, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x40, 0x20, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x3F, 0xFF, 0x00, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x18, 0x00,
  0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x60, 0x00, 0x11,
  0x80, 0x00, 0x44, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80, 0x00, 0x16, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x00, 0xC1, 0xF8, 0x00, 0x80,
  0x0C, 0x00, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x02, 0x01, 0x80,
  0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00,
  0x02, 0x02, 0x00, 0x06, 0x02, 0x00, 0x06, 0x02, 0x00, 0x04, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x04, 0x00, 0x30, 0x04, 0x00, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x0C, 0x01, 0xC0, 0x08, 0x00, 0x60, 0x08, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10, 0x10, 0x00,
  0x10, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00,
  0x30, 0x20, 0x00, 0x30, 0x20, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x40, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x40, 0x07, 0x00, 0xC0, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1C,
  0x03, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x61, 0xF8, 0x00, 0x20, 0x06, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x01,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x82, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x40,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x08,
  0x00, 0x30, 0x04, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x03, 0x0F, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x70, 0x07, 0x80, 0x18, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFC, 0x30, 0x00, 0xFF, 0x86, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x30, 0x08, 0x00, 0x02, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x04,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x08, 0x00, 0x30, 0x02, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x04, 0x00,
  0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x04, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x36, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x02, 0x84, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x08, 0x00, 0x04, 0x03, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x01, 0x80,
  0x02, 0x00, 0x60, 0x00, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x01, 0x00, 0x06, 0x00, 0x40, 0x01, 0x80, 0x30,
  0x00, 0x20, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0A, 0x01, 0xA0, 0x00, 0x01, 0xA0, 0x1A,
  0x00, 0x00, 0x16, 0x01, 0xA0, 0x00, 0x03, 0x60, 0x12, 0x00, 0x00, 0x24,
  0x01, 0x20, 0x00, 0x06, 0x40, 0x32, 0x00, 0x00, 0x44, 0x03, 0x20, 0x00,
  0x0C, 0xC0, 0x23, 0x00, 0x00, 0x8C, 0x02, 0x30, 0x00, 0x18, 0x80, 0x23,
  0x00, 0x01, 0x08, 0x06, 0x30, 0x00, 0x31, 0x80, 0x61, 0x00, 0x02, 0x18,
  0x04, 0x10, 0x00, 0x61, 0x80, 0x41, 0x00, 0x04, 0x10, 0x0C, 0x10, 0x00,
  0xC1, 0x00, 0xC1, 0x00, 0x08, 0x30, 0x0C, 0x10, 0x01, 0x83, 0x00, 0x81,
  0x00, 0x10, 0x20, 0x08, 0x18, 0x03, 0x02, 0x01, 0x81, 0x80, 0x20, 0x20,
  0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x40, 0x60, 0x10, 0x08, 0x0C,
  0x04, 0x01, 0x00, 0x80, 0x80, 0x40, 0x30, 0x08, 0x18, 0x0C, 0x03, 0x00,
  0x83, 0x00, 0xC0, 0x20, 0x08, 0x30, 0x0C, 0x02, 0x00, 0x86, 0x00, 0x80,
  0x60, 0x08, 0x60, 0x08, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x60, 0x0C, 0x80,
  0x18, 0x04, 0x00, 0xD8, 0x01, 0x00, 0x40, 0x0D, 0x00, 0x10, 0x0C, 0x00,
  0xF0, 0x01, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x04, 0x01,
  0xC0, 0x00, 0x20, 0x1A, 0x00, 0x03, 0x00, 0xD0, 0x00, 0x18, 0x06, 0xC0,
  0x00, 0x80, 0x26, 0x00, 0x04, 0x01, 0x10, 0x00, 0x20, 0x18, 0x80, 0x03,
  0x00, 0xC6, 0x00, 0x18, 0x04, 0x30, 0x00, 0x80, 0x20, 0x80, 0x04, 0x01,
  0x06, 0x00, 0x60, 0x18, 0x30, 0x03, 0x00, 0xC0, 0x80, 0x18, 0x04, 0x04,
  0x00, 0x80, 0x20, 0x30, 0x04, 0x03, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x10, 0x04, 0x01, 0x80, 0x80, 0x20, 0x0C, 0x04, 0x03,
  0x00, 0x20, 0x60, 0x18, 0x01, 0x03, 0x00, 0x80, 0x0C, 0x10, 0x04, 0x00,
  0x60, 0x80, 0x20, 0x01, 0x0C, 0x03, 0x00, 0x08, 0x60, 0x18, 0x00, 0x63,
  0x00, 0x80, 0x03, 0x10, 0x04, 0x00, 0x08, 0x80, 0x60, 0x00, 0x4C, 0x03,
  0x00, 0x03, 0x60, 0x18, 0x00, 0x1B, 0x00, 0x80, 0x00, 0x50, 0x04, 0x00,
  0x02, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0E, 0x07, 0x00, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x0C,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x24, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00,
  0x01, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0x87, 0xC0, 0x02, 0x00, 0xE0, 0x04, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x60, 0x01, 0x80, 0x80, 0x03,
  0x01, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30,
  0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x04,
  0x00, 0x18, 0x08, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x07, 0x00, 0xC0,
  0x1C, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x20,
  0x0C, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x08, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0x87, 0xC0, 0x02, 0x00, 0xE0, 0x04, 0x00, 0x40,
  0x18, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x60, 0x01, 0x00, 0x80, 0x03, 0x01,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20,
  0x00, 0x40, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x18, 0x08, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0xF8,
  0x01, 0xFF, 0x80, 0x02, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x08, 0x00, 0x40, 0x10, 0x00, 0x80, 0x20, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x38, 0x07, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x80, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x18, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x10,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x60, 0x40, 0x00, 0x18, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18, 0x10, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x08, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x20,
  0x00, 0x10, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x40, 0x01, 0x00,
  0x18, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00,
  0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0xC3, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40,
  0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x10, 0x01, 0x80, 0x40, 0x04,
  0x01, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x40, 0x10, 0x01,
  0x00, 0xC0, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x60, 0x01, 0x03,
  0x00, 0x04, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x41, 0x80, 0x01, 0x04, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0x66, 0x00, 0x01, 0x90, 0x00, 0x06,
  0xC0, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x00,
  0xA0, 0x00, 0x4C, 0x00, 0x1A, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0xCC,
  0x00, 0x12, 0x00, 0x08, 0xC0, 0x03, 0x20, 0x01, 0x8C, 0x00, 0x22, 0x00,
  0x10, 0xC0, 0x06, 0x20, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x20, 0xC0, 0x0C,
  0x20, 0x06, 0x0C, 0x00, 0xC2, 0x00, 0x60, 0xC0, 0x08, 0x20, 0x04, 0x0C,
  0x01, 0x82, 0x00, 0xC0, 0xC0, 0x10, 0x20, 0x08, 0x0C, 0x03, 0x02, 0x01,
  0x80, 0xC0, 0x20, 0x20, 0x10, 0x0C, 0x02, 0x02, 0x01, 0x00, 0xC0, 0x60,
  0x20, 0x30, 0x0C, 0x04, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x20, 0x60, 0x04,
  0x08, 0x02, 0x04, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x04, 0x18, 0x02, 0x0C,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x04, 0x30, 0x02, 0x18, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x04, 0x60, 0x02, 0x30, 0x00, 0x44, 0x00, 0x22, 0x00, 0x04,
  0xC0, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x04, 0x80, 0x02, 0x40,
  0x00, 0x58, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00,
  0x28, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x60, 0x04, 0x00, 0x08, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x20, 0x06,
  0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x18, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x80,
  0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0B,
  0x00, 0x03, 0x60, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC2,
  0x00, 0x30, 0x60, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x20, 0x10, 0x0C, 0x02,
  0x03, 0x00, 0x40, 0x60, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x02,
  0x10, 0x00, 0x46, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x81, 0x02, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x18, 0x30, 0x60, 0x40,
  0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04,
  0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x00, 0x1F, 0xF8, 0x01, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x40, 0x00,
  0x0D, 0x80, 0x00, 0x62, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20,
  0x40, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x20, 0x08, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x40, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x08, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x06, 0xC0, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x06, 0x08, 0x20, 0x41, 0x82, 0x04,
  0x00, 0x3E, 0x08, 0x07, 0xBC, 0x40, 0x60, 0x26, 0x06, 0x01, 0xA0, 0x60,
  0x05, 0x06, 0x00, 0x28, 0x20, 0x01, 0xC3, 0x00, 0x0E, 0x10, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30,
  0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0xC0, 0x05, 0x06, 0x00, 0x78, 0x10, 0x02, 0xC0, 0xC0,
  0x24, 0x03, 0x06, 0x20, 0x0F, 0xE1, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x07, 0xC0, 0x08,
  0xE7, 0x80, 0x4C, 0x06, 0x06, 0xC0, 0x30, 0x3C, 0x00, 0xC1, 0x40, 0x06,
  0x0E, 0x00, 0x30, 0x60, 0x00, 0x87, 0x00, 0x04, 0x30, 0x00, 0x21, 0x80,
  0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x21, 0x00, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x38,
  0x00, 0x41, 0xC0, 0x06, 0x0A, 0x00, 0x60, 0xD8, 0x06, 0x04, 0x60, 0xE0,
  0x21, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x78, 0xC0, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x81, 0x00, 0xFF, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0x08, 0x00, 0xF3, 0x88, 0x01, 0x80, 0xD8,
  0x03, 0x00, 0x58, 0x06, 0x00, 0x78, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x20,
  0x20, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0x40,
  0x40, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80,
  0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0D, 0x00, 0x40, 0x19, 0x00,
  0x60, 0x3B, 0x00, 0x30, 0x62, 0x00, 0x1F, 0xC2, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x3C, 0xE0, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0xC3,
  0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x62, 0x00,
  0x31, 0x80, 0x18, 0x60, 0x0C, 0x10, 0x0E, 0x07, 0xFE, 0x01, 0xFC, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x18, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC2, 0x00, 0x79, 0xC4, 0x01, 0x80, 0xC8, 0x06, 0x00, 0xB0,
  0x18, 0x01, 0xE0, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x40, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0xF0, 0x30, 0x01, 0xC0,
  0x60, 0x06, 0x80, 0x40, 0x1B, 0x00, 0xC0, 0x76, 0x00, 0xC1, 0xC8, 0x00,
  0xFE, 0x10, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x80, 0x18, 0x01, 0x80, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0xF8, 0x02, 0x38, 0xE0, 0x26, 0x03, 0x06, 0xC0, 0x30, 0x78,
  0x01, 0x05, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x10, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x30, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x84, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x03, 0x02,
  0x00, 0x60, 0x20, 0x04, 0x06, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0x40, 0x60, 0x04, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x00, 0x82, 0x00,
  0x08, 0x60, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0x34, 0x00, 0x16, 0x60,
  0x01, 0x46, 0x00, 0x38, 0x20, 0x03, 0x03, 0x00, 0x30, 0x30, 0x02, 0x01,
  0x00, 0x20, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x00, 0x80, 0x40,
  0x08, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x40, 0x80, 0x06, 0x00,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x02, 0x1F, 0x80, 0xFC, 0x02, 0x39,
  0xC3, 0x8E, 0x02, 0xC0, 0x66, 0x03, 0x06, 0x80, 0x6C, 0x03, 0x05, 0x00,
  0x28, 0x01, 0x07, 0x00, 0x30, 0x01, 0x06, 0x00, 0x30, 0x01, 0x06, 0x00,
  0x20, 0x01, 0x0C, 0x00, 0x60, 0x01, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00,
  0x60, 0x03, 0x08, 0x00, 0x40, 0x02, 0x18, 0x00, 0x40, 0x02, 0x18, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x10, 0x00, 0x80, 0x04, 0x10, 0x00,
  0x80, 0x04, 0x30, 0x00, 0x80, 0x04, 0x30, 0x01, 0x80, 0x0C, 0x20, 0x01,
  0x80, 0x0C, 0x20, 0x01, 0x00, 0x08, 0x20, 0x01, 0x00, 0x08, 0x60, 0x03,
  0x00, 0x08, 0x60, 0x03, 0x00, 0x18, 0x40, 0x02, 0x00, 0x18, 0x40, 0x02,
  0x00, 0x10, 0x40, 0x02, 0x00, 0x10, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x06,
  0x00, 0x30, 0x80, 0x04, 0x00, 0x30, 0x02, 0x0F, 0x80, 0x23, 0x8E, 0x02,
  0x60, 0x30, 0x68, 0x03, 0x05, 0x80, 0x10, 0x70, 0x01, 0x06, 0x00, 0x10,
  0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0x80, 0x02,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x04, 0x10, 0x00,
  0x43, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00,
  0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x20, 0x00, 0x3F, 0x00,
  0x0E, 0x38, 0x01, 0x80, 0xC0, 0x30, 0x04, 0x06, 0x00, 0x60, 0xC0, 0x02,
  0x08, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00,
  0x32, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x04,
  0x00, 0x60, 0x60, 0x04, 0x06, 0x00, 0xC0, 0x30, 0x38, 0x01, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x41, 0xF0, 0x00, 0x47, 0xBC, 0x00, 0x4C, 0x06,
  0x00, 0xD8, 0x06, 0x00, 0xB0, 0x03, 0x00, 0xA0, 0x03, 0x00, 0xE0, 0x01,
  0x00, 0xC0, 0x01, 0x01, 0xC0, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01,
  0x01, 0x80, 0x01, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x04, 0x06, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x08,
  0x0C, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x0E, 0x00, 0x30, 0x0A, 0x00, 0x60,
  0x1B, 0x00, 0xC0, 0x19, 0x83, 0x80, 0x10, 0xFF, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x08, 0x07, 0xBC, 0x40, 0x60, 0x32, 0x06, 0x00, 0xB0, 0x60,
  0x07, 0x86, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E,
  0x18, 0x00, 0x70, 0xC0, 0x07, 0x06, 0x00, 0x68, 0x10, 0x02, 0xC0, 0xC0,
  0x36, 0x03, 0x07, 0x20, 0x0F, 0xE1, 0x00, 0x08, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x02, 0x0F, 0x02, 0x39, 0x02, 0x60, 0x06,
  0xC0, 0x05, 0x80, 0x05, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xF1, 0xF0, 0x60, 0x08,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x82, 0x00, 0x60, 0xC0, 0x70, 0x3F, 0xF0,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x7F, 0x3F, 0xF0, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x7E, 0x00, 0xC0,
  0x04, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00,
  0x04, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x20,
  0x00, 0x82, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60,
  0x80, 0x06, 0x08, 0x00, 0xA0, 0xC0, 0x1E, 0x0C, 0x03, 0x60, 0x60, 0xE4,
  0x03, 0xF8, 0x40, 0x06, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x58, 0x00, 0x6C, 0x00, 0x26, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0xC0,
  0x08, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x06, 0x04, 0x03, 0x02, 0x03, 0x01,
  0x01, 0x80, 0x81, 0x80, 0x40, 0xC0, 0x20, 0xC0, 0x10, 0x60, 0x08, 0x20,
  0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x6C, 0x00, 0x34,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x2C, 0x00, 0x60, 0x06,
  0xC0, 0x0A, 0x00, 0x6C, 0x00, 0xA0, 0x04, 0xC0, 0x1A, 0x00, 0xCC, 0x01,
  0x20, 0x08, 0xC0, 0x32, 0x01, 0x8C, 0x02, 0x20, 0x18, 0xC0, 0x62, 0x01,
  0x04, 0x04, 0x20, 0x30, 0x40, 0x42, 0x02, 0x04, 0x0C, 0x20, 0x60, 0x40,
  0x83, 0x04, 0x04, 0x18, 0x30, 0x40, 0x41, 0x03, 0x0C, 0x04, 0x30, 0x30,
  0x80, 0x42, 0x03, 0x18, 0x04, 0x60, 0x31, 0x00, 0x44, 0x03, 0x10, 0x04,
  0x40, 0x33, 0x00, 0x4C, 0x03, 0x20, 0x04, 0x80, 0x36, 0x00, 0x58, 0x03,
  0x40, 0x05, 0x00, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x60, 0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0x01, 0x00, 0x04, 0x04, 0x00,
  0x30, 0x18, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x30, 0x02, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x41, 0x80, 0x01, 0x8C, 0x00, 0x06,
  0x20, 0x00, 0x09, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x62, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x60, 0x40, 0x03, 0x01,
  0x80, 0x08, 0x06, 0x00, 0x60, 0x08, 0x03, 0x00, 0x20, 0x18, 0x00, 0xC0,
  0x60, 0x01, 0x03, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x20, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x18, 0x00, 0x10, 0x02,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x20, 0x30, 0x00, 0x04, 0x04, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x10, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08,
  0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x0B, 0x87, 0x00, 0x70, 0x0E, 0x07,
  0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 40, 11, 1, -40 },
  { 56, 11, 14, 15, 6, -40 },
  { 76, 24, 40, 25, 1, -40 },
  { 196, 23, 46, 23, 0, -43 },
  { 329, 28, 42, 33, 3, -41 },
  { 476, 23, 42, 24, 0, -41 },
  { 597, 4, 14, 9, 6, -40 },
  { 604, 15, 49, 14, 2, -40 },
  { 696, 15, 49, 14, -4, -40 },
  { 788, 16, 17, 21, 7, -42 },
  { 822, 21, 26, 25, 2, -33 },
  { 891, 7, 12, 9, -2, -5 },
  { 902, 12, 2, 16, 2, -16 },
  { 905, 3, 4, 10, 1, -4 },
  { 907, 23, 40, 17, -2, -40 },
  { 1022, 20, 42, 23, 2, -41 },
  { 1127, 11, 40, 23, 7, -40 },
  { 1182, 23, 41, 23, -1, -41 },
  { 1300, 23, 42, 23, -1, -41 },
  { 1421, 23, 40, 23, -1, -40 },
  { 1536, 23, 41, 23, 0, -40 },
  { 1654, 21, 42, 23, 2, -41 },
  { 1765, 21, 40, 23, 3, -40 },
  { 1870, 23, 42, 23, 0, -41 },
  { 1991, 21, 42, 23, 1, -41 },
  { 2102, 8, 30, 10, 1, -30 },
  { 2132, 12, 37, 10, -3, -30 },
  { 2188, 21, 24, 25, 2, -32 },
  { 2251, 21, 13, 25, 2, -26 },
  { 2286, 21, 24, 25, 2, -32 },
  { 2349, 16, 41, 16, 2, -41 },
  { 2431, 31, 45, 34, 2, -40 },
  { 2606, 22, 40, 22, -4, -40 },
  { 2716, 24, 40, 25, 1, -40 },
  { 2836, 24, 42, 23, 3, -41 },
  { 2962, 25, 40, 28, 1, -40 },
  { 3087, 23, 40, 22, 1, -40 },
  { 3202, 23, 40, 20, 1, -40 },
  { 3317, 27, 42, 29, 3, -41 },
  { 3459, 28, 40, 29, 1, -40 },
  { 3599, 17, 40, 11, -2, -40 },
  { 3684, 19, 50, 10, -8, -40 },
  { 3803, 26, 40, 23, 1, -40 },
  { 3933, 15, 40, 20, 1, -40 },
  { 4008, 36, 40, 37, 1, -40 },
  { 4188, 29, 40, 29, 1, -40 },
  { 4333, 25, 42, 29, 3, -41 },
  { 4465, 23, 40, 23, 1, -40 },
  { 4580, 25, 51, 29, 3, -41 },
  { 4740, 23, 40, 23, 1, -40 },
  { 4855, 24, 42, 22, -1, -41 },
  { 4981, 19, 40, 20, 5, -40 },
  { 5076, 26, 41, 28, 3, -40 },
  { 5210, 22, 40, 22, 5, -40 },
  { 5320, 36, 40, 37, 5, -40 },
  { 5500, 27, 40, 20, -3, -40 },
  { 5635, 19, 40, 19, 5, -40 },
  { 5730, 26, 40, 21, -2, -40 },
  { 5860, 20, 49, 16, -1, -40 },
  { 5983, 7, 40, 18, 6, -40 },
  { 6018, 21, 49, 16, -4, -40 },
  { 6147, 22, 21, 25, 2, -40 },
  { 6205, 16, 2, 16, -4, 5 },
  { 6209, 6, 9, 12, 8, -43 },
  { 6216, 21, 31, 24, 2, -30 },
  { 6298, 21, 44, 24, 1, -43 },
  { 6414, 17, 31, 18, 2, -30 },
  { 6480, 24, 44, 24, 2, -43 },
  { 6612, 18, 31, 21, 2, -30 },
  { 6682, 26, 56, 12, -7, -43 },
  { 6864, 23, 43, 24, 0, -30 },
  { 6988, 20, 43, 23, 1, -43 },
  { 7096, 10, 40, 10, 1, -40 },
  { 7146, 19, 53, 10, -8, -40 },
  { 7272, 20, 43, 19, 1, -43 },
  { 7380, 10, 43, 9, 1, -43 },
  { 7434, 32, 30, 36, 1, -30 },
  { 7554, 20, 30, 23, 1, -30 },
  { 7629, 20, 31, 24, 2, -30 },
  { 7707, 24, 43, 24, -2, -30 },
  { 7836, 21, 43, 24, 2, -30 },
  { 7949, 16, 30, 15, 1, -30 },
  { 8009, 18, 31, 18, 0, -30 },
  { 8079, 12, 38, 12, 1, -37 },
  { 8136, 20, 31, 23, 2, -30 },
  { 8214, 17, 30, 18, 3, -30 },
  { 8278, 28, 30, 29, 3, -30 },
  { 8383, 22, 30, 19, -2, -30 },
  { 8466, 27, 44, 18, -6, -30 },
  { 8615, 20, 30, 16, -2, -30 },
  { 8690, 19, 49, 18, 2, -40 },
  { 8807, 1, 57, 22, 11, -43 },
  { 8815, 19, 49, 18, -3, -40 },
  { 8932, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_THINITALIC56PT7B_H_
