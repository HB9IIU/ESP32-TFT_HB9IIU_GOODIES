#ifndef _NOTOSANS_CONDENSED_THINITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x40, 0x00, 0x80, 0x55, 0x99, 0x90,
  0x04, 0x81, 0x20, 0x88, 0x24, 0x3F, 0xC4, 0x41, 0x20, 0x48, 0x22, 0x3F,
  0xC2, 0x40, 0x90, 0x48, 0x12, 0x04, 0x80, 0x02, 0x02, 0x07, 0xE4, 0x82,
  0x41, 0x20, 0xA0, 0x30, 0x08, 0x06, 0x02, 0x82, 0x41, 0x20, 0x93, 0x70,
  0x40, 0x20, 0x00, 0x38, 0x49, 0x11, 0x22, 0x44, 0x88, 0x91, 0x14, 0x23,
  0x74, 0xA9, 0xEA, 0x21, 0x44, 0x49, 0x0A, 0x22, 0x44, 0x89, 0x10, 0xE0,
  0x0E, 0x11, 0x11, 0x12, 0x12, 0x14, 0x08, 0x18, 0x28, 0x45, 0x85, 0x86,
  0x82, 0x86, 0x79, 0x5A, 0x80, 0x08, 0x84, 0x44, 0x22, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x00, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x11, 0x08, 0x84, 0x44, 0x00, 0x10, 0x8E, 0x0F, 0x52, 0x41, 0x00, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x29, 0x28, 0xF0, 0x80,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x00, 0x1E, 0x44, 0x8A, 0x14, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x14, 0x28, 0x91, 0x3C, 0x00, 0x35, 0xA2, 0x22, 0x24, 0x44,
  0x48, 0x88, 0x80, 0x1E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0xFC, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x1C, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x01, 0x03, 0x05,
  0x05, 0x09, 0x12, 0x12, 0x22, 0x42, 0x44, 0x84, 0x7F, 0x04, 0x04, 0x08,
  0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x00, 0xF0, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x23, 0xE0, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x40, 0xBC,
  0xC2, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x7F, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x0F,
  0x08, 0x48, 0x24, 0x12, 0x10, 0x88, 0x58, 0x30, 0x24, 0x21, 0x20, 0x90,
  0x48, 0x24, 0x11, 0xF0, 0x0E, 0x11, 0x21, 0x21, 0x41, 0x41, 0x41, 0x43,
  0x3D, 0x02, 0x02, 0x02, 0x04, 0x08, 0xF0, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x44, 0x88, 0x01, 0x06, 0x18, 0x60, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0x78, 0x10, 0x41, 0x08, 0x21, 0x08,
  0x41, 0x08, 0x00, 0x00, 0x08, 0x00, 0x07, 0xC3, 0x04, 0x80, 0x90, 0x14,
  0x72, 0x92, 0x62, 0x4C, 0x89, 0x91, 0x32, 0x46, 0x89, 0x4B, 0x28, 0x99,
  0x00, 0x20, 0x02, 0x00, 0x3C, 0x00, 0x02, 0x02, 0x05, 0x05, 0x09, 0x09,
  0x11, 0x11, 0x3F, 0x21, 0x21, 0x41, 0x41, 0x81, 0x81, 0x1F, 0x08, 0x44,
  0x22, 0x12, 0x09, 0x04, 0x84, 0x7C, 0x21, 0x20, 0x90, 0x48, 0x24, 0x14,
  0x13, 0xF0, 0x0F, 0x88, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x02, 0x00, 0xF0, 0x1F, 0x04, 0x21, 0x04, 0x41,
  0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x90, 0x24, 0x09, 0x04, 0x41, 0x21,
  0x8F, 0x80, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x7C, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x03, 0xF0, 0x1F, 0x88, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x7C, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00,
  0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x0C, 0x80, 0xA0,
  0x28, 0x12, 0x04, 0x81, 0x10, 0x43, 0xE0, 0x10, 0x22, 0x04, 0x40, 0x88,
  0x22, 0x04, 0x40, 0x88, 0x11, 0xFE, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44,
  0x11, 0x02, 0x20, 0x40, 0x1C, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x8E, 0x00, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x44, 0x21,
  0x10, 0x48, 0x24, 0x0A, 0x02, 0x80, 0xE0, 0x28, 0x11, 0x04, 0x41, 0x10,
  0x42, 0x20, 0x88, 0x20, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x10, 0x42, 0x0F, 0xC0, 0x10, 0x04, 0x40, 0x31, 0x80, 0x86, 0x06, 0x28,
  0x28, 0xA0, 0xA2, 0x84, 0x8A, 0x12, 0x48, 0x91, 0x22, 0x44, 0x91, 0x11,
  0x44, 0x46, 0x22, 0x18, 0x88, 0x42, 0x00, 0x10, 0x23, 0x04, 0x60, 0x8C,
  0x12, 0x44, 0x48, 0x89, 0x11, 0x22, 0x42, 0x48, 0x51, 0x0A, 0x21, 0x44,
  0x19, 0x02, 0x20, 0x40, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18,
  0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x87, 0xC0, 0x1F,
  0x08, 0x44, 0x22, 0x12, 0x09, 0x04, 0x84, 0x44, 0x3C, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18,
  0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x87, 0x40, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x1F, 0x08, 0x44, 0x22, 0x12, 0x09, 0x04, 0x84,
  0x44, 0x5C, 0x22, 0x11, 0x08, 0x84, 0x24, 0x12, 0x08, 0x1F, 0x90, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x23, 0xE0, 0xFE, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x00, 0x20, 0x48, 0x12, 0x05, 0x02, 0x40, 0x90, 0x24,
  0x09, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x82, 0x20, 0x87, 0xC0, 0x81,
  0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0xC0,
  0xC0, 0x80, 0x82, 0x0C, 0x10, 0x61, 0x83, 0x0C, 0x28, 0xA1, 0x45, 0x12,
  0x28, 0x92, 0x44, 0x92, 0x45, 0x12, 0x28, 0xA1, 0x85, 0x0C, 0x30, 0x41,
  0x82, 0x08, 0x00, 0x10, 0x42, 0x20, 0x88, 0x24, 0x0A, 0x02, 0x80, 0x40,
  0x10, 0x0C, 0x05, 0x02, 0x40, 0x88, 0x42, 0x10, 0x88, 0x20, 0x83, 0x0A,
  0x14, 0x48, 0x92, 0x14, 0x30, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x00,
  0x0F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x0F, 0xE0, 0x1E, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0xC0, 0x92,
  0x44, 0x92, 0x48, 0x92, 0x48, 0x1E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x11, 0xE0, 0x08, 0x14, 0x14,
  0x24, 0x42, 0x42, 0x81, 0x81, 0xFE, 0x94, 0x3D, 0x42, 0x42, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x10, 0x10, 0x10, 0x10, 0x20, 0x2F,
  0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x3D, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x80, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x91, 0xA9, 0x08, 0x84, 0x82, 0x41, 0x20, 0x90, 0x48, 0x44, 0x22, 0x31,
  0xE8, 0x3D, 0x14, 0x61, 0x8B, 0xC8, 0x20, 0x82, 0x07, 0x80, 0x01, 0xC0,
  0x80, 0x20, 0x08, 0x02, 0x03, 0x40, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0xE0,
  0x00, 0x1E, 0x90, 0x88, 0x48, 0x24, 0x12, 0x09, 0x04, 0x84, 0x42, 0x23,
  0x1E, 0x80, 0x40, 0x40, 0x20, 0x21, 0xE0, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x2F, 0x31, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x84, 0x10,
  0x00, 0x22, 0x22, 0x44, 0x44, 0x48, 0x80, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x86,
  0x00, 0x10, 0x10, 0x10, 0x10, 0x20, 0x21, 0x22, 0x24, 0x28, 0x50, 0x68,
  0x48, 0x48, 0x48, 0x84, 0x84, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x44,
  0x88, 0x2E, 0xF1, 0x88, 0x48, 0x42, 0x42, 0x24, 0x21, 0x21, 0x09, 0x08,
  0x48, 0x42, 0x44, 0x24, 0x21, 0x21, 0x08, 0x2F, 0x31, 0x21, 0x21, 0x41,
  0x42, 0x42, 0x42, 0x42, 0x82, 0x84, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x85, 0x11, 0xC0, 0x17, 0x8C, 0x44, 0x22, 0x12, 0x09, 0x04, 0x82,
  0x41, 0x21, 0x10, 0x97, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x3D, 0x42,
  0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x2E, 0x60, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00,
  0x3E, 0x81, 0x02, 0x02, 0x02, 0x02, 0x04, 0x08, 0x13, 0xC0, 0x22, 0x4F,
  0x44, 0x48, 0x88, 0x88, 0x8C, 0x42, 0x85, 0x0A, 0x18, 0x30, 0xA1, 0x42,
  0x85, 0x13, 0xE0, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50, 0xA0, 0x81,
  0x00, 0x84, 0x30, 0x8A, 0x31, 0x46, 0x49, 0x49, 0x29, 0x29, 0x45, 0x28,
  0xC6, 0x18, 0x42, 0x10, 0x00, 0x11, 0x88, 0x84, 0x82, 0x80, 0x80, 0x40,
  0x60, 0x48, 0x24, 0x22, 0x21, 0x00, 0x10, 0x44, 0x21, 0x08, 0x44, 0x09,
  0x02, 0x80, 0xA0, 0x28, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x03, 0x00, 0x1F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0xF8, 0x0E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x41, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x80, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x04, 0x0C, 0x20, 0x81, 0x02, 0x04, 0x08, 0x21, 0x80,
  0xFF,
};

const GFXglyph NotoSans_Condensed_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 15, 4, 0, -15 },
  { 9, 4, 5, 6, 2, -15 },
  { 12, 10, 15, 9, 0, -15 },
  { 31, 9, 17, 8, 0, -16 },
  { 51, 11, 15, 12, 1, -15 },
  { 72, 8, 15, 9, 0, -15 },
  { 87, 2, 5, 3, 2, -15 },
  { 89, 5, 18, 5, 1, -15 },
  { 101, 5, 18, 5, -1, -15 },
  { 113, 6, 7, 8, 3, -16 },
  { 119, 8, 9, 9, 1, -12 },
  { 128, 3, 5, 3, -1, -2 },
  { 130, 4, 1, 6, 1, -6 },
  { 131, 1, 1, 4, 0, -1 },
  { 132, 9, 15, 6, -1, -15 },
  { 149, 7, 15, 9, 1, -15 },
  { 163, 4, 15, 9, 3, -15 },
  { 171, 8, 15, 9, 0, -15 },
  { 186, 8, 15, 9, 0, -15 },
  { 201, 8, 15, 9, 0, -15 },
  { 216, 9, 15, 9, 0, -15 },
  { 233, 8, 15, 9, 1, -15 },
  { 248, 8, 15, 9, 1, -15 },
  { 263, 9, 15, 9, 0, -15 },
  { 280, 8, 15, 9, 0, -15 },
  { 295, 3, 11, 4, 0, -11 },
  { 300, 4, 14, 4, -1, -11 },
  { 307, 8, 9, 9, 1, -12 },
  { 316, 8, 5, 9, 1, -10 },
  { 321, 8, 9, 9, 1, -12 },
  { 330, 6, 15, 6, 1, -15 },
  { 342, 11, 17, 13, 1, -15 },
  { 366, 8, 15, 8, -1, -15 },
  { 381, 9, 15, 9, 0, -15 },
  { 398, 9, 15, 9, 1, -15 },
  { 415, 10, 15, 10, 0, -15 },
  { 434, 9, 15, 8, 0, -15 },
  { 451, 9, 15, 8, 0, -15 },
  { 468, 10, 15, 11, 1, -15 },
  { 487, 11, 15, 11, 0, -15 },
  { 508, 6, 15, 4, -1, -15 },
  { 520, 7, 19, 4, -3, -15 },
  { 537, 10, 15, 9, 0, -15 },
  { 556, 6, 15, 8, 0, -15 },
  { 568, 14, 15, 14, 0, -15 },
  { 595, 11, 15, 11, 0, -15 },
  { 616, 10, 15, 11, 1, -15 },
  { 635, 9, 15, 9, 0, -15 },
  { 652, 10, 19, 11, 1, -15 },
  { 676, 9, 15, 9, 0, -15 },
  { 693, 9, 15, 8, 0, -15 },
  { 710, 7, 15, 7, 2, -15 },
  { 724, 10, 15, 11, 1, -15 },
  { 743, 8, 15, 8, 2, -15 },
  { 758, 13, 15, 14, 2, -15 },
  { 783, 10, 15, 8, -1, -15 },
  { 802, 7, 15, 7, 2, -15 },
  { 816, 10, 15, 8, -1, -15 },
  { 835, 7, 18, 6, 0, -15 },
  { 851, 3, 15, 7, 2, -15 },
  { 857, 7, 18, 6, -1, -15 },
  { 873, 8, 8, 9, 1, -15 },
  { 881, 7, 1, 6, -2, 2 },
  { 882, 2, 3, 4, 3, -16 },
  { 883, 8, 11, 9, 1, -11 },
  { 894, 8, 16, 9, 0, -16 },
  { 910, 6, 11, 7, 1, -11 },
  { 919, 9, 16, 9, 1, -16 },
  { 937, 6, 11, 8, 1, -11 },
  { 946, 10, 21, 4, -3, -16 },
  { 973, 9, 16, 9, 0, -11 },
  { 991, 8, 16, 9, 0, -16 },
  { 1007, 4, 15, 4, 0, -15 },
  { 1015, 7, 20, 4, -3, -15 },
  { 1033, 8, 16, 7, 0, -16 },
  { 1049, 4, 16, 3, 0, -16 },
  { 1057, 13, 11, 13, 0, -11 },
  { 1075, 8, 11, 9, 0, -11 },
  { 1086, 7, 11, 9, 1, -11 },
  { 1096, 9, 16, 9, -1, -11 },
  { 1114, 8, 16, 9, 1, -11 },
  { 1130, 7, 11, 6, 0, -11 },
  { 1140, 7, 11, 7, 0, -11 },
  { 1150, 4, 14, 5, 1, -14 },
  { 1157, 7, 11, 9, 1, -11 },
  { 1167, 7, 11, 7, 1, -11 },
  { 1177, 11, 11, 11, 1, -11 },
  { 1193, 9, 11, 7, -1, -11 },
  { 1206, 10, 16, 7, -2, -11 },
  { 1226, 8, 11, 6, -1, -11 },
  { 1237, 7, 18, 7, 1, -15 },
  { 1253, 1, 21, 8, 4, -16 },
  { 1256, 7, 18, 7, -1, -15 },
  { 1272, 8, 1, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_THINITALIC21PT7B_H_
