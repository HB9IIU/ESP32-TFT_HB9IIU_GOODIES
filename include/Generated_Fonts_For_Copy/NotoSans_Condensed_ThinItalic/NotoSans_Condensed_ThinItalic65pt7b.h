#ifndef _NOTOSANS_CONDENSED_THINITALIC65PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x0C, 0x1C, 0x60, 0x61, 0x81, 0x86, 0x06, 0x10,
  0x10, 0x40, 0x43, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0x80, 0x82, 0x02, 0x18,
  0x18, 0x60, 0x61, 0x01, 0x04, 0x04, 0x30, 0x30, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x20, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x60, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x20, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x30, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xC3, 0x0F, 0x00, 0xC0, 0x80,
  0x80, 0x60, 0x20, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x01, 0xD0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x18, 0x00,
  0x04, 0x0C, 0x02, 0x03, 0x0E, 0x00, 0xF8, 0xDF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x08, 0x07, 0x0C, 0x00, 0x18,
  0x06, 0x06, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x04, 0x06, 0x00, 0x40, 0x0C, 0x0C, 0x00,
  0xC0, 0x0C, 0x08, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x0C, 0x30, 0x00,
  0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x60, 0xFC, 0xC0, 0x18, 0x61, 0xCE,
  0xC0, 0x30, 0xC3, 0x06, 0xC0, 0x30, 0x86, 0x02, 0xC0, 0x21, 0x8C, 0x02,
  0xC0, 0x63, 0x0C, 0x03, 0xC0, 0xC3, 0x18, 0x03, 0x61, 0x86, 0x18, 0x03,
  0x7F, 0x06, 0x10, 0x03, 0x3E, 0x0C, 0x30, 0x02, 0x00, 0x08, 0x30, 0x02,
  0x00, 0x18, 0x30, 0x06, 0x00, 0x30, 0x60, 0x06, 0x00, 0x30, 0x60, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x04,
  0x00, 0x80, 0x40, 0x0C, 0x01, 0x80, 0x40, 0x0C, 0x01, 0x00, 0xC0, 0x08,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x40, 0x60, 0x18, 0x00, 0x60, 0x60,
  0x10, 0x00, 0x71, 0xC0, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x03, 0x0C, 0x03, 0x00, 0xC6, 0x00,
  0x40, 0x21, 0x80, 0x18, 0x18, 0xC0, 0x06, 0x06, 0x30, 0x00, 0xC3, 0x18,
  0x00, 0x30, 0xC6, 0x00, 0x04, 0x61, 0x00, 0x01, 0x98, 0x40, 0x00, 0x6C,
  0x30, 0x00, 0x0F, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x38, 0x10, 0x00, 0x1E, 0x06, 0x00, 0x0C, 0x81, 0x80, 0x06, 0x30, 0x30,
  0x03, 0x0C, 0x07, 0x03, 0x81, 0x80, 0xFF, 0x80, 0x60, 0x0F, 0x00, 0x00,
  0x0C, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x01, 0x80, 0xC0, 0x1C, 0x10, 0x00, 0xC2, 0x00,
  0x06, 0x40, 0xE0, 0x3B, 0xF8, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x32, 0x00,
  0x08, 0x40, 0x06, 0x04, 0x01, 0x80, 0x80, 0x60, 0x18, 0x08, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03,
  0x03, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0xFF, 0xFC, 0x6F, 0xB0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x02, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x03, 0x00, 0x60,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x80, 0x7C, 0x06, 0x60,
  0xE3, 0x0E, 0x18, 0xC0, 0x9C, 0x0C, 0x40, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x00,
  0xE0, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x10, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00,
  0x04, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x0F,
  0xF0, 0x01, 0x1E, 0x1E, 0x01, 0x98, 0x03, 0x00, 0xD8, 0x00, 0xC0, 0x58,
  0x00, 0x30, 0x38, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x02, 0x0C,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x71, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x40, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x02, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x70, 0x40, 0x00, 0x38, 0x30, 0x00, 0x38, 0x18,
  0x00, 0x34, 0x0C, 0x00, 0x16, 0x03, 0x00, 0x3B, 0x00, 0xC0, 0x39, 0x00,
  0x3F, 0xF1, 0x80, 0x07, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x04, 0x07, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0x38, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x01, 0xFC, 0x03, 0x04, 0x00, 0x79, 0xE0, 0x30, 0xC0, 0x0C,
  0x06, 0x03, 0x0C, 0x01, 0x80, 0x40, 0x31, 0x80, 0x30, 0x0C, 0x03, 0x18,
  0x02, 0x00, 0xC0, 0x31, 0x00, 0x60, 0x0C, 0x03, 0x30, 0x0C, 0x00, 0x80,
  0x33, 0x00, 0xC0, 0x18, 0x03, 0x30, 0x18, 0x01, 0x80, 0x22, 0x01, 0x80,
  0x18, 0x06, 0x60, 0x18, 0x01, 0x00, 0x66, 0x03, 0x00, 0x30, 0x06, 0x60,
  0x30, 0x03, 0x00, 0x46, 0x03, 0x00, 0x30, 0x0C, 0x40, 0x30, 0x06, 0x00,
  0xC4, 0x02, 0x00, 0x60, 0x08, 0xC0, 0x20, 0x06, 0x01, 0x8C, 0x06, 0x00,
  0xE0, 0x18, 0xC0, 0x20, 0x0E, 0x03, 0x0C, 0x02, 0x01, 0xE0, 0x30, 0xC0,
  0x30, 0x16, 0x06, 0x0C, 0x03, 0x03, 0x60, 0xC0, 0xC0, 0x38, 0x63, 0x18,
  0x0C, 0x01, 0xFC, 0x3F, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00,
  0xC0, 0x10, 0x00, 0x40, 0x08, 0x00, 0x60, 0x04, 0x00, 0x30, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00, 0x60, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00,
  0x3F, 0xFE, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20,
  0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x20, 0x00, 0xE0, 0x02, 0x00, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x06, 0x03, 0xF0, 0x00, 0x60, 0x03, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0xE0, 0x04, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x00, 0xF8, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x40, 0x00, 0x7F, 0xE0, 0x40,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x19, 0xB0, 0x00, 0x00, 0x6C, 0xC0,
  0x00, 0x01, 0xA3, 0x00, 0x00, 0x05, 0x04, 0x00, 0x00, 0x3C, 0x18, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x40, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x16, 0x00, 0x00,
  0x03, 0x60, 0x0D, 0x80, 0x00, 0x00, 0xD8, 0x03, 0x60, 0x00, 0x00, 0x64,
  0x00, 0xC8, 0x00, 0x00, 0x1B, 0x00, 0x32, 0x00, 0x00, 0x0C, 0xC0, 0x08,
  0x80, 0x00, 0x02, 0x30, 0x06, 0x20, 0x00, 0x01, 0x88, 0x01, 0x8C, 0x00,
  0x00, 0x42, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x00, 0x08,
  0x60, 0x04, 0x30, 0x00, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x01, 0x04, 0x00,
  0xC3, 0x00, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x08, 0x10,
  0x00, 0x18, 0x30, 0x06, 0x04, 0x00, 0x0C, 0x0C, 0x01, 0x81, 0x00, 0x03,
  0x02, 0x00, 0x60, 0x40, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x04, 0x06, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x04, 0x00, 0xC0,
  0x60, 0x06, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0xC0, 0x30, 0x02, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x20, 0x18, 0x02,
  0x00, 0x60, 0x08, 0x06, 0x01, 0x80, 0x18, 0x02, 0x03, 0x00, 0x60, 0x04,
  0x00, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0x02, 0x00, 0x31, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x60, 0x02, 0x00,
  0x60, 0x03, 0x30, 0x00, 0x80, 0x18, 0x00, 0x48, 0x00, 0x60, 0x06, 0x00,
  0x16, 0x00, 0x18, 0x01, 0x00, 0x05, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00, 0x18, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0x78, 0x00, 0x01, 0x80, 0x12, 0x00, 0x00, 0x40, 0x0C, 0xC0,
  0x00, 0x30, 0x03, 0x30, 0x00, 0x0C, 0x00, 0xCC, 0x00, 0x03, 0x00, 0x31,
  0x00, 0x00, 0xC0, 0x08, 0x60, 0x00, 0x20, 0x06, 0x18, 0x00, 0x18, 0x01,
  0x86, 0x00, 0x06, 0x00, 0x60, 0x80, 0x01, 0x80, 0x10, 0x30, 0x00, 0x40,
  0x04, 0x0C, 0x00, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x40, 0x03,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x20, 0x06, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x10, 0x0C, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x60, 0x30, 0x02,
  0x00, 0x0C, 0x08, 0x01, 0x80, 0x03, 0x06, 0x00, 0x60, 0x00, 0xC1, 0x80,
  0x18, 0x00, 0x30, 0x60, 0x04, 0x00, 0x06, 0x10, 0x03, 0x00, 0x01, 0x8C,
  0x00, 0xC0, 0x00, 0x63, 0x00, 0x30, 0x00, 0x08, 0xC0, 0x0C, 0x00, 0x03,
  0x30, 0x02, 0x00, 0x00, 0xC8, 0x01, 0x80, 0x00, 0x36, 0x00, 0x60, 0x00,
  0x05, 0x80, 0x18, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x78, 0x01, 0x00,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x04, 0x03, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x30, 0x03, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x08, 0x0F, 0x80, 0x06, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x10, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08,
  0x00, 0x04, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x08, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x07, 0x00, 0x60, 0x03, 0x80, 0x18, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x00,
  0x02, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x10, 0x02, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x20,
  0x00, 0xC0, 0x10, 0x00, 0x40, 0x08, 0x00, 0x60, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00, 0x40, 0x0C, 0x00,
  0x20, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x40, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x70, 0x00, 0x0C, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0x8C, 0x00, 0x06, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xB0, 0x00, 0x18,
  0xC0, 0x00, 0x4C, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x03, 0x0C, 0x00,
  0x08, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x8C,
  0x00, 0x10, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x03, 0x00, 0x08, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x30,
  0x01, 0x83, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x00, 0xC0, 0x08, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x03, 0x06, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0,
  0x00, 0x61, 0x00, 0x01, 0x84, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x81, 0x80, 0x04, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x20, 0x06, 0x00,
  0x80, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x10, 0x00, 0xC0,
  0xC0, 0x01, 0x06, 0x00, 0x04, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01,
  0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xC1,
  0x81, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xF0, 0xC0, 0x1C, 0x0C, 0x40, 0x18, 0x03, 0x20, 0x18, 0x00, 0xB0,
  0x18, 0x00, 0x78, 0x18, 0x00, 0x3C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x18, 0x60, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x04,
  0x00, 0x0E, 0x03, 0x00, 0x0F, 0x01, 0x80, 0x0D, 0x00, 0xC0, 0x0C, 0x80,
  0x30, 0x0C, 0x40, 0x0C, 0x1C, 0x60, 0x03, 0xFC, 0x30, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x07, 0xC0,
  0x03, 0x1F, 0xF8, 0x01, 0x1C, 0x0E, 0x00, 0x9C, 0x03, 0x00, 0xD8, 0x00,
  0xC0, 0x6C, 0x00, 0x60, 0x3C, 0x00, 0x10, 0x1C, 0x00, 0x0C, 0x1E, 0x00,
  0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x08, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x05, 0x80, 0x06, 0x02, 0x40, 0x06,
  0x03, 0x30, 0x06, 0x01, 0x8E, 0x0E, 0x00, 0x83, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x70, 0x10, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x60, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xC1,
  0x80, 0x03, 0xFF, 0x18, 0x00, 0x70, 0x39, 0x80, 0x0C, 0x01, 0x98, 0x01,
  0x80, 0x0D, 0x00, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x04, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0x40,
  0x01, 0xA0, 0x06, 0x00, 0x1A, 0x00, 0x60, 0x03, 0x60, 0x06, 0x00, 0x66,
  0x00, 0x30, 0x0E, 0x40, 0x01, 0x83, 0x84, 0x00, 0x0F, 0xF0, 0x40, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x1C, 0x0C, 0x01,
  0x80, 0x70, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x18, 0x00, 0x60, 0xC0, 0x0E, 0x04, 0x00, 0xE0, 0x60, 0x7C, 0x03,
  0xFF, 0x80, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x01, 0x00, 0xF0, 0x38, 0x01, 0xFF, 0x80, 0x01,
  0xA0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0x04, 0x00, 0x70, 0x31, 0x80, 0x18, 0x03, 0x30, 0x06, 0x00, 0x34, 0x01,
  0x80, 0x06, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xF0, 0x18, 0x00, 0x1E, 0x01, 0x00, 0x06, 0x80, 0x30, 0x00, 0xF0, 0x06,
  0x00, 0x36, 0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0x03, 0x90, 0x00, 0xC1, 0xC2,
  0x00, 0x0F, 0xF0, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00,
  0xE0, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x83, 0xF0, 0x01, 0x8F, 0xFC, 0x01,
  0x1C, 0x0C, 0x01, 0x30, 0x06, 0x03, 0x60, 0x02, 0x03, 0xC0, 0x02, 0x03,
  0x80, 0x03, 0x03, 0x80, 0x02, 0x03, 0x00, 0x02, 0x07, 0x00, 0x02, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C,
  0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20,
  0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03,
  0x01, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x8E, 0x00, 0x02, 0x3C, 0x00, 0x04, 0xC8, 0x00, 0x1B, 0x18,
  0x00, 0x3C, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0,
  0x06, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x08, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x08,
  0x00, 0x60, 0x30, 0x00, 0x40, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x83, 0xE0, 0x07, 0xC0, 0x04, 0x3F, 0xE0, 0xFF, 0xC0, 0x11,
  0x81, 0x87, 0x03, 0x80, 0x4C, 0x03, 0x30, 0x06, 0x03, 0x60, 0x05, 0x80,
  0x08, 0x0F, 0x00, 0x16, 0x00, 0x30, 0x28, 0x00, 0x70, 0x00, 0xC0, 0xC0,
  0x01, 0x80, 0x03, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x00,
  0x20, 0x60, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x01,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x20, 0x00,
  0x60, 0x00, 0xC1, 0x80, 0x01, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x01, 0x81, 0x00, 0x02,
  0x00, 0x06, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0x03, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x60, 0x00, 0xC0, 0x00, 0x81, 0x80, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x80,
  0x01, 0x83, 0x00, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0x0F, 0xFC, 0x01, 0x1C, 0x0C, 0x01, 0x30, 0x06,
  0x03, 0x60, 0x06, 0x03, 0xC0, 0x02, 0x02, 0x80, 0x03, 0x03, 0x80, 0x02,
  0x07, 0x00, 0x02, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x20,
  0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60,
  0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x60, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x90, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x09, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x18, 0x01, 0xC0, 0x30, 0x07, 0x00, 0x38, 0x3C, 0x00, 0x3F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x3E, 0x00, 0x02, 0x0F, 0xF8,
  0x00, 0x23, 0x81, 0xC0, 0x02, 0x70, 0x0C, 0x00, 0x6E, 0x00, 0x60, 0x06,
  0xC0, 0x06, 0x00, 0x58, 0x00, 0x20, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x20, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x60, 0x0F, 0x00, 0x0C, 0x00, 0x90, 0x01, 0x80, 0x19, 0x80, 0x30,
  0x01, 0x8C, 0x0E, 0x00, 0x18, 0x7F, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x40, 0x1C, 0x0C, 0x60, 0x18, 0x03,
  0x30, 0x18, 0x00, 0xD0, 0x18, 0x00, 0x68, 0x18, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02, 0x0C,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x1E, 0x04, 0x00, 0x1A, 0x03, 0x00, 0x0F, 0x01, 0x80, 0x0D,
  0x80, 0xC0, 0x0C, 0xC0, 0x30, 0x0E, 0x40, 0x0C, 0x1C, 0x20, 0x03, 0xFC,
  0x30, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x21, 0xFC, 0x04, 0x70, 0x00, 0x98, 0x00, 0x36,
  0x00, 0x07, 0x80, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x60, 0x02,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x06, 0x03, 0xC0, 0x70, 0x03, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x04, 0xFF, 0xE0, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x04, 0x07, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x04, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x10,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x20,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0xE0,
  0x40, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x02, 0xC0, 0x40, 0x06, 0x80, 0x60, 0x1C, 0x80, 0x70, 0x39, 0x80,
  0x1F, 0xE1, 0x80, 0x07, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x06, 0x80,
  0x00, 0xC8, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x18, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0,
  0xC0, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x0C, 0x06, 0x00, 0x40, 0x60, 0x04, 0x0C, 0x00, 0x40, 0xC0, 0x04, 0x18,
  0x00, 0x41, 0x80, 0x04, 0x30, 0x00, 0x43, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x02, 0x80, 0x06, 0xC0,
  0x02, 0x80, 0x04, 0xC0, 0x06, 0x80, 0x0C, 0xC0, 0x04, 0x80, 0x08, 0xC0,
  0x0C, 0x80, 0x18, 0xC0, 0x08, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x30, 0xC0,
  0x10, 0x80, 0x30, 0xC0, 0x30, 0x80, 0x20, 0xC0, 0x30, 0x80, 0x60, 0xC0,
  0x20, 0x80, 0x60, 0xC0, 0x60, 0x80, 0xC0, 0xC0, 0x40, 0x80, 0xC0, 0xC0,
  0xC0, 0xC0, 0x80, 0xC0, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x00, 0xC1,
  0x80, 0xC3, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0xC2, 0x00, 0xC2,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0xC4, 0x00, 0xC4, 0x00, 0xCC, 0x00, 0xCC,
  0x00, 0xCC, 0x00, 0xC8, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0xD8,
  0x00, 0xD0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x02, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x00, 0x20, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x07, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0x70,
  0x78, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_ThinItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 46, 13, 1, -46 },
  { 76, 14, 16, 18, 6, -46 },
  { 104, 29, 46, 29, 1, -46 },
  { 271, 26, 53, 26, 1, -49 },
  { 444, 32, 48, 39, 4, -47 },
  { 636, 26, 48, 28, 0, -47 },
  { 792, 6, 16, 10, 6, -46 },
  { 804, 18, 56, 16, 2, -46 },
  { 930, 17, 56, 16, -4, -46 },
  { 1049, 19, 20, 25, 8, -49 },
  { 1097, 24, 30, 29, 3, -38 },
  { 1187, 8, 14, 11, -3, -6 },
  { 1201, 14, 1, 18, 2, -18 },
  { 1203, 3, 4, 11, 1, -4 },
  { 1205, 27, 46, 19, -3, -46 },
  { 1361, 24, 48, 26, 2, -47 },
  { 1505, 13, 46, 26, 8, -46 },
  { 1580, 27, 47, 26, -1, -47 },
  { 1739, 27, 48, 26, -1, -47 },
  { 1901, 27, 47, 26, -1, -47 },
  { 2060, 27, 47, 26, -1, -46 },
  { 2219, 25, 48, 26, 2, -47 },
  { 2369, 24, 46, 26, 4, -46 },
  { 2507, 26, 48, 26, 0, -47 },
  { 2663, 25, 48, 26, 1, -47 },
  { 2813, 9, 34, 11, 1, -34 },
  { 2852, 14, 42, 11, -3, -34 },
  { 2926, 24, 28, 29, 3, -37 },
  { 3010, 24, 16, 29, 3, -31 },
  { 3058, 24, 28, 29, 3, -37 },
  { 3142, 19, 47, 19, 2, -47 },
  { 3254, 36, 52, 39, 2, -46 },
  { 3488, 25, 47, 25, -4, -47 },
  { 3635, 28, 46, 29, 1, -46 },
  { 3796, 28, 48, 27, 3, -47 },
  { 3964, 29, 46, 32, 1, -46 },
  { 4131, 27, 46, 26, 1, -46 },
  { 4287, 27, 46, 24, 1, -46 },
  { 4443, 32, 48, 34, 3, -47 },
  { 4635, 33, 46, 33, 1, -46 },
  { 4825, 19, 46, 13, -2, -46 },
  { 4935, 23, 57, 12, -10, -46 },
  { 5099, 30, 46, 26, 1, -46 },
  { 5272, 17, 46, 23, 1, -46 },
  { 5370, 42, 46, 42, 1, -46 },
  { 5612, 34, 46, 34, 1, -46 },
  { 5808, 30, 48, 34, 3, -47 },
  { 5988, 27, 46, 27, 1, -46 },
  { 6144, 30, 58, 34, 3, -47 },
  { 6362, 26, 46, 27, 1, -46 },
  { 6512, 28, 48, 25, -1, -47 },
  { 6680, 22, 46, 23, 6, -46 },
  { 6807, 31, 47, 33, 3, -46 },
  { 6990, 25, 46, 26, 6, -46 },
  { 7134, 42, 46, 43, 6, -46 },
  { 7376, 32, 46, 23, -4, -46 },
  { 7560, 22, 46, 23, 6, -46 },
  { 7687, 30, 46, 24, -2, -46 },
  { 7860, 23, 56, 18, -1, -46 },
  { 8021, 9, 46, 20, 7, -46 },
  { 8073, 23, 56, 18, -4, -46 },
  { 8234, 25, 24, 29, 2, -46 },
  { 8309, 19, 2, 19, -5, 6 },
  { 8314, 7, 11, 14, 9, -50 },
  { 8324, 25, 36, 28, 2, -35 },
  { 8437, 25, 50, 28, 1, -49 },
  { 8594, 20, 36, 21, 2, -35 },
  { 8684, 28, 50, 28, 2, -49 },
  { 8859, 21, 36, 24, 2, -35 },
  { 8954, 31, 66, 14, -9, -50 },
  { 9210, 27, 51, 28, 0, -35 },
  { 9383, 24, 49, 27, 1, -49 },
  { 9530, 12, 46, 11, 1, -46 },
  { 9599, 22, 62, 11, -9, -46 },
  { 9770, 23, 49, 22, 1, -49 },
  { 9911, 12, 49, 11, 1, -49 },
  { 9985, 38, 35, 41, 1, -35 },
  { 10152, 24, 35, 27, 1, -35 },
  { 10257, 23, 36, 27, 2, -35 },
  { 10361, 28, 50, 28, -2, -35 },
  { 10536, 25, 50, 28, 2, -35 },
  { 10693, 19, 35, 18, 1, -35 },
  { 10777, 22, 36, 21, -1, -35 },
  { 10876, 14, 44, 14, 2, -43 },
  { 10953, 24, 35, 27, 2, -34 },
  { 11058, 20, 34, 20, 4, -34 },
  { 11143, 32, 34, 34, 4, -34 },
  { 11279, 27, 34, 22, -3, -34 },
  { 11394, 32, 50, 21, -7, -34 },
  { 11594, 22, 34, 19, -2, -34 },
  { 11688, 22, 56, 20, 2, -46 },
  { 11842, 1, 65, 26, 13, -49 },
  { 11851, 22, 56, 20, -4, -46 },
  { 12005, 24, 6, 29, 3, -26 },
};

const GFXfont NotoSans_Condensed_ThinItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_THINITALIC65PT7B_H_
