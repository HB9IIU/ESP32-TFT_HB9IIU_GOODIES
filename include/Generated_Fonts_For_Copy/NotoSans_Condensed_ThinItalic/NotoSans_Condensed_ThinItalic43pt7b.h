#ifndef _NOTOSANS_CONDENSED_THINITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0x90, 0xC8, 0x44,
  0x22, 0x12, 0x09, 0x08, 0x84, 0x42, 0x21, 0x21, 0x80, 0x00, 0x20, 0xC0,
  0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x0C, 0x10, 0x01, 0x02, 0x00,
  0x20, 0x40, 0x04, 0x10, 0x01, 0x02, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x81,
  0x02, 0x00, 0x20, 0x40, 0x04, 0x18, 0x01, 0x82, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x01, 0x82, 0x00, 0x20, 0x40, 0x04, 0x08, 0x0F, 0xFF, 0xF0, 0x20,
  0x40, 0x04, 0x08, 0x00, 0x83, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x83,
  0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x64,
  0x70, 0x21, 0x00, 0x10, 0x40, 0x04, 0x10, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x64, 0x00, 0x0D, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x23,
  0x00, 0x08, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40,
  0x04, 0x20, 0x02, 0x18, 0x30, 0x8C, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x20, 0xC4,
  0x01, 0x0C, 0x20, 0x10, 0x41, 0x81, 0x86, 0x0C, 0x08, 0x20, 0x60, 0x81,
  0x02, 0x04, 0x18, 0x10, 0x40, 0x80, 0x82, 0x04, 0x04, 0x20, 0x20, 0x23,
  0x01, 0x03, 0x10, 0x08, 0x11, 0x0E, 0x40, 0x88, 0xDA, 0x0C, 0x88, 0x50,
  0x44, 0x82, 0x86, 0x44, 0x1E, 0x66, 0x40, 0xDE, 0x22, 0x04, 0x03, 0x10,
  0x20, 0x11, 0x01, 0x01, 0x08, 0x08, 0x08, 0x40, 0x40, 0x82, 0x06, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x20, 0x82, 0x01, 0x04,
  0x10, 0x08, 0x41, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x63,
  0x00, 0x60, 0x80, 0x20, 0x40, 0x30, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x0C, 0x02, 0x04, 0x01, 0x06, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x12, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x04, 0xC0, 0x04, 0x20, 0x04, 0x10,
  0x24, 0x04, 0x12, 0x02, 0x12, 0x01, 0x89, 0x00, 0x4D, 0x80, 0x24, 0x80,
  0x0C, 0x40, 0x06, 0x20, 0x03, 0x18, 0x02, 0x84, 0x02, 0x43, 0x02, 0x10,
  0xFE, 0x08, 0x32, 0x22, 0x24, 0x44, 0x44, 0x80, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x0C, 0x20, 0x19, 0x00,
  0x39, 0xE0, 0x70, 0x06, 0x00, 0xC8, 0x08, 0x40, 0x81, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x0C, 0x21, 0x84, 0x10, 0x82, 0x10, 0x42,
  0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0x86, 0x03, 0x02, 0x02, 0x03, 0x04, 0x01,
  0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x20, 0x01, 0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x08,
  0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x40,
  0x20, 0x80, 0x1F, 0x00, 0x03, 0x06, 0x0A, 0x32, 0x62, 0x86, 0x04, 0x04,
  0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x00,
  0x7E, 0x00, 0xE0, 0x40, 0x10, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x01,
  0x81, 0x81, 0x80, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x04, 0x03,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0xA0,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21,
  0x00, 0x20, 0x80, 0x30, 0xC0, 0x10, 0x40, 0x10, 0x20, 0x18, 0x10, 0x08,
  0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x02, 0x04, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x83, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x80,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0x00, 0x20, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x04, 0x03,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x43, 0x80, 0x4E, 0x70, 0x50, 0x10, 0xE0, 0x08, 0xC0,
  0x08, 0xC0, 0x08, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0xC0,
  0x60, 0x60, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0x40, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xC1, 0x80,
  0xC0, 0x60, 0x40, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01,
  0x04, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x40, 0x40, 0x30, 0x40, 0x0C,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x30, 0x04, 0x0C, 0x04, 0x02, 0x04,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09, 0x00, 0x04, 0x80, 0x06,
  0x40, 0x02, 0x30, 0x01, 0x08, 0x01, 0x86, 0x00, 0x81, 0x81, 0x80, 0x7F,
  0x80, 0x00, 0x7C, 0x00, 0xC3, 0x00, 0xC0, 0x40, 0xC0, 0x20, 0x40, 0x18,
  0x60, 0x04, 0x20, 0x02, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x31, 0x00, 0x18, 0x80, 0x08, 0x40, 0x0C, 0x30, 0x0E, 0x08,
  0x0D, 0x06, 0x0D, 0x00, 0xF8, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x03, 0xF8, 0x00, 0x06, 0x0C, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x0C, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0xC1,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x02, 0x03, 0x00, 0x02, 0x06, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x08, 0x07, 0xC1, 0x10, 0x18, 0x41, 0x10, 0x30, 0x41,
  0x30, 0x60, 0xC1, 0x20, 0x40, 0x81, 0x20, 0xC0, 0x81, 0x60, 0x80, 0x81,
  0x41, 0x81, 0x83, 0x41, 0x01, 0x02, 0x41, 0x01, 0x02, 0x41, 0x03, 0x06,
  0x41, 0x03, 0x04, 0x41, 0x02, 0x04, 0xC1, 0x06, 0x08, 0xC1, 0x06, 0x18,
  0xC1, 0x89, 0x30, 0x40, 0xF1, 0xE0, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x20, 0x04,
  0x10, 0x06, 0x08, 0x02, 0x04, 0x03, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0xFF, 0xE0, 0x40, 0x10, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02, 0x10, 0x01,
  0x18, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0A, 0x00,
  0x07, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x83, 0xC0, 0x20, 0x18, 0x08, 0x02,
  0x04, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x0C, 0x00, 0xC2,
  0x00, 0x20, 0x80, 0x08, 0x20, 0x04, 0x08, 0x03, 0x06, 0x01, 0x81, 0xFF,
  0x80, 0x41, 0xE0, 0x10, 0x0C, 0x04, 0x01, 0x83, 0x00, 0x20, 0x80, 0x08,
  0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10,
  0x01, 0x84, 0x00, 0x41, 0x00, 0x20, 0x80, 0x18, 0x20, 0x18, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x0C, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x30, 0x10,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x41, 0xC0, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x18, 0x20, 0x01, 0x0C, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00,
  0x44, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x01,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x42, 0x00, 0x18,
  0x40, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x30, 0x60, 0x0C, 0x08, 0x03, 0x01,
  0x03, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0xFC, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0x01, 0xC0, 0x60, 0x02, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x1F, 0xC4, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00,
  0x02, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40,
  0xC0, 0x02, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x3F, 0xF0, 0x00, 0x02,
  0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x82, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x40,
  0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x0C, 0x00, 0x30,
  0x7F, 0xFF, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x0C, 0x00,
  0x30, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x41, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x41, 0x80, 0x06,
  0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x00, 0x01, 0xF8, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x03, 0xF8, 0x00,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x30, 0x20, 0x06,
  0x02, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x20, 0x04, 0x04,
  0x00, 0x40, 0xC0, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x08, 0x60, 0x00, 0x8C,
  0x00, 0x08, 0x80, 0x01, 0x90, 0x00, 0x13, 0x80, 0x01, 0x48, 0x00, 0x1C,
  0x80, 0x01, 0x88, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02,
  0x06, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00, 0x40, 0x30, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x0C,
  0x00, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x50, 0x50, 0x00,
  0x1E, 0x0A, 0x00, 0x02, 0x81, 0x40, 0x00, 0xD0, 0x2C, 0x00, 0x12, 0x0C,
  0x80, 0x06, 0x41, 0x10, 0x00, 0x90, 0x22, 0x00, 0x32, 0x04, 0x40, 0x04,
  0x40, 0x88, 0x01, 0x88, 0x31, 0x00, 0x23, 0x04, 0x20, 0x0C, 0x40, 0x84,
  0x01, 0x08, 0x10, 0x80, 0x61, 0x02, 0x10, 0x08, 0x20, 0xC3, 0x02, 0x0C,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x18, 0x10,
  0x80, 0x82, 0x02, 0x10, 0x20, 0x40, 0x44, 0x04, 0x08, 0x08, 0x80, 0x81,
  0x01, 0x20, 0x10, 0x60, 0x24, 0x06, 0x08, 0x05, 0x00, 0x81, 0x00, 0xE0,
  0x10, 0x20, 0x18, 0x02, 0x00, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x80, 0xC0, 0x02, 0x05, 0x80, 0x08, 0x12, 0x00, 0x20, 0x48, 0x01,
  0x81, 0x20, 0x04, 0x0C, 0xC0, 0x10, 0x21, 0x00, 0x40, 0x84, 0x01, 0x02,
  0x10, 0x0C, 0x08, 0x60, 0x20, 0x60, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x30, 0x40, 0x40, 0x41, 0x03, 0x01, 0x04, 0x08, 0x04, 0x10,
  0x20, 0x18, 0xC0, 0x80, 0x22, 0x06, 0x00, 0x88, 0x10, 0x02, 0x20, 0x40,
  0x04, 0x81, 0x00, 0x16, 0x04, 0x00, 0x50, 0x30, 0x01, 0x40, 0x80, 0x03,
  0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x18,
  0x01, 0x00, 0x40, 0x20, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x33, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x6C, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8,
  0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x0C, 0x00, 0x30,
  0x40, 0x02, 0x04, 0x00, 0x40, 0x20, 0x08, 0x03, 0x03, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x01, 0x0F, 0x00, 0x80, 0xC0, 0x40, 0x30, 0x60, 0x08,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x84, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x30, 0x80, 0x10, 0xC0, 0x18, 0x40, 0x18, 0x20, 0x18, 0x10,
  0x78, 0x0F, 0xE0, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x18,
  0x01, 0x00, 0x40, 0x20, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x33, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x6C, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8,
  0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x0C, 0x00, 0x30,
  0x40, 0x02, 0x04, 0x00, 0x40, 0x20, 0x08, 0x03, 0x03, 0x00, 0x1F, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x01, 0x0F, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x60, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x0C,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x61, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x10,
  0x40, 0x18, 0x20, 0x30, 0x1F, 0xF0, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x08,
  0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x30, 0x20,
  0x08, 0x10, 0x04, 0x18, 0x02, 0x08, 0x01, 0x84, 0x00, 0x42, 0x00, 0x20,
  0x00, 0x7F, 0x80, 0x18, 0x1C, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x81, 0x80, 0x60, 0x1F,
  0xF8, 0x00, 0xFF, 0xFE, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x03, 0x08,
  0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x61,
  0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0xC2, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x0C, 0x00, 0x80, 0x40,
  0x18, 0x06, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xA0,
  0x00, 0xD0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10,
  0x80, 0x08, 0x40, 0x08, 0x20, 0x04, 0x10, 0x04, 0x08, 0x02, 0x04, 0x03,
  0x02, 0x01, 0x01, 0x01, 0x80, 0x40, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x08,
  0x20, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x02, 0x80, 0x0E, 0x00, 0x28,
  0x00, 0xE0, 0x04, 0x80, 0x0E, 0x00, 0x48, 0x01, 0x60, 0x08, 0x80, 0x16,
  0x00, 0x88, 0x03, 0x60, 0x18, 0x80, 0x26, 0x01, 0x08, 0x02, 0x60, 0x10,
  0x80, 0x46, 0x02, 0x08, 0x04, 0x60, 0x20, 0x80, 0x86, 0x06, 0x08, 0x08,
  0x60, 0x40, 0x81, 0x86, 0x04, 0x08, 0x10, 0x40, 0x80, 0x81, 0x04, 0x08,
  0x08, 0x20, 0x41, 0x00, 0x82, 0x04, 0x10, 0x08, 0x60, 0x43, 0x00, 0x84,
  0x04, 0x20, 0x08, 0x40, 0x42, 0x00, 0x88, 0x04, 0x40, 0x08, 0x80, 0x44,
  0x00, 0x90, 0x04, 0xC0, 0x09, 0x00, 0x48, 0x00, 0xB0, 0x04, 0x80, 0x0A,
  0x00, 0x50, 0x00, 0xA0, 0x05, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x10,
  0x0C, 0x00, 0x40, 0x20, 0x01, 0x01, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x20,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x09, 0x80, 0x00,
  0x34, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00,
  0x04, 0x20, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x20,
  0x10, 0x01, 0x80, 0x40, 0x04, 0x01, 0x80, 0x20, 0x02, 0x01, 0x80, 0x08,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48,
  0x01, 0x08, 0x06, 0x10, 0x08, 0x20, 0x20, 0x40, 0x40, 0x81, 0x01, 0x02,
  0x03, 0x08, 0x02, 0x30, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x28, 0x00,
  0x70, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x40, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x81, 0x04, 0x10,
  0x41, 0x04, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x04,
  0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x40, 0x00, 0xFF, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x12, 0x00, 0x11, 0x00,
  0x08, 0x40, 0x08, 0x20, 0x0C, 0x18, 0x04, 0x04, 0x06, 0x02, 0x02, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x31, 0x00, 0x09, 0x80, 0x05, 0x80, 0x01, 0xFF,
  0xF0, 0xC4, 0x42, 0x21, 0x10, 0x01, 0xF1, 0x06, 0x1A, 0x0C, 0x0A, 0x18,
  0x06, 0x10, 0x06, 0x20, 0x06, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x80, 0x50, 0x80, 0xA0, 0x41,
  0xA0, 0x3E, 0x20, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x78, 0x09, 0x86, 0x0B, 0x02, 0x0E, 0x03, 0x1C, 0x01, 0x18, 0x01, 0x18,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x03, 0x20,
  0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40,
  0x08, 0xA0, 0x18, 0xA0, 0x30, 0xB0, 0x60, 0x9F, 0xC0, 0x01, 0xF8, 0x30,
  0x43, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x1F, 0x10,
  0x18, 0x64, 0x0C, 0x0B, 0x06, 0x01, 0x81, 0x00, 0x60, 0x80, 0x18, 0x20,
  0x06, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03,
  0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01, 0x82,
  0x00, 0xC0, 0x80, 0x30, 0x20, 0x14, 0x08, 0x0D, 0x01, 0x06, 0x80, 0x3F,
  0x20, 0x00, 0x01, 0xF0, 0x30, 0xC3, 0x02, 0x30, 0x11, 0x00, 0x90, 0x04,
  0x80, 0x28, 0x02, 0x40, 0x36, 0x03, 0x20, 0x61, 0xFC, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x20, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x11, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x00, 0x09, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x40, 0x61, 0x90, 0x30, 0x24, 0x18,
  0x06, 0x04, 0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x40, 0x04, 0x10, 0x01,
  0x04, 0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80,
  0x50, 0x20, 0x34, 0x04, 0x1A, 0x00, 0xFC, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x02, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x23, 0xE0, 0x4C, 0x30, 0xA0, 0x21, 0x80, 0x43, 0x00, 0x8C,
  0x01, 0x18, 0x02, 0x20, 0x04, 0x40, 0x19, 0x80, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x06, 0x60, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x30, 0x02, 0x0C, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x60, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x08, 0x40, 0x20, 0x80, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x30,
  0x10, 0x40, 0x21, 0x00, 0x44, 0x01, 0x90, 0x02, 0x70, 0x05, 0xA0, 0x0E,
  0x40, 0x18, 0x80, 0x60, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x30, 0x80, 0x20, 0x03, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x08, 0xF8, 0x3E, 0x04, 0x86, 0x61, 0x82,
  0x81, 0x60, 0x41, 0x80, 0xA0, 0x31, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x08,
  0x60, 0x10, 0x04, 0x20, 0x08, 0x02, 0x10, 0x04, 0x01, 0x18, 0x02, 0x00,
  0x88, 0x02, 0x00, 0x84, 0x01, 0x00, 0x42, 0x00, 0x80, 0x21, 0x00, 0x40,
  0x11, 0x80, 0x60, 0x18, 0x80, 0x20, 0x08, 0x40, 0x10, 0x04, 0x20, 0x08,
  0x02, 0x10, 0x04, 0x01, 0x10, 0x06, 0x01, 0x88, 0x02, 0x00, 0x84, 0x01,
  0x00, 0x42, 0x00, 0x80, 0x20, 0x08, 0xF8, 0x13, 0x0C, 0x28, 0x08, 0x60,
  0x11, 0xC0, 0x23, 0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x06, 0x60, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C,
  0x00, 0x01, 0xF0, 0x0C, 0x30, 0x30, 0x30, 0xC0, 0x21, 0x00, 0x44, 0x00,
  0x88, 0x01, 0xA0, 0x03, 0x40, 0x06, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x50, 0x01, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x22, 0x00,
  0x44, 0x01, 0x0C, 0x04, 0x08, 0x18, 0x0F, 0xC0, 0x00, 0x02, 0x1E, 0x00,
  0x98, 0x60, 0x2C, 0x08, 0x0E, 0x03, 0x03, 0x00, 0x41, 0xC0, 0x10, 0x60,
  0x04, 0x18, 0x01, 0x04, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x03,
  0x08, 0x00, 0x82, 0x00, 0x21, 0x80, 0x08, 0x60, 0x06, 0x10, 0x01, 0x04,
  0x00, 0xC1, 0x00, 0x20, 0xA0, 0x18, 0x28, 0x0C, 0x0B, 0x06, 0x02, 0x7F,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xF1, 0x06, 0x19, 0x0C, 0x09, 0x18, 0x06, 0x10, 0x06, 0x20, 0x06,
  0x20, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x30,
  0x80, 0x30, 0x80, 0x50, 0x80, 0xD0, 0x41, 0xB0, 0x3E, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x08, 0xF0, 0x98, 0x0A, 0x00, 0xC0,
  0x14, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x30, 0x30, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x42, 0x02, 0x0F, 0xF0, 0x00, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x81, 0xFD, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x0F, 0x00, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x06, 0x30, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x60, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30, 0xC0, 0x30, 0x40, 0x50,
  0x40, 0x90, 0x3F, 0x20, 0x80, 0x0F, 0x00, 0x2C, 0x01, 0x90, 0x04, 0x40,
  0x31, 0x00, 0x84, 0x06, 0x10, 0x10, 0x40, 0xC1, 0x02, 0x04, 0x18, 0x10,
  0x40, 0x43, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x00, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x05, 0x00, 0xC0, 0x28, 0x0A, 0x02, 0x40, 0x50,
  0x12, 0x04, 0x81, 0x10, 0x24, 0x08, 0x82, 0x20, 0xC4, 0x11, 0x04, 0x21,
  0x88, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x44, 0x11, 0x82, 0x20, 0x88,
  0x12, 0x04, 0x40, 0x90, 0x24, 0x05, 0x81, 0x20, 0x28, 0x0A, 0x01, 0xC0,
  0x50, 0x0C, 0x02, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0xC0, 0x80, 0x60, 0x20, 0x10, 0x0C, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00,
  0x10, 0x80, 0x06, 0x60, 0x00, 0x90, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x20,
  0x02, 0x0C, 0x01, 0x81, 0x00, 0x40, 0x40, 0x20, 0x10, 0x18, 0x02, 0x0C,
  0x00, 0x80, 0x00, 0x80, 0x08, 0x04, 0x00, 0x40, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x03, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02,
  0x40, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x78, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x20, 0x00, 0x78, 0x00, 0xF0, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x3E, 0x01, 0xC3, 0x81, 0x80,
  0xFE, 0x00, 0x18,
};

const GFXglyph NotoSans_Condensed_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 9, 11, 12, 4, -31 },
  { 45, 19, 31, 19, 1, -31 },
  { 119, 18, 36, 17, 0, -33 },
  { 200, 21, 32, 26, 3, -31 },
  { 284, 17, 31, 19, 0, -31 },
  { 350, 4, 11, 7, 4, -31 },
  { 356, 12, 38, 10, 1, -31 },
  { 413, 12, 38, 10, -3, -31 },
  { 470, 13, 14, 16, 5, -33 },
  { 493, 16, 20, 19, 2, -25 },
  { 533, 6, 10, 7, -2, -4 },
  { 541, 10, 1, 12, 1, -12 },
  { 543, 2, 3, 7, 1, -3 },
  { 544, 18, 31, 13, -2, -31 },
  { 614, 16, 31, 17, 1, -31 },
  { 676, 8, 31, 17, 6, -31 },
  { 707, 18, 31, 17, -1, -31 },
  { 777, 17, 31, 17, 0, -31 },
  { 843, 17, 31, 17, 0, -31 },
  { 909, 17, 31, 17, 0, -31 },
  { 975, 16, 31, 17, 2, -31 },
  { 1037, 16, 31, 17, 3, -31 },
  { 1099, 17, 31, 17, 0, -31 },
  { 1165, 17, 31, 17, 0, -31 },
  { 1231, 7, 23, 7, 0, -23 },
  { 1252, 9, 29, 7, -2, -23 },
  { 1285, 16, 18, 19, 2, -24 },
  { 1321, 16, 10, 19, 2, -20 },
  { 1341, 16, 18, 19, 2, -24 },
  { 1377, 13, 31, 12, 1, -31 },
  { 1428, 24, 35, 26, 1, -31 },
  { 1533, 17, 31, 17, -3, -31 },
  { 1599, 18, 31, 19, 1, -31 },
  { 1669, 19, 31, 18, 2, -31 },
  { 1743, 19, 31, 21, 1, -31 },
  { 1817, 18, 31, 17, 1, -31 },
  { 1887, 18, 31, 16, 1, -31 },
  { 1957, 21, 31, 22, 2, -31 },
  { 2039, 21, 31, 22, 1, -31 },
  { 2121, 13, 31, 9, -2, -31 },
  { 2172, 14, 38, 8, -6, -31 },
  { 2239, 20, 31, 17, 1, -31 },
  { 2317, 11, 31, 15, 1, -31 },
  { 2360, 27, 31, 28, 1, -31 },
  { 2465, 22, 31, 23, 1, -31 },
  { 2551, 20, 31, 23, 2, -31 },
  { 2629, 17, 31, 18, 1, -31 },
  { 2695, 20, 38, 23, 2, -31 },
  { 2790, 17, 31, 18, 1, -31 },
  { 2856, 19, 31, 17, -1, -31 },
  { 2930, 15, 31, 15, 4, -31 },
  { 2989, 20, 31, 22, 2, -31 },
  { 3067, 17, 31, 17, 4, -31 },
  { 3133, 28, 31, 29, 4, -31 },
  { 3242, 22, 31, 15, -3, -31 },
  { 3328, 15, 31, 15, 4, -31 },
  { 3387, 19, 31, 16, -1, -31 },
  { 3461, 16, 38, 12, -1, -31 },
  { 3537, 6, 31, 14, 4, -31 },
  { 3561, 16, 38, 12, -3, -31 },
  { 3637, 17, 16, 19, 1, -31 },
  { 3671, 12, 1, 13, -3, 4 },
  { 3673, 4, 7, 9, 6, -33 },
  { 3677, 16, 23, 18, 2, -23 },
  { 3723, 16, 33, 19, 1, -33 },
  { 3789, 13, 23, 14, 2, -23 },
  { 3827, 18, 33, 19, 2, -33 },
  { 3902, 13, 23, 16, 2, -23 },
  { 3940, 20, 43, 9, -6, -33 },
  { 4048, 18, 33, 19, 0, -23 },
  { 4123, 15, 33, 18, 1, -33 },
  { 4185, 7, 31, 7, 1, -31 },
  { 4213, 15, 41, 8, -6, -31 },
  { 4290, 15, 33, 15, 1, -33 },
  { 4352, 8, 33, 7, 1, -33 },
  { 4385, 25, 23, 27, 1, -23 },
  { 4457, 15, 23, 18, 1, -23 },
  { 4501, 15, 23, 18, 2, -23 },
  { 4545, 18, 33, 19, -1, -23 },
  { 4620, 16, 33, 19, 2, -23 },
  { 4686, 12, 23, 12, 1, -23 },
  { 4721, 14, 23, 14, 0, -23 },
  { 4762, 9, 28, 9, 1, -28 },
  { 4794, 16, 23, 18, 1, -23 },
  { 4840, 14, 23, 13, 2, -23 },
  { 4881, 21, 23, 22, 3, -23 },
  { 4942, 18, 23, 14, -2, -23 },
  { 4994, 21, 33, 14, -5, -23 },
  { 5081, 15, 23, 13, -1, -23 },
  { 5125, 15, 38, 14, 1, -31 },
  { 5197, 1, 43, 17, 8, -33 },
  { 5203, 15, 38, 14, -3, -31 },
  { 5275, 16, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_THINITALIC43PT7B_H_
