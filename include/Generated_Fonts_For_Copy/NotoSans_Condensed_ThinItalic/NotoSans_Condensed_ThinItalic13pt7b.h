#ifndef _NOTOSANS_CONDENSED_THINITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0xB6, 0x80, 0x14, 0xA7, 0xCA, 0x53, 0xE5,
  0x14, 0xA0, 0x11, 0xD4, 0xA6, 0x10, 0xC5, 0x36, 0x10, 0xE6, 0xAA, 0xAF,
  0xF4, 0xD5, 0x55, 0x98, 0x39, 0x4C, 0x46, 0x4E, 0x72, 0xE8, 0xE0, 0x12,
  0x44, 0x88, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11, 0x12, 0x24, 0x80, 0x59,
  0xD0, 0x44, 0x4F, 0x44, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x84,
  0x10, 0x80, 0x3A, 0x52, 0x98, 0xC6, 0x32, 0x60, 0x75, 0xAA, 0x80, 0x38,
  0x42, 0x11, 0x11, 0x08, 0xF0, 0x78, 0x42, 0x13, 0x04, 0x22, 0xF0, 0x08,
  0xCA, 0x55, 0x4B, 0xE2, 0x10, 0x3A, 0x10, 0xE0, 0x84, 0x22, 0xF0, 0x3A,
  0x10, 0xE8, 0xC6, 0x31, 0x70, 0xF8, 0x84, 0x42, 0x21, 0x10, 0x80, 0x7A,
  0x52, 0x67, 0x46, 0x31, 0xF0, 0x7A, 0x52, 0x95, 0x94, 0x42, 0xE0, 0x40,
  0x08, 0x20, 0x00, 0x12, 0x80, 0x34, 0x86, 0x10, 0xF0, 0xF0, 0xC2, 0x16,
  0x80, 0x71, 0x12, 0x24, 0x40, 0x80, 0x1E, 0x21, 0x4D, 0x55, 0xA5, 0xAA,
  0xAA, 0x94, 0x80, 0x78, 0x08, 0xC6, 0x52, 0xAD, 0x29, 0x88, 0x3D, 0x14,
  0x52, 0x79, 0x28, 0xA2, 0xF0, 0x7A, 0x21, 0x08, 0x42, 0x10, 0xE0, 0x3D,
  0x14, 0x51, 0x45, 0x18, 0xA2, 0xF0, 0x3D, 0x04, 0x10, 0x79, 0x08, 0x20,
  0xF0, 0x3D, 0x04, 0x10, 0x71, 0x08, 0x20, 0x80, 0x7D, 0x08, 0x20, 0x9A,
  0x28, 0xA2, 0xF8, 0x22, 0x85, 0x12, 0x27, 0xC8, 0xA1, 0x44, 0x88, 0x31,
  0x22, 0x22, 0x44, 0xC0, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x30, 0x25,
  0x25, 0x18, 0x61, 0x49, 0x24, 0x88, 0x24, 0x44, 0x44, 0x88, 0xF0, 0x21,
  0xB0, 0x98, 0xCC, 0x66, 0x52, 0xAA, 0x69, 0x24, 0x92, 0x00, 0x22, 0xC5,
  0x4A, 0xA5, 0x4A, 0xA2, 0x44, 0x88, 0x7A, 0x18, 0x61, 0x86, 0x28, 0xA4,
  0xF0, 0x39, 0x14, 0x52, 0x71, 0x08, 0x20, 0x80, 0x7A, 0x18, 0x61, 0x86,
  0x28, 0xA4, 0xD0, 0x82, 0x00, 0x3A, 0x52, 0x97, 0x2A, 0x52, 0x90, 0x7A,
  0x10, 0x82, 0x08, 0x22, 0xF0, 0xF9, 0x10, 0x84, 0x22, 0x10, 0x80, 0x46,
  0x18, 0xA2, 0x8A, 0x28, 0xA4, 0xE0, 0x8C, 0x65, 0x2A, 0x53, 0x18, 0x80,
  0x88, 0xC4, 0xA6, 0x55, 0x4A, 0xA5, 0x63, 0x31, 0x10, 0x88, 0x00, 0x26,
  0x28, 0x60, 0x81, 0x06, 0x0A, 0x24, 0x88, 0x9C, 0xA9, 0x44, 0x22, 0x10,
  0x80, 0x3C, 0x21, 0x04, 0x21, 0x04, 0x20, 0xF0, 0x32, 0x44, 0x44, 0x88,
  0x88, 0xC0, 0xA9, 0x55, 0x40, 0x18, 0x42, 0x21, 0x08, 0x42, 0x21, 0x38,
  0x31, 0x52, 0x98, 0x80, 0xF0, 0xC0, 0x3A, 0x53, 0x18, 0xC9, 0xC0, 0x21,
  0x10, 0x74, 0xA5, 0x31, 0x8F, 0x80, 0x3A, 0x11, 0x08, 0x41, 0x80, 0x04,
  0x10, 0x4E, 0x49, 0x28, 0xA2, 0x93, 0xC0, 0x3A, 0x54, 0xC8, 0x41, 0xC0,
  0x0C, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0xC0, 0x3A, 0x53,
  0x18, 0xCB, 0xC2, 0x17, 0x00, 0x21, 0x10, 0x74, 0xA5, 0x31, 0x94, 0x80,
  0x21, 0x24, 0xA4, 0x80, 0x08, 0x04, 0x21, 0x08, 0x84, 0x21, 0x09, 0x80,
  0x21, 0x10, 0x95, 0x31, 0x94, 0x94, 0x80, 0x25, 0x24, 0x94, 0x90, 0x3F,
  0x49, 0x49, 0x49, 0x92, 0x92, 0x92, 0x3A, 0x52, 0x98, 0xCA, 0x40, 0x3A,
  0x53, 0x18, 0xC5, 0xC0, 0x3A, 0x52, 0x98, 0xC7, 0xD0, 0x84, 0x00, 0x3A,
  0x53, 0x18, 0xCB, 0xC2, 0x10, 0x80, 0x34, 0x44, 0x88, 0x80, 0x74, 0x42,
  0x21, 0xE0, 0x29, 0xA5, 0x24, 0xC0, 0x4A, 0x52, 0x98, 0xCB, 0xC0, 0x9A,
  0xAC, 0xC8, 0x80, 0xA6, 0x9A, 0x76, 0x92, 0x49, 0x00, 0x24, 0xA3, 0x04,
  0x31, 0x4C, 0x80, 0x12, 0x24, 0x50, 0xA1, 0x82, 0x04, 0x08, 0x21, 0xC0,
  0x71, 0x24, 0x48, 0xE0, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF,
  0xF8, 0x10, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF0,
};

const GFXglyph NotoSans_Condensed_ThinItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 11, 5, 0, -10 },
  { 21, 6, 9, 8, 1, -9 },
  { 28, 5, 9, 6, 0, -9 },
  { 34, 1, 3, 2, 1, -9 },
  { 35, 4, 11, 3, 0, -9 },
  { 41, 4, 11, 3, -1, -9 },
  { 47, 3, 4, 5, 2, -10 },
  { 49, 4, 6, 6, 1, -8 },
  { 52, 2, 3, 2, -1, -1 },
  { 53, 3, 1, 4, 0, -4 },
  { 54, 1, 1, 2, 0, -1 },
  { 55, 6, 9, 4, -1, -9 },
  { 62, 5, 9, 5, 0, -9 },
  { 68, 2, 9, 5, 2, -9 },
  { 71, 5, 9, 5, 0, -9 },
  { 77, 5, 9, 5, 0, -9 },
  { 83, 5, 9, 5, 0, -9 },
  { 89, 5, 9, 5, 0, -9 },
  { 95, 5, 9, 5, 0, -9 },
  { 101, 5, 9, 5, 1, -9 },
  { 107, 5, 9, 5, 0, -9 },
  { 113, 5, 9, 5, 0, -9 },
  { 119, 2, 7, 2, 0, -7 },
  { 121, 3, 9, 2, -1, -7 },
  { 125, 4, 5, 6, 1, -7 },
  { 128, 4, 3, 6, 1, -6 },
  { 130, 4, 5, 6, 1, -7 },
  { 133, 4, 9, 4, 0, -9 },
  { 138, 8, 10, 8, 0, -9 },
  { 148, 5, 9, 5, -1, -9 },
  { 154, 6, 9, 6, 0, -9 },
  { 161, 5, 9, 5, 1, -9 },
  { 167, 6, 9, 6, 0, -9 },
  { 174, 6, 9, 5, 0, -9 },
  { 181, 6, 9, 5, 0, -9 },
  { 188, 6, 9, 7, 1, -9 },
  { 195, 7, 9, 7, 0, -9 },
  { 203, 4, 9, 3, -1, -9 },
  { 208, 5, 11, 2, -2, -9 },
  { 215, 6, 9, 5, 0, -9 },
  { 222, 4, 9, 5, 0, -9 },
  { 227, 9, 9, 8, 0, -9 },
  { 238, 7, 9, 7, 0, -9 },
  { 246, 6, 9, 7, 1, -9 },
  { 253, 6, 9, 5, 0, -9 },
  { 260, 6, 11, 7, 1, -9 },
  { 269, 5, 9, 5, 0, -9 },
  { 275, 5, 9, 5, 0, -9 },
  { 281, 5, 9, 5, 1, -9 },
  { 287, 6, 9, 7, 1, -9 },
  { 294, 5, 9, 5, 1, -9 },
  { 300, 9, 9, 9, 1, -9 },
  { 311, 7, 9, 5, -1, -9 },
  { 319, 5, 9, 5, 1, -9 },
  { 325, 6, 9, 5, 0, -9 },
  { 332, 4, 11, 4, 0, -9 },
  { 338, 2, 9, 4, 1, -9 },
  { 341, 5, 11, 4, -1, -9 },
  { 348, 5, 5, 6, 0, -9 },
  { 352, 4, 1, 4, -1, 1 },
  { 353, 1, 2, 3, 2, -10 },
  { 354, 5, 7, 6, 0, -7 },
  { 359, 5, 10, 6, 0, -10 },
  { 366, 5, 7, 4, 0, -7 },
  { 371, 6, 10, 6, 0, -10 },
  { 379, 5, 7, 5, 0, -7 },
  { 384, 6, 13, 3, -2, -10 },
  { 394, 5, 10, 6, 0, -7 },
  { 401, 5, 10, 5, 0, -10 },
  { 408, 3, 9, 2, 0, -9 },
  { 412, 5, 12, 2, -2, -9 },
  { 420, 5, 10, 4, 0, -10 },
  { 427, 3, 10, 2, 0, -10 },
  { 431, 8, 7, 8, 0, -7 },
  { 438, 5, 7, 5, 0, -7 },
  { 443, 5, 7, 5, 0, -7 },
  { 448, 5, 10, 6, 0, -7 },
  { 455, 5, 10, 6, 0, -7 },
  { 462, 4, 7, 4, 0, -7 },
  { 466, 4, 7, 4, 0, -7 },
  { 470, 3, 9, 3, 0, -9 },
  { 474, 5, 7, 5, 0, -7 },
  { 479, 4, 7, 4, 1, -7 },
  { 483, 6, 7, 7, 1, -7 },
  { 489, 6, 7, 4, -1, -7 },
  { 495, 7, 10, 4, -2, -7 },
  { 504, 4, 7, 4, 0, -7 },
  { 508, 5, 11, 4, 0, -9 },
  { 515, 1, 13, 5, 2, -10 },
  { 517, 5, 11, 4, -1, -9 },
  { 524, 4, 1, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_ThinItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_THINITALIC13PT7B_H_
