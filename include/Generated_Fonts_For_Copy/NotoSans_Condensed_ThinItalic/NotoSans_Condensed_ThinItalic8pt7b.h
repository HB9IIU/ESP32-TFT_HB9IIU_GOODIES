#ifndef _NOTOSANS_CONDENSED_THINITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xC0, 0x26, 0x74, 0xAC, 0x75, 0x27, 0x80, 0x5A, 0xA7,
  0x77, 0x2D, 0x6B, 0xC0, 0xC0, 0x5A, 0xA8, 0x24, 0x92, 0xB0, 0x70, 0x4B,
  0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x6E, 0xDB, 0x80, 0x7A, 0xA0,
  0x64, 0x95, 0x80, 0x64, 0xB3, 0xC0, 0x25, 0xDE, 0x80, 0x6B, 0x13, 0xC0,
  0x2B, 0x5B, 0xC0, 0x64, 0xA5, 0x00, 0x75, 0xDB, 0xC0, 0x76, 0xB3, 0x80,
  0x10, 0x18, 0x2B, 0x10, 0xFC, 0x8C, 0xE0, 0xE5, 0x29, 0x00, 0x32, 0x6F,
  0xBF, 0x41, 0x80, 0x12, 0x27, 0x59, 0x65, 0xEA, 0xAE, 0x34, 0x88, 0x8E,
  0x65, 0x99, 0x9E, 0x6B, 0xC9, 0x80, 0x6A, 0x79, 0x00, 0x34, 0x8B, 0x9F,
  0x55, 0xF9, 0x9A, 0x56, 0xA0, 0x25, 0x24, 0xB0, 0x56, 0xCC, 0xAA, 0x5A,
  0xB0, 0x4A, 0x77, 0xBE, 0xD4, 0x55, 0xBB, 0xAA, 0x35, 0x99, 0x9E, 0x6E,
  0xA9, 0x00, 0x35, 0x99, 0x9E, 0x20, 0x6E, 0xEB, 0x40, 0x71, 0x13, 0xC0,
  0xEA, 0xA0, 0x55, 0x99, 0x9E, 0xB7, 0x49, 0x00, 0xAE, 0x75, 0x6A, 0x50,
  0x6D, 0x2D, 0x40, 0xFA, 0xA0, 0x65, 0x29, 0x80, 0x6A, 0x49, 0x20, 0xFC,
  0x24, 0x92, 0x70, 0x2E, 0x80, 0xE0, 0x80, 0x76, 0xF0, 0x4A, 0xDB, 0xC0,
  0x72, 0x60, 0x11, 0x6A, 0xAE, 0x7E, 0x60, 0x36, 0x24, 0x44, 0x48, 0x76,
  0xF3, 0x80, 0x4A, 0xDB, 0x40, 0x4A, 0xA0, 0x21, 0x24, 0x94, 0x4A, 0xAD,
  0x80, 0x5A, 0xA0, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x76, 0xF0, 0xF6, 0xF9,
  0x00, 0x76, 0xF2, 0x40, 0xF2, 0x40, 0xF1, 0x60, 0x6A, 0x80, 0xB6, 0xE0,
  0xB9, 0x40, 0xBB, 0xEA, 0xA9, 0x60, 0x55, 0x64, 0x4C, 0x6A, 0x60, 0x29,
  0x65, 0x30, 0xFF, 0x55, 0x68, 0xE0,
};

const GFXglyph NotoSans_Condensed_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 1, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 4, 6, 5, 0, -6 },
  { 13, 3, 6, 3, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 3, 7, 2, -1, -6 },
  { 22, 2, 2, 3, 1, -6 },
  { 23, 3, 4, 4, 0, -5 },
  { 25, 1, 2, 1, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 1, 0, -1 },
  { 28, 3, 6, 2, 0, -6 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 2, 6, 3, 1, -6 },
  { 36, 3, 6, 3, 0, -6 },
  { 39, 3, 6, 3, 0, -6 },
  { 42, 3, 6, 3, 0, -6 },
  { 45, 3, 6, 3, 0, -6 },
  { 48, 3, 6, 3, 0, -6 },
  { 51, 3, 6, 3, 0, -6 },
  { 54, 3, 6, 3, 0, -6 },
  { 57, 3, 6, 3, 0, -6 },
  { 60, 1, 4, 1, 0, -4 },
  { 61, 1, 5, 1, 0, -4 },
  { 62, 3, 4, 4, 0, -5 },
  { 64, 3, 2, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -5 },
  { 67, 3, 6, 2, 0, -6 },
  { 70, 5, 7, 5, 0, -6 },
  { 75, 4, 6, 3, -1, -6 },
  { 78, 4, 6, 4, 0, -6 },
  { 81, 4, 6, 3, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 3, 6, 3, 0, -6 },
  { 90, 3, 6, 3, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 2, 6, 2, 0, -6 },
  { 101, 3, 7, 1, -1, -6 },
  { 104, 4, 6, 3, 0, -6 },
  { 107, 2, 6, 3, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 4, 6, 4, 0, -6 },
  { 116, 4, 6, 4, 0, -6 },
  { 119, 3, 6, 3, 0, -6 },
  { 122, 4, 7, 4, 0, -6 },
  { 126, 3, 6, 3, 0, -6 },
  { 129, 3, 6, 3, 0, -6 },
  { 132, 2, 6, 3, 1, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 3, 6, 3, 1, -6 },
  { 140, 5, 6, 5, 1, -6 },
  { 144, 3, 6, 3, 0, -6 },
  { 147, 2, 6, 3, 1, -6 },
  { 149, 3, 6, 3, 0, -6 },
  { 152, 3, 7, 2, 0, -6 },
  { 155, 1, 6, 3, 1, -6 },
  { 156, 3, 7, 2, -1, -6 },
  { 159, 3, 3, 4, 0, -6 },
  { 161, 3, 1, 2, -1, 0 },
  { 162, 1, 1, 2, 1, -6 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 3, 6, 3, 0, -6 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 4, 6, 3, 0, -6 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 4, 8, 2, -1, -6 },
  { 179, 3, 6, 3, 0, -4 },
  { 182, 3, 6, 3, 0, -6 },
  { 185, 2, 6, 1, 0, -6 },
  { 187, 3, 8, 1, -1, -6 },
  { 190, 3, 6, 3, 0, -6 },
  { 193, 2, 6, 1, 0, -6 },
  { 195, 5, 4, 5, 0, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 3, 6, 3, 0, -4 },
  { 205, 3, 6, 3, 0, -4 },
  { 208, 3, 4, 2, 0, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 2, 5, 2, 0, -5 },
  { 214, 3, 4, 3, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 4, 6, 3, -1, -4 },
  { 225, 3, 4, 2, 0, -4 },
  { 227, 3, 7, 3, 0, -6 },
  { 230, 1, 8, 3, 1, -6 },
  { 231, 2, 7, 3, 0, -6 },
  { 233, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_THINITALIC8PT7B_H_
