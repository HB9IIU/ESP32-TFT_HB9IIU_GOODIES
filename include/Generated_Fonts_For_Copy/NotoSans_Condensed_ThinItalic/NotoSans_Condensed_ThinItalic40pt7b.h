#ifndef _NOTOSANS_CONDENSED_THINITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x06, 0x08, 0x00, 0x21, 0x21, 0x23, 0x42, 0x42, 0x42, 0x42, 0x44, 0x84,
  0x84, 0x84, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08,
  0x20, 0x0C, 0x10, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x1F, 0xFF, 0xC0,
  0x82, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x80, 0x10, 0x40, 0x10, 0x20,
  0x08, 0x20, 0x04, 0x10, 0x06, 0x08, 0x1F, 0xFF, 0x81, 0x04, 0x00, 0x82,
  0x00, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08,
  0x20, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0xFE,
  0x03, 0x23, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x04, 0x40, 0x06, 0x40, 0x03, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xA0, 0x01, 0x10, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x82, 0x20, 0x7F, 0xC0,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x07, 0x00, 0x20, 0x88,
  0x04, 0x10, 0xC0, 0x41, 0x04, 0x08, 0x20, 0x41, 0x82, 0x04, 0x10, 0x40,
  0x42, 0x04, 0x08, 0x20, 0x40, 0x84, 0x04, 0x08, 0x40, 0x40, 0x88, 0x0C,
  0x19, 0x80, 0x81, 0x11, 0xE8, 0x12, 0x23, 0x82, 0x24, 0x14, 0x24, 0xC1,
  0x44, 0x48, 0x13, 0x88, 0x81, 0x01, 0x98, 0x10, 0x11, 0x03, 0x02, 0x10,
  0x20, 0x21, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x81,
  0x04, 0x10, 0x10, 0x83, 0x01, 0x08, 0x20, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x8C, 0x01, 0x04, 0x02, 0x04, 0x02, 0x04, 0x02, 0x04, 0x02, 0x04, 0x02,
  0x0C, 0x02, 0x08, 0x02, 0x18, 0x02, 0x30, 0x02, 0x60, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x10, 0x41, 0x20, 0x41, 0x40,
  0x62, 0x40, 0x22, 0x40, 0x24, 0x80, 0x14, 0x80, 0x18, 0x80, 0x18, 0x80,
  0x38, 0x40, 0x28, 0x60, 0xC4, 0x3F, 0x84, 0x24, 0xA4, 0x92, 0x92, 0x00,
  0x00, 0x60, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x18, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x0C, 0x20, 0x24, 0x01, 0xDF, 0x06, 0x00, 0xA0, 0x32, 0x04,
  0x10, 0x81, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88, 0xC0, 0xFF, 0x80, 0xBC, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0x18, 0x08, 0x10, 0x20, 0x20, 0x40, 0x21, 0x00,
  0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00, 0x32,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x80, 0x11, 0x00,
  0x26, 0x00, 0x48, 0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x10, 0xC0, 0x20,
  0x80, 0x81, 0x03, 0x03, 0x0C, 0x03, 0xF0, 0x00, 0x01, 0x07, 0x0E, 0x12,
  0x62, 0xC2, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x00, 0x7C, 0x00, 0xC3, 0x00, 0x80, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0x04, 0x04, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x80, 0xC0, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x05, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x12, 0x00, 0x26, 0x00, 0x44, 0x00, 0x44, 0x00, 0x84, 0x01, 0x04, 0x03,
  0x08, 0x02, 0x08, 0x04, 0x08, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x30, 0xFF, 0xFE, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x01,
  0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1F,
  0xC0, 0x08, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x80, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0xC1, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x27, 0xE0, 0x28,
  0x10, 0x50, 0x08, 0x60, 0x08, 0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x08, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x10, 0x40, 0x10, 0x40,
  0x20, 0x40, 0x60, 0x20, 0xC0, 0x1F, 0x80, 0x3F, 0xFE, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0x86, 0x02, 0x02, 0x04, 0x01, 0x04, 0x01,
  0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x0C, 0x01, 0x04, 0x02, 0x04, 0x04,
  0x02, 0x0C, 0x03, 0x10, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x20, 0x18, 0x10,
  0x30, 0x18, 0x60, 0x08, 0x40, 0x08, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x08, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F, 0xC0,
  0x00, 0xF8, 0x01, 0x8C, 0x02, 0x02, 0x04, 0x02, 0x0C, 0x02, 0x08, 0x01,
  0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x06, 0x10, 0x06, 0x18, 0x0A, 0x0C, 0x34, 0x03, 0xC4,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0xFE, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x10, 0xC0, 0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x40, 0x40, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x00, 0x07, 0x81, 0x86, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0xF7, 0x80, 0x04, 0x01, 0x00,
  0x60, 0x02, 0x03, 0x00, 0x08, 0x18, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x40, 0x7E, 0x11, 0x02, 0x08, 0x48, 0x10, 0x41,
  0x20, 0x81, 0x04, 0x82, 0x04, 0x14, 0x10, 0x30, 0x50, 0x40, 0x81, 0x41,
  0x02, 0x0D, 0x08, 0x08, 0x24, 0x20, 0x60, 0xB0, 0x81, 0x06, 0xC2, 0x0C,
  0x12, 0x08, 0x30, 0xC8, 0x31, 0x42, 0x20, 0x7C, 0xF0, 0xC0, 0x40, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x12,
  0x00, 0x22, 0x00, 0x22, 0x00, 0x62, 0x00, 0x42, 0x00, 0x42, 0x00, 0x82,
  0x00, 0x83, 0x01, 0x01, 0x01, 0x01, 0x02, 0x01, 0x03, 0xFF, 0x04, 0x01,
  0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x03, 0xE0, 0x03, 0x0F,
  0x01, 0x00, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x20, 0x0C, 0x30, 0x06, 0x10,
  0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x82, 0x00, 0xC1, 0x00, 0xC0,
  0xFF, 0x80, 0x43, 0xC0, 0x20, 0x30, 0x20, 0x0C, 0x10, 0x02, 0x08, 0x01,
  0x04, 0x00, 0x86, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x40,
  0x08, 0x60, 0x0C, 0x20, 0x0C, 0x10, 0x1C, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x60, 0x40, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xC0, 0x01, 0x8F, 0x00, 0x40, 0x20, 0x10, 0x04, 0x04, 0x01, 0x81,
  0x00, 0x20, 0xC0, 0x08, 0x20, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x10, 0x80,
  0x0C, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02,
  0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x60, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x41, 0x00, 0x30, 0x40, 0x18, 0x20, 0x0C, 0x08, 0x06,
  0x02, 0x07, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x18, 0x1C, 0x04, 0x00, 0x81, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x01, 0xFC, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x00, 0x88, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x86, 0x00, 0x10, 0x40,
  0x02, 0x08, 0x00, 0x40, 0x80, 0x10, 0x08, 0x02, 0x00, 0xFF, 0x80, 0x02,
  0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20,
  0x40, 0x02, 0x08, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04,
  0x08, 0x00, 0x41, 0x00, 0x0C, 0x10, 0x00, 0x81, 0xFF, 0xF8, 0x10, 0x00,
  0x81, 0x00, 0x08, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00,
  0x10, 0x60, 0x01, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x08, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x00,
  0x03, 0xF0, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x08, 0xC0, 0x3C, 0x00, 0x02,
  0x00, 0x41, 0x80, 0x20, 0x40, 0x10, 0x10, 0x0C, 0x04, 0x06, 0x01, 0x03,
  0x00, 0x80, 0x80, 0x20, 0x40, 0x08, 0x20, 0x02, 0x10, 0x00, 0x8C, 0x00,
  0x46, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x50, 0x00, 0x64, 0x00, 0x30,
  0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x81, 0x00, 0x60, 0x40, 0x10, 0x10,
  0x04, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x0C, 0x08, 0x01, 0x02,
  0x00, 0x40, 0x80, 0x18, 0x00, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xA0, 0x00, 0x50, 0x50, 0x00, 0x38, 0x28, 0x00,
  0x28, 0x34, 0x00, 0x14, 0x12, 0x00, 0x12, 0x09, 0x00, 0x09, 0x04, 0x80,
  0x09, 0x82, 0x40, 0x04, 0x82, 0x20, 0x04, 0x41, 0x10, 0x02, 0x20, 0x88,
  0x02, 0x10, 0x42, 0x01, 0x10, 0x21, 0x01, 0x08, 0x20, 0x81, 0x84, 0x10,
  0x40, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x06, 0x08, 0x60, 0x82,
  0x04, 0x20, 0x41, 0x02, 0x30, 0x20, 0x81, 0x10, 0x30, 0x40, 0x90, 0x10,
  0x40, 0x48, 0x08, 0x20, 0x18, 0x04, 0x10, 0x0C, 0x02, 0x08, 0x04, 0x02,
  0x00, 0x02, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0x50, 0x01, 0x05,
  0x00, 0x20, 0x50, 0x02, 0x0D, 0x00, 0x20, 0x88, 0x02, 0x08, 0x80, 0x20,
  0x88, 0x04, 0x08, 0x80, 0x41, 0x04, 0x04, 0x10, 0x40, 0x41, 0x04, 0x0C,
  0x10, 0x40, 0x81, 0x02, 0x08, 0x20, 0x20, 0x82, 0x02, 0x08, 0x20, 0x31,
  0x02, 0x01, 0x10, 0x60, 0x11, 0x04, 0x01, 0x10, 0x40, 0x19, 0x04, 0x00,
  0xA0, 0x40, 0x0A, 0x08, 0x00, 0xA0, 0x80, 0x0E, 0x08, 0x00, 0x60, 0x80,
  0x04, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x20, 0x18, 0x10, 0x02, 0x0C,
  0x00, 0xC2, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x34, 0x00, 0x0B,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x02,
  0x04, 0x01, 0x80, 0x80, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x06, 0x3C,
  0x04, 0x06, 0x04, 0x02, 0x04, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x0C,
  0x10, 0x18, 0x10, 0x70, 0x3F, 0x80, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x20,
  0x18, 0x10, 0x02, 0x0C, 0x00, 0xC2, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x34, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10,
  0xC0, 0x04, 0x10, 0x02, 0x04, 0x01, 0x00, 0x80, 0x80, 0x1F, 0xC0, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x06, 0x3C, 0x04, 0x06, 0x04, 0x02, 0x04,
  0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x03, 0x08,
  0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x18, 0x1F, 0xE0, 0x20,
  0x80, 0x20, 0x80, 0x20, 0x40, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80,
  0x10, 0x00, 0x7E, 0x00, 0xE0, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x10, 0x04,
  0x07, 0xFC, 0x00, 0x7F, 0xFE, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x21, 0x00, 0x0C, 0x20,
  0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x20, 0x80,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x82, 0x00,
  0x10, 0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x41, 0x00, 0x08, 0x60, 0x03, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01,
  0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x02, 0x01, 0x00, 0x40, 0x30, 0x30,
  0x03, 0xFC, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0x42, 0x01, 0x84,
  0x02, 0x08, 0x0C, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01, 0x04,
  0x02, 0x08, 0x04, 0x20, 0x08, 0x40, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x00,
  0x50, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x28, 0x03,
  0x80, 0x14, 0x01, 0x40, 0x12, 0x00, 0xA0, 0x09, 0x00, 0x90, 0x08, 0x80,
  0x48, 0x04, 0x40, 0x44, 0x02, 0x20, 0x22, 0x02, 0x10, 0x11, 0x01, 0x08,
  0x10, 0x81, 0x04, 0x08, 0x40, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x40,
  0x86, 0x08, 0x20, 0x42, 0x04, 0x20, 0x21, 0x02, 0x10, 0x11, 0x01, 0x10,
  0x08, 0x80, 0x88, 0x04, 0x80, 0x44, 0x02, 0x40, 0x24, 0x01, 0x20, 0x12,
  0x00, 0xA0, 0x0A, 0x00, 0x50, 0x05, 0x00, 0x30, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x18, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x10,
  0x00, 0x84, 0x00, 0x19, 0x80, 0x01, 0x20, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x24, 0x00,
  0x0C, 0x80, 0x01, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00,
  0x80, 0x80, 0x10, 0x10, 0x04, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x08,
  0x00, 0x80, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00,
  0x84, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x02, 0x18, 0x08, 0x40, 0x22,
  0x00, 0xC8, 0x01, 0x40, 0x07, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0xFC, 0x00, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x02, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0x82, 0x08,
  0x20, 0x82, 0x0C, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xA0, 0x01, 0x20, 0x01, 0x30, 0x02, 0x10, 0x06, 0x10, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x20, 0x02, 0x60,
  0x02, 0xC0, 0x03, 0xFF, 0xF0, 0x88, 0x44, 0x22, 0x10, 0x03, 0xF2, 0x0C,
  0x14, 0x20, 0x28, 0xC0, 0x31, 0x00, 0x66, 0x00, 0x88, 0x01, 0x10, 0x02,
  0x40, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x98, 0x03, 0x30,
  0x04, 0x60, 0x08, 0x40, 0x30, 0x80, 0xA1, 0x01, 0x43, 0x05, 0x03, 0xF2,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x13, 0xF0, 0x28, 0x30, 0xA0, 0x21,
  0xC0, 0x23, 0x00, 0x46, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80,
  0x19, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40, 0x09,
  0x80, 0x23, 0x00, 0xC5, 0x01, 0x0A, 0x04, 0x13, 0xF0, 0x00, 0x03, 0xF8,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0xFC, 0x40, 0x60, 0xA0, 0x20, 0x18,
  0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x60, 0x80, 0x10, 0x20, 0x04, 0x10,
  0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x10, 0x10, 0x0C, 0x04, 0x07, 0x01, 0x01, 0x40,
  0x60, 0x90, 0x0F, 0xC8, 0x00, 0x03, 0xF0, 0x30, 0x43, 0x02, 0x30, 0x11,
  0x00, 0x98, 0x04, 0x80, 0x44, 0x06, 0x40, 0x62, 0x0C, 0x1F, 0x80, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x01, 0xD0, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x02, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x81, 0x82, 0x81, 0x80, 0xC1, 0x80, 0x60, 0x80, 0x30,
  0xC0, 0x18, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01,
  0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x20,
  0x18, 0x10, 0x1C, 0x08, 0x0A, 0x06, 0x09, 0x01, 0xF9, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x08, 0x08, 0x07, 0x38, 0x00, 0x20, 0x00, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x27,
  0xE0, 0xA0, 0xC5, 0x01, 0x18, 0x04, 0x60, 0x11, 0x00, 0x44, 0x01, 0x30,
  0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x44, 0x01, 0x10,
  0x04, 0x40, 0x11, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x80,
  0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x58, 0x03, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x30,
  0x81, 0x86, 0x04, 0x10, 0x20, 0x41, 0x01, 0x08, 0x04, 0x40, 0x23, 0x00,
  0x98, 0x02, 0x60, 0x0A, 0x80, 0x31, 0x01, 0x84, 0x04, 0x10, 0x10, 0x40,
  0x40, 0x83, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x42, 0x01, 0x00, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08,
  0x10, 0x00, 0x09, 0xF0, 0xFC, 0x14, 0x12, 0x08, 0x50, 0x28, 0x08, 0xC0,
  0x60, 0x11, 0x80, 0xC0, 0x22, 0x01, 0x00, 0x44, 0x02, 0x01, 0x18, 0x04,
  0x02, 0x20, 0x08, 0x04, 0x40, 0x20, 0x08, 0x80, 0x40, 0x21, 0x00, 0x80,
  0x44, 0x01, 0x00, 0x88, 0x06, 0x01, 0x10, 0x08, 0x02, 0x20, 0x10, 0x08,
  0xC0, 0x20, 0x11, 0x00, 0x40, 0x22, 0x01, 0x00, 0x44, 0x02, 0x00, 0x88,
  0x04, 0x02, 0x00, 0x09, 0xF8, 0x28, 0x31, 0x40, 0x46, 0x01, 0x18, 0x04,
  0x40, 0x11, 0x00, 0x4C, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x32, 0x00, 0x88, 0x02,
  0x20, 0x08, 0x80, 0x20, 0x03, 0xF0, 0x18, 0x20, 0xC0, 0x46, 0x01, 0x10,
  0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x60, 0x05, 0x00, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x0F, 0x00, 0x2C, 0x00, 0xB0, 0x04, 0x40, 0x11, 0x00, 0x84,
  0x06, 0x08, 0x30, 0x3F, 0x80, 0x02, 0x7E, 0x01, 0x61, 0x81, 0x60, 0x40,
  0xA0, 0x10, 0x60, 0x08, 0x30, 0x04, 0x10, 0x02, 0x18, 0x01, 0x08, 0x00,
  0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x08, 0x20, 0x04, 0x10, 0x04, 0x18, 0x02, 0x0A, 0x02, 0x05, 0x02, 0x02,
  0x7E, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF1, 0x06,
  0x0A, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x40, 0x70, 0x40, 0x50, 0x60,
  0x90, 0x3F, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x09, 0xE1, 0x40,
  0x50, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x07, 0xF0, 0x40, 0x44, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x21, 0x03, 0x0F, 0xF0,
  0x00, 0x04, 0x02, 0x02, 0x01, 0x00, 0x83, 0xFC, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x3C, 0x00, 0x08, 0x02, 0x10, 0x04, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x08,
  0x40, 0x10, 0x80, 0x22, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20,
  0x18, 0x80, 0x21, 0x00, 0xC3, 0x03, 0x82, 0x0D, 0x03, 0xE2, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0x84, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x50,
  0x05, 0x00, 0x70, 0x06, 0x00, 0x60, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x0A, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x08, 0x42, 0x20, 0x84, 0x22, 0x10, 0x44, 0x21, 0x04, 0x42,
  0x30, 0x4C, 0x22, 0x04, 0x82, 0x20, 0x48, 0x24, 0x05, 0x02, 0x40, 0x50,
  0x28, 0x06, 0x02, 0x80, 0x60, 0x28, 0x04, 0x03, 0x00, 0x40, 0x30, 0x00,
  0x06, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x40, 0x80, 0x10, 0x80, 0x08,
  0xC0, 0x04, 0x40, 0x02, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x28, 0x00, 0x34, 0x00, 0x12, 0x00, 0x11, 0x00, 0x10, 0x40, 0x08, 0x20,
  0x08, 0x10, 0x08, 0x04, 0x0C, 0x02, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x80, 0x40, 0x08, 0x08,
  0x00, 0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00, 0x82,
  0x00, 0x04, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x50, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x09, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x01, 0xE0, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x03, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x00, 0x0F, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0x86, 0x06,
  0x07, 0xF0, 0x01, 0x00,
};

const GFXglyph NotoSans_Condensed_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 29, 8, 1, -29 },
  { 27, 8, 11, 11, 4, -29 },
  { 38, 17, 29, 18, 1, -29 },
  { 100, 16, 32, 16, 0, -30 },
  { 164, 20, 29, 24, 2, -29 },
  { 237, 16, 29, 17, 0, -29 },
  { 295, 3, 11, 6, 4, -29 },
  { 300, 11, 34, 10, 1, -28 },
  { 347, 11, 34, 10, -3, -28 },
  { 394, 12, 12, 15, 5, -30 },
  { 412, 15, 18, 18, 2, -23 },
  { 446, 5, 9, 7, -2, -4 },
  { 452, 9, 1, 11, 1, -11 },
  { 454, 2, 3, 7, 1, -3 },
  { 455, 17, 29, 12, -2, -29 },
  { 517, 15, 29, 16, 1, -29 },
  { 572, 8, 29, 16, 5, -29 },
  { 601, 17, 29, 16, -1, -29 },
  { 663, 16, 29, 16, 0, -29 },
  { 721, 16, 29, 16, 0, -29 },
  { 779, 16, 29, 16, 0, -29 },
  { 837, 16, 29, 16, 1, -29 },
  { 895, 15, 29, 16, 2, -29 },
  { 950, 16, 29, 16, 0, -29 },
  { 1008, 16, 29, 16, 0, -29 },
  { 1066, 6, 21, 7, 0, -21 },
  { 1082, 9, 26, 7, -2, -21 },
  { 1112, 15, 17, 18, 2, -23 },
  { 1144, 15, 10, 18, 2, -19 },
  { 1163, 15, 17, 18, 2, -23 },
  { 1195, 12, 29, 12, 1, -29 },
  { 1239, 22, 33, 24, 1, -29 },
  { 1330, 16, 29, 16, -3, -29 },
  { 1388, 17, 29, 18, 1, -29 },
  { 1450, 17, 29, 17, 2, -29 },
  { 1512, 18, 29, 20, 1, -29 },
  { 1578, 16, 29, 16, 1, -29 },
  { 1636, 16, 29, 15, 1, -29 },
  { 1694, 19, 29, 21, 2, -29 },
  { 1763, 20, 29, 20, 1, -29 },
  { 1836, 12, 29, 8, -2, -29 },
  { 1880, 14, 36, 7, -6, -29 },
  { 1943, 18, 29, 16, 1, -29 },
  { 2009, 10, 29, 14, 1, -29 },
  { 2046, 25, 29, 26, 1, -29 },
  { 2137, 20, 29, 21, 1, -29 },
  { 2210, 18, 29, 21, 2, -29 },
  { 2276, 16, 29, 17, 1, -29 },
  { 2334, 18, 36, 21, 2, -29 },
  { 2415, 16, 29, 17, 1, -29 },
  { 2473, 17, 29, 16, -1, -29 },
  { 2535, 14, 29, 14, 3, -29 },
  { 2586, 19, 29, 20, 2, -29 },
  { 2655, 15, 29, 16, 4, -29 },
  { 2710, 25, 29, 27, 4, -29 },
  { 2801, 19, 29, 14, -2, -29 },
  { 2870, 14, 29, 14, 3, -29 },
  { 2921, 18, 29, 15, -1, -29 },
  { 2987, 15, 35, 11, -1, -29 },
  { 3053, 6, 29, 13, 4, -29 },
  { 3075, 15, 35, 11, -3, -29 },
  { 3141, 16, 15, 18, 1, -29 },
  { 3171, 12, 1, 12, -3, 4 },
  { 3173, 4, 7, 8, 6, -31 },
  { 3177, 15, 21, 17, 1, -21 },
  { 3217, 15, 30, 17, 1, -30 },
  { 3274, 13, 21, 13, 1, -21 },
  { 3309, 18, 30, 17, 1, -30 },
  { 3377, 13, 21, 15, 1, -21 },
  { 3412, 18, 41, 8, -5, -31 },
  { 3505, 17, 31, 17, 0, -21 },
  { 3571, 14, 30, 17, 1, -30 },
  { 3624, 7, 29, 7, 1, -29 },
  { 3650, 13, 39, 7, -5, -29 },
  { 3714, 14, 30, 14, 1, -30 },
  { 3767, 7, 30, 7, 1, -30 },
  { 3794, 23, 21, 25, 1, -21 },
  { 3855, 14, 21, 17, 1, -21 },
  { 3892, 14, 21, 17, 1, -21 },
  { 3929, 17, 30, 17, -1, -21 },
  { 3993, 16, 30, 17, 1, -21 },
  { 4053, 11, 21, 11, 1, -21 },
  { 4082, 13, 21, 13, 0, -21 },
  { 4117, 9, 26, 9, 1, -26 },
  { 4147, 15, 21, 17, 1, -21 },
  { 4187, 12, 21, 13, 2, -21 },
  { 4219, 20, 21, 21, 2, -21 },
  { 4272, 17, 21, 13, -2, -21 },
  { 4317, 20, 31, 13, -5, -21 },
  { 4395, 14, 21, 12, -1, -21 },
  { 4432, 14, 35, 13, 1, -29 },
  { 4494, 1, 40, 16, 8, -30 },
  { 4499, 13, 35, 13, -2, -29 },
  { 4556, 15, 4, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_THINITALIC40PT7B_H_
