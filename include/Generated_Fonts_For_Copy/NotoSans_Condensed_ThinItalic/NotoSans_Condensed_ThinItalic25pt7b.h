#ifndef _NOTOSANS_CONDENSED_THINITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x20, 0x00, 0x46,
  0x00, 0x25, 0x24, 0x92, 0x4A, 0x49, 0x00, 0x02, 0x20, 0x44, 0x11, 0x02,
  0x20, 0x44, 0x7F, 0xC2, 0x20, 0x44, 0x09, 0x02, 0x20, 0x44, 0x6E, 0xE2,
  0x20, 0x44, 0x08, 0x82, 0x20, 0x44, 0x08, 0x80, 0x01, 0x00, 0x40, 0xFC,
  0x48, 0x12, 0x08, 0x82, 0x20, 0x50, 0x14, 0x03, 0x00, 0x40, 0x18, 0x09,
  0x02, 0x40, 0x90, 0x24, 0x12, 0x3F, 0x01, 0x00, 0x40, 0x1C, 0x11, 0x21,
  0x11, 0x08, 0x88, 0x84, 0x44, 0x22, 0x42, 0x12, 0x10, 0xA6, 0x8A, 0x4C,
  0x54, 0x5D, 0x22, 0x0A, 0x10, 0x90, 0x84, 0x88, 0x44, 0x44, 0x22, 0x21,
  0x22, 0x0E, 0x00, 0x07, 0x02, 0x20, 0x88, 0x42, 0x10, 0x84, 0x40, 0xA0,
  0x30, 0x08, 0x05, 0x02, 0x45, 0x09, 0x82, 0xA0, 0xA8, 0x12, 0x04, 0x83,
  0x1F, 0x20, 0x55, 0x68, 0x06, 0x08, 0x20, 0x82, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x00,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x20, 0x41, 0x04, 0x18, 0x00, 0x08, 0x13, 0x41, 0xF1,
  0x0D, 0x22, 0x02, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x25, 0x28, 0xF8, 0xC0, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x08, 0x48, 0x24,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0, 0xA0, 0x50, 0x28, 0x14, 0x12,
  0x09, 0x08, 0x84, 0x3C, 0x00, 0x09, 0xD3, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x21, 0x08, 0x44, 0x00, 0x07, 0x81, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x1F, 0xE0, 0x0F, 0x84, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x04, 0x1E, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x3F, 0x00, 0x00, 0x40, 0x30, 0x14, 0x0A, 0x02, 0x81,
  0x20, 0x88, 0x24, 0x11, 0x08, 0x42, 0x11, 0x04, 0x82, 0x3F, 0xE0, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0xF0, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x3F, 0x00, 0x07, 0x84, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0xBC,
  0xA1, 0x60, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x84, 0x3C, 0x00,
  0x3F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x00, 0x0F,
  0x84, 0x11, 0x04, 0x41, 0x10, 0x44, 0x11, 0x08, 0x24, 0x06, 0x06, 0x82,
  0x11, 0x04, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0x0F, 0x04,
  0x21, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x61, 0xE8,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x3E, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x44,
  0x21, 0x10, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x00, 0x7C, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x00, 0x00, 0x81,
  0x00, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x02, 0x20, 0x04, 0x87, 0x14,
  0x24, 0x51, 0x11, 0x88, 0x46, 0x22, 0x28, 0x88, 0xA4, 0x22, 0x91, 0x92,
  0x44, 0x48, 0xEE, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xC0,
  0x00, 0x80, 0x30, 0x14, 0x05, 0x02, 0x40, 0x90, 0x24, 0x11, 0x04, 0x42,
  0x10, 0xFC, 0x41, 0x10, 0x48, 0x12, 0x05, 0x01, 0x40, 0x70, 0x10, 0x0F,
  0x81, 0x08, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x11, 0x04, 0x3F, 0x04,
  0x10, 0x82, 0x10, 0x24, 0x04, 0x80, 0x90, 0x22, 0x04, 0x41, 0x1F, 0xC0,
  0x03, 0xE1, 0x80, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x07,
  0xC0, 0x0F, 0x80, 0x84, 0x08, 0x21, 0x02, 0x10, 0x11, 0x01, 0x10, 0x12,
  0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x40, 0x44, 0x04, 0x40, 0x84,
  0x10, 0x42, 0x0F, 0xC0, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x3F, 0x84, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x1F, 0xC0, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x07, 0xF0, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x00, 0x03, 0xF0, 0xC0, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x1E, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x44, 0x04, 0x40, 0x83, 0xF8, 0x08, 0x08, 0x40,
  0x42, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x02, 0x3F, 0xE1,
  0x01, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40,
  0x44, 0x02, 0x00, 0x0F, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x87, 0x80, 0x08, 0x10,
  0x82, 0x08, 0x41, 0x08, 0x11, 0x01, 0x20, 0x12, 0x02, 0x40, 0x2C, 0x03,
  0x40, 0x24, 0x02, 0x20, 0x42, 0x04, 0x20, 0x41, 0x04, 0x10, 0x41, 0x08,
  0x18, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x41, 0xFC, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0xC2,
  0x80, 0x61, 0x40, 0x50, 0xA0, 0x28, 0x50, 0x28, 0x48, 0x14, 0x24, 0x12,
  0x12, 0x09, 0x09, 0x09, 0x04, 0x88, 0x84, 0x44, 0x42, 0x14, 0x21, 0x0A,
  0x10, 0x86, 0x10, 0x43, 0x08, 0x41, 0x04, 0x00, 0x08, 0x08, 0x40, 0x43,
  0x02, 0x28, 0x11, 0x40, 0x8A, 0x08, 0x48, 0x44, 0x42, 0x22, 0x11, 0x11,
  0x08, 0x48, 0x42, 0x44, 0x12, 0x20, 0x51, 0x03, 0x08, 0x18, 0x40, 0xC4,
  0x02, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x22, 0x01, 0x20, 0x14, 0x01, 0x40,
  0x14, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80,
  0x88, 0x08, 0x41, 0x03, 0xE0, 0x0F, 0x81, 0x08, 0x21, 0x08, 0x11, 0x02,
  0x20, 0x44, 0x11, 0x02, 0x20, 0x84, 0xE0, 0xE0, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x22, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x41, 0x03, 0xE0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x0F, 0x81, 0x08, 0x21, 0x08, 0x11, 0x02, 0x20, 0x44,
  0x11, 0x02, 0x20, 0x87, 0xE0, 0x88, 0x11, 0x04, 0x20, 0x84, 0x10, 0x42,
  0x08, 0x41, 0x10, 0x20, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x3F, 0x00, 0xFF, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x00,
  0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02,
  0x40, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x10,
  0x41, 0x07, 0xE0, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x22,
  0x08, 0x84, 0x21, 0x08, 0x81, 0x20, 0x50, 0x14, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x00, 0x80, 0x81, 0x80, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x90,
  0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x80, 0x08, 0x10, 0x82, 0x08, 0x40, 0x84, 0x04, 0x80, 0x48, 0x05,
  0x00, 0x60, 0x02, 0x00, 0x60, 0x0A, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x21,
  0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0xC0, 0xA0, 0x50, 0x44, 0x42, 0x21,
  0x20, 0x90, 0x50, 0x28, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x0F, 0xF0, 0x0F, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x07, 0x80, 0x92, 0x49, 0x24, 0x49, 0x24, 0x89,
  0x24, 0x07, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x87, 0xC0, 0x04, 0x02, 0x80, 0xA0, 0x48, 0x11, 0x08, 0x44, 0x09, 0x02,
  0x80, 0xC0, 0xFE, 0xA5, 0x1F, 0x90, 0xD0, 0x28, 0x14, 0x14, 0x0A, 0x05,
  0x02, 0x81, 0x41, 0x20, 0x90, 0xC7, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0xC1, 0x48, 0x61, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x50,
  0x24, 0x09, 0x02, 0x41, 0x30, 0x4B, 0xE0, 0x1F, 0x20, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x08, 0x86, 0xE1, 0x04, 0x40, 0x88, 0x11, 0x02, 0x40,
  0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0xC1, 0xE8, 0x00, 0x1E,
  0x21, 0x41, 0x41, 0x82, 0x8C, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C,
  0x00, 0xE0, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x03, 0xE0, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x0F,
  0xC4, 0x32, 0x04, 0x81, 0x20, 0x50, 0x24, 0x09, 0x02, 0x40, 0x90, 0x44,
  0x11, 0x0C, 0x3D, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x0F, 0x80, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x98, 0x72, 0x21, 0x10, 0x90, 0x48, 0x24,
  0x12, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x40, 0x08, 0x40, 0x00,
  0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x42, 0x22, 0x22, 0x12, 0x0A, 0x05, 0x03, 0x83,
  0x21, 0x10, 0x88, 0x44, 0x41, 0x20, 0x80, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x20, 0x1F, 0xBC, 0x21, 0x84, 0x42,
  0x09, 0x04, 0x12, 0x08, 0x24, 0x10, 0x88, 0x41, 0x20, 0x82, 0x41, 0x04,
  0x82, 0x09, 0x04, 0x24, 0x10, 0x48, 0x20, 0x80, 0x1F, 0x88, 0x44, 0x24,
  0x12, 0x09, 0x04, 0x82, 0x81, 0x41, 0x20, 0x90, 0x50, 0x28, 0x10, 0x1F,
  0x10, 0x90, 0x28, 0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90,
  0x87, 0x80, 0x0B, 0xC1, 0x84, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x09,
  0x01, 0x20, 0x44, 0x08, 0x82, 0x30, 0x45, 0xF0, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x90, 0xD0, 0x28, 0x14, 0x0C, 0x0A,
  0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0xC7, 0xA0, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x1F, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x1F, 0x20, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x04, 0x04, 0x04, 0xF8, 0x21, 0x09, 0xF4, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x42, 0x1C, 0x20, 0x90, 0x50, 0x28, 0x24, 0x12, 0x0A, 0x05, 0x04,
  0x82, 0x41, 0x21, 0x90, 0x8F, 0xC0, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88,
  0x48, 0x50, 0x50, 0x50, 0x60, 0x40, 0x40, 0x82, 0x0C, 0x10, 0xA1, 0x85,
  0x0C, 0x28, 0xA2, 0x45, 0x12, 0x49, 0x12, 0x48, 0x91, 0x45, 0x0C, 0x28,
  0x60, 0x82, 0x04, 0x10, 0x00, 0x10, 0x44, 0x20, 0x90, 0x24, 0x0A, 0x01,
  0x00, 0x40, 0x30, 0x14, 0x08, 0x82, 0x21, 0x08, 0x82, 0x00, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x05, 0x00,
  0x50, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x0F, 0xC0, 0x03, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x60, 0xC0, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x40, 0x70, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x07, 0x00, 0x78, 0xC3, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 18, 5, 0, -18 },
  { 13, 6, 7, 7, 2, -18 },
  { 19, 11, 18, 11, 0, -18 },
  { 44, 10, 20, 10, 0, -19 },
  { 69, 13, 18, 15, 1, -18 },
  { 99, 10, 18, 11, 0, -18 },
  { 122, 2, 7, 4, 2, -18 },
  { 124, 7, 22, 6, 1, -18 },
  { 144, 7, 22, 6, -2, -18 },
  { 164, 7, 8, 10, 3, -19 },
  { 171, 9, 12, 11, 1, -15 },
  { 185, 3, 5, 4, -1, -2 },
  { 187, 5, 1, 7, 1, -7 },
  { 188, 1, 2, 4, 1, -2 },
  { 189, 10, 18, 7, -1, -18 },
  { 212, 9, 18, 10, 1, -18 },
  { 233, 5, 18, 10, 3, -18 },
  { 245, 11, 18, 10, -1, -18 },
  { 270, 10, 18, 10, 0, -18 },
  { 293, 10, 18, 10, 0, -18 },
  { 316, 10, 18, 10, 0, -18 },
  { 339, 9, 18, 10, 1, -18 },
  { 360, 10, 18, 10, 1, -18 },
  { 383, 10, 18, 10, 0, -18 },
  { 406, 10, 18, 10, 0, -18 },
  { 429, 4, 13, 4, 0, -13 },
  { 436, 5, 16, 4, -1, -13 },
  { 446, 9, 10, 11, 1, -14 },
  { 458, 9, 6, 11, 1, -12 },
  { 465, 9, 10, 11, 1, -14 },
  { 477, 7, 18, 7, 1, -18 },
  { 493, 14, 20, 15, 1, -18 },
  { 528, 10, 18, 10, -2, -18 },
  { 551, 11, 18, 11, 0, -18 },
  { 576, 11, 18, 10, 1, -18 },
  { 601, 12, 18, 12, 0, -18 },
  { 628, 11, 18, 10, 0, -18 },
  { 653, 11, 18, 9, 0, -18 },
  { 678, 12, 18, 13, 1, -18 },
  { 705, 13, 18, 13, 0, -18 },
  { 735, 8, 18, 5, -1, -18 },
  { 753, 9, 22, 4, -4, -18 },
  { 778, 12, 18, 10, 0, -18 },
  { 805, 7, 18, 9, 0, -18 },
  { 821, 17, 18, 16, 0, -18 },
  { 860, 13, 18, 13, 0, -18 },
  { 890, 12, 18, 13, 1, -18 },
  { 917, 11, 18, 10, 0, -18 },
  { 942, 12, 22, 13, 1, -18 },
  { 975, 11, 18, 10, 0, -18 },
  { 1000, 10, 18, 10, 0, -18 },
  { 1023, 9, 18, 9, 2, -18 },
  { 1044, 12, 18, 13, 1, -18 },
  { 1071, 10, 18, 10, 2, -18 },
  { 1094, 16, 18, 17, 2, -18 },
  { 1130, 12, 18, 9, -1, -18 },
  { 1157, 9, 18, 9, 2, -18 },
  { 1178, 12, 18, 9, -1, -18 },
  { 1205, 9, 22, 7, 0, -18 },
  { 1230, 3, 18, 8, 3, -18 },
  { 1237, 9, 22, 7, -2, -18 },
  { 1262, 10, 9, 11, 1, -18 },
  { 1274, 7, 1, 7, -2, 2 },
  { 1275, 2, 4, 5, 4, -19 },
  { 1276, 9, 13, 11, 1, -13 },
  { 1291, 10, 19, 11, 0, -19 },
  { 1315, 8, 13, 8, 1, -13 },
  { 1328, 11, 19, 11, 1, -19 },
  { 1355, 8, 13, 9, 1, -13 },
  { 1368, 11, 25, 5, -3, -19 },
  { 1403, 10, 19, 11, 0, -13 },
  { 1427, 9, 19, 10, 0, -19 },
  { 1449, 5, 18, 4, 0, -18 },
  { 1461, 8, 24, 4, -3, -18 },
  { 1485, 9, 19, 8, 0, -19 },
  { 1507, 5, 19, 4, 0, -19 },
  { 1519, 15, 13, 16, 0, -13 },
  { 1544, 9, 13, 10, 0, -13 },
  { 1559, 9, 13, 11, 1, -13 },
  { 1574, 11, 19, 11, -1, -13 },
  { 1601, 9, 19, 11, 1, -13 },
  { 1623, 8, 13, 7, 0, -13 },
  { 1636, 8, 13, 8, 0, -13 },
  { 1649, 5, 16, 5, 1, -16 },
  { 1659, 9, 13, 10, 1, -13 },
  { 1674, 8, 13, 8, 1, -13 },
  { 1687, 13, 13, 13, 1, -13 },
  { 1709, 10, 13, 8, -1, -13 },
  { 1726, 12, 19, 8, -3, -13 },
  { 1755, 9, 13, 7, -1, -13 },
  { 1770, 8, 22, 8, 1, -18 },
  { 1792, 1, 25, 10, 5, -19 },
  { 1796, 9, 22, 8, -2, -18 },
  { 1821, 9, 2, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_THINITALIC25PT7B_H_
