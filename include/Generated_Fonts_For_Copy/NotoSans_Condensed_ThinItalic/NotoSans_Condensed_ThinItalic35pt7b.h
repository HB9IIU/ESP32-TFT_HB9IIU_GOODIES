#ifndef _NOTOSANS_CONDENSED_THINITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x84, 0x00, 0x00, 0x00, 0x20, 0x80, 0x23, 0x22, 0x22, 0x42,
  0x42, 0x44, 0x44, 0x44, 0x84, 0x00, 0x42, 0x00, 0x82, 0x00, 0x84, 0x00,
  0x84, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08, 0x1F, 0xFF, 0x02, 0x08, 0x02,
  0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08,
  0x40, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0x40, 0x10, 0x80, 0x20, 0x80, 0x20,
  0x80, 0x21, 0x00, 0x21, 0x00, 0x41, 0x00, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x38, 0x03, 0x4C, 0x31, 0x00, 0x84, 0x02, 0x20, 0x10, 0x80, 0x42,
  0x00, 0x88, 0x02, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x40, 0x08, 0x80, 0x21, 0x00, 0x84, 0x02, 0x10, 0x10, 0x80, 0x42, 0x01,
  0x10, 0xE5, 0x80, 0x78, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x0F, 0x01,
  0x08, 0x81, 0x08, 0x40, 0x84, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x04,
  0x21, 0x02, 0x20, 0x81, 0x20, 0x41, 0x10, 0x20, 0x91, 0xD0, 0x49, 0x18,
  0x49, 0x0C, 0x64, 0x85, 0xE4, 0x82, 0x04, 0x41, 0x02, 0x20, 0x82, 0x20,
  0x41, 0x10, 0x21, 0x08, 0x20, 0x84, 0x10, 0x82, 0x08, 0x81, 0x08, 0x40,
  0x8C, 0x40, 0x3C, 0x00, 0x01, 0xF0, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04,
  0x10, 0x10, 0x40, 0x41, 0x01, 0x08, 0x04, 0x60, 0x13, 0x00, 0x38, 0x00,
  0x80, 0x05, 0x00, 0x24, 0x01, 0x10, 0x48, 0x21, 0x40, 0x89, 0x01, 0x28,
  0x05, 0x20, 0x14, 0x80, 0x22, 0x00, 0x88, 0x05, 0x10, 0x24, 0x3F, 0x10,
  0x24, 0xA4, 0x92, 0x80, 0x00, 0xC0, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x00, 0x04, 0x00, 0x40, 0x10, 0x42, 0x06,
  0x40, 0x3F, 0xC3, 0x00, 0xA0, 0x22, 0x08, 0x40, 0x04, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x12, 0x24, 0x44, 0x80, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x30, 0x83, 0x02,
  0x10, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x08, 0x60, 0x3E, 0x00,
  0x04, 0x72, 0x52, 0x88, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x80, 0x01, 0xF8, 0x0C, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x30, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x70, 0x07, 0x80, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x20, 0x20,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x80, 0x0A, 0x00, 0x48, 0x01,
  0x20, 0x09, 0x00, 0x44, 0x02, 0x10, 0x08, 0x40, 0x41, 0x02, 0x08, 0x08,
  0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x42, 0x01, 0x0F, 0xFF, 0x80,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFC,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0xF8, 0x04, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x20, 0x20, 0xFF, 0x00, 0x00, 0xFC, 0x0C, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0xFC, 0x14, 0x18, 0x60, 0x21, 0x00, 0x44, 0x01, 0x30, 0x04, 0x80, 0x12,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x04, 0x0C, 0x10, 0x60,
  0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x18, 0x20, 0x40,
  0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x03, 0x08, 0x08, 0x10,
  0x40, 0x26, 0x00, 0xE0, 0x06, 0x80, 0x21, 0x03, 0x02, 0x08, 0x08, 0x40,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x84, 0x02, 0x18,
  0x10, 0x1F, 0x80, 0x03, 0xF0, 0x18, 0x20, 0xC0, 0x82, 0x01, 0x10, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x88, 0x02,
  0x10, 0x18, 0x40, 0xA0, 0xFC, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0xC0, 0xFC, 0x00, 0x08,
  0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x02, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40,
  0xC0, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x88, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x08, 0x03, 0x00,
  0x40, 0x60, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21, 0x03,
  0xE1, 0x20, 0x44, 0x12, 0x08, 0x42, 0x21, 0x04, 0x24, 0x10, 0x42, 0x42,
  0x08, 0x24, 0x20, 0x82, 0x42, 0x08, 0x28, 0x40, 0x84, 0x84, 0x10, 0x48,
  0x41, 0x0C, 0x84, 0x30, 0x88, 0x64, 0x90, 0x83, 0xCE, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x10,
  0x00, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x48,
  0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82,
  0x02, 0x08, 0x10, 0x20, 0x7F, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00,
  0x88, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0xB0, 0x01, 0x80, 0x04, 0x07,
  0xF0, 0x10, 0x20, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x44,
  0x01, 0x10, 0x0C, 0x40, 0x21, 0x03, 0x0F, 0xF0, 0x20, 0xC0, 0x80, 0xC2,
  0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x12,
  0x00, 0x88, 0x04, 0x20, 0x20, 0xFE, 0x00, 0x01, 0xFE, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x08, 0x30, 0x20, 0x10,
  0x40, 0x20, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02,
  0x40, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00, 0x84, 0x03, 0x10, 0x04, 0x20,
  0x30, 0x41, 0xC0, 0xFC, 0x00, 0x07, 0xFC, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0F, 0xF8, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xFF, 0x82, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x01,
  0x80, 0xC1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x03, 0xE2, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x01, 0x08, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40, 0x40, 0x20,
  0x1F, 0xF0, 0x00, 0x04, 0x00, 0x82, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x10, 0x40, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x01,
  0x04, 0x00, 0x87, 0xFF, 0xC2, 0x00, 0x21, 0x00, 0x20, 0x80, 0x10, 0x40,
  0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x00, 0x07, 0xC0, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0xF8, 0x00, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0xF0, 0x00, 0x04, 0x03, 0x04, 0x06, 0x08, 0x0C, 0x08, 0x08,
  0x08, 0x10, 0x08, 0x20, 0x10, 0x40, 0x10, 0x80, 0x11, 0x80, 0x13, 0x00,
  0x16, 0x00, 0x26, 0x00, 0x2A, 0x00, 0x32, 0x00, 0x21, 0x00, 0x21, 0x00,
  0x41, 0x00, 0x40, 0x80, 0x40, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0x04,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x42, 0x80, 0x06, 0x0A, 0x00,
  0x28, 0x28, 0x00, 0xA1, 0x20, 0x04, 0x84, 0x80, 0x12, 0x12, 0x00, 0x90,
  0x48, 0x02, 0x41, 0x20, 0x11, 0x08, 0x80, 0x44, 0x22, 0x02, 0x10, 0x88,
  0x08, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x41, 0x08, 0x21, 0x04, 0x21,
  0x04, 0x11, 0x04, 0x10, 0x44, 0x10, 0x81, 0x20, 0x42, 0x04, 0x81, 0x08,
  0x14, 0x08, 0x20, 0x50, 0x20, 0x80, 0x80, 0x80, 0x04, 0x00, 0x41, 0x00,
  0x20, 0xA0, 0x08, 0x28, 0x02, 0x0A, 0x00, 0x82, 0x80, 0x21, 0x10, 0x10,
  0x44, 0x04, 0x11, 0x01, 0x04, 0x40, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x04, 0x20, 0x81, 0x10, 0x40, 0x44, 0x10, 0x11,
  0x04, 0x02, 0x41, 0x00, 0x90, 0x80, 0x28, 0x20, 0x0A, 0x08, 0x01, 0x82,
  0x00, 0x60, 0x80, 0x10, 0x00, 0x01, 0xF8, 0x06, 0x04, 0x08, 0x02, 0x08,
  0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x20, 0x01, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x80,
  0x10, 0x40, 0x20, 0x60, 0x40, 0x3F, 0x80, 0x07, 0xE0, 0x10, 0x40, 0x80,
  0x82, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40,
  0x21, 0x00, 0x88, 0x04, 0x20, 0x60, 0xFE, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x01, 0xF8, 0x06, 0x04, 0x08, 0x02, 0x08, 0x02, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x01, 0x20, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x40,
  0x20, 0x60, 0x40, 0x3F, 0x80, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x07, 0xE0, 0x10, 0x40, 0x80, 0x82, 0x01,
  0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40, 0x21, 0x01,
  0x08, 0x0C, 0x20, 0x60, 0xFE, 0x02, 0x10, 0x08, 0x40, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x40, 0x01, 0xFE, 0x04, 0x04, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x40, 0x20, 0x7F, 0x80,
  0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x00, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x20, 0x80, 0x40,
  0x40, 0xC0, 0x3F, 0x00, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x12, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80, 0x42, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x04,
  0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x0A, 0x00, 0xC0, 0x14, 0x01, 0x80, 0x48,
  0x05, 0x00, 0x90, 0x0A, 0x02, 0x20, 0x24, 0x04, 0x40, 0x48, 0x08, 0x80,
  0x90, 0x21, 0x02, 0x20, 0x42, 0x04, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x82, 0x10, 0x21, 0x04, 0x20, 0x42, 0x08, 0x80, 0x88, 0x11,
  0x01, 0x10, 0x24, 0x02, 0x40, 0x48, 0x04, 0x80, 0x90, 0x09, 0x01, 0x40,
  0x14, 0x02, 0x80, 0x28, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x02, 0x00, 0x81, 0x00, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x08,
  0x20, 0x04, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x50, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x04, 0x40,
  0x02, 0x10, 0x02, 0x08, 0x03, 0x04, 0x01, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x80, 0x20, 0x80, 0x10, 0x00, 0x80, 0x18, 0x02, 0x80, 0x24, 0x04,
  0x40, 0x44, 0x08, 0x41, 0x04, 0x10, 0x42, 0x04, 0x20, 0x24, 0x02, 0x40,
  0x28, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x01, 0xF8,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xF8,
  0x00, 0x88, 0x88, 0x88, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x11,
  0x11, 0x10, 0x03, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0xFC,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x20, 0x80,
  0x82, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x00, 0x90, 0x02, 0xC0, 0x04,
  0xFF, 0xC0, 0x84, 0x42, 0x21, 0x03, 0xC0, 0x21, 0x42, 0x06, 0x20, 0x33,
  0x01, 0x90, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x32, 0x01, 0x10, 0x18, 0x40, 0xC2, 0x0A, 0x0F, 0x90,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0xE0, 0x24, 0x60, 0xA0, 0x83, 0x01, 0x08, 0x04, 0x60,
  0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x46, 0x01, 0x18, 0x08, 0x60, 0x21, 0x41, 0x09, 0xF8, 0x00,
  0x01, 0xE0, 0xC4, 0x20, 0x08, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xC4, 0x08, 0x50, 0x20, 0x60,
  0x80, 0xC3, 0x01, 0x84, 0x03, 0x08, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x18, 0x40, 0x50,
  0x40, 0xC0, 0x82, 0x80, 0xF9, 0x00, 0x03, 0xC0, 0x84, 0x20, 0x88, 0x12,
  0x02, 0x40, 0x50, 0x1A, 0x02, 0x41, 0x8F, 0xC2, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x10, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x24, 0x00, 0xEC, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x04, 0x24, 0x10, 0x30, 0x40, 0x61, 0x80, 0xC2, 0x01, 0x84,
  0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x62, 0x00, 0x84, 0x01,
  0x08, 0x06, 0x10, 0x0C, 0x20, 0x30, 0x20, 0x60, 0x41, 0x40, 0x7C, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x81, 0x02,
  0x03, 0xF8, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0xE0, 0x58, 0xC3, 0x02, 0x18, 0x10, 0x80,
  0x8C, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x01, 0x30, 0x10, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0xC0, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0xF0, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x08, 0x40, 0x82, 0x08, 0x10, 0x41, 0x04, 0x08, 0x40, 0x44, 0x02,
  0x40, 0x16, 0x01, 0x50, 0x0A, 0x40, 0x62, 0x02, 0x10, 0x10, 0x81, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x30, 0x10, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x00, 0x00, 0xE0, 0xE0, 0x58, 0x98,
  0x83, 0x05, 0x02, 0x18, 0x18, 0x10, 0x80, 0x80, 0x8C, 0x04, 0x04, 0x40,
  0x40, 0x42, 0x02, 0x02, 0x10, 0x10, 0x11, 0x00, 0x80, 0x88, 0x08, 0x04,
  0x40, 0x40, 0x42, 0x02, 0x02, 0x10, 0x10, 0x11, 0x00, 0x80, 0x88, 0x08,
  0x04, 0x40, 0x40, 0x42, 0x02, 0x02, 0x30, 0x10, 0x10, 0x00, 0xE0, 0x58,
  0xC3, 0x02, 0x18, 0x10, 0x80, 0x8C, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11,
  0x00, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x22, 0x01, 0x30, 0x10, 0x03, 0xC0, 0x42, 0x08, 0x11, 0x01, 0x30, 0x12,
  0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x40, 0xC4, 0x18, 0x3F, 0x00, 0x00, 0x70, 0x09,
  0x18, 0x14, 0x10, 0x30, 0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x84, 0x01,
  0x08, 0x02, 0x10, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x0C,
  0x02, 0x18, 0x08, 0x30, 0x10, 0x50, 0x40, 0xBF, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xC0, 0x10, 0x90, 0x81, 0x84, 0x06, 0x30, 0x18, 0x80, 0x62, 0x01,
  0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01,
  0x88, 0x06, 0x20, 0x30, 0x40, 0xC1, 0x05, 0x03, 0xE4, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x00, 0xE1, 0x60, 0x38, 0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x00, 0x07, 0xC1, 0x0C, 0x40, 0x10, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x10, 0x23, 0xF8, 0x00, 0x08, 0x10, 0x20, 0x81, 0x0F, 0xC4,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x3C, 0x00, 0x10, 0x08, 0x80, 0x44, 0x04, 0x40, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x44, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x88, 0x04,
  0x40, 0x22, 0x03, 0x10, 0x28, 0xC3, 0x83, 0xE4, 0x00, 0x80, 0x70, 0x0A,
  0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x84, 0x10, 0x84, 0x10, 0x82, 0x20,
  0x44, 0x05, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0x80, 0x80,
  0xE0, 0x20, 0x28, 0x14, 0x12, 0x05, 0x04, 0x82, 0x41, 0x20, 0x90, 0x88,
  0x44, 0x22, 0x11, 0x10, 0x84, 0x44, 0x22, 0x12, 0x08, 0x84, 0x82, 0x41,
  0x20, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x30, 0x10, 0x00, 0x08, 0x0C, 0x20, 0x40, 0x41, 0x01, 0x08, 0x04, 0x40,
  0x11, 0x00, 0x28, 0x00, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x50, 0x02, 0x40,
  0x10, 0x80, 0x42, 0x02, 0x08, 0x10, 0x20, 0x40, 0x42, 0x01, 0x00, 0x01,
  0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20,
  0x04, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x58, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF0, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xF0,
  0x00, 0x70, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x30, 0x0E, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x07, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x07,
  0x00, 0x80, 0x00, 0x78, 0x0C, 0x30, 0x60, 0x7C,
};

const GFXglyph NotoSans_Condensed_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 25, 7, 1, -25 },
  { 20, 8, 9, 10, 3, -25 },
  { 29, 16, 25, 15, 0, -25 },
  { 79, 14, 29, 14, 0, -27 },
  { 130, 17, 25, 21, 2, -25 },
  { 184, 14, 25, 15, 0, -25 },
  { 228, 3, 9, 5, 3, -25 },
  { 232, 10, 31, 8, 1, -25 },
  { 271, 9, 31, 8, -2, -25 },
  { 306, 11, 11, 13, 4, -27 },
  { 322, 14, 16, 16, 1, -20 },
  { 350, 4, 7, 6, -1, -3 },
  { 354, 8, 1, 10, 1, -10 },
  { 355, 1, 2, 6, 1, -2 },
  { 356, 15, 25, 10, -2, -25 },
  { 403, 13, 25, 14, 1, -25 },
  { 444, 6, 25, 14, 5, -25 },
  { 463, 15, 25, 14, -1, -25 },
  { 510, 14, 25, 14, 0, -25 },
  { 554, 14, 25, 14, 0, -25 },
  { 598, 14, 25, 14, 0, -25 },
  { 642, 14, 25, 14, 1, -25 },
  { 686, 13, 25, 14, 2, -25 },
  { 727, 14, 25, 14, 0, -25 },
  { 771, 14, 25, 14, 0, -25 },
  { 815, 6, 19, 6, 0, -19 },
  { 830, 8, 23, 6, -2, -19 },
  { 853, 14, 15, 16, 1, -20 },
  { 880, 14, 8, 16, 1, -16 },
  { 894, 14, 15, 16, 1, -20 },
  { 921, 10, 25, 10, 1, -25 },
  { 953, 20, 28, 21, 1, -25 },
  { 1023, 14, 25, 14, -2, -25 },
  { 1067, 14, 25, 15, 1, -25 },
  { 1111, 15, 25, 14, 2, -25 },
  { 1158, 15, 25, 17, 1, -25 },
  { 1205, 14, 25, 14, 1, -25 },
  { 1249, 14, 25, 13, 1, -25 },
  { 1293, 17, 25, 18, 2, -25 },
  { 1347, 17, 25, 18, 1, -25 },
  { 1401, 10, 25, 7, -1, -25 },
  { 1433, 12, 31, 6, -5, -25 },
  { 1480, 16, 25, 14, 1, -25 },
  { 1530, 9, 25, 13, 1, -25 },
  { 1559, 22, 25, 23, 1, -25 },
  { 1628, 18, 25, 18, 1, -25 },
  { 1685, 16, 25, 18, 2, -25 },
  { 1735, 14, 25, 14, 1, -25 },
  { 1779, 16, 31, 18, 2, -25 },
  { 1841, 14, 25, 15, 1, -25 },
  { 1885, 15, 25, 14, -1, -25 },
  { 1932, 12, 25, 12, 3, -25 },
  { 1970, 16, 25, 18, 2, -25 },
  { 2020, 14, 25, 14, 3, -25 },
  { 2064, 23, 25, 23, 3, -25 },
  { 2136, 17, 25, 13, -2, -25 },
  { 2190, 12, 25, 12, 3, -25 },
  { 2228, 16, 25, 13, -1, -25 },
  { 2278, 13, 31, 10, -1, -25 },
  { 2329, 4, 25, 11, 4, -25 },
  { 2342, 12, 31, 10, -2, -25 },
  { 2389, 14, 13, 15, 1, -25 },
  { 2412, 10, 1, 10, -3, 3 },
  { 2414, 4, 6, 7, 5, -27 },
  { 2417, 13, 19, 15, 1, -19 },
  { 2448, 14, 27, 15, 0, -27 },
  { 2496, 11, 19, 11, 1, -19 },
  { 2523, 15, 27, 15, 1, -27 },
  { 2574, 11, 19, 13, 1, -19 },
  { 2601, 17, 35, 7, -5, -27 },
  { 2676, 15, 27, 15, 0, -19 },
  { 2727, 13, 27, 15, 0, -27 },
  { 2771, 7, 25, 6, 0, -25 },
  { 2793, 12, 33, 6, -5, -25 },
  { 2843, 13, 27, 12, 0, -27 },
  { 2887, 7, 27, 6, 0, -27 },
  { 2911, 21, 19, 22, 0, -19 },
  { 2961, 13, 19, 15, 0, -19 },
  { 2992, 12, 19, 15, 1, -19 },
  { 3021, 15, 27, 15, -1, -19 },
  { 3072, 14, 27, 15, 1, -19 },
  { 3120, 11, 19, 10, 0, -19 },
  { 3147, 11, 19, 11, 0, -19 },
  { 3174, 7, 23, 8, 1, -23 },
  { 3195, 13, 18, 15, 1, -18 },
  { 3225, 11, 18, 11, 2, -18 },
  { 3250, 18, 18, 18, 2, -18 },
  { 3291, 14, 18, 12, -1, -18 },
  { 3323, 17, 27, 12, -4, -18 },
  { 3381, 12, 18, 10, -1, -18 },
  { 3408, 12, 31, 11, 1, -25 },
  { 3455, 1, 36, 14, 7, -27 },
  { 3460, 12, 31, 11, -2, -25 },
  { 3507, 13, 3, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_THINITALIC35PT7B_H_
