#ifndef _NOTOSANS_CONDENSED_THINITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x03, 0x00, 0x30, 0x4C,
  0x32, 0x0C, 0x82, 0x20, 0x98, 0x24, 0x19, 0x04, 0x41, 0x10, 0x4C, 0x12,
  0x0C, 0x82, 0x00, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00,
  0x04, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x18,
  0x18, 0x00, 0x40, 0x40, 0x01, 0x01, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x00, 0x80, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x01,
  0x01, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x06, 0x06,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x3F, 0xFF, 0xF8, 0x08, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x80, 0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40,
  0x40, 0x03, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x81, 0x80,
  0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0x18,
  0xE0, 0x20, 0x80, 0x03, 0x04, 0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x08,
  0x18, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00,
  0x03, 0x10, 0x00, 0x08, 0x80, 0x00, 0x64, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x23, 0x00,
  0x03, 0x08, 0x00, 0x10, 0x60, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x60,
  0x40, 0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x04, 0x10, 0x20,
  0x63, 0x01, 0xFA, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0x03, 0x30, 0x01, 0x03, 0x0C, 0x01, 0x03, 0x06, 0x01, 0x81, 0x01, 0x00,
  0x81, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x40, 0x40, 0x60, 0x60, 0x60, 0x30,
  0x20, 0x20, 0x18, 0x20, 0x10, 0x08, 0x30, 0x08, 0x04, 0x10, 0x0C, 0x02,
  0x18, 0x06, 0x03, 0x08, 0x02, 0x01, 0x8C, 0x01, 0x00, 0x84, 0x3C, 0x80,
  0x46, 0x33, 0x40, 0x62, 0x20, 0xE0, 0x22, 0x30, 0x78, 0x33, 0x10, 0x1C,
  0x31, 0x18, 0x0B, 0x31, 0x88, 0x04, 0xF0, 0x8C, 0x06, 0x00, 0xC6, 0x03,
  0x00, 0x42, 0x01, 0x80, 0x41, 0x00, 0x80, 0x61, 0x80, 0x40, 0x20, 0xC0,
  0x20, 0x30, 0x60, 0x30, 0x10, 0x20, 0x10, 0x18, 0x10, 0x08, 0x08, 0x08,
  0x0C, 0x08, 0x04, 0x04, 0x0C, 0x02, 0x06, 0x04, 0x01, 0x82, 0x06, 0x00,
  0x43, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xDC, 0x00, 0x18, 0x30, 0x01, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x20,
  0x06, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x04, 0x00, 0x60,
  0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x43, 0x00, 0x02, 0x30, 0x00,
  0x1B, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x68, 0x00, 0x06, 0x40,
  0x00, 0x63, 0x00, 0x06, 0x08, 0x0C, 0x60, 0x60, 0x46, 0x01, 0x02, 0x20,
  0x08, 0x23, 0x00, 0x61, 0x10, 0x01, 0x18, 0x80, 0x0C, 0x8C, 0x00, 0x2C,
  0x60, 0x01, 0x43, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x02, 0x00,
  0x6C, 0x18, 0x06, 0x20, 0x60, 0x61, 0x81, 0xFE, 0x04, 0x01, 0x00, 0x00,
  0x33, 0x22, 0x26, 0x44, 0x44, 0xC8, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x08, 0x0C, 0x10, 0x06,
  0x40, 0x02, 0x8F, 0x03, 0xE0, 0x06, 0x00, 0x12, 0x00, 0xC4, 0x03, 0x04,
  0x0C, 0x08, 0x10, 0x08, 0x00, 0x18, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x04, 0x30, 0x82, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x20,
  0xFF, 0xF0, 0xFB, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1D, 0xC0, 0x18, 0x18, 0x04, 0x02,
  0x02, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x04, 0x30, 0x01, 0x08, 0x00, 0x46,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x30, 0x00, 0x48, 0x00, 0x32, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00,
  0x82, 0x00, 0x60, 0x80, 0x10, 0x30, 0x0C, 0x04, 0x06, 0x01, 0x83, 0x00,
  0x3F, 0x80, 0x01, 0x00, 0x00, 0x01, 0x83, 0x43, 0x63, 0x26, 0x16, 0x0A,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xCF, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xCF, 0x00, 0x70, 0x0C, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x81, 0x80, 0x38, 0x07, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00,
  0x66, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x30, 0xC0,
  0x01, 0x06, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x40, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x20, 0x04, 0x03, 0x00, 0x20, 0x30, 0x01, 0x01, 0x00, 0x18,
  0x18, 0x00, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x31, 0x00, 0x01, 0xFF, 0x80,
  0x08, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x04, 0x00, 0x60, 0x30,
  0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0x8C, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x1F, 0xC0, 0x66, 0x0C,
  0x0D, 0x00, 0xC1, 0x40, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x11, 0x80, 0x02,
  0x30, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x01, 0x88, 0x00, 0x31, 0x00, 0x04, 0x20, 0x01, 0x86, 0x00, 0x20,
  0xC0, 0x0C, 0x08, 0x01, 0x01, 0x80, 0x40, 0x18, 0x38, 0x01, 0xFC, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xCE, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x10, 0x01, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x60,
  0x40, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x60, 0x30, 0x02, 0x00, 0x80, 0x20, 0x06, 0x02, 0x00, 0x18, 0x60, 0x00,
  0x46, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x18, 0x00, 0x60, 0x60,
  0x06, 0x01, 0x00, 0x40, 0x04, 0x06, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00,
  0x04, 0x10, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x43,
  0x00, 0x02, 0x18, 0x00, 0x30, 0x40, 0x01, 0x03, 0x00, 0x18, 0x0C, 0x01,
  0x80, 0x30, 0x18, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x1E, 0x60, 0x06, 0x02, 0x01, 0x80, 0x60, 0x60, 0x04, 0x08, 0x00, 0xC3,
  0x00, 0x18, 0x40, 0x01, 0x18, 0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0xC2, 0x00, 0x18, 0x40, 0x05, 0x0C, 0x01, 0xE0, 0xC0, 0x68, 0x0F,
  0xF1, 0x00, 0x78, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x40, 0xC0, 0x0F, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC1, 0x83, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x3C, 0xF0, 0x40, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18,
  0x03, 0xF0, 0x31, 0x80, 0x61, 0x81, 0x10, 0x08, 0x10, 0x33, 0x01, 0x01,
  0x03, 0x20, 0x30, 0x10, 0x32, 0x02, 0x03, 0x03, 0x60, 0x40, 0x20, 0x34,
  0x04, 0x02, 0x02, 0x40, 0xC0, 0x60, 0x24, 0x08, 0x06, 0x06, 0xC0, 0x80,
  0x40, 0x6C, 0x18, 0x04, 0x04, 0x81, 0x80, 0xC0, 0x48, 0x10, 0x0C, 0x0C,
  0x81, 0x01, 0x80, 0x88, 0x10, 0x18, 0x18, 0x81, 0x83, 0x81, 0x08, 0x18,
  0x28, 0x30, 0x80, 0x84, 0x46, 0x08, 0x0F, 0x87, 0xC0, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x40, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x04, 0x60, 0x00,
  0x46, 0x00, 0x08, 0x60, 0x00, 0x86, 0x00, 0x10, 0x60, 0x01, 0x02, 0x00,
  0x30, 0x20, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x01, 0x80, 0x20, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x20, 0x02,
  0x02, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00,
  0x21, 0x80, 0x02, 0x10, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00,
  0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x01, 0xFF, 0xC0,
  0x0C, 0x03, 0x80, 0x40, 0x04, 0x02, 0x00, 0x30, 0x10, 0x00, 0x81, 0x80,
  0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x30, 0x00, 0x41,
  0x80, 0x06, 0x08, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x30, 0x30, 0x03,
  0x01, 0x80, 0x30, 0x0F, 0xFE, 0x00, 0x41, 0xF0, 0x02, 0x00, 0xE0, 0x30,
  0x01, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x03, 0x06,
  0x00, 0x70, 0x30, 0x1E, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0xF0, 0x06, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x01, 0x00, 0x0F,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x01, 0xC0, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x60, 0x01, 0x80, 0x80,
  0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00,
  0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x01,
  0x80, 0x40, 0x0E, 0x01, 0x80, 0x30, 0x03, 0x07, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x04, 0x03,
  0xFF, 0xC0, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x60,
  0x00, 0x40, 0x60, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20,
  0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x40, 0x20, 0x00, 0x10, 0x08, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x10, 0x0F, 0xFF, 0xFC,
  0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x18, 0x00,
  0x08, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30,
  0x00, 0x10, 0x08, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x02, 0x00,
  0x03, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0x80, 0x07, 0x01, 0x80, 0x0C, 0x01, 0x00,
  0x18, 0x01, 0x00, 0x30, 0x01, 0x00, 0x20, 0x03, 0x00, 0x40, 0x02, 0x00,
  0xC0, 0x02, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x04, 0x18, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x09, 0xC0, 0x00, 0x0B, 0x60, 0x00, 0x0A, 0x20,
  0x00, 0x1C, 0x20, 0x00, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x10,
  0x00, 0x30, 0x10, 0x00, 0x30, 0x18, 0x00, 0x20, 0x08, 0x00, 0x20, 0x08,
  0x00, 0x20, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x60, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x40, 0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x01, 0xC0, 0x28, 0x00, 0x00, 0xA0, 0x14, 0x00, 0x00, 0xF0,
  0x1A, 0x00, 0x00, 0x50, 0x09, 0x00, 0x00, 0x48, 0x04, 0x80, 0x00, 0x64,
  0x02, 0x40, 0x00, 0x26, 0x03, 0x20, 0x00, 0x33, 0x01, 0x90, 0x00, 0x11,
  0x00, 0x8C, 0x00, 0x18, 0x80, 0x46, 0x00, 0x08, 0x40, 0x23, 0x00, 0x0C,
  0x60, 0x30, 0x80, 0x04, 0x30, 0x18, 0x40, 0x06, 0x10, 0x08, 0x20, 0x02,
  0x08, 0x04, 0x10, 0x03, 0x04, 0x02, 0x08, 0x01, 0x06, 0x03, 0x04, 0x01,
  0x82, 0x01, 0x02, 0x00, 0x81, 0x00, 0x81, 0x00, 0xC0, 0x80, 0x40, 0xC0,
  0x40, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x20, 0x20, 0x10, 0x08,
  0x30, 0x10, 0x08, 0x04, 0x10, 0x08, 0x04, 0x02, 0x18, 0x0C, 0x06, 0x01,
  0x08, 0x06, 0x03, 0x00, 0x8C, 0x02, 0x01, 0x00, 0x44, 0x01, 0x00, 0x80,
  0x26, 0x00, 0x80, 0x40, 0x12, 0x00, 0xC0, 0x60, 0x0F, 0x00, 0x40, 0x30,
  0x07, 0x00, 0x20, 0x10, 0x03, 0x80, 0x10, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x70, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x05, 0x00, 0x02, 0x01, 0x40, 0x00,
  0x80, 0xD8, 0x00, 0x20, 0x26, 0x00, 0x18, 0x08, 0x80, 0x06, 0x02, 0x20,
  0x01, 0x01, 0x8C, 0x00, 0x40, 0x63, 0x00, 0x30, 0x10, 0x40, 0x0C, 0x04,
  0x10, 0x02, 0x01, 0x06, 0x00, 0x80, 0xC0, 0x80, 0x20, 0x30, 0x20, 0x18,
  0x08, 0x08, 0x06, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x60, 0x10,
  0x10, 0x10, 0x04, 0x0C, 0x04, 0x01, 0x83, 0x01, 0x00, 0x20, 0x80, 0xC0,
  0x08, 0x20, 0x30, 0x02, 0x18, 0x08, 0x00, 0xC6, 0x02, 0x00, 0x11, 0x00,
  0x80, 0x04, 0x40, 0x60, 0x01, 0x90, 0x18, 0x00, 0x6C, 0x04, 0x00, 0x0B,
  0x01, 0x00, 0x02, 0x80, 0x40, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0C, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x70, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04, 0x03, 0x00, 0x06, 0x02,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x03, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x18, 0x02, 0x00, 0x60, 0x10, 0x01,
  0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x18,
  0x30, 0x00, 0x81, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x0C, 0x02, 0x01,
  0x80, 0x3F, 0xF8, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x04, 0x03, 0x00, 0x06, 0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x03, 0x18, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00,
  0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00,
  0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x60, 0x10, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40,
  0x03, 0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x04, 0x08, 0x00, 0x20,
  0x40, 0x03, 0x02, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x18, 0x08, 0x01,
  0x80, 0x40, 0x18, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x60, 0x06, 0x03, 0x00, 0x30, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00,
  0x10, 0x08, 0x00, 0xC0, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF3, 0xE0, 0x0E, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x07, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x01,
  0x02, 0x00, 0x01, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x0C,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30,
  0x20, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x68, 0x00, 0x09,
  0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC2,
  0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x04,
  0x00, 0x80, 0x80, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x20, 0x0C,
  0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x43, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x12,
  0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xA0, 0x00,
  0xE0, 0x00, 0x90, 0x00, 0x50, 0x00, 0xC8, 0x00, 0x28, 0x00, 0x44, 0x00,
  0x34, 0x00, 0x22, 0x00, 0x12, 0x00, 0x31, 0x00, 0x19, 0x00, 0x10, 0x80,
  0x08, 0x80, 0x18, 0x40, 0x0C, 0x40, 0x08, 0x20, 0x04, 0x20, 0x04, 0x10,
  0x02, 0x10, 0x06, 0x08, 0x03, 0x08, 0x02, 0x04, 0x01, 0x04, 0x03, 0x02,
  0x01, 0x82, 0x01, 0x01, 0x00, 0x81, 0x01, 0x80, 0x80, 0x40, 0x80, 0x80,
  0x40, 0x60, 0x40, 0x40, 0x20, 0x20, 0x20, 0x60, 0x10, 0x30, 0x10, 0x20,
  0x08, 0x10, 0x08, 0x30, 0x04, 0x18, 0x04, 0x10, 0x02, 0x08, 0x02, 0x08,
  0x01, 0x04, 0x01, 0x0C, 0x00, 0x86, 0x00, 0x84, 0x00, 0x42, 0x00, 0x46,
  0x00, 0x23, 0x00, 0x22, 0x00, 0x11, 0x00, 0x13, 0x00, 0x08, 0x80, 0x09,
  0x00, 0x04, 0xC0, 0x04, 0x80, 0x02, 0x40, 0x02, 0xC0, 0x01, 0x60, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x01,
  0x00, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x20, 0x00, 0x10, 0x20, 0x00,
  0x08, 0x30, 0x00, 0x04, 0x10, 0x00, 0x03, 0x10, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x08, 0x00, 0x01, 0x84, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x40,
  0x10, 0x00, 0x60, 0x08, 0x00, 0x20, 0x04, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x00, 0x80, 0x10, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x18,
  0x01, 0x86, 0x00, 0x40, 0x80, 0x30, 0x20, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x00, 0xC0, 0x80, 0x30, 0x60, 0x04, 0x10, 0x01, 0x0C, 0x00, 0x46, 0x00,
  0x11, 0x00, 0x04, 0xC0, 0x01, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xC1, 0x81, 0x02, 0x04, 0x08, 0x18,
  0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC1,
  0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C,
  0x08, 0x10, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0x20,
  0x00, 0x66, 0x00, 0x08, 0xC0, 0x03, 0x08, 0x00, 0x41, 0x80, 0x18, 0x10,
  0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x04, 0x04, 0x00, 0xC1, 0x80, 0x08,
  0x20, 0x01, 0x0C, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x78, 0x00, 0x04,
  0xFF, 0xFE, 0xC2, 0x18, 0x41, 0x08, 0x21, 0x00, 0xFC, 0x20, 0x70, 0x44,
  0x18, 0x05, 0x82, 0x00, 0xA0, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x31,
  0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x80, 0x06, 0x20, 0x00, 0xC4,
  0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x18, 0x80, 0x03, 0x10,
  0x00, 0x42, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x18, 0x30,
  0x07, 0x06, 0x00, 0xA0, 0x40, 0x24, 0x0C, 0x18, 0x80, 0xFE, 0x20, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x63, 0xF0, 0x08, 0xC3, 0x01,
  0x20, 0x30, 0x28, 0x03, 0x0F, 0x00, 0x61, 0xC0, 0x04, 0x30, 0x00, 0x86,
  0x00, 0x10, 0xC0, 0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10,
  0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x40,
  0x01, 0x98, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80,
  0x08, 0x78, 0x03, 0x09, 0x00, 0xC1, 0x30, 0x30, 0x23, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0x03, 0x81, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x20, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0xFE, 0x20, 0x0E, 0x0C, 0x80,
  0x60, 0x16, 0x01, 0x00, 0x78, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x80, 0x02, 0x06, 0x00, 0x08,
  0x10, 0x00, 0x60, 0x40, 0x01, 0x83, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x20,
  0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x01,
  0x80, 0x80, 0x0E, 0x02, 0x00, 0x38, 0x0C, 0x01, 0xE0, 0x30, 0x05, 0x00,
  0x40, 0x24, 0x01, 0x83, 0x10, 0x03, 0xF8, 0x40, 0x01, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0x86, 0x06, 0x03, 0x04, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10,
  0x03, 0x30, 0x03, 0x20, 0x06, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x30, 0x41,
  0xE0, 0xFF, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x10, 0x1F, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x71, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x88, 0x07, 0x06, 0x40, 0x60, 0x12,
  0x02, 0x00, 0xF0, 0x20, 0x03, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80,
  0x06, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0xC1,
  0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00,
  0xC1, 0x00, 0x06, 0x08, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x38, 0x10,
  0x01, 0xC0, 0xC0, 0x1E, 0x06, 0x01, 0xA0, 0x10, 0x09, 0x00, 0xC1, 0x88,
  0x03, 0xF8, 0xC0, 0x02, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x08, 0x03, 0x00, 0x60, 0x70, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x3F, 0x01, 0x38, 0x60, 0x58, 0x0C, 0x14, 0x01, 0x0E,
  0x00, 0x43, 0x80, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x63, 0x00, 0x10,
  0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x20, 0x01,
  0x08, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x01,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0xC1, 0x00, 0x60, 0x40, 0x10,
  0x10, 0x08, 0x0C, 0x04, 0x03, 0x03, 0x00, 0x81, 0x80, 0x20, 0xC0, 0x08,
  0x60, 0x06, 0x10, 0x01, 0x88, 0x00, 0x46, 0x00, 0x13, 0x80, 0x05, 0xB0,
  0x03, 0xC4, 0x00, 0xE1, 0x00, 0x30, 0x40, 0x08, 0x18, 0x06, 0x02, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x04, 0x01, 0x03, 0x00, 0x40, 0xC0,
  0x10, 0x20, 0x06, 0x08, 0x00, 0x80, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x00, 0x06, 0x7F, 0x07, 0xE0, 0x26, 0x0C, 0xE1, 0xC1, 0x60, 0x24,
  0x06, 0x0E, 0x01, 0x40, 0x10, 0xE0, 0x0E, 0x00, 0x86, 0x00, 0x60, 0x04,
  0x30, 0x03, 0x00, 0x21, 0x80, 0x10, 0x01, 0x08, 0x00, 0x80, 0x18, 0xC0,
  0x0C, 0x00, 0xC6, 0x00, 0x60, 0x04, 0x20, 0x02, 0x00, 0x21, 0x00, 0x10,
  0x01, 0x08, 0x00, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x40, 0x04,
  0x20, 0x02, 0x00, 0x21, 0x00, 0x10, 0x01, 0x18, 0x01, 0x80, 0x18, 0xC0,
  0x0C, 0x00, 0x84, 0x00, 0x40, 0x04, 0x20, 0x02, 0x00, 0x21, 0x00, 0x10,
  0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x08, 0x00, 0x84, 0x00, 0x40, 0x04,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x3F, 0x01, 0x30, 0x60, 0x58, 0x0C, 0x1C,
  0x01, 0x0E, 0x00, 0x43, 0x80, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x08, 0x00,
  0xC6, 0x00, 0x21, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x63,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04,
  0x20, 0x01, 0x08, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xE0, 0xC0, 0x60, 0x10,
  0x30, 0x06, 0x08, 0x00, 0x86, 0x00, 0x21, 0x00, 0x0C, 0xC0, 0x03, 0x20,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00,
  0x2C, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32,
  0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x60,
  0x10, 0x0C, 0x18, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x00, 0xC7, 0xE0, 0x02,
  0x30, 0xC0, 0x09, 0x01, 0x80, 0x28, 0x03, 0x01, 0xE0, 0x0C, 0x07, 0x00,
  0x10, 0x1C, 0x00, 0x40, 0x60, 0x01, 0x01, 0x80, 0x04, 0x0C, 0x00, 0x10,
  0x30, 0x00, 0x40, 0xC0, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60,
  0x00, 0x81, 0x80, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x60, 0x40, 0x01,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x04, 0x07,
  0x80, 0x30, 0x1A, 0x01, 0x80, 0x4C, 0x0C, 0x01, 0x1F, 0xC0, 0x04, 0x08,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x20, 0x70,
  0x64, 0x18, 0x04, 0x82, 0x00, 0xF0, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00,
  0x31, 0x80, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0x80, 0x03,
  0x10, 0x00, 0x62, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x1C,
  0x30, 0x07, 0x86, 0x00, 0xA0, 0x40, 0x34, 0x0C, 0x18, 0x80, 0xFE, 0x30,
  0x02, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x04, 0x3E, 0x09, 0x80, 0x16, 0x00, 0x28,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFE, 0x07, 0x03,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x80, 0x60,
  0xFF, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x0F, 0xF8, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x7C, 0x02, 0x00, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03, 0x18, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x08, 0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x42, 0x00, 0x30,
  0x80, 0x0C, 0x20, 0x07, 0x08, 0x01, 0xC2, 0x00, 0xE0, 0xC0, 0x68, 0x30,
  0x32, 0x07, 0xF8, 0x80, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14,
  0x00, 0x68, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40, 0x18, 0xC0, 0x21, 0x80,
  0xC3, 0x01, 0x06, 0x02, 0x0C, 0x0C, 0x18, 0x10, 0x10, 0x60, 0x20, 0x80,
  0x43, 0x00, 0x84, 0x01, 0x18, 0x02, 0x20, 0x04, 0xC0, 0x09, 0x00, 0x16,
  0x00, 0x28, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x05, 0x00, 0x50, 0x02, 0x80, 0x28, 0x03, 0x40,
  0x34, 0x01, 0x20, 0x12, 0x00, 0x90, 0x19, 0x00, 0x88, 0x08, 0x80, 0x44,
  0x04, 0x40, 0x62, 0x06, 0x20, 0x21, 0x02, 0x10, 0x30, 0x83, 0x08, 0x10,
  0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x10, 0x81, 0x04, 0x08, 0x40, 0xC4,
  0x04, 0x60, 0x62, 0x02, 0x20, 0x33, 0x01, 0x10, 0x19, 0x00, 0x90, 0x0D,
  0x80, 0x48, 0x06, 0x80, 0x2C, 0x03, 0xC0, 0x14, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x18, 0x08, 0x01, 0x80, 0x40, 0x18, 0x02, 0x00, 0x80, 0x18, 0x08, 0x00,
  0x40, 0xC0, 0x02, 0x04, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x02, 0x60,
  0x00, 0x12, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0x86, 0x00,
  0x0C, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x06, 0x00, 0x60, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x04, 0x03, 0x00, 0x30, 0x30, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x80, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x30, 0x00, 0x80, 0x10, 0x00, 0x40, 0x18, 0x00, 0x20,
  0x08, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x80, 0x2C, 0x38, 0x07, 0x00, 0xE3, 0xC0, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 36, 10, 1, -36 },
  { 46, 10, 13, 14, 5, -36 },
  { 63, 22, 36, 22, 1, -36 },
  { 162, 21, 42, 21, 0, -39 },
  { 273, 25, 38, 30, 3, -37 },
  { 392, 21, 38, 22, 0, -37 },
  { 492, 4, 13, 8, 5, -36 },
  { 499, 14, 44, 12, 1, -36 },
  { 576, 13, 44, 12, -3, -36 },
  { 648, 15, 16, 19, 6, -39 },
  { 678, 19, 24, 23, 2, -30 },
  { 735, 6, 12, 8, -2, -5 },
  { 744, 12, 1, 14, 1, -14 },
  { 746, 3, 3, 9, 1, -3 },
  { 748, 21, 36, 15, -2, -36 },
  { 843, 18, 38, 21, 2, -37 },
  { 929, 9, 36, 21, 7, -36 },
  { 970, 21, 37, 21, -1, -37 },
  { 1068, 21, 38, 21, -1, -37 },
  { 1168, 21, 37, 21, -1, -37 },
  { 1266, 21, 37, 21, 0, -36 },
  { 1364, 19, 38, 21, 2, -37 },
  { 1455, 19, 36, 21, 3, -36 },
  { 1541, 21, 38, 21, 0, -37 },
  { 1641, 19, 38, 21, 1, -37 },
  { 1732, 7, 27, 9, 1, -27 },
  { 1756, 10, 34, 9, -2, -27 },
  { 1799, 19, 22, 23, 2, -29 },
  { 1852, 19, 12, 23, 2, -24 },
  { 1881, 19, 22, 23, 2, -29 },
  { 1934, 15, 37, 15, 2, -37 },
  { 2004, 28, 41, 31, 2, -36 },
  { 2148, 20, 37, 20, -3, -37 },
  { 2241, 21, 36, 22, 1, -36 },
  { 2336, 22, 38, 21, 3, -37 },
  { 2441, 23, 36, 25, 1, -36 },
  { 2545, 21, 36, 20, 1, -36 },
  { 2640, 21, 36, 19, 1, -36 },
  { 2735, 24, 38, 27, 3, -37 },
  { 2849, 26, 36, 26, 1, -36 },
  { 2966, 15, 36, 10, -2, -36 },
  { 3034, 18, 45, 9, -8, -36 },
  { 3136, 24, 36, 21, 1, -36 },
  { 3244, 13, 36, 18, 1, -36 },
  { 3303, 33, 36, 33, 1, -36 },
  { 3452, 26, 36, 27, 1, -36 },
  { 3569, 24, 38, 27, 2, -37 },
  { 3683, 21, 36, 21, 1, -36 },
  { 3778, 24, 46, 27, 2, -37 },
  { 3916, 21, 36, 21, 1, -36 },
  { 4011, 22, 38, 20, -1, -37 },
  { 4116, 18, 36, 18, 4, -36 },
  { 4197, 24, 37, 26, 2, -36 },
  { 4308, 19, 36, 20, 5, -36 },
  { 4394, 33, 36, 34, 5, -36 },
  { 4543, 25, 36, 18, -3, -36 },
  { 4656, 18, 36, 18, 4, -36 },
  { 4737, 24, 36, 19, -2, -36 },
  { 4845, 19, 44, 14, -1, -36 },
  { 4950, 7, 36, 16, 5, -36 },
  { 4982, 18, 44, 14, -3, -36 },
  { 5081, 19, 18, 22, 2, -36 },
  { 5124, 15, 1, 15, -4, 5 },
  { 5126, 5, 8, 11, 7, -39 },
  { 5131, 19, 28, 22, 2, -27 },
  { 5198, 19, 40, 22, 1, -39 },
  { 5293, 16, 28, 17, 2, -27 },
  { 5349, 22, 40, 22, 2, -39 },
  { 5459, 16, 28, 19, 2, -27 },
  { 5515, 24, 51, 11, -7, -39 },
  { 5668, 21, 39, 22, 0, -27 },
  { 5771, 18, 39, 21, 1, -39 },
  { 5859, 9, 36, 9, 1, -36 },
  { 5900, 17, 48, 9, -7, -36 },
  { 6002, 18, 39, 17, 1, -39 },
  { 6090, 9, 39, 8, 1, -39 },
  { 6134, 29, 27, 32, 1, -27 },
  { 6232, 18, 27, 21, 1, -27 },
  { 6293, 18, 28, 21, 2, -27 },
  { 6356, 22, 39, 22, -2, -27 },
  { 6464, 19, 39, 22, 2, -27 },
  { 6557, 15, 27, 14, 1, -27 },
  { 6608, 16, 28, 16, 0, -27 },
  { 6664, 11, 34, 11, 1, -33 },
  { 6711, 18, 28, 21, 2, -27 },
  { 6774, 15, 27, 16, 3, -27 },
  { 6825, 25, 27, 26, 3, -27 },
  { 6910, 21, 27, 17, -2, -27 },
  { 6981, 25, 39, 17, -6, -27 },
  { 7103, 17, 27, 15, -1, -27 },
  { 7161, 17, 44, 16, 2, -36 },
  { 7255, 1, 51, 20, 10, -39 },
  { 7262, 17, 44, 16, -3, -36 },
  { 7356, 19, 4, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_THINITALIC51PT7B_H_
