#ifndef _NOTOSANS_CONDENSED_THINITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x45, 0x14, 0x92, 0x8A, 0x28, 0x80, 0x01, 0x08, 0x04,
  0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x83, 0xFF, 0xC1, 0x08, 0x04,
  0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x10, 0x83, 0xFF, 0xC1, 0x08, 0x04,
  0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x10, 0x80, 0x42, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x7F, 0x08, 0x81, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x10, 0x0A, 0x00, 0x60, 0x02, 0x00, 0x30, 0x04, 0x80, 0x44, 0x04, 0x40,
  0x44, 0x04, 0x40, 0x88, 0x89, 0x07, 0xE0, 0x08, 0x00, 0x80, 0x10, 0x00,
  0x1C, 0x04, 0x88, 0x22, 0x20, 0x90, 0x84, 0x42, 0x22, 0x08, 0x88, 0x24,
  0x21, 0x10, 0x84, 0x82, 0x12, 0x78, 0x92, 0x62, 0x51, 0x92, 0x45, 0x92,
  0x10, 0x48, 0x42, 0x21, 0x09, 0x04, 0x44, 0x11, 0x10, 0x88, 0x42, 0x41,
  0x11, 0x03, 0xC0, 0x01, 0x80, 0x24, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84,
  0x08, 0x40, 0x88, 0x05, 0x80, 0x70, 0x04, 0x00, 0xA0, 0x12, 0x02, 0x21,
  0x41, 0x14, 0x12, 0x80, 0xA8, 0x0C, 0x80, 0x88, 0x0C, 0x41, 0x47, 0xE2,
  0x55, 0xA8, 0x03, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x08, 0x08, 0x88, 0xC8, 0x37, 0x18,
  0x28, 0x44, 0x84, 0x04, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x24, 0xA5, 0x20, 0xFC, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x00, 0x03, 0x80, 0x88, 0x20, 0x88, 0x11, 0x02, 0x40, 0x48, 0x0A, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80,
  0x90, 0x22, 0x04, 0x41, 0x04, 0x20, 0xF8, 0x00, 0x1C, 0xA4, 0xA2, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x80,
  0x00, 0xC0, 0x31, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xE0,
  0x03, 0xC0, 0xC2, 0x10, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x0F, 0x80, 0x30, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x0F, 0xE0, 0x00, 0x10, 0x03,
  0x00, 0x50, 0x0A, 0x00, 0xA0, 0x12, 0x02, 0x20, 0x24, 0x04, 0x40, 0x84,
  0x08, 0x41, 0x04, 0x20, 0x82, 0x08, 0x40, 0x88, 0x08, 0xFF, 0xE0, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x3E, 0x02, 0x18, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0xFE, 0x00, 0x01, 0xF0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0xF0, 0x70, 0x84, 0x04, 0xC0, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x43, 0x03, 0xC0, 0x7F,
  0xE0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x00, 0x03, 0xC0, 0x42, 0x08, 0x11, 0x01, 0x10, 0x11,
  0x01, 0x10, 0x11, 0x02, 0x08, 0x40, 0x48, 0x03, 0x00, 0xD0, 0x10, 0x82,
  0x04, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x40, 0x83,
  0xF0, 0x03, 0x80, 0x46, 0x08, 0x21, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x06, 0x11, 0xA0, 0xE2, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x0F, 0xC0, 0x08, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x18, 0x04, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x41, 0x08, 0x20, 0x00,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x00, 0x1C, 0x10, 0x80, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x01, 0xFC, 0x01, 0x01, 0x01, 0x00, 0x41, 0x00, 0x21,
  0x00, 0x11, 0x00, 0x04, 0x83, 0xC2, 0x42, 0x21, 0x42, 0x10, 0xA2, 0x08,
  0x91, 0x08, 0x50, 0x84, 0x28, 0x82, 0x14, 0x41, 0x12, 0x21, 0x09, 0x11,
  0x48, 0x84, 0xAC, 0x41, 0x88, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC1, 0x00, 0x1F, 0x00, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0xA0, 0x0A, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x04, 0x20, 0x41,
  0x08, 0x10, 0xFF, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x18, 0x01, 0x0F, 0xE0, 0x81, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x02, 0x20, 0x43, 0xF0, 0x20, 0x84, 0x04, 0x40, 0x44, 0x02,
  0x40, 0x24, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x10, 0xFC, 0x00, 0x01,
  0xE0, 0x61, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0xF0, 0x0F, 0xE0, 0x41, 0x84,
  0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x80, 0x44,
  0x06, 0x20, 0x61, 0x04, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFE, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xF0,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x06, 0x0C, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x07, 0xC4, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80,
  0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x82, 0x02, 0x03, 0xFC, 0x00, 0x04,
  0x01, 0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x1F, 0xFC, 0x10, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x20, 0xC0, 0x20, 0x0F, 0x81, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x0F, 0x00, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x1E, 0x00, 0x04, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08,
  0x08, 0x40, 0x22, 0x01, 0x18, 0x04, 0xC0, 0x12, 0x00, 0x58, 0x01, 0xA0,
  0x0C, 0x80, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x80, 0x40, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0xFF, 0x04, 0x00, 0x30, 0x40, 0x05, 0x0A, 0x00, 0x60, 0xA0,
  0x0A, 0x0A, 0x00, 0xA0, 0xA0, 0x12, 0x12, 0x01, 0x41, 0x20, 0x24, 0x12,
  0x02, 0x41, 0x20, 0x44, 0x12, 0x04, 0x42, 0x20, 0x88, 0x22, 0x08, 0x82,
  0x11, 0x08, 0x21, 0x10, 0x82, 0x12, 0x08, 0x41, 0x21, 0x04, 0x14, 0x10,
  0x41, 0x41, 0x04, 0x18, 0x10, 0xC1, 0x82, 0x00, 0x04, 0x01, 0x04, 0x01,
  0x0A, 0x02, 0x0A, 0x02, 0x0A, 0x02, 0x09, 0x02, 0x11, 0x02, 0x11, 0x04,
  0x11, 0x04, 0x10, 0x84, 0x10, 0x84, 0x20, 0x84, 0x20, 0x88, 0x20, 0x48,
  0x20, 0x48, 0x20, 0x48, 0x40, 0x50, 0x40, 0x30, 0x40, 0x30, 0x40, 0x30,
  0x80, 0x30, 0x01, 0xC0, 0x08, 0x40, 0x40, 0x82, 0x01, 0x10, 0x04, 0x40,
  0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x44, 0x02, 0x10,
  0x10, 0x20, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x10,
  0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x04, 0x21, 0x83, 0xE0, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x08, 0x40, 0x40, 0x82, 0x01, 0x10, 0x04, 0x40, 0x12,
  0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x44, 0x02, 0x10, 0x10,
  0x20, 0x80, 0x7C, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x0F, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x22,
  0x02, 0x20, 0x22, 0x04, 0x21, 0x85, 0xE0, 0x42, 0x04, 0x20, 0x42, 0x04,
  0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0x80, 0x03, 0xE0, 0x41,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x0F, 0xE0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x00, 0x08, 0x06, 0x20,
  0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x08, 0x02, 0x10, 0x04,
  0x20, 0x08, 0x40, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10,
  0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x81, 0x01, 0x02, 0x04, 0x03, 0xF0,
  0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x44, 0x08,
  0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90,
  0x14, 0x02, 0x80, 0x60, 0x04, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A, 0x03,
  0x01, 0x40, 0xA0, 0x28, 0x14, 0x09, 0x02, 0x81, 0x20, 0x90, 0x44, 0x12,
  0x08, 0x84, 0x42, 0x10, 0x88, 0x42, 0x21, 0x08, 0x44, 0x22, 0x08, 0x84,
  0x41, 0x20, 0x90, 0x24, 0x12, 0x05, 0x02, 0x40, 0xA0, 0x50, 0x14, 0x0A,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x04, 0x00, 0x02, 0x06, 0x04, 0x08,
  0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x02, 0x20,
  0x04, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x02, 0x02, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x28, 0x12, 0x04, 0x82, 0x20, 0x84, 0x41, 0x10, 0x48, 0x14,
  0x05, 0x01, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xFF, 0xC0, 0x07, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3E,
  0x00, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x11, 0x10,
  0x07, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x00,
  0x03, 0x00, 0x50, 0x05, 0x00, 0x88, 0x08, 0x81, 0x04, 0x20, 0x42, 0x04,
  0x40, 0x24, 0x02, 0x80, 0x10, 0xFF, 0x89, 0x12, 0x07, 0xA3, 0x0C, 0x41,
  0x90, 0x34, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40,
  0x48, 0x19, 0x03, 0x10, 0xC3, 0xE8, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xBC, 0x14, 0x21, 0x81, 0x18, 0x11, 0x01,
  0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x24, 0x02, 0x40, 0x24, 0x04,
  0x60, 0x46, 0x08, 0x9F, 0x00, 0x07, 0x8C, 0x04, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x7C, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xF2,
  0x18, 0x60, 0x83, 0x08, 0x08, 0x80, 0x44, 0x04, 0x20, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x03, 0x08, 0x18, 0x21, 0x41, 0xF4,
  0x00, 0x07, 0x86, 0x21, 0x04, 0x81, 0x40, 0x90, 0x24, 0x12, 0x78, 0xE0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0xF8, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x03,
  0x80, 0x00, 0x03, 0xC8, 0x61, 0x82, 0x0C, 0x20, 0x22, 0x01, 0x10, 0x10,
  0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x0C, 0x20,
  0x60, 0x85, 0x07, 0xD0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x5E, 0x14, 0x23, 0x04, 0x40, 0x88, 0x11, 0x02, 0x40, 0x48,
  0x09, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24, 0x08, 0x81, 0x20, 0x20,
  0x0C, 0x20, 0x00, 0x00, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10,
  0x41, 0x04, 0x10, 0x80, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x03, 0x80, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x41, 0x10, 0x42, 0x10, 0x44, 0x08, 0x81, 0x20, 0x48, 0x0B, 0x01,
  0xA0, 0x22, 0x08, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x20, 0x40, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x41, 0x08, 0x00, 0x0B, 0xC7, 0x85, 0x0A, 0x11, 0x83, 0x04,
  0x40, 0x81, 0x10, 0x20, 0x44, 0x08, 0x12, 0x04, 0x08, 0x81, 0x02, 0x20,
  0x40, 0x88, 0x10, 0x24, 0x08, 0x11, 0x02, 0x04, 0x40, 0x81, 0x10, 0x20,
  0x44, 0x08, 0x12, 0x04, 0x08, 0x13, 0xC2, 0x84, 0x60, 0x88, 0x11, 0x02,
  0x20, 0x48, 0x09, 0x01, 0x20, 0x44, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81,
  0x10, 0x24, 0x04, 0x07, 0x83, 0x08, 0x41, 0x10, 0x14, 0x02, 0x80, 0x50,
  0x0C, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x02, 0x10, 0x83,
  0xE0, 0x05, 0xE0, 0x50, 0x83, 0x02, 0x18, 0x10, 0x80, 0x84, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10,
  0xC1, 0x09, 0xF0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x07, 0x91, 0x86, 0x10, 0x62, 0x02, 0x40, 0x24, 0x04,
  0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x88, 0x18,
  0x42, 0x87, 0xD0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x13, 0x8A, 0x06, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x0F, 0xC4, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x80, 0x23, 0xF0, 0x10, 0x41, 0x04, 0x7C, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x38, 0x20, 0x24, 0x04, 0x80, 0x90,
  0x22, 0x04, 0x80, 0x90, 0x12, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48,
  0x11, 0x06, 0x20, 0xC3, 0xE8, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22,
  0x11, 0x10, 0x88, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x00, 0x81,
  0x03, 0x06, 0x0A, 0x0C, 0x14, 0x28, 0x48, 0x50, 0x90, 0xA1, 0x22, 0x44,
  0x44, 0x88, 0x91, 0x21, 0x22, 0x42, 0x84, 0x85, 0x0A, 0x0C, 0x14, 0x18,
  0x30, 0x20, 0x60, 0x40, 0x80, 0x10, 0x10, 0x82, 0x08, 0x40, 0x84, 0x04,
  0x80, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x0A, 0x01, 0x10, 0x21,
  0x04, 0x10, 0x41, 0x08, 0x08, 0x04, 0x04, 0x10, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x10, 0x40, 0x42, 0x01, 0x08, 0x04, 0x40, 0x09, 0x00, 0x24,
  0x00, 0xA0, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x0F, 0xC0,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x03, 0xF8, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xC0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0xC0,
  0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x38, 0x00, 0x38, 0x1C, 0x62, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 21, 6, 1, -21 },
  { 15, 6, 7, 8, 3, -21 },
  { 21, 14, 21, 13, 0, -21 },
  { 58, 12, 25, 12, 0, -23 },
  { 96, 14, 22, 18, 2, -22 },
  { 135, 12, 22, 13, 0, -22 },
  { 168, 2, 7, 5, 3, -21 },
  { 170, 8, 26, 7, 1, -21 },
  { 196, 8, 26, 7, -2, -21 },
  { 222, 8, 10, 11, 4, -23 },
  { 232, 12, 13, 14, 1, -17 },
  { 252, 3, 7, 5, -1, -3 },
  { 255, 6, 1, 8, 1, -9 },
  { 256, 1, 2, 5, 1, -2 },
  { 257, 12, 21, 9, -1, -21 },
  { 289, 11, 22, 12, 1, -22 },
  { 320, 6, 21, 12, 4, -21 },
  { 336, 13, 22, 12, -1, -22 },
  { 372, 12, 22, 12, 0, -22 },
  { 405, 12, 22, 12, 0, -22 },
  { 438, 12, 21, 12, 0, -21 },
  { 470, 12, 22, 12, 1, -22 },
  { 503, 11, 21, 12, 2, -21 },
  { 532, 12, 22, 12, 0, -22 },
  { 565, 12, 22, 12, 0, -22 },
  { 598, 5, 16, 5, 0, -16 },
  { 608, 6, 20, 5, -1, -16 },
  { 623, 12, 13, 14, 1, -17 },
  { 643, 12, 7, 14, 1, -14 },
  { 654, 12, 13, 14, 1, -17 },
  { 674, 9, 22, 9, 1, -22 },
  { 699, 17, 24, 18, 1, -21 },
  { 750, 12, 22, 12, -2, -22 },
  { 783, 12, 21, 13, 1, -21 },
  { 815, 12, 22, 12, 2, -22 },
  { 848, 13, 21, 15, 1, -21 },
  { 883, 13, 21, 12, 0, -21 },
  { 918, 13, 21, 11, 0, -21 },
  { 953, 15, 22, 16, 1, -22 },
  { 995, 16, 21, 15, 0, -21 },
  { 1037, 9, 21, 6, -1, -21 },
  { 1061, 11, 26, 5, -5, -21 },
  { 1097, 14, 21, 12, 0, -21 },
  { 1134, 8, 21, 11, 0, -21 },
  { 1155, 20, 21, 20, 0, -21 },
  { 1208, 16, 21, 16, 0, -21 },
  { 1250, 14, 22, 16, 1, -22 },
  { 1289, 12, 21, 12, 1, -21 },
  { 1321, 14, 27, 16, 1, -22 },
  { 1369, 12, 21, 13, 1, -21 },
  { 1401, 12, 22, 12, 0, -22 },
  { 1434, 10, 21, 11, 3, -21 },
  { 1461, 15, 21, 15, 1, -21 },
  { 1501, 11, 21, 12, 3, -21 },
  { 1530, 19, 21, 20, 3, -21 },
  { 1580, 15, 21, 11, -2, -21 },
  { 1620, 10, 21, 10, 3, -21 },
  { 1647, 14, 21, 11, -1, -21 },
  { 1684, 10, 26, 8, 0, -21 },
  { 1717, 4, 21, 9, 3, -21 },
  { 1728, 11, 26, 8, -2, -21 },
  { 1764, 12, 11, 13, 1, -21 },
  { 1781, 8, 1, 9, -2, 3 },
  { 1782, 3, 5, 6, 4, -23 },
  { 1784, 11, 16, 13, 1, -16 },
  { 1806, 12, 23, 13, 0, -23 },
  { 1841, 9, 16, 10, 1, -16 },
  { 1859, 13, 23, 13, 1, -23 },
  { 1897, 10, 16, 11, 1, -16 },
  { 1917, 14, 30, 6, -4, -23 },
  { 1970, 13, 23, 13, 0, -16 },
  { 2008, 11, 23, 12, 0, -23 },
  { 2040, 6, 21, 5, 0, -21 },
  { 2056, 10, 28, 5, -4, -21 },
  { 2091, 11, 23, 10, 0, -23 },
  { 2123, 6, 23, 5, 0, -23 },
  { 2141, 18, 16, 19, 0, -16 },
  { 2177, 11, 16, 12, 0, -16 },
  { 2199, 11, 16, 13, 1, -16 },
  { 2221, 13, 23, 13, -1, -16 },
  { 2259, 12, 23, 13, 1, -16 },
  { 2294, 9, 16, 8, 0, -16 },
  { 2312, 10, 16, 10, 0, -16 },
  { 2332, 6, 20, 7, 1, -20 },
  { 2347, 11, 16, 12, 1, -16 },
  { 2369, 9, 16, 9, 2, -16 },
  { 2387, 15, 16, 16, 2, -16 },
  { 2417, 12, 16, 10, -1, -16 },
  { 2441, 14, 23, 10, -3, -16 },
  { 2482, 10, 16, 9, -1, -16 },
  { 2502, 10, 26, 9, 1, -21 },
  { 2535, 1, 30, 12, 6, -23 },
  { 2539, 10, 26, 9, -2, -21 },
  { 2572, 12, 3, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_THINITALIC30PT7B_H_
