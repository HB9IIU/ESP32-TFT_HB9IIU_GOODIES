#ifndef _NOTOSANS_CONDENSED_THINITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x86, 0x06,
  0x10, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x04, 0x30, 0x30, 0x80, 0xC6, 0x03,
  0x18, 0x08, 0x60, 0x21, 0x01, 0x84, 0x06, 0x30, 0x10, 0xC0, 0x42, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x80, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x40, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFA, 0x7F, 0x00, 0x78, 0x60, 0x60, 0x0E,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x03, 0x00, 0x80, 0x60, 0xE0, 0x0C,
  0x06, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x18, 0x60, 0x00, 0x30,
  0x0C, 0x0C, 0x00, 0x18, 0x06, 0x03, 0x00, 0x04, 0x03, 0x00, 0x40, 0x03,
  0x00, 0xC0, 0x10, 0x01, 0x80, 0x60, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x00,
  0x30, 0x18, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18,
  0x01, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x18, 0x30, 0x00,
  0xC0, 0x06, 0x18, 0x04, 0x30, 0x03, 0x06, 0x0F, 0xCC, 0x00, 0xC3, 0x07,
  0x3B, 0x00, 0x30, 0xC3, 0x03, 0xC0, 0x18, 0x61, 0x80, 0xF0, 0x06, 0x18,
  0xC0, 0x3C, 0x03, 0x0C, 0x30, 0x0F, 0x01, 0xC6, 0x18, 0x01, 0x60, 0x61,
  0x86, 0x00, 0x5C, 0x70, 0xC1, 0x00, 0x33, 0xF8, 0x30, 0xC0, 0x0C, 0x30,
  0x18, 0x30, 0x03, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18, 0x01, 0x80, 0xC0,
  0x06, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x0C,
  0x00, 0x18, 0x18, 0x06, 0x00, 0x07, 0x1C, 0x03, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0,
  0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x18,
  0x03, 0x06, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x1C, 0x00, 0xC0, 0x61,
  0x80, 0x0C, 0x06, 0x30, 0x00, 0x60, 0x43, 0x00, 0x06, 0x0C, 0x60, 0x00,
  0x60, 0xC6, 0x00, 0x03, 0x18, 0x60, 0x00, 0x31, 0x86, 0x00, 0x01, 0xB0,
  0xC0, 0x00, 0x1F, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x60, 0x60, 0x00, 0x66,
  0x07, 0x00, 0x0C, 0x30, 0x38, 0x03, 0x83, 0x01, 0xC0, 0xF0, 0x10, 0x0F,
  0xFC, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31,
  0x18, 0xC6, 0x21, 0x18, 0xC4, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x08, 0x02, 0x00, 0xE0,
  0x20, 0x07, 0x06, 0x00, 0x1C, 0x60, 0x00, 0x64, 0x0F, 0x01, 0xDF, 0xE0,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x32, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x00,
  0x18, 0x18, 0x07, 0x00, 0x80, 0xC0, 0x0C, 0x04, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x77, 0xF6, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x03, 0x80,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03, 0xB0, 0x71, 0x07, 0x18,
  0x70, 0xCE, 0x06, 0xE0, 0x32, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x3C,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3C, 0x04, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x0C, 0x1F, 0xF0, 0x03, 0x1E, 0x1E, 0x00, 0x8C, 0x01,
  0xC0, 0x66, 0x00, 0x38, 0x1B, 0x00, 0x06, 0x07, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x30, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x38, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x78, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x18, 0x01, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xF0, 0x18, 0x00, 0x36,
  0x03, 0x00, 0x0E, 0xC0, 0x38, 0x03, 0x10, 0x03, 0xC3, 0xC6, 0x00, 0x3F,
  0xF0, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x18, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xFC, 0x01, 0xE0, 0x70, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xF8, 0x01,
  0x83, 0x00, 0x0F, 0xFC, 0x03, 0x06, 0x00, 0x38, 0x18, 0x06, 0x18, 0x00,
  0xE0, 0x30, 0x0C, 0x30, 0x03, 0x00, 0x60, 0x18, 0x60, 0x0C, 0x01, 0x80,
  0x31, 0x80, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x06, 0x00, 0xC6, 0x01,
  0xC0, 0x0C, 0x01, 0x98, 0x03, 0x00, 0x30, 0x02, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x60, 0x18, 0x00, 0xC0, 0x18, 0xC0, 0x30, 0x01, 0x00, 0x33, 0x00,
  0xC0, 0x06, 0x00, 0x66, 0x01, 0x80, 0x0C, 0x01, 0x8C, 0x03, 0x00, 0x18,
  0x03, 0x18, 0x06, 0x00, 0x60, 0x06, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x60,
  0x30, 0x01, 0x80, 0x30, 0x80, 0x60, 0x07, 0x00, 0x61, 0x00, 0xC0, 0x0E,
  0x01, 0x86, 0x01, 0x80, 0x3C, 0x03, 0x0C, 0x03, 0x00, 0x78, 0x0C, 0x18,
  0x03, 0x01, 0xB0, 0x18, 0x30, 0x06, 0x06, 0x60, 0x60, 0x60, 0x0E, 0x1C,
  0xC1, 0x80, 0xC0, 0x0F, 0xF0, 0xFE, 0x01, 0x80, 0x0F, 0x80, 0xF8, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0x08, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x03, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x78, 0x00, 0x60,
  0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x07, 0x00, 0x18, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x60, 0x01, 0xE0, 0x00, 0x60, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xC1, 0x80, 0x00, 0x7F, 0xF0, 0x60, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x10, 0x01, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x20, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x06, 0x6C, 0x00, 0x00, 0x02, 0x66, 0x00,
  0x00, 0x03, 0x63, 0x00, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x00, 0xF0, 0x60,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x16, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x0D, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x6C, 0x00, 0x00, 0x03, 0x20, 0x03, 0x20, 0x00, 0x00, 0x33, 0x00, 0x11,
  0x00, 0x00, 0x01, 0x98, 0x01, 0x88, 0x00, 0x00, 0x18, 0xC0, 0x0C, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x20, 0x03, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x20, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18,
  0x01, 0x81, 0x00, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x0C, 0x06,
  0x00, 0x18, 0x04, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x00, 0x30, 0x04, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x86, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x80, 0x0C, 0x00,
  0x63, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x18, 0x00, 0x60, 0x06, 0x00, 0x09,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x18, 0x01, 0x80, 0x03, 0xC0,
  0x00, 0x80, 0x0C, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x02, 0xC0, 0x00, 0x06, 0x00,
  0x64, 0x00, 0x00, 0x60, 0x06, 0x60, 0x00, 0x06, 0x00, 0x66, 0x00, 0x00,
  0x60, 0x06, 0x60, 0x00, 0x0C, 0x00, 0x43, 0x00, 0x00, 0xC0, 0x0C, 0x30,
  0x00, 0x0C, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x08, 0x00,
  0xC1, 0x80, 0x01, 0x80, 0x18, 0x18, 0x00, 0x18, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x18, 0x18, 0x00, 0x18, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x10, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0xC0, 0x01, 0x81, 0x80, 0x18, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x00,
  0xC1, 0x80, 0x18, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x00, 0x43, 0x00, 0x10,
  0x00, 0x06, 0x30, 0x03, 0x00, 0x00, 0x63, 0x00, 0x30, 0x00, 0x06, 0x30,
  0x03, 0x00, 0x00, 0x22, 0x00, 0x30, 0x00, 0x03, 0x60, 0x06, 0x00, 0x00,
  0x36, 0x00, 0x60, 0x00, 0x03, 0x60, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x02, 0x00, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x7E, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0x01, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0xE0, 0x02, 0x00, 0x0E, 0x00, 0x30, 0x03, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x30, 0x02, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x0F,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x20, 0x08, 0x00, 0x02, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x80, 0x00, 0x09, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x58, 0x00, 0x03, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x19, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x63, 0x00, 0x03, 0x03, 0x00, 0x06, 0x18, 0x00, 0x10,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x81, 0x80, 0x06, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x60, 0x06,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x20, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0x32, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xB0, 0x00, 0x0C, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x20, 0x00, 0x60, 0x20, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x10, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x08, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xF0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x07, 0xF8, 0x30, 0x07, 0x87, 0x0C, 0x03, 0x80, 0x62,
  0x01, 0x80, 0x0C, 0x80, 0xE0, 0x03, 0x60, 0x70, 0x00, 0x58, 0x18, 0x00,
  0x1E, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x0E, 0x08,
  0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x70, 0x20, 0x00, 0x1C,
  0x0C, 0x00, 0x0F, 0x03, 0x00, 0x02, 0x80, 0xC0, 0x01, 0xA0, 0x30, 0x00,
  0xD8, 0x06, 0x00, 0x66, 0x01, 0xC0, 0x31, 0x80, 0x38, 0x38, 0x40, 0x07,
  0xFC, 0x10, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0xC3, 0xFE, 0x00, 0x30, 0xE1, 0xE0, 0x06, 0x30, 0x0E, 0x00, 0xCC,
  0x00, 0xC0, 0x1B, 0x00, 0x0C, 0x02, 0xC0, 0x01, 0x80, 0xF8, 0x00, 0x30,
  0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x18, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xC0,
  0x48, 0x00, 0x30, 0x09, 0x80, 0x0C, 0x03, 0x18, 0x03, 0x00, 0x63, 0xC1,
  0xC0, 0x0C, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xC0, 0x1E, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x07, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x1F, 0xF0, 0xC0, 0x01, 0xE1, 0xE3, 0x00,
  0x0E, 0x01, 0xCC, 0x00, 0x70, 0x03, 0x30, 0x03, 0x80, 0x07, 0x80, 0x1C,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x38, 0x02, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x03, 0x80, 0x20, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0x70, 0x03, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x1F, 0x00,
  0x30, 0x00, 0x6C, 0x00, 0xC0, 0x03, 0x20, 0x01, 0x80, 0x1C, 0x80, 0x07,
  0x00, 0xE6, 0x00, 0x0E, 0x0E, 0x18, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x07, 0x87, 0x00,
  0x38, 0x06, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x70, 0x60,
  0x03, 0x81, 0x80, 0x78, 0x0C, 0x7F, 0x80, 0x3F, 0xF8, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x1E, 0x07, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xC1, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xF0, 0x40, 0x03, 0xC3, 0xC6, 0x00, 0x38,
  0x07, 0x30, 0x03, 0x80, 0x19, 0x80, 0x30, 0x00, 0x68, 0x03, 0x80, 0x03,
  0x40, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00, 0x38, 0x04, 0x00, 0x01,
  0xC0, 0x20, 0x00, 0x0E, 0x01, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x78, 0x03, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x36, 0x00, 0xC0,
  0x03, 0x20, 0x03, 0x00, 0x3B, 0x00, 0x1C, 0x03, 0x98, 0x00, 0x70, 0x70,
  0xC0, 0x01, 0xFF, 0x06, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x83, 0xFE,
  0x00, 0xC7, 0x83, 0x80, 0x67, 0x00, 0xE0, 0x36, 0x00, 0x30, 0x1F, 0x00,
  0x18, 0x0B, 0x00, 0x04, 0x0F, 0x00, 0x02, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x78, 0x00, 0x06, 0x6C, 0x00, 0x03, 0x63,
  0x00, 0x01, 0x71, 0x80, 0x01, 0xB0, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0x70,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x18, 0x01, 0x00, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x08, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0x40,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x43, 0xFE, 0x03, 0xFE, 0x00,
  0x63, 0x83, 0x83, 0x83, 0x80, 0x33, 0x00, 0xC3, 0x00, 0xE0, 0x1B, 0x00,
  0x33, 0x00, 0x30, 0x0B, 0x00, 0x1B, 0x00, 0x0C, 0x05, 0x00, 0x0F, 0x00,
  0x06, 0x07, 0x80, 0x07, 0x80, 0x03, 0x03, 0x80, 0x03, 0x80, 0x01, 0x81,
  0xC0, 0x01, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x00, 0x30, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00, 0x08, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x41, 0xFF, 0x00, 0x63,
  0xC3, 0xC0, 0x33, 0x80, 0x70, 0x1B, 0x00, 0x18, 0x0B, 0x00, 0x0C, 0x05,
  0x80, 0x02, 0x07, 0x80, 0x01, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x08,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x08, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x07, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x41, 0xFF, 0x00, 0x03, 0x0E, 0x1E, 0x00,
  0x0C, 0x60, 0x1C, 0x00, 0x33, 0x00, 0x30, 0x00, 0x98, 0x00, 0x60, 0x02,
  0xC0, 0x01, 0x80, 0x1B, 0x00, 0x06, 0x00, 0x78, 0x00, 0x0C, 0x01, 0xE0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0xC0, 0x00, 0xE0,
  0x0F, 0x00, 0x03, 0x00, 0x34, 0x00, 0x18, 0x00, 0xD8, 0x00, 0xC0, 0x02,
  0x30, 0x06, 0x00, 0x18, 0xE0, 0x70, 0x00, 0x61, 0xFF, 0x80, 0x01, 0x80,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0xF8, 0x10, 0x07, 0x87, 0x8C, 0x03, 0x80, 0x73,
  0x01, 0x80, 0x0C, 0xC0, 0xC0, 0x01, 0xA0, 0x70, 0x00, 0x78, 0x18, 0x00,
  0x1E, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08,
  0x00, 0x03, 0x82, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x70, 0x20, 0x00, 0x1C,
  0x0C, 0x00, 0x0F, 0x03, 0x00, 0x03, 0xC0, 0xC0, 0x01, 0xB0, 0x30, 0x00,
  0xC8, 0x06, 0x00, 0x76, 0x01, 0xC0, 0x39, 0x80, 0x38, 0x3C, 0x60, 0x07,
  0xFC, 0x18, 0x00, 0x38, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x04, 0x1F,
  0xC0, 0x63, 0xC2, 0x03, 0x38, 0x00, 0x1B, 0x80, 0x00, 0x98, 0x00, 0x05,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0xF8, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0F, 0x80, 0xE0, 0x07, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x08, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x02, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x04, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x01, 0xC0, 0x40, 0x00, 0x70, 0x10, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x03, 0x00, 0x06, 0x80, 0x40, 0x03, 0x60, 0x18, 0x00, 0xD8, 0x06,
  0x00, 0xE6, 0x00, 0xE0, 0xF1, 0x00, 0x1F, 0xF0, 0x40, 0x01, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x20,
  0x03, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x03, 0x60, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x1E, 0x00,
  0x19, 0x80, 0x02, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x46, 0x00, 0x1B,
  0x00, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0xC3, 0x00,
  0x11, 0x80, 0x18, 0x60, 0x06, 0x30, 0x06, 0x0C, 0x00, 0x86, 0x00, 0xC1,
  0x80, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00,
  0xC0, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x80, 0x80, 0x60, 0x20, 0x10, 0x30, 0x0C, 0x0C, 0x02, 0x06, 0x01, 0x81,
  0x00, 0x41, 0x80, 0x10, 0x60, 0x08, 0x30, 0x02, 0x0C, 0x01, 0x04, 0x00,
  0x43, 0x00, 0x21, 0x80, 0x08, 0x60, 0x04, 0x20, 0x01, 0x18, 0x00, 0x8C,
  0x00, 0x23, 0x00, 0x11, 0x80, 0x04, 0xC0, 0x02, 0x60, 0x00, 0x98, 0x00,
  0x4C, 0x00, 0x12, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x01, 0x60, 0x00, 0x58,
  0x00, 0x2C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x18, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x08, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x17, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x03, 0xFF, 0xA0, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 50, 14, 1, -50 },
  { 89, 14, 18, 19, 7, -50 },
  { 121, 31, 50, 31, 1, -50 },
  { 315, 28, 57, 28, 1, -53 },
  { 515, 34, 52, 42, 4, -51 },
  { 736, 28, 52, 30, 0, -51 },
  { 918, 5, 18, 11, 7, -50 },
  { 930, 19, 61, 17, 2, -50 },
  { 1075, 19, 61, 17, -5, -50 },
  { 1220, 20, 22, 27, 9, -53 },
  { 1275, 26, 32, 32, 3, -41 },
  { 1379, 9, 16, 11, -3, -7 },
  { 1397, 15, 2, 19, 2, -20 },
  { 1401, 4, 4, 12, 1, -4 },
  { 1403, 29, 50, 21, -3, -50 },
  { 1585, 26, 52, 28, 2, -51 },
  { 1754, 13, 50, 28, 9, -50 },
  { 1836, 30, 51, 28, -2, -51 },
  { 2028, 29, 52, 28, -1, -51 },
  { 2217, 29, 51, 28, -1, -51 },
  { 2402, 29, 51, 28, -1, -50 },
  { 2587, 26, 52, 28, 3, -51 },
  { 2756, 26, 50, 28, 4, -50 },
  { 2919, 28, 52, 28, 0, -51 },
  { 3101, 27, 52, 28, 1, -51 },
  { 3277, 10, 37, 12, 1, -37 },
  { 3324, 14, 46, 12, -3, -37 },
  { 3405, 26, 30, 32, 3, -40 },
  { 3503, 26, 17, 32, 3, -33 },
  { 3559, 26, 30, 32, 3, -40 },
  { 3657, 21, 51, 20, 2, -51 },
  { 3791, 39, 56, 42, 2, -50 },
  { 4064, 27, 50, 27, -4, -50 },
  { 4233, 30, 50, 31, 1, -50 },
  { 4421, 30, 52, 29, 4, -51 },
  { 4616, 32, 50, 34, 1, -50 },
  { 4816, 29, 50, 28, 1, -50 },
  { 4998, 29, 50, 25, 1, -50 },
  { 5180, 34, 52, 37, 3, -51 },
  { 5401, 35, 50, 36, 1, -50 },
  { 5620, 21, 50, 14, -3, -50 },
  { 5752, 25, 62, 12, -11, -50 },
  { 5946, 33, 50, 28, 1, -50 },
  { 6153, 18, 50, 25, 1, -50 },
  { 6266, 45, 50, 46, 1, -50 },
  { 6548, 36, 50, 37, 1, -50 },
  { 6773, 32, 52, 37, 3, -51 },
  { 6981, 29, 50, 29, 1, -50 },
  { 7163, 32, 63, 37, 3, -51 },
  { 7415, 29, 50, 29, 1, -50 },
  { 7597, 30, 52, 27, -1, -51 },
  { 7792, 24, 50, 25, 6, -50 },
  { 7942, 33, 51, 35, 3, -50 },
  { 8153, 28, 50, 28, 6, -50 },
  { 8328, 45, 50, 47, 7, -50 },
  { 8610, 34, 50, 25, -4, -50 },
  { 8823, 24, 50, 24, 6, -50 },
  { 8973, 32, 50, 26, -2, -50 },
  { 9173, 25, 61, 20, -1, -50 },
  { 9364, 10, 50, 22, 7, -50 },
  { 9427, 25, 61, 20, -4, -50 },
  { 9618, 27, 26, 31, 2, -50 },
  { 9706, 20, 1, 21, -5, 7 },
  { 9709, 7, 11, 15, 10, -53 },
  { 9719, 26, 39, 30, 3, -38 },
  { 9846, 27, 54, 30, 1, -53 },
  { 10029, 21, 39, 23, 3, -38 },
  { 10132, 30, 54, 31, 3, -53 },
  { 10335, 22, 39, 26, 3, -38 },
  { 10443, 32, 71, 15, -9, -54 },
  { 10727, 29, 55, 30, 0, -38 },
  { 10927, 25, 53, 29, 1, -53 },
  { 11093, 13, 50, 12, 1, -50 },
  { 11175, 24, 67, 12, -10, -50 },
  { 11376, 25, 53, 24, 1, -53 },
  { 11542, 13, 53, 12, 1, -53 },
  { 11629, 41, 38, 44, 1, -38 },
  { 11824, 25, 38, 29, 1, -38 },
  { 11943, 24, 39, 29, 3, -38 },
  { 12060, 30, 54, 30, -2, -38 },
  { 12263, 26, 54, 31, 3, -38 },
  { 12439, 21, 38, 19, 1, -38 },
  { 12539, 23, 39, 22, -1, -38 },
  { 12652, 15, 47, 15, 2, -46 },
  { 12741, 26, 38, 29, 2, -37 },
  { 12865, 21, 37, 22, 4, -37 },
  { 12963, 35, 37, 36, 4, -37 },
  { 13125, 28, 37, 23, -3, -37 },
  { 13255, 34, 54, 23, -8, -37 },
  { 13485, 24, 37, 20, -2, -37 },
  { 13596, 24, 61, 22, 2, -50 },
  { 13779, 1, 70, 28, 14, -53 },
  { 13788, 24, 61, 22, -4, -50 },
  { 13971, 26, 6, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_THINITALIC70PT7B_H_
