#ifndef _NOTOSANS_CONDENSED_THINITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x10, 0x76, 0xD0, 0x14, 0x52, 0x5E, 0x28, 0xAF,
  0x94, 0x52, 0x80, 0x08, 0x67, 0x54, 0x50, 0x81, 0x0A, 0x28, 0xCE, 0x10,
  0x65, 0x4A, 0xA5, 0x4B, 0xFD, 0x4C, 0xA9, 0x55, 0x38, 0x38, 0xA2, 0x8C,
  0x21, 0x49, 0x66, 0x8B, 0xE0, 0xF0, 0x12, 0x24, 0x48, 0x88, 0x88, 0x84,
  0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x2C, 0x7A, 0x20, 0x21, 0x09, 0xF2,
  0x10, 0x58, 0xE0, 0x80, 0x04, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0x00,
  0x38, 0x94, 0x51, 0x46, 0x28, 0xA2, 0x91, 0xC0, 0x75, 0x5A, 0xA0, 0x38,
  0x10, 0x42, 0x08, 0x42, 0x10, 0x83, 0xC0, 0x38, 0x10, 0x42, 0x30, 0x20,
  0x82, 0x0B, 0xC0, 0x0C, 0x21, 0x8A, 0x29, 0x29, 0x3E, 0x10, 0x40, 0x3C,
  0x84, 0x10, 0x70, 0x20, 0x82, 0x0B, 0xC0, 0x1C, 0x84, 0x10, 0x7A, 0x28,
  0xA2, 0x89, 0xC0, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x84, 0x00, 0x39, 0x14,
  0x52, 0x31, 0x48, 0xA2, 0x8B, 0xC0, 0x39, 0x14, 0x51, 0x49, 0xE0, 0x82,
  0x13, 0x80, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x1B, 0x21, 0x82, 0x0C,
  0xF8, 0x01, 0xF0, 0x83, 0x06, 0x26, 0x40, 0x70, 0x42, 0x22, 0x21, 0x08,
  0x04, 0x00, 0x1E, 0x21, 0x41, 0x4D, 0x55, 0xA5, 0xA5, 0xAA, 0x94, 0x80,
  0x78, 0x08, 0x21, 0x45, 0x24, 0xF4, 0x51, 0x46, 0x10, 0x3C, 0x92, 0x51,
  0x79, 0x24, 0x61, 0x8B, 0xC0, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83,
  0xC0, 0x3C, 0x44, 0x8A, 0x14, 0x28, 0x51, 0x42, 0x89, 0xE0, 0x3C, 0x84,
  0x10, 0x79, 0x04, 0x20, 0x83, 0xC0, 0x3C, 0x84, 0x10, 0x41, 0xE4, 0x20,
  0x82, 0x00, 0x3D, 0x08, 0x20, 0x82, 0x78, 0x62, 0x8B, 0xE0, 0x22, 0x45,
  0x0A, 0x17, 0xA8, 0x91, 0x42, 0x85, 0x08, 0x18, 0x84, 0x42, 0x10, 0x84,
  0x47, 0x00, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x09, 0x80, 0x22, 0x49,
  0x22, 0x86, 0x0A, 0x14, 0x48, 0x89, 0x10, 0x22, 0x44, 0x44, 0x48, 0x8F,
  0x20, 0x90, 0x48, 0x6A, 0x35, 0x2A, 0x99, 0x55, 0x32, 0x99, 0x48, 0x80,
  0x22, 0x44, 0x8A, 0x95, 0x2A, 0x53, 0x46, 0x85, 0x08, 0x3D, 0x18, 0x61,
  0x86, 0x18, 0x62, 0x8B, 0xC0, 0x38, 0x92, 0x51, 0x45, 0xE4, 0x20, 0x82,
  0x00, 0x3D, 0x18, 0x61, 0x86, 0x18, 0x62, 0x8B, 0x42, 0x0C, 0x38, 0x92,
  0x51, 0x49, 0xC5, 0x24, 0x8A, 0x20, 0x3D, 0x04, 0x10, 0x20, 0x40, 0x82,
  0x0B, 0xC0, 0xF9, 0x08, 0x84, 0x21, 0x08, 0x84, 0x00, 0x45, 0x18, 0x61,
  0x86, 0x28, 0xA2, 0x8B, 0xC0, 0x86, 0x28, 0xA4, 0x92, 0x8A, 0x28, 0x42,
  0x00, 0x88, 0xC4, 0x66, 0x33, 0x2A, 0x95, 0x52, 0xA9, 0x98, 0x84, 0x44,
  0x00, 0x22, 0x28, 0x50, 0xC1, 0x02, 0x0A, 0x24, 0x49, 0x10, 0x8C, 0x65,
  0x44, 0x21, 0x08, 0x84, 0x00, 0x3C, 0x20, 0x84, 0x10, 0x84, 0x10, 0x83,
  0xC0, 0x39, 0x08, 0x84, 0x21, 0x10, 0x84, 0x21, 0x80, 0xA9, 0x55, 0x50,
  0x18, 0x42, 0x11, 0x08, 0x42, 0x11, 0x09, 0xC0, 0x10, 0xA2, 0x91, 0xC4,
  0xF0, 0xE0, 0x18, 0x94, 0x52, 0x8A, 0x28, 0x9C, 0x20, 0x82, 0x16, 0x25,
  0x14, 0x51, 0x8A, 0x2F, 0x00, 0x34, 0x88, 0x88, 0x8E, 0x02, 0x04, 0x10,
  0xE2, 0x48, 0x91, 0x44, 0x89, 0x11, 0xC0, 0x25, 0x9A, 0xC8, 0x8E, 0x06,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x18, 0x00,
  0x18, 0x94, 0x51, 0x8A, 0x28, 0x9C, 0x10, 0x4F, 0x00, 0x21, 0x08, 0xA2,
  0xA5, 0x29, 0x8C, 0x64, 0x20, 0x24, 0x94, 0x90, 0x08, 0x00, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x4C, 0x00, 0x21, 0x08, 0x84, 0xA9, 0x8C, 0x94, 0xA4,
  0x24, 0xA4, 0x92, 0x92, 0x00, 0x1A, 0x65, 0x49, 0x49, 0x49, 0x89, 0x91,
  0x91, 0x13, 0x52, 0x94, 0xC6, 0x32, 0x11, 0x52, 0x98, 0xC6, 0x2E, 0x18,
  0x94, 0x51, 0x46, 0x28, 0xBC, 0x82, 0x08, 0x00, 0x18, 0x94, 0x51, 0x8A,
  0x28, 0x9C, 0x10, 0x41, 0x00, 0x12, 0x44, 0x48, 0x88, 0x34, 0x44, 0x21,
  0x1E, 0x2D, 0x24, 0xA4, 0xC0, 0x45, 0x24, 0x92, 0x8A, 0x2F, 0x00, 0x9A,
  0xAC, 0xC8, 0x80, 0x93, 0x6A, 0xD6, 0xA9, 0x92, 0x24, 0x00, 0x24, 0xA1,
  0x04, 0x31, 0x48, 0x80, 0x12, 0x24, 0x50, 0xA1, 0x82, 0x04, 0x08, 0x21,
  0xC0, 0x71, 0x24, 0x48, 0xE0, 0x18, 0x88, 0x42, 0x13, 0x08, 0x42, 0x10,
  0xC0, 0xFF, 0xFC, 0x10, 0x42, 0x21, 0x08, 0x62, 0x21, 0x09, 0x80, 0x45,
  0xC0,
};

const GFXglyph NotoSans_Condensed_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 4, 1, -10 },
  { 7, 6, 10, 6, 0, -10 },
  { 15, 6, 12, 6, 0, -11 },
  { 24, 7, 10, 8, 1, -10 },
  { 33, 6, 10, 6, 0, -10 },
  { 41, 1, 4, 2, 1, -10 },
  { 42, 4, 12, 3, 0, -10 },
  { 48, 4, 12, 3, -1, -10 },
  { 54, 4, 5, 5, 2, -11 },
  { 57, 5, 6, 6, 1, -8 },
  { 61, 2, 3, 2, -1, -1 },
  { 62, 3, 1, 4, 0, -4 },
  { 63, 1, 1, 2, 0, -1 },
  { 64, 6, 10, 4, -1, -10 },
  { 72, 6, 10, 6, 0, -10 },
  { 80, 2, 10, 6, 2, -10 },
  { 83, 6, 10, 6, 0, -10 },
  { 91, 6, 10, 6, 0, -10 },
  { 99, 6, 10, 6, 0, -10 },
  { 107, 6, 10, 6, 0, -10 },
  { 115, 6, 10, 6, 0, -10 },
  { 123, 5, 10, 6, 1, -10 },
  { 130, 6, 10, 6, 0, -10 },
  { 138, 6, 10, 6, 0, -10 },
  { 146, 2, 7, 2, 0, -7 },
  { 148, 3, 9, 2, -1, -7 },
  { 152, 5, 6, 6, 1, -8 },
  { 156, 5, 4, 6, 1, -7 },
  { 159, 5, 6, 6, 1, -8 },
  { 163, 5, 10, 4, 0, -10 },
  { 170, 8, 11, 8, 0, -10 },
  { 181, 6, 10, 5, -1, -10 },
  { 189, 6, 10, 6, 0, -10 },
  { 197, 6, 10, 6, 1, -10 },
  { 205, 7, 10, 7, 0, -10 },
  { 214, 6, 10, 6, 0, -10 },
  { 222, 6, 10, 5, 0, -10 },
  { 230, 6, 10, 7, 1, -10 },
  { 238, 7, 10, 7, 0, -10 },
  { 247, 5, 10, 3, -1, -10 },
  { 254, 5, 12, 2, -2, -10 },
  { 262, 7, 10, 6, 0, -10 },
  { 271, 4, 10, 5, 0, -10 },
  { 276, 9, 10, 9, 0, -10 },
  { 288, 7, 10, 7, 0, -10 },
  { 297, 6, 10, 7, 1, -10 },
  { 305, 6, 10, 6, 0, -10 },
  { 313, 6, 12, 7, 1, -10 },
  { 322, 6, 10, 6, 0, -10 },
  { 330, 6, 10, 5, 0, -10 },
  { 338, 5, 10, 5, 1, -10 },
  { 345, 6, 10, 7, 1, -10 },
  { 353, 6, 10, 6, 1, -10 },
  { 361, 9, 10, 9, 1, -10 },
  { 373, 7, 10, 5, -1, -10 },
  { 382, 5, 10, 5, 1, -10 },
  { 389, 6, 10, 5, 0, -10 },
  { 397, 5, 12, 4, 0, -10 },
  { 405, 2, 10, 4, 1, -10 },
  { 408, 5, 12, 4, -1, -10 },
  { 416, 6, 5, 6, 0, -10 },
  { 420, 4, 1, 4, -1, 1 },
  { 421, 1, 3, 3, 2, -11 },
  { 422, 6, 8, 6, 0, -8 },
  { 428, 6, 11, 6, 0, -11 },
  { 437, 4, 8, 5, 1, -8 },
  { 441, 7, 11, 6, 0, -11 },
  { 451, 4, 8, 5, 1, -8 },
  { 455, 7, 14, 3, -2, -11 },
  { 468, 6, 11, 6, 0, -8 },
  { 477, 5, 11, 6, 0, -11 },
  { 484, 3, 10, 2, 0, -10 },
  { 488, 5, 13, 2, -2, -10 },
  { 497, 5, 11, 5, 0, -11 },
  { 504, 3, 11, 2, 0, -11 },
  { 509, 8, 8, 9, 0, -8 },
  { 517, 5, 8, 6, 0, -8 },
  { 522, 5, 8, 6, 0, -8 },
  { 527, 6, 11, 6, 0, -8 },
  { 536, 6, 11, 6, 0, -8 },
  { 545, 4, 8, 4, 0, -8 },
  { 549, 4, 8, 4, 0, -8 },
  { 553, 3, 9, 3, 0, -9 },
  { 557, 6, 7, 6, 0, -7 },
  { 563, 4, 7, 4, 1, -7 },
  { 567, 7, 7, 7, 1, -7 },
  { 574, 6, 7, 5, -1, -7 },
  { 580, 7, 10, 5, -2, -7 },
  { 589, 4, 7, 4, 0, -7 },
  { 593, 5, 12, 4, 0, -10 },
  { 601, 1, 14, 6, 2, -11 },
  { 603, 5, 12, 4, -1, -10 },
  { 611, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_THINITALIC14PT7B_H_
