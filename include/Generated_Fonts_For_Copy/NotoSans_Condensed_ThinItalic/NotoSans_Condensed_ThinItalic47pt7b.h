#ifndef _NOTOSANS_CONDENSED_THINITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x20, 0x90, 0x48, 0x6C, 0x24, 0x12, 0x09, 0x04,
  0x84, 0xC2, 0x41, 0x20, 0x90, 0x48, 0x40, 0x00, 0x10, 0x20, 0x03, 0x02,
  0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0x40,
  0x80, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x18, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x01, 0x03, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x60, 0x02,
  0x04, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00,
  0xC0, 0x80, 0xFF, 0xFF, 0x80, 0x81, 0x00, 0x18, 0x10, 0x01, 0x03, 0x00,
  0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x06, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x01, 0xDF, 0xC0, 0x62,
  0x08, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x40, 0x02, 0x08,
  0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x11, 0x00, 0x03, 0x20,
  0x00, 0x34, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x05, 0x80, 0x00, 0x98,
  0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x82, 0x00, 0x10, 0x60, 0x02, 0x0C,
  0x00, 0x41, 0x80, 0x08, 0x20, 0x02, 0x04, 0x00, 0x41, 0x00, 0x08, 0x60,
  0xE1, 0x30, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x07, 0x80, 0x08, 0x19, 0x80, 0x10, 0x61,
  0x00, 0x40, 0x83, 0x01, 0x82, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x18, 0x18,
  0x10, 0x20, 0x30, 0x40, 0x40, 0x60, 0x81, 0x80, 0x82, 0x03, 0x01, 0x0C,
  0x04, 0x02, 0x10, 0x08, 0x0C, 0x60, 0x10, 0x10, 0x80, 0x20, 0x23, 0x1F,
  0x40, 0xC4, 0x42, 0x81, 0x11, 0x07, 0x06, 0x66, 0x0E, 0x08, 0x88, 0x0E,
  0x23, 0x30, 0x37, 0x84, 0x40, 0x60, 0x18, 0x80, 0xC0, 0x21, 0x01, 0x00,
  0x86, 0x02, 0x01, 0x08, 0x04, 0x04, 0x10, 0x08, 0x18, 0x20, 0x30, 0x20,
  0x40, 0x40, 0xC0, 0x80, 0x81, 0x01, 0x03, 0x04, 0x02, 0x04, 0x08, 0x04,
  0x18, 0x20, 0x0C, 0x60, 0xC0, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3E,
  0x00, 0x0C, 0x60, 0x03, 0x04, 0x00, 0x40, 0xC0, 0x18, 0x18, 0x02, 0x03,
  0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x01, 0x00, 0x20, 0x60, 0x04, 0x08,
  0x00, 0x83, 0x00, 0x10, 0xC0, 0x03, 0x30, 0x00, 0x2C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x80, 0x06, 0x10, 0x01, 0x83, 0x06,
  0x60, 0x20, 0x88, 0x04, 0x13, 0x00, 0xC6, 0x40, 0x08, 0x88, 0x01, 0x33,
  0x00, 0x14, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x02, 0x82,
  0x00, 0x88, 0x60, 0x61, 0x03, 0xF8, 0x30, 0x24, 0xB4, 0x92, 0xD2, 0x48,
  0x00, 0x18, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x81, 0x01, 0x88, 0x01, 0xA0, 0x81, 0xFD,
  0x06, 0x00, 0x24, 0x01, 0x10, 0x08, 0x20, 0x40, 0x82, 0x01, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x0F,
  0xFF, 0xFC, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x30, 0x82, 0x10, 0x43, 0x08, 0x61, 0x08, 0x00, 0xFF, 0xE0,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xE3, 0x00, 0xC0, 0xC0, 0x40, 0x20, 0x40, 0x10, 0x60, 0x08, 0x20,
  0x06, 0x30, 0x03, 0x10, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x22,
  0x00, 0x13, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x0C, 0x40, 0x04, 0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x04,
  0x01, 0x02, 0x01, 0x80, 0x80, 0x80, 0x61, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x81, 0xC1, 0xE1, 0x23, 0x13, 0x0B, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x38, 0x06, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x38, 0x30, 0x1C, 0x03, 0x01, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x80, 0x70, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x2C, 0x00,
  0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x06, 0x30, 0x00,
  0x84, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x40, 0xC0, 0x18,
  0x10, 0x06, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0x40, 0x40, 0x08, 0x18, 0x01, 0x02, 0x00, 0x60, 0x80, 0x08, 0x1F, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0xF8, 0x00, 0x71, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x80, 0x70, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1C, 0x20, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x7F, 0x01, 0x30, 0x20, 0x50, 0x04, 0x18, 0x01, 0x8E, 0x00, 0x63,
  0x00, 0x08, 0xC0, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0x80,
  0x06, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0x80, 0x08, 0x20, 0x06,
  0x0C, 0x01, 0x01, 0x00, 0x80, 0x60, 0x60, 0x0F, 0xE0, 0x00, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1C, 0x30, 0x06, 0x03, 0x01, 0x80, 0x30, 0x20, 0x02, 0x0C,
  0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x18,
  0x01, 0x01, 0x00, 0x60, 0x30, 0x18, 0x02, 0x06, 0x00, 0x61, 0x80, 0x06,
  0xC0, 0x00, 0xE0, 0x00, 0x32, 0x00, 0x18, 0x20, 0x06, 0x02, 0x01, 0x00,
  0x60, 0x40, 0x04, 0x18, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00,
  0x23, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x30, 0x80, 0x04, 0x10, 0x01,
  0x83, 0x00, 0x60, 0x30, 0x18, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xC3,
  0x00, 0xC0, 0x40, 0xC0, 0x30, 0x40, 0x08, 0x40, 0x04, 0x20, 0x02, 0x30,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x06, 0x60, 0x03, 0x30, 0x03, 0x88, 0x03, 0x86, 0x03,
  0x41, 0xC7, 0x20, 0x3E, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x04, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x80, 0x00, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xC0, 0xC3, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x01,
  0x80, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x08, 0x10, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x00, 0x7E, 0x0C, 0x40, 0x31,
  0x83, 0x30, 0x30, 0x60, 0xC8, 0x08, 0x10, 0x26, 0x04, 0x04, 0x09, 0x03,
  0x01, 0x02, 0x40, 0x80, 0xC0, 0x90, 0x20, 0x20, 0x2C, 0x10, 0x08, 0x1A,
  0x04, 0x06, 0x04, 0x81, 0x01, 0x81, 0x20, 0xC0, 0x40, 0x48, 0x30, 0x30,
  0x22, 0x0C, 0x0C, 0x08, 0x83, 0x03, 0x06, 0x20, 0xC1, 0x41, 0x08, 0x10,
  0xD0, 0x82, 0x07, 0x67, 0xC0, 0x80, 0xE0, 0x60, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x01, 0x08, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x04, 0x0C,
  0x01, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x03,
  0xFF, 0xC0, 0x80, 0x10, 0x60, 0x04, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00,
  0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x05,
  0x80, 0x01, 0x40, 0x00, 0x70, 0x00, 0x10, 0x01, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x02, 0x00, 0x20, 0x20, 0x03, 0x02, 0x00,
  0x30, 0x60, 0x03, 0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x06, 0x0C, 0x00, 0x40, 0x80, 0x08, 0x08, 0x03, 0x00, 0x80, 0xE0, 0x0F,
  0xF8, 0x01, 0x80, 0xE0, 0x10, 0x03, 0x01, 0x00, 0x10, 0x10, 0x01, 0x83,
  0x00, 0x08, 0x30, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x18,
  0x60, 0x01, 0x84, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x06,
  0x0C, 0x00, 0xC0, 0x80, 0x70, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xC1, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x04, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x20, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x03, 0x04,
  0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x00,
  0x84, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x10, 0xC0,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x02, 0x18, 0x00, 0x10,
  0x80, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x18, 0x00,
  0x60, 0x80, 0x02, 0x04, 0x00, 0x30, 0x20, 0x03, 0x01, 0x00, 0x30, 0x18,
  0x07, 0x00, 0x80, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFE,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x38, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x0F, 0xE1, 0x00, 0x1F, 0xC2, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x60, 0x00, 0x10, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00,
  0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x08, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x02, 0x02, 0x00, 0x04, 0x0C, 0x00,
  0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x01,
  0x03, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0x20,
  0x20, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x06, 0x04,
  0x00, 0x08, 0x1F, 0xFF, 0xF0, 0x30, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x80,
  0x01, 0x01, 0x00, 0x02, 0x06, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x30, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x06,
  0x04, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40,
  0x80, 0x01, 0x81, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x86, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x80, 0x18, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x20,
  0x10, 0x01, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x10, 0x30, 0x00, 0x41, 0x80,
  0x01, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x02,
  0x60, 0x00, 0x1B, 0xC0, 0x00, 0x79, 0x00, 0x01, 0x44, 0x00, 0x06, 0x18,
  0x00, 0x10, 0x60, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x08, 0x0C, 0x00,
  0x20, 0x10, 0x00, 0x80, 0x40, 0x06, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x80, 0x06,
  0x02, 0x00, 0x18, 0x00, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC0, 0xA0, 0x00, 0x06, 0x02, 0x80,
  0x00, 0x28, 0x0A, 0x00, 0x01, 0xA0, 0x28, 0x00, 0x04, 0x81, 0xA0, 0x00,
  0x36, 0x04, 0x80, 0x00, 0x90, 0x13, 0x00, 0x06, 0x40, 0x4C, 0x00, 0x11,
  0x01, 0x30, 0x00, 0xCC, 0x0C, 0x40, 0x02, 0x30, 0x21, 0x00, 0x18, 0x80,
  0x84, 0x00, 0x42, 0x02, 0x10, 0x03, 0x08, 0x18, 0x40, 0x08, 0x60, 0x61,
  0x00, 0x61, 0x01, 0x04, 0x01, 0x04, 0x04, 0x10, 0x0C, 0x10, 0x10, 0x40,
  0x20, 0x40, 0xC1, 0x81, 0x83, 0x02, 0x06, 0x04, 0x08, 0x08, 0x08, 0x30,
  0x20, 0x20, 0x20, 0x80, 0x80, 0x80, 0x86, 0x02, 0x06, 0x02, 0x10, 0x18,
  0x10, 0x08, 0x80, 0x40, 0x40, 0x22, 0x01, 0x01, 0x00, 0x90, 0x04, 0x0C,
  0x02, 0x40, 0x30, 0x30, 0x0A, 0x00, 0x80, 0x80, 0x38, 0x02, 0x02, 0x00,
  0xC0, 0x08, 0x00, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x03, 0x80, 0x03,
  0x02, 0x80, 0x02, 0x02, 0x80, 0x02, 0x02, 0xC0, 0x02, 0x02, 0x40, 0x06,
  0x06, 0x40, 0x06, 0x04, 0x40, 0x04, 0x04, 0x60, 0x04, 0x04, 0x20, 0x04,
  0x04, 0x20, 0x0C, 0x0C, 0x20, 0x08, 0x08, 0x30, 0x08, 0x08, 0x10, 0x08,
  0x08, 0x10, 0x08, 0x18, 0x10, 0x18, 0x18, 0x18, 0x10, 0x10, 0x08, 0x10,
  0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x30, 0x0C, 0x30, 0x20, 0x04, 0x20,
  0x20, 0x04, 0x20, 0x20, 0x04, 0x20, 0x20, 0x06, 0x60, 0x60, 0x02, 0x60,
  0x40, 0x02, 0x40, 0x40, 0x02, 0x40, 0x40, 0x03, 0x40, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x00, 0x1F, 0x80,
  0x01, 0xC3, 0x80, 0x0C, 0x03, 0x00, 0x40, 0x04, 0x02, 0x00, 0x18, 0x18,
  0x00, 0x20, 0x40, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x60, 0x00,
  0x31, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x26,
  0x00, 0x00, 0x98, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x64, 0x00,
  0x01, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10,
  0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x04, 0x06, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0x18, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x20, 0x04, 0x04, 0x00, 0xC0, 0x80, 0x08,
  0x30, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x20,
  0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0x40, 0x0C, 0x18, 0x03, 0x03,
  0x01, 0xC0, 0x7F, 0xE0, 0x0F, 0xC0, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC3, 0x80, 0x0C, 0x03,
  0x00, 0x40, 0x04, 0x02, 0x00, 0x18, 0x18, 0x00, 0x20, 0x40, 0x00, 0x82,
  0x00, 0x02, 0x08, 0x00, 0x08, 0x60, 0x00, 0x31, 0x00, 0x00, 0x8C, 0x00,
  0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x26, 0x00, 0x00, 0x98, 0x00, 0x02,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x04, 0xC0,
  0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40, 0x01, 0x81,
  0x00, 0x04, 0x06, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x18, 0x18, 0x00, 0x3F,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x20, 0x04,
  0x04, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C,
  0x10, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x60,
  0x40, 0x08, 0x18, 0x06, 0x03, 0x03, 0x80, 0x7F, 0xC0, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x60, 0x60, 0x08, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x80, 0x60, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10,
  0x03, 0x06, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x80, 0x00, 0x1F, 0xC0,
  0x07, 0x07, 0x01, 0x80, 0x10, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x02, 0x00, 0x04, 0x18, 0x00, 0x10,
  0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0xC0,
  0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x18, 0x20, 0x00, 0x41, 0x80, 0x01,
  0x06, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00, 0x02, 0x0C,
  0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x04, 0x08, 0x00,
  0x10, 0x60, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20,
  0x40, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x40, 0xC0,
  0x03, 0x03, 0x00, 0x08, 0x04, 0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0B, 0x00, 0x03, 0x60,
  0x00, 0x4C, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x40,
  0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x0C, 0x01, 0x01,
  0x00, 0x20, 0x60, 0x04, 0x08, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x08,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0xC0,
  0x00, 0x90, 0x00, 0x16, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x28, 0x00, 0x60, 0x01,
  0xA0, 0x01, 0x80, 0x04, 0x80, 0x0E, 0x00, 0x12, 0x00, 0x28, 0x00, 0x88,
  0x01, 0xA0, 0x02, 0x20, 0x04, 0x80, 0x18, 0x80, 0x12, 0x00, 0x42, 0x00,
  0x88, 0x03, 0x08, 0x02, 0x20, 0x08, 0x20, 0x18, 0x80, 0x20, 0x80, 0x42,
  0x01, 0x82, 0x01, 0x08, 0x04, 0x08, 0x08, 0x20, 0x30, 0x20, 0x20, 0x80,
  0x80, 0x81, 0x82, 0x02, 0x02, 0x04, 0x08, 0x10, 0x08, 0x30, 0x20, 0x40,
  0x20, 0x80, 0x83, 0x00, 0x82, 0x02, 0x08, 0x02, 0x10, 0x08, 0x60, 0x08,
  0x40, 0x21, 0x00, 0x23, 0x00, 0x84, 0x00, 0x88, 0x02, 0x30, 0x02, 0x20,
  0x08, 0x80, 0x09, 0x00, 0x26, 0x00, 0x24, 0x00, 0x90, 0x00, 0xB0, 0x02,
  0x40, 0x02, 0x80, 0x0A, 0x00, 0x0E, 0x00, 0x28, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x80, 0x0C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x06, 0x01, 0x80,
  0x0C, 0x02, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30, 0x00, 0x20, 0x40, 0x00,
  0x61, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x02,
  0x40, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x60, 0x00, 0x04, 0x40, 0x00, 0x18, 0x80,
  0x00, 0x21, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00, 0x04, 0x04, 0x00,
  0x10, 0x08, 0x00, 0x60, 0x10, 0x00, 0x80, 0x20, 0x03, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x10, 0x00, 0x80, 0x60, 0x01, 0x01, 0x80, 0x02, 0x00, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x04, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x10, 0x60, 0x30, 0x60, 0x20, 0x20, 0x60, 0x20, 0x40, 0x20,
  0x80, 0x21, 0x80, 0x21, 0x00, 0x33, 0x00, 0x12, 0x00, 0x16, 0x00, 0x14,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x01, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x82, 0x08, 0x20,
  0xC1, 0x04, 0x10, 0x41, 0x06, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04,
  0x10, 0x41, 0x06, 0x08, 0x20, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x24,
  0x00, 0x0C, 0x80, 0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x30, 0x02, 0x02,
  0x00, 0xC0, 0x40, 0x10, 0x0C, 0x06, 0x00, 0x80, 0x80, 0x18, 0x30, 0x01,
  0x0C, 0x00, 0x21, 0x00, 0x06, 0x60, 0x00, 0x58, 0x00, 0x0C, 0xFF, 0xFC,
  0x8C, 0x46, 0x21, 0x11, 0x01, 0xF8, 0x81, 0x86, 0x41, 0x01, 0xA1, 0x00,
  0x51, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x20,
  0x01, 0x10, 0x00, 0x98, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x32, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x02, 0x10, 0x03, 0x08, 0x01,
  0x84, 0x01, 0x43, 0x01, 0x20, 0xC1, 0x20, 0x3F, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x11,
  0xF8, 0x04, 0xC3, 0x03, 0x40, 0x60, 0xA0, 0x08, 0x38, 0x02, 0x0C, 0x00,
  0x83, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x23,
  0x00, 0x08, 0xC0, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x11, 0x80,
  0x04, 0x60, 0x03, 0x18, 0x00, 0x86, 0x00, 0x61, 0x80, 0x10, 0xA0, 0x0C,
  0x2C, 0x06, 0x09, 0x83, 0x02, 0x3F, 0x80, 0x01, 0xFC, 0x0C, 0x10, 0x40,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x10, 0x3F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x1F, 0x8C, 0x03, 0x0C, 0x80,
  0x40, 0x28, 0x08, 0x02, 0x81, 0x80, 0x38, 0x10, 0x01, 0x83, 0x00, 0x10,
  0x20, 0x01, 0x06, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x20, 0xC0, 0x02,
  0x0C, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00,
  0xC0, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x80, 0x1C, 0x08, 0x03, 0x80, 0x80,
  0x28, 0x0C, 0x06, 0x80, 0x60, 0xC8, 0x03, 0xF1, 0x00, 0x01, 0xF8, 0x06,
  0x18, 0x10, 0x10, 0x40, 0x31, 0x80, 0x62, 0x00, 0xC8, 0x01, 0x10, 0x02,
  0x60, 0x08, 0x80, 0x31, 0x01, 0x86, 0x0E, 0x0F, 0xE0, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x10, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0x10, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x10, 0x0C, 0x32, 0x01,
  0x00, 0xA0, 0x20, 0x0A, 0x06, 0x00, 0xA0, 0x40, 0x06, 0x0C, 0x00, 0x40,
  0x80, 0x04, 0x18, 0x00, 0xC1, 0x00, 0x0C, 0x10, 0x00, 0x83, 0x00, 0x08,
  0x30, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x10, 0x20, 0x03,
  0x02, 0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x70, 0x20, 0x0E, 0x02, 0x00,
  0xA0, 0x30, 0x1A, 0x01, 0x83, 0x20, 0x0F, 0xC4, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xC0, 0xC0, 0x07, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x8F, 0xC0, 0x4C, 0x30, 0x68, 0x08, 0x28, 0x06, 0x18, 0x03, 0x0C, 0x01,
  0x84, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x0C, 0x60, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x8C, 0x00, 0x86,
  0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0xC0, 0x08, 0x40, 0x04,
  0x20, 0x02, 0x10, 0x03, 0x00, 0x01, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x30, 0x40, 0x30, 0x60, 0x30, 0x20, 0x30,
  0x10, 0x10, 0x08, 0x10, 0x04, 0x10, 0x06, 0x10, 0x02, 0x18, 0x01, 0x18,
  0x00, 0x98, 0x00, 0xCE, 0x00, 0x4B, 0x00, 0x28, 0x80, 0x18, 0x40, 0x08,
  0x30, 0x0C, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0xC0, 0x20, 0x40, 0x10, 0x20, 0x0C, 0x10, 0x02, 0x00, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x04, 0x7C, 0x1F,
  0x80, 0xB0, 0xC6, 0x18, 0x2C, 0x0D, 0x01, 0x85, 0x00, 0xE0, 0x10, 0xC0,
  0x18, 0x02, 0x18, 0x02, 0x00, 0x42, 0x00, 0x40, 0x08, 0xC0, 0x18, 0x03,
  0x18, 0x02, 0x00, 0x42, 0x00, 0x40, 0x08, 0x40, 0x08, 0x01, 0x18, 0x01,
  0x00, 0x63, 0x00, 0x60, 0x0C, 0x40, 0x08, 0x01, 0x08, 0x01, 0x00, 0x21,
  0x00, 0x20, 0x04, 0x60, 0x0C, 0x01, 0x88, 0x01, 0x00, 0x21, 0x00, 0x20,
  0x04, 0x20, 0x04, 0x00, 0x84, 0x00, 0x80, 0x11, 0x80, 0x30, 0x06, 0x20,
  0x04, 0x00, 0x84, 0x00, 0x80, 0x10, 0x80, 0x10, 0x02, 0x00, 0x04, 0x7E,
  0x02, 0x61, 0x82, 0x40, 0x41, 0x40, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x20,
  0x04, 0x30, 0x02, 0x18, 0x01, 0x08, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x43,
  0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x60, 0x04, 0x20, 0x02,
  0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x42, 0x00, 0x21, 0x00,
  0x10, 0x80, 0x18, 0x00, 0x01, 0xF8, 0x03, 0x0C, 0x04, 0x02, 0x08, 0x02,
  0x18, 0x03, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x10,
  0x40, 0x20, 0x60, 0x40, 0x3F, 0x80, 0x00, 0x8F, 0xC0, 0x04, 0xC3, 0x00,
  0x6C, 0x0C, 0x02, 0xC0, 0x20, 0x1C, 0x01, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x04, 0x04,
  0x00, 0x20, 0x60, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x04,
  0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0xC0,
  0x08, 0x0E, 0x00, 0xC0, 0x58, 0x0C, 0x02, 0x40, 0xC0, 0x11, 0xFC, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x40, 0xC3, 0x20, 0x40, 0x28,
  0x20, 0x0A, 0x18, 0x02, 0x84, 0x00, 0x63, 0x00, 0x10, 0x80, 0x04, 0x60,
  0x01, 0x10, 0x00, 0xC4, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0xC2,
  0x00, 0x70, 0x80, 0x18, 0x20, 0x0A, 0x0C, 0x06, 0x81, 0x83, 0x60, 0x3F,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x04, 0x7C, 0x13, 0x00, 0x90, 0x02, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x03, 0xFC,
  0x0C, 0x0C, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x40, 0x60, 0xFF, 0x80, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x03, 0xFC, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x07, 0xC0,
  0x08, 0x01, 0x8C, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x18, 0xC0, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x8C,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x31, 0x80, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x20, 0x06, 0x10, 0x03, 0x08, 0x03, 0x04, 0x03, 0x82, 0x01,
  0x41, 0x83, 0x20, 0x7F, 0x30, 0x00, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0,
  0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x18, 0x80, 0x42, 0x03, 0x08,
  0x08, 0x20, 0x60, 0x81, 0x02, 0x0C, 0x08, 0x20, 0x31, 0x80, 0xC4, 0x03,
  0x30, 0x04, 0x80, 0x16, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x0E, 0x00, 0xC0, 0x14, 0x01,
  0x80, 0x28, 0x05, 0x00, 0x90, 0x0A, 0x01, 0x20, 0x34, 0x06, 0x40, 0x48,
  0x08, 0x80, 0x90, 0x11, 0x02, 0x20, 0x42, 0x04, 0x60, 0x84, 0x10, 0xC3,
  0x08, 0x21, 0x84, 0x10, 0xC3, 0x18, 0x21, 0x06, 0x20, 0x46, 0x0C, 0x40,
  0x88, 0x19, 0x01, 0x10, 0x12, 0x02, 0x40, 0x2C, 0x04, 0x80, 0x50, 0x0A,
  0x00, 0xA0, 0x14, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x08, 0x00, 0x02, 0x00, 0x60, 0x40, 0x08, 0x0C, 0x02, 0x00, 0x80, 0xC0,
  0x10, 0x10, 0x03, 0x04, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0x88, 0x00,
  0x1B, 0x00, 0x01, 0x40, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x68, 0x00, 0x09, 0x00, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x04,
  0x0C, 0x01, 0x80, 0x80, 0x20, 0x10, 0x08, 0x02, 0x03, 0x00, 0x60, 0xC0,
  0x04, 0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x04, 0x01, 0x80, 0x08, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x20,
  0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x02, 0x04,
  0x00, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x21, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x90, 0x00, 0x01, 0x60, 0x00,
  0x02, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x04, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x1F, 0xE0,
  0x1C, 0x0C, 0x0A, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 9, 13, 13, 5, -34 },
  { 55, 20, 34, 21, 1, -34 },
  { 140, 19, 39, 19, 0, -36 },
  { 233, 23, 35, 28, 3, -34 },
  { 334, 19, 34, 20, 0, -34 },
  { 415, 3, 13, 7, 5, -34 },
  { 420, 13, 40, 11, 1, -33 },
  { 485, 13, 40, 11, -3, -33 },
  { 550, 14, 15, 18, 6, -36 },
  { 577, 18, 21, 21, 2, -27 },
  { 625, 6, 11, 8, -2, -5 },
  { 634, 11, 1, 13, 1, -13 },
  { 636, 2, 3, 8, 1, -3 },
  { 637, 19, 34, 14, -2, -34 },
  { 718, 17, 34, 19, 2, -34 },
  { 791, 9, 34, 19, 6, -34 },
  { 830, 19, 34, 19, -1, -34 },
  { 911, 19, 35, 19, 0, -34 },
  { 995, 19, 34, 19, 0, -34 },
  { 1076, 19, 34, 19, 0, -34 },
  { 1157, 18, 34, 19, 2, -34 },
  { 1234, 17, 34, 19, 3, -34 },
  { 1307, 19, 34, 19, 0, -34 },
  { 1388, 17, 34, 19, 1, -34 },
  { 1461, 6, 25, 8, 1, -25 },
  { 1480, 10, 31, 8, -2, -25 },
  { 1519, 18, 20, 21, 2, -27 },
  { 1564, 18, 11, 21, 2, -22 },
  { 1589, 18, 20, 21, 2, -27 },
  { 1634, 13, 34, 14, 2, -34 },
  { 1690, 26, 38, 28, 2, -34 },
  { 1814, 18, 34, 18, -3, -34 },
  { 1891, 20, 34, 21, 1, -34 },
  { 1976, 21, 34, 19, 2, -34 },
  { 2066, 21, 34, 23, 1, -34 },
  { 2156, 19, 34, 19, 1, -34 },
  { 2237, 19, 34, 17, 1, -34 },
  { 2318, 23, 34, 25, 2, -34 },
  { 2416, 23, 34, 24, 1, -34 },
  { 2514, 14, 34, 9, -2, -34 },
  { 2574, 16, 42, 8, -7, -34 },
  { 2658, 22, 34, 19, 1, -34 },
  { 2752, 12, 34, 17, 1, -34 },
  { 2803, 30, 34, 31, 1, -34 },
  { 2931, 24, 34, 25, 1, -34 },
  { 3033, 22, 34, 25, 2, -34 },
  { 3127, 19, 34, 19, 1, -34 },
  { 3208, 22, 42, 25, 2, -34 },
  { 3324, 19, 34, 20, 1, -34 },
  { 3405, 20, 34, 18, -1, -34 },
  { 3490, 16, 34, 17, 4, -34 },
  { 3558, 22, 34, 24, 2, -34 },
  { 3652, 19, 34, 19, 4, -34 },
  { 3733, 30, 34, 31, 5, -34 },
  { 3861, 23, 34, 17, -3, -34 },
  { 3959, 16, 34, 16, 4, -34 },
  { 4027, 22, 34, 18, -2, -34 },
  { 4121, 17, 41, 13, -1, -34 },
  { 4209, 6, 34, 15, 5, -34 },
  { 4235, 17, 41, 13, -3, -34 },
  { 4323, 19, 18, 21, 1, -34 },
  { 4366, 14, 1, 14, -4, 5 },
  { 4368, 4, 8, 10, 7, -36 },
  { 4372, 17, 25, 20, 2, -25 },
  { 4426, 18, 36, 20, 1, -36 },
  { 4507, 14, 25, 15, 2, -25 },
  { 4551, 20, 36, 20, 2, -36 },
  { 4641, 15, 25, 18, 2, -25 },
  { 4688, 22, 47, 10, -6, -36 },
  { 4818, 20, 36, 20, 0, -25 },
  { 4908, 17, 36, 20, 1, -36 },
  { 4985, 8, 34, 8, 1, -34 },
  { 5019, 15, 45, 8, -6, -34 },
  { 5104, 17, 36, 16, 1, -36 },
  { 5181, 8, 36, 8, 1, -36 },
  { 5217, 27, 25, 30, 1, -25 },
  { 5302, 17, 25, 20, 1, -25 },
  { 5356, 16, 25, 20, 2, -25 },
  { 5406, 21, 36, 20, -2, -25 },
  { 5501, 18, 36, 20, 2, -25 },
  { 5582, 14, 25, 13, 1, -25 },
  { 5626, 15, 25, 15, 0, -25 },
  { 5673, 10, 31, 10, 1, -31 },
  { 5712, 17, 25, 20, 2, -25 },
  { 5766, 14, 25, 15, 3, -25 },
  { 5810, 23, 25, 24, 3, -25 },
  { 5882, 19, 25, 16, -2, -25 },
  { 5942, 23, 36, 15, -5, -25 },
  { 6046, 16, 25, 14, -1, -25 },
  { 6096, 17, 41, 15, 1, -34 },
  { 6184, 1, 47, 19, 9, -36 },
  { 6190, 16, 41, 15, -3, -34 },
  { 6272, 18, 4, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_THINITALIC47PT7B_H_
