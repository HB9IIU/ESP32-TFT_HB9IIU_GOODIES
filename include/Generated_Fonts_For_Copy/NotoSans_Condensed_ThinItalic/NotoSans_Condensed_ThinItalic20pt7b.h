#ifndef _NOTOSANS_CONDENSED_THINITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x44, 0x40, 0x08, 0x59, 0x9A, 0xA0, 0x04,
  0x84, 0x82, 0x41, 0x23, 0xF8, 0x90, 0x48, 0x44, 0x24, 0x7F, 0x91, 0x09,
  0x04, 0x82, 0x40, 0x04, 0x0E, 0x15, 0x24, 0x28, 0x28, 0x28, 0x18, 0x08,
  0x14, 0x12, 0x12, 0x14, 0xD8, 0x20, 0x20, 0x38, 0x92, 0x24, 0x92, 0x28,
  0x8A, 0x25, 0x69, 0x66, 0xA9, 0x4A, 0x45, 0x11, 0x44, 0x92, 0x44, 0x91,
  0xC0, 0x1E, 0x12, 0x12, 0x12, 0x14, 0x18, 0x10, 0x28, 0x49, 0x85, 0x86,
  0x82, 0x86, 0x7A, 0x6A, 0x80, 0x08, 0x88, 0x84, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x80, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21,
  0x10, 0x88, 0x80, 0x12, 0x47, 0xCC, 0x50, 0x20, 0x10, 0x20, 0x40, 0x8F,
  0xE2, 0x04, 0x08, 0x10, 0x20, 0x29, 0x48, 0xF0, 0x80, 0x01, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1E,
  0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x14, 0x48, 0x9E, 0x00,
  0x3E, 0x92, 0x92, 0x4A, 0x49, 0x00, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFC, 0x3F, 0x01, 0x01, 0x01,
  0x01, 0x02, 0x1C, 0x04, 0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x03, 0x03,
  0x05, 0x0A, 0x0A, 0x12, 0x22, 0x44, 0x44, 0x84, 0x7E, 0x04, 0x08, 0x08,
  0x1F, 0x10, 0x20, 0x20, 0x20, 0x78, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0xF8, 0x06, 0x30, 0x82, 0x04, 0x08, 0x2E, 0x62, 0x85, 0x0A, 0x14,
  0x28, 0x51, 0x3C, 0x00, 0x7F, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1F, 0x21, 0x21, 0x21, 0x21, 0x16,
  0x18, 0x24, 0x42, 0x82, 0x82, 0x82, 0x84, 0x78, 0x1E, 0x21, 0x21, 0x41,
  0x41, 0x41, 0x42, 0x25, 0x1A, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x24, 0x00,
  0x00, 0x02, 0x00, 0x11, 0x00, 0x00, 0x00, 0x02, 0x44, 0x88, 0x06, 0x31,
  0x84, 0x04, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x30,
  0x10, 0x43, 0x18, 0x40, 0x78, 0x42, 0x10, 0x88, 0x88, 0x44, 0x20, 0x00,
  0x40, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x73, 0x12, 0x64, 0x4C, 0x91,
  0xA2, 0x54, 0x4A, 0x9A, 0x4C, 0x88, 0x01, 0x00, 0x10, 0x01, 0xE0, 0x02,
  0x06, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x11, 0x2F, 0x21, 0x41, 0x41, 0x81,
  0x81, 0x1F, 0x08, 0x44, 0x24, 0x12, 0x09, 0x08, 0xF8, 0x84, 0x41, 0x20,
  0x90, 0x48, 0x48, 0x27, 0xE0, 0x07, 0x0C, 0x48, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0xF0, 0x1F, 0x08,
  0x44, 0x24, 0x12, 0x09, 0x04, 0x82, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x48,
  0x47, 0xC0, 0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x00, 0xF8, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x07, 0xE0, 0x1F, 0x88, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xBC, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x00, 0x07, 0x06,
  0x32, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x87, 0xA0, 0x48, 0x12,
  0x04, 0x81, 0x10, 0x83, 0xE0, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48,
  0x23, 0xF9, 0x02, 0x40, 0x90, 0x24, 0x11, 0x04, 0x81, 0x20, 0x40, 0x1C,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x23, 0x80, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0xE0, 0x10, 0xC4, 0x41, 0x20, 0x88, 0x24, 0x0A, 0x03, 0x00, 0xA0, 0x48,
  0x11, 0x04, 0x41, 0x10, 0x82, 0x20, 0x80, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x83, 0xF0, 0x10, 0x08, 0x80, 0xC4, 0x06, 0x50,
  0x52, 0x83, 0x14, 0x28, 0xA1, 0x49, 0x12, 0x48, 0x92, 0x49, 0x12, 0x48,
  0x94, 0x48, 0x42, 0x42, 0x10, 0x10, 0x22, 0x04, 0x61, 0x14, 0x22, 0x84,
  0x48, 0x89, 0x22, 0x24, 0x44, 0x88, 0x51, 0x0A, 0x21, 0x88, 0x11, 0x02,
  0x00, 0x1F, 0x10, 0x50, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xA0, 0x50, 0x48, 0x23, 0xE0, 0x1F, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22,
  0x3C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1F, 0x10, 0x50, 0x28, 0x14,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x23, 0x60, 0x40,
  0x10, 0x08, 0x00, 0x1F, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x44,
  0x44, 0x44, 0x44, 0x84, 0x82, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0xFE, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x00, 0x20, 0x90, 0x50, 0x28,
  0x14, 0x0A, 0x09, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x48, 0x43, 0xC0,
  0x83, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0xC0,
  0xC0, 0x80, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x49, 0x12,
  0x49, 0x12, 0x48, 0xA2, 0x85, 0x14, 0x30, 0xC1, 0x86, 0x08, 0x20, 0x41,
  0x00, 0x10, 0xC4, 0x20, 0x90, 0x28, 0x0A, 0x03, 0x00, 0x80, 0x20, 0x14,
  0x05, 0x02, 0x41, 0x10, 0x42, 0x20, 0x80, 0x87, 0x0A, 0x24, 0x49, 0x12,
  0x18, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x00, 0x0F, 0xC0, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x3F, 0x80, 0x1E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x40, 0xE0, 0x92, 0x44, 0x92, 0x49, 0x12, 0x40, 0x1E,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0xF0, 0x08, 0x30, 0x91, 0x24, 0x30, 0x60, 0x80, 0xFC, 0xA4, 0x1A,
  0x4D, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x13, 0xE0, 0x10, 0x10, 0x10,
  0x20, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x44, 0xB8,
  0x1C, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x00, 0x01, 0x01, 0x01,
  0x01, 0x19, 0x26, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0xF4,
  0x18, 0x94, 0x61, 0x8B, 0xC8, 0x20, 0x82, 0x07, 0x80, 0x01, 0xC0, 0x80,
  0x20, 0x08, 0x0F, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x03, 0x00, 0x0D, 0x13,
  0x21, 0x41, 0x41, 0x41, 0x42, 0x82, 0x42, 0x44, 0x7C, 0x04, 0x04, 0x04,
  0x08, 0xF0, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31, 0x21, 0x21, 0x42, 0x42,
  0x42, 0x42, 0x42, 0x84, 0x84, 0x10, 0x02, 0x22, 0x24, 0x44, 0x44, 0x88,
  0x02, 0x00, 0x00, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x10, 0x10, 0x20, 0x21, 0x22, 0x24,
  0x28, 0x50, 0x70, 0x48, 0x48, 0x48, 0x88, 0x84, 0x11, 0x12, 0x22, 0x22,
  0x44, 0x44, 0x48, 0x80, 0x2C, 0xE3, 0x31, 0x21, 0x12, 0x21, 0x42, 0x14,
  0x21, 0x42, 0x24, 0x42, 0x44, 0x28, 0x42, 0x84, 0x40, 0x2E, 0x31, 0x21,
  0x21, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x18, 0x49, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0x13, 0xC0, 0x17, 0x0C, 0x44, 0x22, 0x12, 0x09,
  0x04, 0x82, 0x42, 0x21, 0x11, 0x17, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x1A, 0x4D, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0x13, 0xE0, 0x40, 0x81,
  0x02, 0x08, 0x2C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x00, 0x3D,
  0x04, 0x10, 0x20, 0x40, 0x82, 0x08, 0x2F, 0x00, 0x24, 0xF4, 0x48, 0x88,
  0x88, 0x88, 0xC0, 0x42, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x42, 0x89, 0x13,
  0xE0, 0x86, 0x18, 0xA2, 0x8A, 0x49, 0x28, 0xA1, 0x08, 0x00, 0x84, 0x61,
  0x18, 0xC6, 0x52, 0x94, 0xA5, 0x4A, 0x52, 0x98, 0xC6, 0x31, 0x08, 0x40,
  0x21, 0x11, 0x12, 0x14, 0x14, 0x08, 0x18, 0x28, 0x24, 0x44, 0x84, 0x10,
  0x44, 0x21, 0x08, 0x44, 0x11, 0x04, 0x80, 0xA0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x03, 0x00, 0x1E, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x10, 0x20, 0x83, 0xE0, 0x0C, 0x41, 0x04, 0x20, 0x82, 0x10, 0x81,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x60, 0xFF, 0xFF, 0xF0, 0x1C, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x06, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0xC0,
  0xF3, 0x1C,
};

const GFXglyph NotoSans_Condensed_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 5, 2, -14 },
  { 11, 9, 14, 9, 0, -14 },
  { 27, 8, 16, 8, 0, -15 },
  { 43, 10, 14, 12, 1, -14 },
  { 61, 8, 14, 9, 0, -14 },
  { 75, 2, 5, 3, 2, -14 },
  { 77, 5, 17, 5, 1, -14 },
  { 88, 5, 17, 5, -1, -14 },
  { 99, 6, 6, 8, 2, -15 },
  { 104, 7, 10, 9, 1, -12 },
  { 113, 3, 5, 3, -1, -2 },
  { 115, 4, 1, 6, 1, -6 },
  { 116, 1, 1, 3, 0, -1 },
  { 117, 8, 14, 6, -1, -14 },
  { 131, 7, 14, 8, 1, -14 },
  { 144, 3, 14, 8, 3, -14 },
  { 150, 8, 14, 8, 0, -14 },
  { 164, 8, 14, 8, 0, -14 },
  { 178, 8, 14, 8, 0, -14 },
  { 192, 8, 14, 8, 0, -14 },
  { 206, 7, 15, 8, 1, -15 },
  { 220, 8, 14, 8, 1, -14 },
  { 234, 8, 14, 8, 0, -14 },
  { 248, 8, 14, 8, 0, -14 },
  { 262, 3, 11, 3, 0, -11 },
  { 267, 4, 14, 3, -1, -11 },
  { 274, 7, 8, 9, 1, -11 },
  { 281, 7, 4, 9, 1, -9 },
  { 285, 7, 8, 9, 1, -11 },
  { 292, 5, 14, 6, 1, -14 },
  { 301, 11, 16, 12, 1, -14 },
  { 323, 8, 14, 8, -1, -14 },
  { 337, 9, 14, 9, 0, -14 },
  { 353, 9, 15, 8, 1, -15 },
  { 370, 9, 14, 10, 0, -14 },
  { 386, 9, 14, 8, 0, -14 },
  { 402, 9, 14, 7, 0, -14 },
  { 418, 10, 15, 10, 1, -15 },
  { 437, 10, 14, 10, 0, -14 },
  { 455, 6, 14, 4, -1, -14 },
  { 466, 7, 17, 4, -3, -14 },
  { 481, 10, 14, 8, 0, -14 },
  { 499, 6, 14, 7, 0, -14 },
  { 510, 13, 14, 13, 0, -14 },
  { 533, 11, 14, 11, 0, -14 },
  { 553, 9, 14, 11, 1, -14 },
  { 569, 8, 14, 8, 0, -14 },
  { 583, 9, 17, 11, 1, -14 },
  { 603, 8, 14, 8, 0, -14 },
  { 617, 8, 14, 8, 0, -14 },
  { 631, 7, 14, 7, 2, -14 },
  { 644, 9, 14, 10, 1, -14 },
  { 660, 8, 14, 8, 2, -14 },
  { 674, 13, 14, 13, 2, -14 },
  { 697, 10, 14, 7, -1, -14 },
  { 715, 7, 14, 7, 2, -14 },
  { 728, 10, 14, 8, -1, -14 },
  { 746, 7, 17, 6, 0, -14 },
  { 761, 3, 14, 6, 2, -14 },
  { 767, 7, 17, 6, -1, -14 },
  { 782, 7, 7, 9, 1, -14 },
  { 789, 6, 1, 6, -2, 2 },
  { 790, 2, 3, 4, 3, -15 },
  { 791, 7, 11, 9, 1, -11 },
  { 801, 8, 15, 9, 0, -15 },
  { 816, 6, 11, 6, 1, -11 },
  { 825, 8, 15, 9, 1, -15 },
  { 840, 6, 11, 8, 1, -11 },
  { 849, 10, 20, 4, -3, -15 },
  { 874, 8, 16, 9, 0, -11 },
  { 890, 8, 15, 8, 0, -15 },
  { 905, 4, 14, 3, 0, -14 },
  { 912, 7, 19, 4, -3, -14 },
  { 929, 8, 15, 7, 0, -15 },
  { 944, 4, 15, 3, 0, -15 },
  { 952, 12, 11, 13, 0, -11 },
  { 969, 8, 11, 8, 0, -11 },
  { 980, 7, 11, 8, 1, -11 },
  { 990, 9, 16, 9, -1, -11 },
  { 1008, 7, 16, 9, 1, -11 },
  { 1022, 6, 11, 5, 0, -11 },
  { 1031, 6, 11, 6, 0, -11 },
  { 1040, 4, 13, 4, 1, -13 },
  { 1047, 7, 11, 8, 1, -11 },
  { 1057, 6, 11, 6, 1, -11 },
  { 1066, 10, 11, 10, 1, -11 },
  { 1080, 8, 11, 7, -1, -11 },
  { 1091, 10, 16, 7, -2, -11 },
  { 1111, 7, 11, 6, -1, -11 },
  { 1121, 6, 17, 6, 1, -14 },
  { 1134, 1, 20, 8, 4, -15 },
  { 1137, 7, 17, 6, -1, -14 },
  { 1152, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_THINITALIC20PT7B_H_
