#ifndef _NOTOSANS_CONDENSED_THINITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_THINITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x00, 0x00, 0x00, 0x00, 0x81, 0x00,
  0x42, 0x85, 0x12, 0x28, 0x50, 0xA2, 0x44, 0x89, 0x10, 0x00, 0x43, 0x00,
  0x42, 0x00, 0x82, 0x00, 0x82, 0x00, 0x84, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x08, 0x1F, 0xFF, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04,
  0x10, 0x04, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFC, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x20, 0x80, 0x21, 0x00, 0x41,
  0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x1F, 0xE0, 0x44, 0x21, 0x08,
  0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x64, 0x00,
  0x68, 0x00, 0x60, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x20, 0x04, 0x60, 0x08,
  0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x08, 0x02, 0x30, 0xF7, 0x80,
  0x18, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x84, 0x40,
  0x42, 0x10, 0x20, 0x82, 0x08, 0x40, 0x84, 0x10, 0x41, 0x04, 0x10, 0x81,
  0x04, 0x20, 0x81, 0x10, 0x20, 0x44, 0x08, 0x22, 0x32, 0x09, 0x12, 0x82,
  0x48, 0x61, 0x24, 0x1C, 0xC9, 0x05, 0xE4, 0x81, 0x01, 0x20, 0x40, 0x88,
  0x20, 0x42, 0x08, 0x11, 0x02, 0x08, 0x40, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x22, 0x10, 0x0F, 0x00, 0x00, 0xF0, 0x02, 0x20, 0x08,
  0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x01, 0x04, 0x02, 0x08, 0x04, 0x20,
  0x08, 0x80, 0x0B, 0x00, 0x18, 0x00, 0x30, 0x01, 0xA0, 0x06, 0x40, 0x98,
  0x42, 0x20, 0x84, 0x80, 0x89, 0x01, 0x24, 0x02, 0x48, 0x03, 0x10, 0x06,
  0x20, 0x08, 0x60, 0x28, 0x40, 0x90, 0x7E, 0x10, 0x55, 0xAA, 0xA0, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x00, 0x02, 0x00, 0x42, 0x08, 0x32, 0x01, 0x46, 0x1F, 0x03,
  0x00, 0x90, 0x22, 0x08, 0x20, 0x04, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x11,
  0x22, 0x44, 0x48, 0x80, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x10, 0x81, 0x02,
  0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50,
  0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x02, 0x08, 0x10, 0x41, 0x01,
  0xF0, 0x00, 0x04, 0x31, 0x59, 0x84, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x00, 0xF8,
  0x06, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0xE0, 0x01,
  0xF0, 0x18, 0x20, 0x80, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x07, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x80, 0x83, 0xFC, 0x00, 0x00, 0x04, 0x00,
  0x30, 0x01, 0x40, 0x09, 0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01,
  0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08,
  0x08, 0x20, 0x21, 0x00, 0x88, 0x04, 0x3F, 0xFE, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x80, 0x81, 0xFE, 0x00, 0x00, 0x7C, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x38, 0x13, 0x18, 0x50, 0x21, 0x80, 0x44, 0x01, 0x10, 0x04,
  0xC0, 0x12, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x84, 0x04,
  0x10, 0x10, 0x60, 0x80, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x04, 0x10, 0x10, 0x10, 0x40, 0x20,
  0x80, 0x21, 0x00, 0x42, 0x01, 0x04, 0x02, 0x08, 0x04, 0x08, 0x10, 0x10,
  0x40, 0x13, 0x00, 0x18, 0x00, 0xD8, 0x06, 0x10, 0x18, 0x10, 0x60, 0x10,
  0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x20,
  0x10, 0x60, 0x40, 0x3F, 0x00, 0x01, 0xF0, 0x08, 0x20, 0x40, 0x82, 0x01,
  0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x03, 0x10, 0x08, 0x40, 0x60, 0x86, 0x81, 0xE2, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x03,
  0x03, 0xF0, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x02, 0x00, 0x00, 0x0F,
  0x86, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x06, 0x18, 0x01, 0x80, 0x40, 0x20, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x01, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x3E, 0x12, 0x04, 0x21,
  0x20, 0x82, 0x12, 0x10, 0x41, 0x41, 0x04, 0x14, 0x20, 0x41, 0x42, 0x04,
  0x24, 0x20, 0x82, 0x84, 0x08, 0x28, 0x40, 0x84, 0x84, 0x18, 0x48, 0x42,
  0x88, 0x82, 0x29, 0x88, 0x3C, 0x70, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x01, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x80, 0x22, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08,
  0x20, 0x40, 0x81, 0xFE, 0x08, 0x08, 0x20, 0x11, 0x00, 0x44, 0x01, 0x20,
  0x04, 0x80, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x10, 0x07, 0xE0,
  0x08, 0x30, 0x10, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84,
  0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x81, 0x83, 0xFC, 0x04, 0x0C,
  0x08, 0x04, 0x10, 0x0C, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x01, 0x08, 0x02, 0x20, 0x0C, 0x40, 0x30, 0x80, 0xC1, 0xFE, 0x00, 0x00,
  0xFE, 0x02, 0x04, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x04, 0x38, 0x04, 0x04, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02,
  0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x18, 0x40, 0x10, 0x80, 0x20, 0x80, 0xC0,
  0x81, 0x80, 0xFE, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0xFF, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x07, 0xFC, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x80, 0xC1, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x03, 0xF2,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00,
  0x88, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x30, 0x08, 0x0F,
  0xF8, 0x00, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08, 0x20, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x20, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00,
  0x41, 0x00, 0x10, 0x40, 0x08, 0x3F, 0xFE, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40,
  0x08, 0x10, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x04,
  0x00, 0x07, 0xC0, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x3E, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x0F, 0x00, 0x04, 0x01,
  0x04, 0x02, 0x04, 0x04, 0x08, 0x0C, 0x08, 0x18, 0x08, 0x10, 0x08, 0x20,
  0x10, 0x40, 0x10, 0x80, 0x11, 0x00, 0x13, 0x00, 0x16, 0x00, 0x26, 0x00,
  0x2A, 0x00, 0x31, 0x00, 0x21, 0x00, 0x21, 0x00, 0x40, 0x80, 0x40, 0x80,
  0x40, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20,
  0x80, 0x20, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0x04, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x50, 0x00, 0x60, 0xA0, 0x01, 0x41, 0x40,
  0x02, 0x82, 0x80, 0x09, 0x09, 0x00, 0x14, 0x12, 0x00, 0x48, 0x24, 0x00,
  0x90, 0x48, 0x02, 0x20, 0x90, 0x04, 0x82, 0x10, 0x11, 0x04, 0x20, 0x62,
  0x08, 0x40, 0x84, 0x10, 0x82, 0x08, 0x21, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x81, 0x04, 0x11, 0x02, 0x08, 0x24, 0x08, 0x20,
  0x48, 0x10, 0x40, 0x60, 0x20, 0x80, 0xC0, 0x41, 0x01, 0x01, 0x00, 0x04,
  0x00, 0x41, 0x00, 0x10, 0x60, 0x04, 0x28, 0x01, 0x0A, 0x00, 0x82, 0x80,
  0x20, 0x90, 0x08, 0x44, 0x02, 0x11, 0x01, 0x04, 0x40, 0x41, 0x08, 0x10,
  0x42, 0x04, 0x20, 0x81, 0x08, 0x10, 0x82, 0x04, 0x20, 0x81, 0x08, 0x20,
  0x42, 0x10, 0x08, 0x84, 0x02, 0x41, 0x00, 0x90, 0x40, 0x24, 0x10, 0x05,
  0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20, 0x02, 0x00, 0x00, 0xF8,
  0x03, 0x04, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x40, 0x20, 0x60, 0x40,
  0x3F, 0x80, 0x07, 0xC0, 0x10, 0xC0, 0x40, 0x82, 0x01, 0x08, 0x04, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x20,
  0x10, 0x81, 0x83, 0xF8, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0x04, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x40, 0x20,
  0x60, 0x40, 0x3F, 0x80, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x07, 0xC0, 0x10, 0xC0, 0x40, 0x82, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84,
  0x06, 0x20, 0x30, 0xFF, 0x02, 0x10, 0x08, 0x40, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x41, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42,
  0x00, 0x80, 0x00, 0xFC, 0x03, 0x03, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x80, 0x60, 0x7F, 0x80, 0xFF, 0xF8, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x84, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x08, 0x40, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01,
  0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x80,
  0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x81, 0x00, 0xC0, 0x40, 0xC0, 0x1F, 0xC0, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x40,
  0x41, 0x01, 0x04, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10,
  0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05,
  0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x00, 0x80, 0x10, 0x03, 0x80, 0x18,
  0x02, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x08, 0x80, 0x48, 0x08, 0x80, 0x48, 0x18, 0x80, 0x88, 0x10, 0x80, 0x88,
  0x10, 0x81, 0x08, 0x20, 0x81, 0x08, 0x20, 0x82, 0x08, 0x40, 0x82, 0x08,
  0x40, 0x82, 0x08, 0x40, 0x84, 0x08, 0x80, 0x84, 0x08, 0x80, 0x88, 0x09,
  0x00, 0x88, 0x09, 0x00, 0x88, 0x0A, 0x00, 0x90, 0x12, 0x00, 0x90, 0x12,
  0x00, 0xA0, 0x14, 0x00, 0xA0, 0x14, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x08,
  0x00, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x02,
  0x00, 0x41, 0x00, 0x10, 0x40, 0x02, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x0A, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x14, 0x00, 0x05,
  0x00, 0x02, 0x40, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x18, 0x20,
  0x04, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x10, 0x20, 0x04, 0x00,
  0x80, 0x1C, 0x00, 0xA0, 0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x08,
  0x20, 0x41, 0x02, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x14, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x01,
  0xF8, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x1F, 0xC0, 0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x82, 0x10,
  0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x40, 0x03, 0xF8, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x1F, 0x80,
  0x00, 0x80, 0x06, 0x00, 0x14, 0x00, 0x90, 0x06, 0x40, 0x10, 0x80, 0x82,
  0x02, 0x04, 0x10, 0x10, 0x40, 0x62, 0x00, 0x98, 0x02, 0x40, 0x06, 0x00,
  0x10, 0xFF, 0xE0, 0x84, 0x42, 0x21, 0x03, 0xE4, 0x30, 0x50, 0x81, 0x84,
  0x06, 0x20, 0x08, 0x80, 0x62, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44,
  0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x18, 0x40, 0xC1,
  0x05, 0x03, 0xE4, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x09, 0xF8, 0x2C, 0x20, 0xE0, 0x43,
  0x01, 0x08, 0x04, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x26, 0x01, 0x18, 0x04, 0x60, 0x21,
  0x41, 0x08, 0xF8, 0x00, 0x03, 0xE1, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x03,
  0xE4, 0x0C, 0x14, 0x08, 0x14, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40,
  0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x80, 0x30, 0x80,
  0x20, 0x80, 0x20, 0x80, 0x60, 0x80, 0x60, 0x40, 0xA0, 0x41, 0x40, 0x3E,
  0x40, 0x03, 0xE0, 0xC2, 0x08, 0x11, 0x01, 0x20, 0x12, 0x02, 0x40, 0x64,
  0x0C, 0x43, 0x07, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x08, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x06, 0x40, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x12, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xF2, 0x0C, 0x14, 0x10, 0x28, 0x40, 0x21, 0x00, 0x42, 0x00,
  0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0xC4,
  0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x18, 0x20, 0x50, 0x41, 0x40, 0x7C,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x03, 0x1C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x09, 0xF8, 0x28, 0x20,
  0xC0, 0x43, 0x01, 0x08, 0x08, 0x60, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08,
  0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10, 0x08,
  0x40, 0x21, 0x00, 0x8C, 0x06, 0x00, 0x02, 0x0C, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x41, 0x80, 0x00, 0x10, 0x03, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x09, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x0C, 0x20, 0x40, 0x82, 0x02, 0x18, 0x08, 0x40, 0x42, 0x01, 0x10,
  0x04, 0x80, 0x16, 0x00, 0xA4, 0x03, 0x10, 0x0C, 0x40, 0x21, 0x00, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x0C, 0x04, 0x00, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x00, 0x09, 0xF1,
  0xF0, 0x50, 0x50, 0x43, 0x03, 0x02, 0x10, 0x18, 0x10, 0x80, 0x80, 0x8C,
  0x04, 0x04, 0x40, 0x20, 0x22, 0x02, 0x01, 0x10, 0x10, 0x09, 0x00, 0x80,
  0x88, 0x04, 0x04, 0x40, 0x40, 0x22, 0x02, 0x01, 0x10, 0x10, 0x11, 0x00,
  0x80, 0x88, 0x04, 0x04, 0x40, 0x40, 0x22, 0x02, 0x01, 0x30, 0x10, 0x10,
  0x09, 0xF8, 0x28, 0x20, 0xC0, 0x43, 0x01, 0x08, 0x08, 0x60, 0x21, 0x00,
  0x84, 0x02, 0x10, 0x08, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x44, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x00, 0x03, 0xE0,
  0x60, 0x86, 0x04, 0x20, 0x12, 0x00, 0x90, 0x05, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x08,
  0x40, 0x42, 0x04, 0x0F, 0xC0, 0x04, 0xFC, 0x0B, 0x08, 0x1C, 0x08, 0x30,
  0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x04,
  0x40, 0x08, 0x80, 0x21, 0x00, 0x42, 0x00, 0x8C, 0x02, 0x18, 0x04, 0x30,
  0x10, 0x50, 0x40, 0xBF, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE4, 0x30, 0x50,
  0x81, 0x44, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x90, 0x04, 0x40, 0x11,
  0x00, 0x44, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x18,
  0x40, 0xA1, 0x05, 0x03, 0xE4, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x09, 0xE1, 0x40, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x00, 0x0F,
  0xE3, 0x04, 0x40, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x90, 0x23,
  0xF8, 0x00, 0x08, 0x08, 0x08, 0x08, 0x10, 0x7F, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xF0, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x02, 0x20, 0x12, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x18, 0x80, 0xC2, 0x0A, 0x1F, 0x90, 0x80, 0x30, 0x0A,
  0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x82, 0x10,
  0x26, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x28, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x20,
  0x90, 0x48, 0x24, 0x22, 0x09, 0x08, 0x84, 0x42, 0x21, 0x11, 0x08, 0x84,
  0x42, 0x21, 0x20, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x08, 0x04, 0x20, 0x20, 0x41,
  0x01, 0x04, 0x04, 0x20, 0x11, 0x00, 0x2C, 0x00, 0xA0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x40, 0x09, 0x00, 0x42, 0x01, 0x08, 0x08, 0x20, 0x40,
  0x41, 0x01, 0x08, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x10,
  0x04, 0x04, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x10, 0x01,
  0x04, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x09, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0xFF,
  0x80, 0x00, 0x10, 0x0C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x07,
  0x00, 0xE0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0x00, 0x70, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x30, 0x08, 0x00, 0x7C, 0x0C, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_Condensed_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 26, 7, 1, -26 },
  { 24, 7, 10, 10, 4, -26 },
  { 33, 16, 26, 16, 0, -26 },
  { 85, 15, 29, 15, 0, -27 },
  { 140, 18, 26, 21, 2, -26 },
  { 199, 15, 26, 16, 0, -26 },
  { 248, 2, 10, 5, 4, -26 },
  { 251, 10, 32, 9, 1, -26 },
  { 291, 9, 32, 9, -2, -26 },
  { 327, 11, 11, 14, 4, -27 },
  { 343, 13, 17, 16, 2, -21 },
  { 371, 4, 9, 6, -1, -4 },
  { 376, 8, 1, 10, 1, -10 },
  { 377, 1, 2, 6, 1, -2 },
  { 378, 15, 26, 11, -2, -26 },
  { 427, 13, 26, 15, 1, -26 },
  { 470, 6, 26, 15, 5, -26 },
  { 490, 15, 26, 15, -1, -26 },
  { 539, 14, 26, 15, 0, -26 },
  { 585, 14, 26, 15, 0, -26 },
  { 631, 15, 26, 15, 0, -26 },
  { 680, 14, 26, 15, 1, -26 },
  { 726, 14, 26, 15, 2, -26 },
  { 772, 15, 26, 15, 0, -26 },
  { 821, 14, 26, 15, 0, -26 },
  { 867, 6, 19, 6, 0, -19 },
  { 882, 8, 24, 6, -2, -19 },
  { 906, 13, 15, 16, 2, -20 },
  { 931, 13, 9, 16, 2, -17 },
  { 946, 13, 15, 16, 2, -20 },
  { 971, 11, 26, 10, 1, -26 },
  { 1007, 20, 29, 22, 1, -26 },
  { 1080, 14, 26, 14, -2, -26 },
  { 1126, 15, 26, 16, 1, -26 },
  { 1175, 15, 26, 15, 2, -26 },
  { 1224, 16, 26, 18, 1, -26 },
  { 1276, 15, 26, 14, 1, -26 },
  { 1325, 15, 26, 13, 1, -26 },
  { 1374, 17, 26, 19, 2, -26 },
  { 1430, 18, 26, 18, 1, -26 },
  { 1489, 10, 26, 7, -1, -26 },
  { 1522, 12, 32, 6, -5, -26 },
  { 1570, 16, 26, 15, 1, -26 },
  { 1622, 9, 26, 13, 1, -26 },
  { 1652, 23, 26, 24, 1, -26 },
  { 1727, 18, 26, 19, 1, -26 },
  { 1786, 16, 26, 19, 2, -26 },
  { 1838, 14, 26, 15, 1, -26 },
  { 1884, 16, 32, 19, 2, -26 },
  { 1948, 14, 26, 15, 1, -26 },
  { 1994, 16, 26, 14, -1, -26 },
  { 2046, 13, 26, 13, 3, -26 },
  { 2089, 17, 26, 18, 2, -26 },
  { 2145, 14, 26, 14, 3, -26 },
  { 2191, 24, 26, 24, 3, -26 },
  { 2269, 18, 26, 13, -2, -26 },
  { 2328, 13, 26, 13, 3, -26 },
  { 2371, 16, 26, 14, -1, -26 },
  { 2423, 13, 32, 10, -1, -26 },
  { 2475, 5, 26, 11, 4, -26 },
  { 2492, 13, 32, 10, -2, -26 },
  { 2544, 14, 14, 16, 1, -26 },
  { 2569, 11, 1, 11, -3, 3 },
  { 2571, 4, 6, 8, 5, -28 },
  { 2574, 14, 19, 15, 1, -19 },
  { 2608, 14, 27, 16, 0, -27 },
  { 2656, 11, 19, 12, 1, -19 },
  { 2683, 16, 27, 16, 1, -27 },
  { 2737, 12, 19, 14, 1, -19 },
  { 2766, 17, 37, 7, -5, -28 },
  { 2845, 15, 28, 16, 0, -19 },
  { 2898, 14, 27, 15, 0, -27 },
  { 2946, 7, 26, 6, 0, -26 },
  { 2969, 12, 35, 6, -5, -26 },
  { 3022, 14, 27, 12, 0, -27 },
  { 3070, 7, 27, 6, 0, -27 },
  { 3094, 21, 19, 23, 0, -19 },
  { 3144, 14, 19, 15, 0, -19 },
  { 3178, 13, 19, 15, 1, -19 },
  { 3209, 15, 27, 16, -1, -19 },
  { 3260, 14, 27, 16, 1, -19 },
  { 3308, 11, 19, 10, 0, -19 },
  { 3335, 11, 19, 11, 0, -19 },
  { 3362, 8, 24, 8, 1, -24 },
  { 3386, 13, 19, 15, 1, -19 },
  { 3417, 11, 19, 11, 2, -19 },
  { 3444, 18, 19, 19, 2, -19 },
  { 3487, 14, 19, 12, -1, -19 },
  { 3521, 18, 28, 12, -4, -19 },
  { 3584, 12, 19, 11, -1, -19 },
  { 3613, 12, 32, 11, 1, -26 },
  { 3661, 1, 36, 14, 7, -27 },
  { 3666, 12, 32, 11, -2, -26 },
  { 3714, 13, 3, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ThinItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_THINITALIC36PT7B_H_
