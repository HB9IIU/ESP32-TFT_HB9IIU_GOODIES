#ifndef _UNIFRAKTURMAGUNTIA_REGULAR46PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x0C, 0x0F, 0x0F, 0xEF, 0xF3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0x03, 0xC3, 0xF8, 0xF8,
  0x38, 0x08, 0x00, 0x00, 0x10, 0x08, 0x18, 0x08, 0x3C, 0x1C, 0x7E, 0x3E,
  0xFE, 0x7F, 0x3E, 0x1F, 0x1E, 0x0F, 0x0E, 0x0E, 0x0C, 0x06, 0x0C, 0x04,
  0x08, 0x0C, 0x10, 0x08, 0x10, 0x10, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E,
  0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xE1, 0xE0, 0x07,
  0x0F, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xE0,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x0E, 0x1E, 0x00, 0x70,
  0xE0, 0x07, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x7C, 0x03, 0xFE, 0x0F, 0x0E, 0x1C, 0x0E, 0x70, 0x0C, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x81, 0x9F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x76, 0x01, 0xCE,
  0x03, 0x8E, 0x1E, 0x07, 0xF8, 0x03, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x18, 0xF3,
  0x80, 0x00, 0x61, 0xC7, 0x80, 0x01, 0x87, 0x8F, 0x00, 0x07, 0x0F, 0x0F,
  0x00, 0x1C, 0x3E, 0x1E, 0x00, 0x30, 0x7C, 0x3C, 0x00, 0xC0, 0xF8, 0x78,
  0x03, 0x01, 0xF0, 0xF0, 0x0C, 0x03, 0xE1, 0xE0, 0x30, 0x07, 0xC3, 0xC0,
  0xC0, 0x07, 0x87, 0x83, 0x80, 0x0F, 0x1E, 0x06, 0x00, 0x0E, 0x3C, 0x18,
  0x00, 0x1E, 0x70, 0x60, 0x00, 0x1F, 0xC1, 0x83, 0xC0, 0x0F, 0x06, 0x1F,
  0xE0, 0x00, 0x18, 0x79, 0xE0, 0x00, 0x70, 0xE1, 0xC0, 0x00, 0xC3, 0xC3,
  0xC0, 0x03, 0x07, 0x87, 0x80, 0x0C, 0x0F, 0x0F, 0x00, 0x30, 0x1E, 0x1E,
  0x00, 0xC0, 0x3C, 0x3E, 0x03, 0x00, 0x78, 0x78, 0x0C, 0x00, 0xF0, 0xF0,
  0x38, 0x01, 0xE1, 0xE0, 0x60, 0x03, 0xC3, 0xC1, 0x80, 0x03, 0x87, 0x06,
  0x00, 0x07, 0x9E, 0x18, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0x80, 0x03,
  0xC3, 0x80, 0x07, 0xC3, 0x80, 0x07, 0xC3, 0x80, 0x07, 0xC7, 0x00, 0x07,
  0xE7, 0x00, 0x03, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0x03,
  0xF0, 0xFF, 0x07, 0xF8, 0x1C, 0x1C, 0xF8, 0x18, 0x38, 0xFC, 0x18, 0x38,
  0xFC, 0x18, 0x78, 0x7E, 0x10, 0x78, 0x7E, 0x10, 0x78, 0x3F, 0x20, 0xF8,
  0x3F, 0x60, 0xFC, 0x1F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0x7E,
  0x07, 0xE3, 0x3F, 0x0F, 0xFE, 0x1F, 0xFD, 0xFC, 0x07, 0xF0, 0xF8, 0x10,
  0x20, 0xE3, 0xFF, 0xE7, 0xC7, 0x86, 0x0C, 0x10, 0x60, 0x82, 0x00, 0x01,
  0x81, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x80, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x9F, 0x8F, 0x39, 0xEF, 0x37, 0xDF, 0x4F, 0x3F, 0xFE,
  0x03, 0x80, 0xFF, 0xF9, 0xF5, 0xF3, 0xCD, 0xFF, 0xB9, 0xE3, 0x7A, 0x01,
  0xF8, 0x01, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x10, 0x18, 0x3C, 0x7E, 0xBF, 0x1E, 0x0E, 0x0E, 0x0C, 0x08, 0x08,
  0x10, 0x20, 0x01, 0xF8, 0xFF, 0x87, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0xF1,
  0xFF, 0x0F, 0xF8, 0xFE, 0x00, 0x10, 0x61, 0xE7, 0xF7, 0xC7, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0x1E, 0x00, 0xF0,
  0xF0, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C,
  0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x07,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xFC, 0x1F,
  0xF0, 0x47, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x3F, 0xC3, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1C, 0x1F, 0xC7, 0x01, 0xFC, 0xC0, 0x1F, 0xB0, 0x03, 0xF6, 0x00,
  0x3E, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x08, 0x38, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x38, 0x3F, 0x83, 0x01, 0xFC, 0x40, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF2, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0x78, 0x03, 0x87, 0xC0, 0x70, 0x3E,
  0x0C, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x05, 0xE0, 0x00, 0x9E, 0x00, 0x19, 0xE0,
  0x01, 0x1E, 0x00, 0x31, 0xE0, 0x06, 0x1E, 0x00, 0x41, 0xE0, 0x0C, 0x1E,
  0x01, 0x81, 0xE0, 0x10, 0x1E, 0x03, 0x01, 0xE0, 0x60, 0x1E, 0x04, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0x80, 0x10, 0xC0, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x3F, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3C, 0x1F, 0xC3, 0x00, 0x7E, 0x60, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x20, 0x01,
  0xEF, 0x00, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1C, 0xF8, 0x03, 0xC7, 0x80,
  0x38, 0x7C, 0x07, 0x01, 0xE0, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x61, 0xE0, 0x18, 0x3E, 0x07, 0x03, 0xC1, 0xE0, 0x7C, 0x38, 0x0F, 0x8F,
  0x01, 0xF1, 0xE0, 0x1E, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x1C, 0x0F, 0xCF, 0xE1, 0xFB, 0xFF, 0x3F, 0x43, 0xE7, 0xF0, 0x3E, 0xFE,
  0x07, 0xDF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0x78, 0xF0,
  0x0E, 0x1F, 0x03, 0xC1, 0xE0, 0x70, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x0F,
  0x80, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF,
  0xB8, 0x00, 0x6C, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x1C, 0x00, 0xC7, 0x80,
  0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x7C, 0x01, 0xCF, 0xC0,
  0x71, 0xFE, 0x0E, 0x1F, 0xE3, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x0D, 0xFF, 0x83, 0x0F, 0xF8, 0xC0, 0x7F, 0x38, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xB8, 0x00, 0xE7, 0x00, 0x3C, 0x70, 0x07,
  0x07, 0x03, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xC3, 0x80, 0x30, 0x38,
  0x0E, 0x07, 0x83, 0xC0, 0xF8, 0x70, 0x1F, 0x1E, 0x01, 0xF3, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x7C, 0x0F, 0xEF, 0xC3, 0xFC,
  0xFF, 0xDF, 0x8F, 0xF3, 0xE0, 0xFC, 0x7C, 0x04, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0x87,
  0xC0, 0xE0, 0xF8, 0x1C, 0x0F, 0x03, 0x00, 0xF0, 0xC0, 0x07, 0xE0, 0x00,
  0x10, 0x20, 0xE7, 0xE7, 0xE7, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x30, 0xF3, 0xFB, 0xE3, 0x82, 0x00, 0x00, 0x08, 0x08, 0x1C,
  0x7E, 0x3F, 0x1C, 0x08, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x18, 0x3C, 0x7E, 0xBF, 0x1E, 0x0E, 0x0E, 0x0C, 0x08, 0x08, 0x10,
  0x20, 0x00, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x18,
  0x00, 0x03, 0xF8, 0x07, 0x07, 0x83, 0x80, 0xF1, 0xC0, 0x1E, 0x70, 0x07,
  0x9C, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xCE, 0x03, 0xF0,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0x80, 0x1F, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x08, 0x1E, 0x02,
  0x03, 0x81, 0x80, 0x70, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x40, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x7F, 0x9C, 0x70, 0x3F, 0xF1,
  0x8E, 0x0F, 0x3E, 0x33, 0xC3, 0xC7, 0x86, 0x70, 0x78, 0xF0, 0xCE, 0x1E,
  0x1E, 0x39, 0xC7, 0xC3, 0x87, 0x38, 0xF0, 0xF0, 0xE7, 0x1E, 0x1E, 0x38,
  0xE7, 0xC7, 0xC7, 0x1C, 0xF0, 0xF1, 0xC3, 0x8F, 0x7E, 0x70, 0x39, 0xFF,
  0xFC, 0x67, 0x1E, 0x3E, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x3F, 0xF8,
  0x00, 0x1C, 0x0F, 0xFF, 0xC0, 0x07, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x30,
  0x1F, 0xF0, 0x7E, 0x02, 0x00, 0x7F, 0x1F, 0xE0, 0x60, 0x03, 0xF8, 0x7E,
  0x04, 0x00, 0x3F, 0x87, 0xE0, 0xC0, 0x01, 0xF8, 0x7E, 0x0C, 0x00, 0x0F,
  0xC7, 0xE0, 0xC0, 0x00, 0xFC, 0x7E, 0x0C, 0x00, 0x0F, 0xC7, 0xE0, 0xE0,
  0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x7F, 0x80, 0xF8, 0x7E,
  0x03, 0xFC, 0x0F, 0x07, 0xE0, 0x1F, 0xC0, 0xF0, 0x7E, 0x00, 0xFE, 0x1E,
  0x07, 0xE0, 0x01, 0xE1, 0xC0, 0x7E, 0x00, 0x0C, 0x38, 0x07, 0xE0, 0x00,
  0x83, 0x00, 0x7E, 0x00, 0x08, 0x60, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x7E,
  0x00, 0x01, 0x80, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x04,
  0x7F, 0xE1, 0xFF, 0x60, 0x03, 0xFF, 0xF3, 0xFE, 0x00, 0x1F, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0x80,
  0x0F, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFF, 0xF1, 0x0F, 0xE0, 0x3F, 0x9F,
  0xFA, 0x07, 0xE0, 0x3C, 0x03, 0xFE, 0x07, 0xF0, 0x78, 0x01, 0xFE, 0x03,
  0xF0, 0x70, 0x00, 0xFE, 0x03, 0xF0, 0x60, 0x00, 0x7E, 0x03, 0xF8, 0x60,
  0x00, 0x7E, 0x01, 0xFC, 0x60, 0x00, 0x3E, 0x00, 0xFA, 0x60, 0x00, 0x3E,
  0x00, 0x60, 0x60, 0x00, 0x3E, 0x01, 0x80, 0x60, 0x00, 0x3E, 0x07, 0xC0,
  0x70, 0x00, 0x3C, 0x1F, 0xF0, 0x38, 0x04, 0x3C, 0x7F, 0xF8, 0x1C, 0x0C,
  0x39, 0xFF, 0xFC, 0x0F, 0xF8, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0x1E,
  0x01, 0xBF, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x07,
  0xFE, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80, 0x60, 0x00, 0x01, 0xFF, 0xE1,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0x00, 0x0F, 0x0C, 0x3E, 0x00,
  0x78, 0x19, 0xFF, 0xC3, 0xC0, 0x3F, 0xFE, 0x0F, 0x00, 0xDF, 0xF0, 0x78,
  0x0C, 0x0F, 0x01, 0xE0, 0x60, 0x08, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x3E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x7C, 0x3F, 0x80, 0x01, 0xF0, 0xFF, 0x80, 0x07, 0xC1, 0xFF, 0x00,
  0x1F, 0x83, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x07,
  0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0xC0,
  0x38, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0xFF, 0x0C, 0x00, 0x01, 0xFE, 0x40,
  0x00, 0x03, 0xFE, 0x00, 0x08, 0x07, 0xFF, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x01, 0xF0, 0x0C, 0x1F, 0xF0, 0x78,
  0x03, 0x01, 0xFF, 0x0E, 0x00, 0xC0, 0x0F, 0xE3, 0x80, 0x38, 0x00, 0xFE,
  0x70, 0x0F, 0x80, 0x0F, 0xCC, 0x01, 0xF0, 0x00, 0xFD, 0x80, 0x3F, 0x00,
  0x0F, 0xB0, 0x07, 0xF8, 0x00, 0xF6, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x01, 0xE8, 0x00, 0xFF, 0x00, 0x3D, 0x80, 0x0F, 0xF0, 0x07, 0x98,
  0x00, 0xFE, 0x00, 0x71, 0x80, 0x0F, 0xC0, 0x0E, 0x1C, 0x60, 0xF8, 0x01,
  0xC0, 0x7A, 0x1E, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x01, 0xF4, 0x00, 0x06, 0x00, 0xFF,
  0xC0, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x20, 0x0F, 0xFF, 0xE0, 0x0C, 0x07,
  0x3F, 0xFF, 0x87, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0x00, 0x0F, 0x0C, 0x3F, 0x00, 0x78, 0x19,
  0xFF, 0xC3, 0xC0, 0x3F, 0xFE, 0x0F, 0x00, 0xDF, 0xF0, 0x78, 0x0C, 0x0F,
  0x01, 0xE0, 0x60, 0x08, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0xE0, 0x7C,
  0x3F, 0xC7, 0xE1, 0xF0, 0xFF, 0xBF, 0xF7, 0xC1, 0xFF, 0xFF, 0xDF, 0x03,
  0xFE, 0x7E, 0x7C, 0x07, 0xFC, 0xF1, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x1F,
  0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xF8,
  0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0xC0, 0x38, 0x00,
  0x7F, 0x81, 0xC0, 0x00, 0xFF, 0x0C, 0x00, 0x01, 0xFE, 0x40, 0x00, 0x03,
  0xFE, 0x00, 0x08, 0x07, 0xFF, 0x00, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x03, 0xFF, 0xFC, 0x78, 0x00, 0x7F, 0xF8, 0x78, 0x00, 0x67, 0xF8, 0x38,
  0x00, 0x60, 0xF0, 0x18, 0x00, 0x30, 0x30, 0x1C, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x3E, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x43, 0x00, 0x0F, 0xE0, 0x70,
  0x80, 0x07, 0xF0, 0x7C, 0x60, 0x01, 0xFC, 0x3F, 0xB0, 0x00, 0xFF, 0x3F,
  0x88, 0x00, 0x3F, 0xFF, 0xC6, 0x00, 0x1F, 0xF3, 0xC1, 0xC0, 0x07, 0xF8,
  0xC0, 0x3D, 0xF1, 0xFE, 0x00, 0x03, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x00,
  0x78, 0xC1, 0xE0, 0x00, 0x70, 0x11, 0xF8, 0x00, 0xF0, 0x07, 0xFE, 0x00,
  0x70, 0x02, 0x7F, 0x80, 0x78, 0x06, 0x1F, 0xE0, 0x78, 0x06, 0x07, 0xF8,
  0x7C, 0x0E, 0x01, 0xFE, 0x3E, 0x0E, 0x00, 0x7C, 0x1E, 0x0F, 0x00, 0x1C,
  0x1F, 0x0F, 0x80, 0x18, 0x0F, 0x87, 0xE0, 0x18, 0x07, 0xC3, 0xF0, 0x3F,
  0x83, 0xE0, 0xFC, 0x3F, 0xE3, 0xF0, 0x7F, 0x7F, 0xF9, 0xF8, 0x3F, 0xC1,
  0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0x7F, 0x03, 0xF8, 0x1F, 0xBF, 0x80, 0xFE,
  0x07, 0xEF, 0xC0, 0x7F, 0x03, 0xF7, 0xE0, 0x1F, 0xC1, 0xFB, 0xF0, 0x07,
  0xE0, 0x7D, 0xFC, 0x03, 0xF0, 0x3E, 0x7E, 0x00, 0xF0, 0x1F, 0x3F, 0x80,
  0x70, 0x0F, 0x8F, 0xC0, 0x30, 0x07, 0x87, 0xF0, 0x30, 0x07, 0xC1, 0xF8,
  0x30, 0x03, 0xC0, 0x7E, 0x20, 0x03, 0xC0, 0x1F, 0x80, 0x01, 0xC0, 0x07,
  0xF0, 0x01, 0xC0, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x33, 0xFC, 0x00, 0x00, 0x41, 0xFF, 0x80,
  0x00, 0x80, 0xFE, 0x00, 0x01, 0x80, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x07, 0xC0, 0x03, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0xF0,
  0x03, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x0C, 0x07, 0xC0, 0x3E,
  0x3F, 0x03, 0x80, 0x3E, 0x7F, 0x83, 0x00, 0x3E, 0xFF, 0xC3, 0x00, 0x3C,
  0x9F, 0xE6, 0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x70,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x83,
  0xFF, 0x00, 0x70, 0x07, 0xFE, 0x47, 0x00, 0x0F, 0xFF, 0x38, 0x00, 0x3F,
  0xE1, 0x80, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0xF8, 0x07, 0x00,
  0x07, 0xC0, 0x18, 0x00, 0x3E, 0x00, 0x60, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x07, 0xDE, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0x1E,
  0x7F, 0xF8, 0x00, 0xF6, 0x7F, 0xE0, 0x07, 0x00, 0xFF, 0x80, 0x30, 0x03,
  0xFE, 0x03, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0xFF, 0xC0, 0x07, 0x00, 0x7F, 0xE4, 0x1C, 0x00, 0x7F, 0xF8,
  0x30, 0x00, 0x3F, 0xE0, 0x60, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0xC0, 0x0C,
  0x00, 0x07, 0x80, 0x18, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x18,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x1E, 0x38, 0xFC, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x03,
  0xC1, 0xFC, 0x00, 0x07, 0x07, 0xFE, 0x00, 0x0E, 0x1F, 0xFE, 0x00, 0x18,
  0x43, 0xFE, 0x00, 0x70, 0x03, 0xFE, 0x00, 0xC0, 0x03, 0xFE, 0x03, 0x00,
  0x03, 0xFF, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x3C, 0x1F, 0xE0, 0x60, 0x0F,
  0x0F, 0xFE, 0x0E, 0x01, 0xE3, 0xFF, 0xE0, 0xC0, 0x7C, 0x61, 0xFE, 0x1C,
  0x0F, 0x88, 0x1F, 0xC3, 0x81, 0xF2, 0x01, 0xFC, 0x70, 0x3F, 0x40, 0x1F,
  0x8E, 0x07, 0xE8, 0x03, 0xF9, 0xC0, 0xFF, 0x00, 0x3F, 0xB8, 0x0F, 0xE0,
  0x07, 0xC6, 0x01, 0xFE, 0x00, 0x60, 0xC0, 0x3F, 0xC0, 0x18, 0x30, 0x03,
  0xFC, 0x0E, 0x0C, 0x00, 0x3F, 0xC7, 0xF2, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x7C, 0x0E,
  0x03, 0xF0, 0x1F, 0xC1, 0xC0, 0x7F, 0x0F, 0xF8, 0x30, 0x07, 0xE1, 0x3F,
  0xCC, 0x00, 0xFF, 0x43, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xE0,
  0x03, 0xC0, 0xF8, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3F, 0x00, 0x0F,
  0x3F, 0x00, 0x0F, 0x3F, 0x80, 0x0F, 0x3F, 0x80, 0x1F, 0x3F, 0xC0, 0x1E,
  0x1F, 0xC0, 0x3C, 0x0F, 0xEF, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xCF, 0xFE, 0x02, 0x03, 0xFF, 0xDE,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0x83, 0xFE, 0x0F, 0xF0,
  0x03, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0xE8, 0x7F,
  0x03, 0xE7, 0xFF, 0x07, 0xFC, 0x1F, 0x83, 0x80, 0x7F, 0x81, 0xFC, 0x07,
  0xC1, 0x80, 0x1F, 0xE0, 0x7E, 0x03, 0xF1, 0x80, 0x07, 0xF8, 0x1F, 0x81,
  0xF8, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0xFC, 0x40, 0x00, 0x7E, 0x03, 0xE0,
  0x7F, 0x20, 0x00, 0x1F, 0x81, 0xF0, 0x1F, 0xD0, 0x00, 0x0F, 0xC0, 0xFC,
  0x0F, 0x8C, 0x00, 0x07, 0xE0, 0x7E, 0x03, 0x82, 0x00, 0x01, 0xF0, 0x1F,
  0x01, 0x01, 0x83, 0x80, 0xF8, 0x0F, 0x01, 0x80, 0x7F, 0xE0, 0x7C, 0x07,
  0x81, 0x80, 0x3F, 0xF8, 0x3E, 0x03, 0xC1, 0xC0, 0x07, 0xFC, 0x0F, 0x01,
  0xE1, 0xC0, 0x00, 0x06, 0x07, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0x03, 0x80,
  0x70, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x38, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x1C, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x3F, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x1F, 0x80, 0x00, 0x00, 0x30, 0x03, 0x0F, 0xC0, 0x01, 0xF0, 0x31,
  0x03, 0x07, 0xF0, 0x03, 0xFC, 0x13, 0xE1, 0x01, 0xF8, 0x03, 0xFE, 0x1B,
  0xFD, 0x80, 0xFF, 0x73, 0x7F, 0x9B, 0xFF, 0x80, 0x3F, 0xE1, 0x1F, 0xFB,
  0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF9, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x18, 0x7E,
  0x03, 0xC3, 0xFF, 0x60, 0x7E, 0x0E, 0x01, 0xFF, 0x80, 0xFC, 0x10, 0x00,
  0xFF, 0x01, 0xF8, 0x60, 0x00, 0xFE, 0x01, 0xF8, 0x80, 0x01, 0xFC, 0x03,
  0xF1, 0x00, 0x01, 0xF8, 0x07, 0xF2, 0x00, 0x01, 0xF8, 0x0F, 0xF4, 0x00,
  0x03, 0xF0, 0x0F, 0x0C, 0x00, 0x03, 0xE0, 0x0C, 0x08, 0x00, 0x07, 0xC0,
  0x30, 0x1C, 0x78, 0x0F, 0x80, 0xC0, 0x1F, 0xF8, 0x1F, 0x03, 0x00, 0x1F,
  0xF8, 0x1E, 0x0E, 0x00, 0x1F, 0xF0, 0x3C, 0x1C, 0x00, 0x00, 0x20, 0x70,
  0x78, 0x00, 0x00, 0x40, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xC3, 0xE0, 0x00,
  0x00, 0x07, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x00, 0x1C,
  0x1F, 0x80, 0x00, 0x00, 0x30, 0x3F, 0x00, 0x07, 0xC0, 0xC0, 0x7F, 0x00,
  0x3F, 0xC1, 0x80, 0x7E, 0x00, 0xFF, 0xC6, 0x00, 0xFF, 0xE3, 0x3F, 0xD8,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0C,
  0x01, 0xFF, 0xC0, 0x18, 0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x07, 0xF8, 0x1C,
  0x00, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x1F, 0xC7,
  0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x00, 0x7C,
  0xFF, 0xE0, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x07,
  0x83, 0xFF, 0x80, 0x03, 0xC0, 0x7F, 0xC0, 0x01, 0xE0, 0x0F, 0xE0, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x1C, 0x07, 0x90, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x06, 0x0F, 0xFC, 0x00,
  0x06, 0x0F, 0xFF, 0x80, 0x02, 0x08, 0xFF, 0xE0, 0x02, 0x00, 0x1F, 0xFC,
  0x06, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0E, 0x00,
  0x1F, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x01, 0xFF, 0xFE,
  0x0F, 0xE0, 0x07, 0x81, 0xFE, 0x7F, 0xC0, 0x1C, 0x01, 0xFF, 0x1F, 0xC0,
  0x30, 0x01, 0xFC, 0x3F, 0xC0, 0x60, 0x01, 0xF8, 0x7F, 0xC0, 0x80, 0x03,
  0xF8, 0x7F, 0xC1, 0x00, 0x03, 0xF0, 0x7F, 0xC2, 0x00, 0x07, 0xE0, 0x7F,
  0xC4, 0x00, 0x0F, 0xC0, 0x7F, 0xCC, 0x00, 0x1F, 0x80, 0x7F, 0xC8, 0x00,
  0x3F, 0x00, 0x3F, 0x98, 0x00, 0x7E, 0x00, 0x3F, 0x18, 0x0C, 0x7C, 0x00,
  0x3F, 0x0F, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x02, 0x00,
  0x00, 0x7C, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x1F, 0xF8,
  0x00, 0x60, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0x06, 0x00,
  0x06, 0x1F, 0xFF, 0xF8, 0x00, 0x08, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x39, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x1F, 0xFC, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x18, 0x00, 0x07,
  0xF8, 0x07, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x07, 0xF0, 0x3C, 0x00,
  0x00, 0x7F, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7C, 0x1F,
  0xE0, 0x00, 0x07, 0xC3, 0xFF, 0x80, 0x00, 0xF8, 0x7F, 0xF8, 0x00, 0x0F,
  0x07, 0xFF, 0x80, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0x3C, 0x01, 0xFF, 0x00,
  0x07, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x90, 0x03, 0xCC, 0x03,
  0xFC, 0x01, 0xFD, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFE, 0x1B, 0xFC,
  0x30, 0xFF, 0xE0, 0x1F, 0xCC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF1, 0xF8, 0x00, 0x1F, 0xF8, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xFF,
  0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0x10,
  0xFE, 0x01, 0xFB, 0xFF, 0xD0, 0x3F, 0x81, 0xE0, 0x1F, 0xE8, 0x0F, 0xC0,
  0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x60, 0x00, 0xFE, 0x03, 0xF8, 0x60, 0x00,
  0x3F, 0x00, 0xFE, 0x30, 0x00, 0x1F, 0x80, 0x7F, 0x98, 0x00, 0x07, 0xC0,
  0x1F, 0x8C, 0x00, 0x03, 0xE0, 0x07, 0x06, 0x00, 0x00, 0xF0, 0x06, 0x03,
  0x00, 0x00, 0x78, 0x06, 0x00, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x60, 0x00,
  0x1F, 0x1E, 0x00, 0x18, 0x00, 0x0F, 0x1F, 0x80, 0x07, 0x03, 0x07, 0xBF,
  0xE0, 0x00, 0xFE, 0x03, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0xE1, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x00, 0x0C, 0x03,
  0xF0, 0x00, 0x7C, 0x0C, 0x01, 0xFC, 0x00, 0xFE, 0x06, 0x00, 0xFE, 0x00,
  0xFF, 0x86, 0x00, 0x3F, 0x90, 0xDF, 0xF6, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x80, 0x07, 0xFF, 0xF0, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0C, 0x07, 0xFF, 0xC0, 0x08, 0x00, 0xFF, 0xC0,
  0x0C, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFE,
  0x03, 0x80, 0x01, 0xFF, 0xC1, 0xC2, 0x03, 0xFF, 0xF1, 0xE0, 0x87, 0xFF,
  0xFC, 0xF0, 0x3F, 0xFF, 0x86, 0x78, 0x0F, 0xFE, 0x01, 0xBC, 0x07, 0xFE,
  0x00, 0x5F, 0x01, 0xFC, 0x00, 0x2F, 0x80, 0x38, 0x00, 0x13, 0xE0, 0x00,
  0x00, 0x09, 0xF8, 0x00, 0x00, 0x04, 0xFC, 0x00, 0x00, 0x02, 0x3F, 0x80,
  0x00, 0x03, 0x1F, 0xE0, 0x00, 0x03, 0x07, 0xFC, 0x00, 0x07, 0x81, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0x81, 0xFF, 0xE0, 0x03, 0x00, 0x1F, 0xFC,
  0x03, 0x00, 0x03, 0xFF, 0x89, 0x00, 0x02, 0xFF, 0xFD, 0x80, 0x06, 0x1F,
  0xF8, 0xC0, 0x07, 0x03, 0xF8, 0x60, 0x07, 0x80, 0xF8, 0x30, 0x07, 0xC0,
  0x00, 0x18, 0x03, 0xF0, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x03, 0x00, 0xFF,
  0x80, 0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x38, 0x4F, 0xF8, 0x00, 0x03, 0xC3,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0xFF,
  0xC0, 0xE0, 0x00, 0xFF, 0xF0, 0xE0, 0x00, 0x07, 0xFC, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80,
  0x03, 0xFF, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x07, 0x08, 0x00, 0x70,
  0x1C, 0x08, 0x03, 0xC0, 0x70, 0x10, 0x1F, 0x01, 0xE0, 0x20, 0xFE, 0x03,
  0xC0, 0xC3, 0xFC, 0x0F, 0xC1, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3F,
  0x80, 0x07, 0xC0, 0x7F, 0x80, 0x0F, 0x80, 0x7F, 0x80, 0x1F, 0x00, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFE,
  0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x0C, 0x00,
  0x7C, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x03,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x81, 0xFF, 0xC0, 0x5F,
  0x86, 0x7F, 0xC3, 0x3F, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xFE, 0x63, 0xF8, 0x07, 0xFF, 0xFE, 0x83,
  0xF8, 0x1E, 0x01, 0xFF, 0x03, 0xF0, 0x38, 0x01, 0xFC, 0x07, 0xF0, 0xE0,
  0x01, 0xFC, 0x07, 0xF1, 0x80, 0x01, 0xF8, 0x0F, 0xF3, 0x00, 0x03, 0xF0,
  0x0F, 0x06, 0x00, 0x03, 0xE0, 0x0C, 0x0C, 0x00, 0x07, 0xC0, 0x30, 0x18,
  0x00, 0x0F, 0x80, 0xE0, 0x10, 0x00, 0x1E, 0x01, 0xC0, 0x30, 0x00, 0x3C,
  0x07, 0x80, 0x20, 0x08, 0x78, 0x0F, 0x80, 0x30, 0x30, 0xE0, 0x3F, 0x80,
  0x3F, 0x81, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x0C,
  0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x33, 0xFF, 0x80, 0x03,
  0x80, 0x41, 0xFF, 0x80, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0xFF, 0xC0, 0x60, 0x00, 0x00, 0xFF, 0xF1, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x20, 0x01, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x07, 0x83, 0xFE, 0x00, 0x3F,
  0xFF, 0x1F, 0x1B, 0xFE, 0x00, 0xFF, 0xFF, 0x63, 0x40, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0x80, 0xFE, 0x0F, 0x81, 0xFE, 0x06, 0x01, 0xFC, 0x1C, 0x00,
  0xFE, 0x1C, 0x01, 0xF8, 0x70, 0x00, 0xFC, 0x38, 0x03, 0xF8, 0xE0, 0x00,
  0xFC, 0xF0, 0x03, 0xF1, 0x80, 0x01, 0xF9, 0xE0, 0x07, 0xFB, 0x00, 0x01,
  0xF3, 0xE0, 0x07, 0xC6, 0x00, 0x03, 0xE7, 0xE0, 0x06, 0x0C, 0x00, 0x07,
  0xCF, 0xC0, 0x0C, 0x08, 0x00, 0x07, 0x9F, 0xC0, 0x30, 0x18, 0x00, 0x1E,
  0x3F, 0x80, 0xE0, 0x10, 0x00, 0x3C, 0x3F, 0x83, 0xE0, 0x10, 0x0C, 0x78,
  0x3F, 0x07, 0xE0, 0x1F, 0xE0, 0xE0, 0x7F, 0x0F, 0xE0, 0x0F, 0x01, 0x80,
  0x7E, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0xFC, 0x3F, 0xE0, 0x00, 0x0C, 0x00,
  0xF8, 0x3F, 0xE0, 0x00, 0x30, 0x01, 0xF0, 0x3F, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0x80, 0x1F, 0x01, 0xFE, 0x00, 0x06,
  0x00, 0x1E, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x38, 0x3F, 0xFE, 0x00, 0x3F,
  0x00, 0x70, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0xC0, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0x00, 0x01, 0xFF, 0x1F, 0xFF, 0x04, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0x00, 0x1F, 0xF8, 0x0F, 0x88, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF,
  0xF8, 0x7F, 0xC7, 0xFF, 0xF8, 0xFF, 0x9E, 0x03, 0xF1, 0xFE, 0x38, 0x03,
  0xF6, 0x38, 0x60, 0x03, 0xE8, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0x00, 0x07,
  0xC0, 0x02, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x3E,
  0x00, 0x08, 0x00, 0x7F, 0xFC, 0x18, 0x01, 0xFF, 0xF0, 0x18, 0x27, 0xFF,
  0xC0, 0x0F, 0x9F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x05, 0xF8, 0x00,
  0x00, 0x0B, 0xF0, 0x00, 0x38, 0x17, 0xF0, 0x00, 0xFC, 0x47, 0xF0, 0x41,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x27,
  0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x7F,
  0xC0, 0x1F, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xFE, 0x41, 0xF8, 0x1F, 0xFF,
  0xFA, 0x0F, 0xE1, 0xE0, 0x1F, 0xF0, 0x3F, 0x0C, 0x00, 0x7F, 0x01, 0xFC,
  0xE0, 0x01, 0xFC, 0x0F, 0xE6, 0x00, 0x07, 0xE0, 0x3F, 0x30, 0x00, 0x3F,
  0x01, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x1E, 0x60,
  0x00, 0x3E, 0x00, 0xC1, 0x00, 0x01, 0xE0, 0x1C, 0x0C, 0x00, 0x0F, 0x01,
  0xE0, 0x30, 0x08, 0x78, 0x1F, 0x00, 0xC0, 0xC3, 0xC0, 0xF8, 0x01, 0xF8,
  0x1C, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0x00, 0x0E, 0x03, 0xFC,
  0x00, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x30,
  0x01, 0xFC, 0x00, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x3F, 0x80,
  0x01, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x03, 0x07, 0xE0, 0x01, 0xFC, 0x30,
  0x3F, 0x00, 0x1F, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x20, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xF8, 0x07, 0x00, 0x1F, 0xC0, 0xE0, 0x00,
  0xFC, 0x0E, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x7C, 0x0C, 0x00, 0x07, 0xC0,
  0xC0, 0x00, 0x7C, 0x04, 0x00, 0x07, 0x80, 0x60, 0x00, 0x78, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF7, 0xFE, 0x00,
  0x0E, 0xFF, 0xF0, 0x00, 0xE0, 0xFF, 0x80, 0x0C, 0x03, 0xFC, 0x01, 0x80,
  0x1F, 0xE0, 0x30, 0x00, 0xFF, 0x8C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x78, 0xF0, 0x78, 0x38,
  0x38, 0x0E, 0x38, 0x03, 0xB8, 0x00, 0xF0, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x71, 0xF1, 0xE1, 0xE1, 0xC1, 0x81, 0x81,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x09, 0xFF, 0x03, 0x1F, 0xE0, 0xC0, 0xF8, 0x38, 0x0F, 0x0F, 0x03, 0xE1,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x93,
  0xFB, 0xFE, 0x3F, 0x9F, 0x87, 0xE3, 0xE0, 0x70, 0x3C, 0x04, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x38, 0x02, 0x1C, 0x00, 0x27, 0x80, 0x04, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x80,
  0x78, 0x30, 0x0F, 0x1F, 0x01, 0xE7, 0xF0, 0x3F, 0x3F, 0x07, 0x83, 0xE0,
  0xF0, 0x7E, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C, 0x1E, 0x03, 0x83,
  0xC0, 0x60, 0xFC, 0x18, 0x3F, 0xE6, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0xDF,
  0x06, 0x3E, 0x38, 0xF8, 0xE1, 0xF7, 0x87, 0x9C, 0x08, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE1, 0x1F, 0xF8, 0x3F, 0x80, 0x78, 0x00,
  0x40, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x06, 0x3F, 0x87, 0x83,
  0xF0, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xF0, 0x0E, 0x1E, 0x01,
  0xC3, 0xE0, 0x30, 0xFE, 0x06, 0x3F, 0xF1, 0x81, 0xFF, 0x60, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x07, 0xE0,
  0x37, 0xC0, 0xC7, 0xC3, 0x8F, 0x87, 0x0F, 0x1E, 0x1F, 0x38, 0x3E, 0x70,
  0x3F, 0xE0, 0x63, 0xC7, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x21, 0xFF, 0x81,
  0xFC, 0x01, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x20, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0x43, 0x81, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0xE0,
  0x0F, 0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x09, 0xFF, 0x83, 0x0F, 0xF0, 0xC0, 0xFC,
  0x38, 0x07, 0x0F, 0x00, 0x61, 0xE0, 0x1C, 0x7C, 0x07, 0x8F, 0x80, 0xF1,
  0xF0, 0x1E, 0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x1F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0xEF, 0x87, 0xE1, 0xF0,
  0x70, 0x3E, 0x08, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC3,
  0x80, 0x38, 0xF8, 0x0E, 0x0F, 0x01, 0x80, 0xF0, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x02, 0x1C, 0x00, 0x27, 0x80, 0x05,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x08, 0x03,
  0xC1, 0x80, 0x78, 0xF0, 0x0F, 0x3F, 0x01, 0xFF, 0xF0, 0x3C, 0x3E, 0x07,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F,
  0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x1F, 0x03, 0xC3, 0xFE, 0x70, 0xFF,
  0x0E, 0x07, 0xC3, 0x80, 0x70, 0x60, 0x02, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x03, 0x00, 0xF0, 0x3F, 0x07, 0xF9, 0x7E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xA1, 0xFC, 0x3F, 0x03, 0xE0, 0x38, 0x01, 0x00, 0x01,
  0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x1F, 0x01, 0xFE, 0x0F, 0xF8, 0x9F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7A, 0x03,
  0x90, 0x38, 0x43, 0x83, 0xF0, 0x00, 0x00, 0x78, 0x0E, 0x20, 0xC0, 0x8E,
  0x12, 0xF3, 0x9F, 0xBC, 0xFD, 0xE3, 0xFF, 0x1F, 0xC0, 0xF8, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0x8F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x27, 0xFE, 0x0F, 0xE0, 0x1E, 0x00, 0x70, 0x01, 0x00,
  0x00, 0x78, 0x0E, 0x21, 0xC0, 0x9E, 0x02, 0xF0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x67, 0xFE, 0x0F,
  0xE0, 0x1E, 0x00, 0x60, 0x01, 0x00, 0x10, 0x04, 0x02, 0x00, 0x70, 0x38,
  0x1C, 0x03, 0xE1, 0xF0, 0xF8, 0x1F, 0xCF, 0xE7, 0xF8, 0x7F, 0x4F, 0xFF,
  0xFA, 0x7E, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1E, 0x03, 0xC1, 0xF0, 0x78,
  0x0F, 0x07, 0xC1, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xF0, 0x7C, 0x1E, 0x03,
  0xC1, 0xF0, 0x78, 0x0F, 0x07, 0xC1, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xF0,
  0x7C, 0x1E, 0x03, 0xC1, 0xF0, 0x78, 0x1F, 0x07, 0xC1, 0xE0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0x7C, 0x1E, 0x07, 0xE3, 0xF0, 0x7D, 0x3F, 0xDF, 0xE1,
  0xFC, 0x7C, 0x1F, 0x07, 0xE0, 0xF0, 0x38, 0x0F, 0x81, 0x80, 0xC0, 0x1C,
  0x04, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x0F, 0x03, 0x80,
  0x7C, 0x3E, 0x07, 0xF7, 0xFE, 0x7F, 0xE7, 0xF8, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0x93, 0xF8, 0x7F, 0x8F,
  0x81, 0xF8, 0x38, 0x0F, 0x80, 0xC0, 0x3C, 0x04, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x3C, 0x7E, 0x0F, 0x1F, 0x83,
  0xC3, 0xF0, 0xF0, 0xFE, 0x3C, 0x1F, 0x8F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07,
  0x9F, 0x81, 0xC7, 0xF0, 0x63, 0xFE, 0x30, 0x3F, 0xF8, 0x03, 0xF8, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x06, 0x07, 0xE0, 0xE0, 0x7F, 0x1F,
  0x03, 0xF7, 0xF8, 0x1F, 0x8F, 0xC0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0,
  0x3E, 0x0F, 0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F,
  0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x7F, 0x01, 0xC7,
  0xF8, 0x38, 0xFF, 0xE3, 0x0D, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x03, 0x3F, 0xC1, 0x87, 0xFC, 0xE0, 0x7C, 0x78, 0x1F, 0x1C, 0x07, 0xCF,
  0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3F, 0x07, 0xC7, 0xC1, 0xF1, 0xF8, 0x7C, 0x3F, 0xBF,
  0x0F, 0xF7, 0xC1, 0xF0, 0xF0, 0x38, 0x3C, 0x04, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x30, 0xF0, 0xE3, 0xF1, 0xE7,
  0xF7, 0xD3, 0xFF, 0xC7, 0xCF, 0x0F, 0x8C, 0x1F, 0x18, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x83, 0xFE, 0x09, 0xF8, 0x01, 0xE0, 0x00,
  0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x08, 0x04, 0x0E, 0x02, 0x0F, 0xC3, 0x0F, 0xFF, 0x89, 0xFF,
  0x88, 0x3F, 0x8C, 0x07, 0x8E, 0x00, 0x87, 0x80, 0x83, 0xE0, 0xE1, 0xF8,
  0xF8, 0x7E, 0xFE, 0x3F, 0xFF, 0x8F, 0x8F, 0xC3, 0x83, 0xE0, 0x80, 0xF0,
  0x80, 0x38, 0xF0, 0x18, 0xFE, 0x08, 0xFF, 0xC8, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x13, 0xFE, 0x5F, 0xC0,
  0x78, 0x03, 0x80, 0x10, 0x00, 0x01, 0x00, 0xC0, 0x18, 0x0F, 0x00, 0xE0,
  0xFC, 0x0F, 0x87, 0xF0, 0xFE, 0x4F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x1F, 0x93, 0xFD, 0x7F, 0x07,
  0xF1, 0xF8, 0x0F, 0x0F, 0x80, 0x30, 0x1C, 0x01, 0x00, 0x40, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x60, 0x0E, 0x07, 0x80, 0xF8, 0x3E,
  0x1F, 0xC1, 0xF9, 0xFF, 0x0F, 0xF0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xC0, 0x38,
  0x06, 0x03, 0x80, 0x78, 0x18, 0x03, 0xF1, 0x80, 0x3F, 0xE8, 0x03, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x7C, 0x06, 0x00, 0x83, 0xF8, 0x3C, 0x07, 0x07, 0xF1, 0xF8, 0x7E, 0x1F,
  0xCF, 0xF7, 0xF8, 0x1F, 0x47, 0xE3, 0xF0, 0x7E, 0x1F, 0x07, 0xE0, 0xF0,
  0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x0F,
  0x01, 0xF0, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0,
  0x78, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x7E, 0x1F, 0xC3, 0x01, 0xF8, 0xFF, 0x98, 0x0F,
  0xF0, 0xFF, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x60,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x04, 0x1E, 0x0C, 0x1F, 0x1E,
  0x3F, 0xBE, 0x3F, 0xFF, 0x4F, 0xDF, 0x07, 0x8E, 0x07, 0x8C, 0x07, 0x84,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xC8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x41, 0xC0, 0x40, 0x80, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x3C, 0x18, 0x7C, 0x0F, 0xFC, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x04, 0x0F, 0xC0, 0x60, 0xFE, 0x1E, 0x07, 0xF3, 0xF0, 0x3F, 0xFF,
  0x81, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x03, 0xE1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xC1,
  0xF2, 0x3C, 0x3F, 0xE3, 0x81, 0xFC, 0x38, 0x0F, 0x83, 0x00, 0x70, 0x60,
  0x02, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x3C, 0x03,
  0xF0, 0x7F, 0xC6, 0x7E, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0x02, 0x38, 0x63, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x0B, 0xF0,
  0xCF, 0xCC, 0x3E, 0x41, 0xF6, 0x0F, 0xB0, 0x3D, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1C, 0x80, 0xE6, 0x06, 0x10, 0x60, 0x82, 0x03, 0xE0,
  0x00, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0x80, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8,
};

const GFXglyph UnifrakturMaguntia_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 34, 11, 1, -33 },
  { 40, 16, 13, 19, 1, -33 },
  { 66, 21, 27, 24, 1, -30 },
  { 137, 15, 37, 19, 2, -35 },
  { 207, 31, 33, 33, 1, -33 },
  { 335, 24, 28, 26, 1, -28 },
  { 419, 7, 13, 9, 1, -33 },
  { 431, 10, 37, 11, 1, -36 },
  { 478, 10, 37, 11, 1, -36 },
  { 525, 15, 18, 16, 0, -34 },
  { 559, 15, 16, 18, 2, -23 },
  { 589, 8, 13, 8, 0, -7 },
  { 602, 13, 9, 14, 1, -18 },
  { 617, 7, 8, 9, 1, -7 },
  { 624, 22, 36, 24, 1, -34 },
  { 723, 20, 32, 22, 1, -32 },
  { 803, 14, 31, 15, 0, -31 },
  { 858, 19, 31, 21, 1, -31 },
  { 932, 20, 32, 21, 1, -32 },
  { 1012, 20, 31, 21, 0, -31 },
  { 1090, 20, 33, 21, 1, -33 },
  { 1173, 19, 32, 21, 1, -32 },
  { 1249, 18, 32, 20, 1, -32 },
  { 1321, 19, 32, 22, 1, -32 },
  { 1397, 19, 33, 21, 1, -33 },
  { 1476, 7, 23, 9, 1, -22 },
  { 1497, 8, 28, 8, 0, -22 },
  { 1525, 13, 16, 13, 0, -21 },
  { 1551, 16, 10, 18, 1, -19 },
  { 1571, 13, 16, 13, 0, -21 },
  { 1597, 18, 34, 21, 1, -33 },
  { 1674, 27, 28, 28, 1, -22 },
  { 1769, 36, 34, 37, 1, -33 },
  { 1922, 40, 34, 41, 0, -33 },
  { 2092, 30, 34, 32, 1, -33 },
  { 2220, 35, 36, 37, 1, -34 },
  { 2378, 30, 34, 32, 1, -33 },
  { 2506, 33, 40, 35, 1, -34 },
  { 2671, 33, 34, 35, 1, -33 },
  { 2812, 32, 42, 34, 1, -36 },
  { 2980, 29, 40, 32, 1, -34 },
  { 3125, 31, 46, 33, 1, -34 },
  { 3304, 35, 34, 37, 1, -33 },
  { 3453, 24, 33, 26, 1, -32 },
  { 3552, 49, 34, 51, 1, -32 },
  { 3761, 39, 33, 41, 1, -32 },
  { 3922, 33, 34, 35, 1, -33 },
  { 4063, 39, 40, 41, 1, -32 },
  { 4258, 35, 36, 37, 1, -33 },
  { 4416, 41, 34, 43, 1, -33 },
  { 4591, 33, 34, 35, 1, -33 },
  { 4732, 33, 32, 34, 1, -32 },
  { 4864, 31, 35, 33, 1, -32 },
  { 5000, 39, 35, 41, 1, -34 },
  { 5171, 47, 34, 50, 1, -33 },
  { 5371, 31, 35, 33, 1, -34 },
  { 5507, 37, 41, 39, 1, -34 },
  { 5697, 28, 40, 31, 1, -34 },
  { 5837, 6, 36, 8, 1, -34 },
  { 5864, 29, 32, 5, -9, -30 },
  { 5980, 6, 36, 8, 1, -34 },
  { 6007, 17, 12, 19, 1, -32 },
  { 6033, 21, 3, 21, 0, 5 },
  { 6041, 7, 8, 23, 7, -32 },
  { 6048, 19, 25, 21, 1, -24 },
  { 6108, 19, 33, 20, 1, -32 },
  { 6187, 14, 24, 16, 1, -23 },
  { 6229, 19, 33, 21, 1, -32 },
  { 6308, 15, 24, 17, 1, -23 },
  { 6353, 14, 41, 11, 0, -34 },
  { 6425, 19, 34, 21, 1, -24 },
  { 6506, 19, 40, 20, 1, -32 },
  { 6601, 11, 33, 13, 1, -32 },
  { 6647, 13, 41, 11, -2, -33 },
  { 6714, 13, 33, 15, 1, -32 },
  { 6768, 13, 33, 13, 1, -32 },
  { 6822, 30, 25, 33, 1, -24 },
  { 6916, 21, 25, 23, 1, -24 },
  { 6982, 18, 25, 19, 0, -24 },
  { 7039, 20, 36, 21, 0, -27 },
  { 7129, 18, 33, 20, 1, -24 },
  { 7204, 15, 25, 17, 1, -24 },
  { 7251, 17, 30, 19, 1, -29 },
  { 7315, 12, 30, 14, 1, -29 },
  { 7360, 21, 25, 23, 1, -24 },
  { 7426, 21, 27, 21, -1, -26 },
  { 7497, 30, 28, 32, 1, -27 },
  { 7602, 16, 34, 18, 1, -24 },
  { 7670, 20, 36, 22, 1, -28 },
  { 7760, 13, 32, 15, 1, -24 },
  { 7812, 12, 37, 15, 1, -36 },
  { 7868, 3, 38, 7, 2, -36 },
  { 7883, 12, 37, 15, 1, -36 },
  { 7939, 15, 3, 17, 1, -15 },
};

const GFXfont UnifrakturMaguntia_Regular46pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular46pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular46pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR46PT7B_H_
