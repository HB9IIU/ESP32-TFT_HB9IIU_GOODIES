#ifndef _UNIFRAKTURMAGUNTIA_REGULAR28PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0x23, 0xBD, 0xE7, 0x39, 0x8C, 0x21, 0x08, 0x42, 0x00, 0x00, 0x23,
  0xBC, 0x40, 0x41, 0x31, 0xBD, 0xEE, 0x33, 0x19, 0x08, 0x84, 0x84, 0x0C,
  0xC0, 0xCC, 0x0C, 0xC1, 0xCC, 0x7F, 0xF7, 0xFF, 0x18, 0xC1, 0x8C, 0x19,
  0x81, 0x98, 0xFF, 0xFF, 0xFF, 0x31, 0x83, 0x18, 0x31, 0x83, 0x38, 0x08,
  0x02, 0x01, 0xE0, 0xC4, 0x61, 0x98, 0x6E, 0x1B, 0xC6, 0x78, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xB0, 0xFC, 0x1F, 0x06, 0xC1, 0x90, 0x63, 0xE0, 0x20,
  0x08, 0x02, 0x00, 0x38, 0x00, 0x5B, 0x00, 0x2E, 0x60, 0x1B, 0x98, 0x0C,
  0xE7, 0x06, 0x31, 0xC1, 0x0C, 0x70, 0x83, 0x98, 0x40, 0xE6, 0x20, 0x1B,
  0x10, 0x03, 0x8C, 0xF0, 0x06, 0x66, 0x01, 0x19, 0xC0, 0x8E, 0x70, 0x43,
  0x9C, 0x20, 0xE7, 0x10, 0x39, 0xCC, 0x06, 0x76, 0x01, 0x99, 0x00, 0x1C,
  0x07, 0x80, 0x33, 0x01, 0x8C, 0x06, 0x30, 0x1C, 0xC0, 0x76, 0x01, 0xE0,
  0x03, 0x8F, 0x3F, 0x19, 0xBC, 0x4E, 0x79, 0x39, 0xE4, 0xE3, 0xE3, 0x8F,
  0x0F, 0x1E, 0x5C, 0x3F, 0x3F, 0x70, 0x21, 0x9E, 0x71, 0x08, 0x84, 0x0C,
  0x30, 0x41, 0x83, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C,
  0x38, 0x70, 0xE0, 0xC1, 0x81, 0x01, 0x01, 0x00, 0x40, 0x60, 0x40, 0xC1,
  0x83, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x38,
  0x60, 0xC1, 0x04, 0x10, 0x00, 0x08, 0x04, 0x0F, 0x9D, 0x36, 0xB8, 0xE9,
  0xEF, 0xD7, 0x3E, 0x06, 0x02, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x23, 0xBE, 0x61, 0x10, 0x80, 0x3E,
  0xFC, 0x07, 0xEF, 0x80, 0x23, 0x9E, 0x40, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x07, 0x80, 0xC6, 0x06, 0x38,
  0x71, 0xC7, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x0F, 0x70, 0x7F, 0x83, 0xFC,
  0x1E, 0xE0, 0xF7, 0x07, 0xB8, 0x39, 0xC1, 0xCF, 0x0E, 0x38, 0x60, 0xC7,
  0x06, 0x30, 0x0F, 0x00, 0x04, 0x06, 0x07, 0x07, 0x87, 0xC4, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0x1F, 0xE0, 0x0F, 0x83, 0xFE, 0x21, 0xE4, 0x0F, 0x40, 0xF8, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0x08,
  0x11, 0x01, 0x3F, 0xF7, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0x8F, 0x10, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x30, 0x0F, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x90, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x61, 0x86,
  0x07, 0xE0, 0x01, 0x80, 0x18, 0x03, 0x80, 0x58, 0x09, 0x80, 0x98, 0x11,
  0x81, 0x18, 0x21, 0x84, 0x18, 0x41, 0x8F, 0xFF, 0xFF, 0xF0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x0F, 0xF0, 0x3C, 0xE1, 0xFE, 0x0F, 0xE0,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xBE, 0x07, 0xFC, 0x3F, 0xE1, 0x87, 0x90,
  0x1C, 0x00, 0xF0, 0x03, 0xB0, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x61, 0x86,
  0x07, 0xE0, 0x07, 0x80, 0x8C, 0x18, 0xE3, 0x8F, 0x30, 0x77, 0x04, 0x70,
  0x07, 0x18, 0x77, 0xE7, 0x8E, 0x78, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70,
  0x77, 0x07, 0x38, 0x63, 0x86, 0x18, 0xC0, 0xF8, 0x3F, 0xF7, 0xFE, 0x40,
  0x28, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x00, 0x07, 0x01, 0x8C, 0x30, 0x66, 0x02, 0x60, 0x37, 0x02, 0x78, 0x63,
  0xEC, 0x3F, 0x81, 0xFC, 0x13, 0xE2, 0x1F, 0x60, 0x76, 0x07, 0xE0, 0x3E,
  0x03, 0x60, 0x36, 0x07, 0x30, 0xE0, 0xF8, 0x0F, 0x01, 0x9C, 0x30, 0xE7,
  0x0E, 0x70, 0xE7, 0x0F, 0x70, 0xFF, 0x0F, 0x70, 0xF7, 0x0F, 0x71, 0x73,
  0xB7, 0x0C, 0x70, 0x0F, 0x00, 0xE7, 0x0E, 0x70, 0xC7, 0x0C, 0x39, 0x81,
  0xF0, 0x23, 0x9E, 0x40, 0x00, 0x00, 0x01, 0x1C, 0xF2, 0x00, 0x23, 0x9E,
  0x40, 0x00, 0x00, 0x01, 0x1D, 0xF3, 0x08, 0x84, 0x03, 0x06, 0x1C, 0x38,
  0x70, 0xF0, 0x38, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x0F, 0x1C, 0x30, 0x60, 0xC0, 0x1F,
  0x0C, 0x33, 0x07, 0x60, 0x6E, 0x0D, 0xC3, 0xC0, 0xF0, 0x7E, 0x1F, 0x87,
  0x81, 0xC0, 0x38, 0x03, 0x08, 0x62, 0x07, 0x80, 0x00, 0x04, 0x01, 0xC0,
  0x7C, 0x02, 0x00, 0x03, 0xF0, 0x07, 0x06, 0x06, 0x01, 0x86, 0x00, 0x43,
  0x1F, 0xB3, 0x1D, 0xD9, 0x9C, 0xCC, 0xCC, 0x66, 0xCE, 0x73, 0x66, 0x33,
  0x13, 0x3B, 0x0C, 0xEF, 0x36, 0x00, 0x31, 0x80, 0x18, 0x60, 0x18, 0x18,
  0x38, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x11, 0xFF, 0x03, 0x18, 0xFC, 0x79,
  0x01, 0xE7, 0xC8, 0x0F, 0x9C, 0x40, 0x3C, 0xE2, 0x01, 0xE7, 0x18, 0x0F,
  0x38, 0xF0, 0x71, 0xC3, 0xE3, 0x8E, 0x0F, 0x18, 0x70, 0x19, 0x83, 0x80,
  0x88, 0x1C, 0x00, 0x80, 0xE0, 0x08, 0x07, 0x00, 0xF0, 0x38, 0x1F, 0xC3,
  0xE0, 0x3F, 0x2F, 0xC0, 0x7E, 0x7C, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE1, 0xF0, 0x1F, 0xF3, 0xF8, 0x3F, 0xFC, 0x3C, 0x60, 0x7C, 0x3C,
  0x40, 0x3C, 0x3C, 0xC0, 0x3C, 0x1E, 0xC0, 0x1C, 0x1C, 0xC0, 0x1C, 0x10,
  0x40, 0x1C, 0x7C, 0x60, 0x99, 0xFE, 0x3F, 0x12, 0x3F, 0x00, 0x30, 0x0F,
  0x00, 0x40, 0x07, 0x00, 0x80, 0x07, 0x01, 0xE0, 0x07, 0x07, 0xF0, 0x07,
  0x09, 0xF8, 0x06, 0x00, 0xFC, 0x0C, 0x00, 0x7F, 0x98, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x8E, 0x06, 0x17, 0xF3, 0x07, 0xF1, 0xC2, 0x08,
  0x71, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0x8F, 0x00, 0xE3, 0xE0, 0x3C,
  0x7C, 0x0F, 0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x07, 0xC1,
  0x80, 0xF0, 0x80, 0x3F, 0x40, 0x07, 0xE0, 0x20, 0xFF, 0xF0, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF0, 0x1F, 0x8E, 0x0C,
  0x3E, 0x60, 0xC0, 0xFA, 0x0E, 0x03, 0xD0, 0x78, 0x0E, 0x83, 0xE0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3E, 0x06, 0x80, 0xF0, 0x33, 0xE3, 0x81, 0x80, 0x18,
  0x08, 0x00, 0x80, 0x40, 0xE8, 0x06, 0x1F, 0xC0, 0x21, 0xFF, 0x82, 0x10,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8E, 0x06, 0x17,
  0xF3, 0x07, 0xF1, 0xC2, 0x08, 0x71, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x03,
  0x8F, 0x3C, 0xE3, 0xEF, 0xF8, 0x7C, 0xEF, 0x0F, 0x93, 0xC1, 0xF0, 0xF0,
  0x3C, 0x1E, 0x07, 0x07, 0xC1, 0x80, 0xF0, 0x80, 0x3F, 0x40, 0x07, 0xE0,
  0x20, 0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0xB3, 0x81, 0xFF, 0x38, 0x0B, 0xE1, 0x80, 0xC6, 0x08,
  0x0E, 0x00, 0x40, 0x78, 0x62, 0x03, 0xE7, 0x90, 0x0F, 0xBE, 0x40, 0x7E,
  0xC3, 0x01, 0xF2, 0x07, 0xE7, 0xC0, 0x60, 0x1E, 0x01, 0xC0, 0xF0, 0x0F,
  0x03, 0x80, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x06, 0x00, 0xE0, 0x30,
  0x07, 0x03, 0x00, 0x1C, 0x30, 0x00, 0x3E, 0x00, 0x07, 0xC2, 0x00, 0xC2,
  0xF0, 0x38, 0x3F, 0x83, 0x04, 0x7C, 0x70, 0x83, 0xE7, 0x38, 0x18, 0xE3,
  0x81, 0x0E, 0x3C, 0x78, 0xE3, 0xCF, 0xCE, 0x1F, 0x3E, 0xF1, 0xF1, 0xEF,
  0x0F, 0x0F, 0xF0, 0x78, 0xFF, 0x03, 0x87, 0x78, 0x30, 0x67, 0x82, 0x0E,
  0x3C, 0x40, 0xE1, 0xE8, 0x0C, 0x0F, 0x01, 0x80, 0x3E, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x02,
  0x3E, 0x00, 0x41, 0xE0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0x00,
  0xE0, 0xF8, 0x0F, 0x3F, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xE0, 0x3C, 0x1F,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0x71, 0x06, 0x07, 0x7C, 0x60,
  0xE7, 0xE4, 0x0E, 0x1F, 0x80, 0xC0, 0xF0, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x61,
  0xF8, 0x18, 0x0F, 0xE2, 0x00, 0xF0, 0x40, 0x04, 0x08, 0x01, 0x81, 0x00,
  0x60, 0x30, 0x0E, 0x02, 0x03, 0xC0, 0x30, 0xBC, 0x01, 0xE7, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC3, 0x80,
  0x39, 0xFC, 0x06, 0x47, 0xC0, 0xC0, 0x7C, 0x10, 0x07, 0xEC, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x61, 0xF8, 0x18, 0x0F, 0xE2, 0x00,
  0xF0, 0x40, 0x04, 0x08, 0x01, 0x81, 0x00, 0x70, 0x20, 0x0E, 0x02, 0x01,
  0xC0, 0x20, 0xBC, 0x03, 0xE7, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x7C, 0x01, 0x9F, 0xE0, 0x20, 0x7C, 0x08, 0x07, 0xE2,
  0x00, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x03, 0x83, 0x80,
  0x18, 0x03, 0x00, 0xC3, 0x86, 0x07, 0x3F, 0x88, 0x19, 0x9E, 0x30, 0xE4,
  0x3C, 0xC3, 0xE0, 0xF3, 0x0F, 0x81, 0xEC, 0x1E, 0x03, 0x20, 0x7C, 0x10,
  0x80, 0xF9, 0xCC, 0x03, 0xEF, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x04,
  0x18, 0x78, 0x3C, 0x61, 0xE1, 0xF9, 0x03, 0xC9, 0xF8, 0x0F, 0xC3, 0xC0,
  0x1C, 0x00, 0x00, 0x40, 0x01, 0xE0, 0x1C, 0x30, 0x60, 0x31, 0xC0, 0x73,
  0x80, 0x67, 0x00, 0xCF, 0x01, 0x9E, 0x07, 0x3E, 0x0C, 0x3D, 0xF0, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x7F, 0x82,
  0x1F, 0x84, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x02, 0x01,
  0xFE, 0x7E, 0x3E, 0x1F, 0xFB, 0xFA, 0x78, 0xC7, 0xE3, 0xE1, 0xC8, 0x0F,
  0x0F, 0x0E, 0x40, 0x3C, 0x38, 0x7A, 0x01, 0xE1, 0xE3, 0xF0, 0x07, 0x0F,
  0x0E, 0x80, 0x3C, 0x38, 0x46, 0x60, 0xE1, 0xC4, 0x1F, 0x87, 0x0C, 0x60,
  0x34, 0x30, 0x63, 0x00, 0x21, 0x83, 0x38, 0x00, 0x0C, 0x19, 0xC0, 0x00,
  0x40, 0x9E, 0x00, 0x06, 0x04, 0x70, 0x1E, 0x2E, 0x43, 0xC3, 0xF2, 0xFC,
  0x1F, 0xC3, 0xEF, 0xE0, 0x7C, 0x1E, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x7F, 0x87, 0xE1, 0xFF, 0x93, 0xC6, 0x1F, 0xC3,
  0xC8, 0x0F, 0x87, 0x90, 0x0F, 0x07, 0x20, 0x0E, 0x0F, 0xC0, 0x1C, 0x0C,
  0x80, 0x3C, 0x11, 0xFC, 0x38, 0x41, 0xF8, 0x71, 0x80, 0xD0, 0xC6, 0x00,
  0x21, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x04, 0x78, 0x00, 0x18, 0xF0, 0x3E,
  0x20, 0xF0, 0xFC, 0x81, 0xFC, 0x3E, 0x01, 0xE0, 0x38, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x06, 0x7F, 0x83,
  0x01, 0xF8, 0xC0, 0x0F, 0xB8, 0x00, 0xF7, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x1D, 0xFC, 0x01, 0x9F, 0xC0, 0x30, 0x78, 0x06, 0x02, 0x00, 0xC4,
  0x80, 0x13, 0xE0, 0x02, 0xFF, 0x00, 0x83, 0xF0, 0x20, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x20, 0x1F, 0xE0, 0x60, 0x3F, 0xF1,
  0xE0, 0x60, 0xF7, 0xE0, 0x40, 0x79, 0xF0, 0xC0, 0x78, 0xF8, 0x80, 0x38,
  0x7C, 0x80, 0x38, 0x3E, 0x40, 0x38, 0x1F, 0x20, 0x38, 0x0F, 0x1F, 0x38,
  0x07, 0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x00, 0x18,
  0x02, 0x00, 0x78, 0x02, 0x00, 0xFE, 0x04, 0x01, 0xFF, 0x88, 0x02, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x80, 0x19, 0xFE, 0x03, 0x01, 0xF8, 0x30, 0x03, 0xE3, 0x80,
  0x0F, 0x1C, 0x00, 0x3C, 0xF8, 0x00, 0xE7, 0xF0, 0x07, 0x1F, 0xC0, 0x18,
  0x7F, 0x00, 0xC0, 0x78, 0x06, 0x00, 0x80, 0x20, 0x48, 0x09, 0x0F, 0x81,
  0xF8, 0xFF, 0x1F, 0x88, 0xFD, 0x1F, 0x83, 0xFF, 0xF8, 0x07, 0xF1, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x1F, 0xC3, 0xF0, 0x7F,
  0xF2, 0xF8, 0x63, 0xF4, 0x78, 0xC0, 0xF8, 0x3C, 0x80, 0x78, 0x3C, 0x80,
  0x3C, 0x1F, 0x80, 0x1C, 0x0C, 0x80, 0x1C, 0x10, 0x80, 0x1C, 0x60, 0x40,
  0x1D, 0xE0, 0x3B, 0x1F, 0xF0, 0x04, 0x1C, 0xF0, 0x00, 0x18, 0x78, 0x00,
  0x18, 0x78, 0x08, 0x10, 0x78, 0x1E, 0x10, 0x7C, 0x3F, 0x20, 0x3D, 0x0F,
  0xC0, 0x3E, 0x07, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x1F, 0x82, 0x07, 0xFF,
  0xC1, 0x83, 0xF8, 0x30, 0x0F, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0xF0, 0xC0, 0x3F, 0x8C, 0x4F, 0xFC, 0xC3, 0xF8, 0x2C, 0x1F, 0x02, 0xE0,
  0x80, 0x2E, 0x00, 0x02, 0xF0, 0x00, 0x27, 0xC0, 0x06, 0x3F, 0x01, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x01,
  0x83, 0xF8, 0x60, 0x1F, 0x98, 0x05, 0xFD, 0x01, 0x0F, 0x20, 0x60, 0x04,
  0x1E, 0x00, 0x83, 0xE0, 0x0C, 0xBE, 0x00, 0x63, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x78, 0x30, 0x1F, 0x8C, 0x04, 0xFA, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x08, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x01, 0x90, 0x1C,
  0x61, 0x0E, 0x1C, 0x27, 0xC3, 0x88, 0x78, 0x78, 0x0F, 0x0F, 0x81, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x01, 0x83, 0xC0,
  0x60, 0x78, 0x08, 0x0F, 0x02, 0x01, 0xE0, 0xF0, 0x3C, 0x3F, 0x0F, 0x99,
  0xF6, 0xFC, 0x1F, 0x8F, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x7F, 0xCB, 0xC1, 0xFF, 0xE3, 0xC6, 0x07, 0xC3, 0xC8,
  0x07, 0x87, 0x90, 0x0F, 0x07, 0xA0, 0x0E, 0x04, 0x40, 0x1C, 0x10, 0x80,
  0x38, 0x60, 0x82, 0x61, 0xE0, 0xF8, 0xC3, 0xE0, 0x03, 0x03, 0xE0, 0x04,
  0x07, 0xC0, 0x30, 0x07, 0x81, 0xF0, 0x07, 0x0F, 0xF0, 0x06, 0x23, 0xF0,
  0x08, 0x03, 0xF8, 0x20, 0x01, 0xFC, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x06, 0x1E, 0x03, 0xFC, 0xF6, 0xF8, 0x7F, 0xF0, 0x87, 0x8E,
  0x1F, 0x18, 0x3C, 0xC0, 0x79, 0x83, 0xC8, 0x07, 0xB8, 0x1E, 0x80, 0x3B,
  0x80, 0xC8, 0x03, 0xBC, 0x08, 0x80, 0x3B, 0xE1, 0x84, 0x13, 0x1E, 0x38,
  0x36, 0x30, 0xE3, 0xE0, 0x82, 0x0F, 0x3F, 0x00, 0x40, 0x71, 0xF0, 0x08,
  0x06, 0x0F, 0x0F, 0x80, 0x60, 0x71, 0xFC, 0x06, 0x03, 0x27, 0xE0, 0xF0,
  0x20, 0x1F, 0x1F, 0xC4, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0x83, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x81, 0x81, 0xFC, 0x3E, 0x3F, 0xE7, 0xE7, 0x0F,
  0x5C, 0x60, 0x78, 0x04, 0x07, 0x80, 0x40, 0x38, 0x04, 0x03, 0x80, 0x20,
  0x7F, 0x81, 0x2F, 0xF8, 0x0C, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1C, 0x9E, 0x01, 0xF9, 0xFE,
  0x3F, 0x8F, 0xC4, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x83, 0xFE,
  0x7F, 0x1F, 0xFE, 0x3C, 0xC0, 0xF8, 0x7A, 0x01, 0xE1, 0xE8, 0x07, 0x87,
  0xE0, 0x0E, 0x0E, 0x80, 0x38, 0x12, 0x00, 0xE1, 0x84, 0x13, 0x0E, 0x0F,
  0x8C, 0x38, 0x00, 0x20, 0xF0, 0x01, 0x83, 0xC0, 0x04, 0x0F, 0x80, 0x20,
  0x1E, 0x01, 0x80, 0x7C, 0x0F, 0x98, 0xF0, 0x7F, 0x83, 0xC0, 0x7E, 0x0E,
  0x00, 0x70, 0x38, 0x20, 0x00, 0xC0, 0x40, 0x06, 0x00, 0xC0, 0x30, 0x00,
  0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xC1, 0xF0, 0x60, 0x1E, 0x10,
  0x07, 0x84, 0x00, 0xC1, 0x80, 0x30, 0x20, 0x18, 0x07, 0x0C, 0x00, 0x07,
  0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xCF, 0x80, 0x67, 0xF0, 0x18, 0x3E, 0x04, 0x07,
  0xC2, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x08, 0x07, 0x01,
  0xE0, 0xFC, 0x63, 0x30, 0x68, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xCC,
  0xE6, 0x21, 0x04, 0x01, 0xC0, 0x7E, 0x13, 0xE6, 0x19, 0x83, 0x30, 0x66,
  0x0C, 0xE1, 0x9C, 0x33, 0x8E, 0x39, 0xF7, 0xDE, 0x63, 0x88, 0x20, 0x0E,
  0x16, 0x02, 0xC0, 0x38, 0x07, 0x00, 0xE2, 0x1C, 0xE3, 0xFE, 0x71, 0xCE,
  0x3D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0x9C, 0x33, 0x84, 0xFD, 0x07, 0xC0,
  0x30, 0x02, 0x00, 0x0E, 0x3E, 0x67, 0x47, 0xC4, 0xC0, 0xC0, 0xE0, 0xE0,
  0xE0, 0xF0, 0x78, 0x7F, 0x1C, 0x10, 0xE0, 0x10, 0x03, 0x00, 0x7C, 0x0F,
  0xE0, 0x7E, 0x03, 0xE0, 0x5E, 0x71, 0xEE, 0x1D, 0xC3, 0xB8, 0x37, 0x06,
  0xE0, 0xDC, 0x13, 0xC6, 0xFC, 0x83, 0xE0, 0x30, 0x00, 0x0E, 0x1F, 0x19,
  0x88, 0xEC, 0x76, 0x1B, 0x31, 0xE0, 0xE0, 0x70, 0x3C, 0x0F, 0x07, 0xF0,
  0xE0, 0x40, 0x00, 0x1D, 0x3F, 0x26, 0x40, 0x20, 0x30, 0xFE, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x00, 0x00, 0x80, 0x3C, 0x0F, 0xE2, 0x3E, 0xC3, 0xB8,
  0x26, 0x0C, 0xE1, 0x9C, 0x33, 0x87, 0x70, 0xE7, 0x1C, 0xFF, 0xCC, 0x39,
  0x07, 0x00, 0xC8, 0x1B, 0x82, 0x38, 0x81, 0xE0, 0x00, 0x03, 0xE2, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x43, 0xBC, 0x7B, 0x8E, 0x39, 0xC7, 0x38,
  0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xCE, 0x9B, 0xE6, 0x18, 0x82,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1C, 0x70, 0x60, 0x00, 0x06,
  0x1E, 0x3E, 0xB8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3E, 0x38, 0x70,
  0x00, 0x0C, 0x1C, 0x1C, 0x08, 0x00, 0x10, 0x18, 0x3C, 0x5E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x32, 0xE0, 0x00, 0x1E, 0x65, 0x97, 0x6F, 0xDE, 0x3F, 0xFE, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xF0, 0xC1, 0x00, 0x02, 0x1A, 0xC5,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xFF, 0xF0, 0xC1, 0x00, 0x00, 0x00, 0x18, 0x63, 0x0F, 0x3D, 0xF3, 0xF7,
  0x9E, 0x39, 0xC7, 0x0E, 0x31, 0xC3, 0x8C, 0x70, 0xE3, 0x1C, 0x38, 0xC7,
  0x0E, 0x31, 0xC3, 0x8C, 0x70, 0xE7, 0x1C, 0x79, 0xE7, 0xCE, 0x78, 0xE3,
  0x0C, 0x18, 0x82, 0x00, 0x61, 0x07, 0x38, 0xF7, 0xF3, 0x8E, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0xC7, 0x8F, 0x78, 0xF3,
  0x06, 0x20, 0x20, 0x03, 0x03, 0xF1, 0xDE, 0x39, 0xE7, 0x1C, 0xE3, 0xDC,
  0x3B, 0x87, 0x70, 0xEE, 0x19, 0xE2, 0x7E, 0x81, 0xE0, 0x18, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0F, 0x08, 0x79, 0xC7, 0xFE, 0x38, 0xE3, 0x8F,
  0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0x6F, 0x84, 0xFE, 0x81, 0xF0,
  0x1E, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x1C, 0x0F, 0xE3, 0x3E, 0x43, 0x98, 0x73, 0x0E, 0x60, 0xDC,
  0x19, 0xC3, 0x38, 0x67, 0x9C, 0x7D, 0x86, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x62, 0x7B, 0xBF, 0xC7, 0x73, 0x21, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0F, 0x83, 0xC0, 0xC0, 0x00, 0x0F, 0x00, 0x20,
  0x04, 0x61, 0x3F, 0xD3, 0xE8, 0x33, 0x08, 0xE7, 0x3F, 0xE7, 0x38, 0x87,
  0x40, 0xBC, 0x4F, 0xF0, 0xF8, 0x0C, 0x00, 0x00, 0x02, 0x02, 0x04, 0x0C,
  0x18, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D,
  0x7E, 0x0C, 0x08, 0x00, 0x86, 0x0C, 0xF1, 0xEF, 0x1E, 0x30, 0xE3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x79, 0xF3, 0xEF,
  0x08, 0x60, 0x00, 0x60, 0x04, 0x08, 0xC1, 0x8E, 0x3C, 0xFD, 0xE7, 0x8E,
  0x78, 0xF3, 0x87, 0x18, 0x71, 0x87, 0x18, 0x61, 0x06, 0x18, 0x43, 0xC8,
  0x5F, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0E, 0x18, 0x23,
  0xC7, 0x3C, 0x7F, 0xF7, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x38,
  0xE1, 0xCE, 0x38, 0x63, 0x8E, 0x18, 0xE3, 0x86, 0x38, 0xE3, 0x1E, 0x7F,
  0x03, 0xC7, 0x80, 0xC0, 0x60, 0x10, 0x10, 0x00, 0x20, 0x18, 0x9E, 0xF7,
  0xF3, 0x99, 0xC8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x23, 0xE3, 0xE2,
  0x31, 0x00, 0x80, 0x40, 0x10, 0xC7, 0xE0, 0x00, 0x40, 0x08, 0x00, 0xC0,
  0x0F, 0x18, 0xF3, 0x87, 0xDC, 0x31, 0xE3, 0x0E, 0x30, 0xE3, 0x0E, 0x38,
  0x73, 0x86, 0x38, 0x63, 0x86, 0x7E, 0xC7, 0xCC, 0x18, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x10, 0x38, 0x7C, 0x9C, 0x0C, 0x08, 0x10,
  0x23, 0xFC, 0x3C, 0x3E, 0x4E, 0x47, 0x87, 0x87, 0x86, 0x86, 0x86, 0x84,
  0x78, 0x02, 0x18, 0x61, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x61, 0x86, 0x06,
  0x06, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x81, 0x81, 0x80, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xC0, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0x60, 0x60, 0x31, 0x86, 0x0C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x0C, 0x20,
  0x00, 0xFF, 0xFF, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 20, 7, 1, -20 },
  { 14, 9, 8, 11, 1, -20 },
  { 23, 12, 16, 14, 1, -18 },
  { 47, 10, 22, 12, 1, -21 },
  { 75, 18, 20, 20, 1, -20 },
  { 120, 14, 17, 16, 1, -17 },
  { 150, 5, 8, 6, 0, -20 },
  { 155, 7, 23, 7, 0, -22 },
  { 176, 7, 23, 7, 0, -22 },
  { 197, 9, 11, 10, 0, -21 },
  { 210, 9, 10, 11, 1, -14 },
  { 222, 5, 7, 5, 0, -4 },
  { 227, 7, 5, 8, 1, -11 },
  { 232, 5, 4, 6, 0, -4 },
  { 235, 13, 22, 15, 1, -21 },
  { 271, 13, 20, 13, 0, -20 },
  { 304, 9, 19, 9, 0, -19 },
  { 326, 12, 19, 13, 0, -19 },
  { 355, 13, 19, 13, 0, -19 },
  { 386, 12, 19, 13, 0, -19 },
  { 415, 13, 19, 13, 0, -19 },
  { 446, 12, 20, 13, 0, -20 },
  { 476, 12, 19, 12, 0, -19 },
  { 505, 12, 20, 13, 0, -20 },
  { 535, 12, 20, 13, 0, -20 },
  { 565, 5, 13, 6, 0, -13 },
  { 574, 5, 16, 5, 0, -13 },
  { 584, 8, 10, 8, 0, -13 },
  { 594, 9, 6, 11, 1, -11 },
  { 601, 8, 10, 8, 0, -13 },
  { 611, 11, 20, 13, 1, -20 },
  { 639, 17, 17, 17, 0, -13 },
  { 676, 21, 21, 23, 1, -20 },
  { 732, 24, 21, 25, 0, -20 },
  { 795, 18, 20, 19, 1, -20 },
  { 840, 21, 21, 23, 1, -20 },
  { 896, 18, 20, 20, 1, -20 },
  { 941, 21, 24, 21, 0, -21 },
  { 1004, 20, 21, 22, 1, -20 },
  { 1057, 20, 26, 21, 0, -22 },
  { 1122, 19, 23, 19, 0, -20 },
  { 1177, 19, 27, 20, 0, -20 },
  { 1242, 22, 21, 23, 0, -20 },
  { 1300, 15, 21, 16, 0, -20 },
  { 1340, 29, 21, 31, 1, -20 },
  { 1417, 23, 21, 25, 1, -20 },
  { 1478, 19, 21, 21, 1, -20 },
  { 1528, 24, 25, 25, 0, -20 },
  { 1603, 21, 22, 22, 1, -20 },
  { 1661, 24, 20, 26, 1, -20 },
  { 1721, 20, 20, 21, 1, -20 },
  { 1771, 19, 20, 21, 1, -20 },
  { 1819, 19, 22, 20, 0, -20 },
  { 1872, 23, 21, 25, 1, -20 },
  { 1933, 28, 21, 30, 1, -20 },
  { 2007, 20, 20, 20, 0, -20 },
  { 2057, 22, 25, 24, 1, -21 },
  { 2126, 18, 23, 19, 0, -20 },
  { 2178, 4, 22, 5, 0, -21 },
  { 2189, 17, 19, 3, -5, -18 },
  { 2230, 4, 22, 5, 0, -21 },
  { 2241, 10, 8, 12, 1, -20 },
  { 2251, 13, 2, 13, 0, 3 },
  { 2255, 4, 6, 14, 5, -20 },
  { 2258, 11, 15, 13, 1, -14 },
  { 2279, 11, 20, 12, 1, -19 },
  { 2307, 8, 15, 10, 1, -14 },
  { 2322, 11, 19, 13, 1, -19 },
  { 2349, 9, 15, 10, 1, -14 },
  { 2366, 8, 25, 7, 0, -21 },
  { 2391, 11, 21, 13, 1, -15 },
  { 2420, 11, 25, 12, 1, -20 },
  { 2455, 7, 20, 8, 0, -19 },
  { 2473, 8, 25, 7, -1, -20 },
  { 2498, 7, 21, 9, 1, -20 },
  { 2517, 7, 21, 8, 1, -20 },
  { 2536, 18, 16, 20, 1, -15 },
  { 2572, 12, 15, 14, 1, -14 },
  { 2595, 11, 15, 12, 0, -14 },
  { 2616, 12, 23, 13, 0, -17 },
  { 2651, 11, 21, 12, 0, -15 },
  { 2680, 9, 15, 10, 1, -14 },
  { 2697, 10, 18, 12, 1, -17 },
  { 2720, 8, 19, 9, 0, -18 },
  { 2739, 12, 16, 14, 1, -15 },
  { 2763, 12, 17, 13, 0, -16 },
  { 2789, 18, 17, 19, 1, -16 },
  { 2828, 9, 21, 11, 1, -15 },
  { 2852, 12, 22, 13, 1, -17 },
  { 2885, 8, 20, 9, 1, -15 },
  { 2905, 7, 23, 9, 1, -22 },
  { 2926, 2, 23, 4, 1, -22 },
  { 2932, 7, 23, 9, 1, -22 },
  { 2953, 9, 2, 10, 1, -9 },
};

const GFXfont UnifrakturMaguntia_Regular28pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular28pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular28pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR28PT7B_H_
