#ifndef _UNIFRAKTURMAGUNTIA_REGULAR19PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0x46, 0x76, 0x62, 0x22, 0x40, 0x04, 0x72, 0x00, 0xC9, 0xB9, 0x12,
  0x49, 0x00, 0x36, 0x36, 0x26, 0xFF, 0x24, 0x24, 0xFF, 0x6C, 0x6C, 0x48,
  0x21, 0xCC, 0xA1, 0xCF, 0x87, 0x0E, 0x9E, 0x38, 0x63, 0x78, 0x82, 0x00,
  0x60, 0x0D, 0x03, 0x98, 0x29, 0x84, 0x98, 0x89, 0x90, 0xD2, 0x06, 0x4E,
  0x09, 0xB1, 0x1B, 0x11, 0xB2, 0x1B, 0x41, 0xB8, 0x0E, 0x1C, 0x1A, 0x09,
  0x06, 0x83, 0x81, 0x9D, 0x65, 0x32, 0xCD, 0x67, 0x31, 0x8F, 0x70, 0x0F,
  0x94, 0x80, 0x11, 0x18, 0xC4, 0x63, 0x18, 0xC6, 0x10, 0x86, 0x10, 0xC0,
  0x41, 0x08, 0x63, 0x18, 0xC6, 0x39, 0x8C, 0x63, 0x10, 0x98, 0x20, 0xCD,
  0xFF, 0xFF, 0x73, 0x08, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x5D, 0x94,
  0x3D, 0x27, 0x00, 0x4F, 0x00, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x02, 0x00, 0x1C, 0x1B,
  0x18, 0xCC, 0x66, 0x37, 0x1F, 0x8F, 0xC7, 0x63, 0x31, 0x98, 0xC4, 0x41,
  0xC0, 0x10, 0xC7, 0x2C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x7C, 0x3E,
  0x47, 0x83, 0x03, 0x03, 0x07, 0x06, 0x0C, 0x18, 0x11, 0x21, 0x7F, 0xFF,
  0x3E, 0x23, 0x80, 0xC0, 0x60, 0x60, 0x70, 0x7C, 0x06, 0x03, 0xE1, 0xB8,
  0xCC, 0x43, 0xC0, 0x04, 0x0C, 0x1C, 0x1C, 0x2C, 0x4C, 0x4C, 0x8C, 0xFF,
  0x0C, 0x0C, 0x0E, 0x1F, 0x3F, 0x1E, 0x10, 0x08, 0x07, 0xC3, 0xF9, 0x0C,
  0x06, 0x01, 0xA0, 0xB8, 0xCC, 0x43, 0xC0, 0x1C, 0x36, 0x23, 0x63, 0x60,
  0x6C, 0x73, 0xE3, 0xE3, 0x63, 0x63, 0x63, 0x22, 0x1C, 0x7F, 0x81, 0x82,
  0x02, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x70, 0x3E, 0x41,
  0x41, 0x63, 0x7A, 0x3C, 0x2E, 0x43, 0xC1, 0xC1, 0xC1, 0x63, 0x3C, 0x1C,
  0x26, 0x67, 0x63, 0xE3, 0xE3, 0x63, 0x6F, 0x33, 0x03, 0x63, 0x66, 0x66,
  0x3C, 0x5D, 0x00, 0x13, 0xC0, 0x5D, 0x00, 0x17, 0x65, 0x00, 0x08, 0x99,
  0x86, 0x08, 0x20, 0xFE, 0x00, 0x07, 0xF0, 0x83, 0x0C, 0x33, 0x32, 0x00,
  0x79, 0x1A, 0x1E, 0x3C, 0x63, 0x9E, 0x20, 0x44, 0xD0, 0xE0, 0x83, 0x82,
  0x00, 0x0F, 0x86, 0x19, 0x81, 0x23, 0xD4, 0xD3, 0xB2, 0x76, 0xD6, 0xBA,
  0x5B, 0xAC, 0x0C, 0xC3, 0x0F, 0x80, 0x04, 0x00, 0x7E, 0x19, 0x1E, 0xE4,
  0x1C, 0xC8, 0x19, 0x98, 0x33, 0x1C, 0x66, 0x1C, 0x8C, 0x0A, 0x18, 0x08,
  0x30, 0x30, 0x60, 0xF0, 0xC2, 0x7F, 0xE0, 0x73, 0x80, 0x1E, 0x18, 0x3F,
  0x7C, 0x63, 0xCE, 0xC1, 0x8E, 0x81, 0x87, 0x80, 0x84, 0x40, 0x9E, 0x2D,
  0x2F, 0x11, 0x03, 0x06, 0x03, 0x0F, 0x01, 0x37, 0x83, 0x03, 0xC2, 0x01,
  0xFC, 0x0C, 0x40, 0x97, 0xC8, 0xD8, 0xC8, 0x06, 0xE0, 0x37, 0x81, 0x9E,
  0x0C, 0x78, 0x71, 0xC3, 0x86, 0x0E, 0x20, 0x7A, 0x01, 0xE1, 0x87, 0xF0,
  0x07, 0x80, 0x3F, 0xE0, 0xE3, 0xE3, 0x11, 0xE4, 0x61, 0xD0, 0xE1, 0xA1,
  0xE1, 0xC1, 0xC3, 0x61, 0x82, 0x39, 0x04, 0x04, 0x10, 0xF8, 0x22, 0xFC,
  0x80, 0x7E, 0x00, 0x00, 0x00, 0x0E, 0x40, 0x97, 0xC8, 0xD8, 0xC8, 0x06,
  0xE0, 0x37, 0xB1, 0x9F, 0xEC, 0x7C, 0x61, 0xC3, 0x86, 0x0E, 0x20, 0x7A,
  0x01, 0xF1, 0x87, 0xF0, 0x0F, 0x80, 0xFF, 0xC6, 0x0F, 0xD0, 0x4C, 0x81,
  0x02, 0x0C, 0x08, 0x39, 0x90, 0x77, 0x3D, 0xE8, 0x03, 0x83, 0x07, 0x06,
  0x1C, 0x18, 0x70, 0x61, 0x81, 0x86, 0x06, 0x30, 0x07, 0x80, 0x06, 0x20,
  0x65, 0x83, 0x1F, 0x98, 0x8F, 0x66, 0x11, 0x98, 0xC6, 0x7F, 0x98, 0xE7,
  0x63, 0x8D, 0xC6, 0x37, 0x18, 0xCE, 0x42, 0x1A, 0x10, 0x38, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x78, 0x06, 0x78, 0x10, 0x00, 0xC1, 0x03,
  0x8E, 0x07, 0x7C, 0x1E, 0x38, 0x38, 0x60, 0x71, 0x80, 0xC6, 0x72, 0x1B,
  0xE8, 0x61, 0xC1, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0x81, 0x0E,
  0x10, 0x3C, 0x80, 0x84, 0x0C, 0x20, 0x60, 0x83, 0x03, 0xDC, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x60, 0x67, 0xC3, 0x4F, 0x10, 0x3F, 0x00, 0x1F, 0x81,
  0x0E, 0x10, 0x3C, 0x80, 0x84, 0x0C, 0x20, 0x60, 0x83, 0x83, 0xDC, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x09, 0xE0, 0x53, 0x84,
  0x0F, 0x40, 0x1C, 0x00, 0x00, 0x80, 0x0E, 0xF0, 0x30, 0x10, 0xCF, 0x21,
  0xA7, 0x23, 0x86, 0x47, 0x0E, 0x8F, 0x12, 0x0E, 0x68, 0x0F, 0xE0, 0x0C,
  0xC3, 0x91, 0xCF, 0xA1, 0xE7, 0x83, 0x80, 0x1F, 0x8C, 0x36, 0x05, 0xC1,
  0x70, 0xCE, 0x33, 0xF0, 0x60, 0x10, 0x0C, 0x07, 0xC6, 0x79, 0x0F, 0x80,
  0x3E, 0x79, 0xC3, 0xFC, 0xF3, 0x20, 0xE3, 0x19, 0x03, 0x9C, 0xE8, 0x1C,
  0xE7, 0x40, 0x63, 0x21, 0xF3, 0x19, 0x00, 0x98, 0x90, 0x00, 0x85, 0x80,
  0x04, 0x2E, 0x06, 0x52, 0x30, 0xFD, 0xE1, 0xE1, 0xF7, 0x06, 0x00, 0x00,
  0x00, 0x3E, 0x3C, 0x7F, 0xCE, 0x83, 0x86, 0x81, 0xC6, 0x80, 0xC7, 0x80,
  0xC4, 0x7C, 0xC8, 0x04, 0xC8, 0x00, 0x98, 0x00, 0x98, 0x39, 0x1C, 0x5D,
  0x0F, 0x0E, 0x06, 0x02, 0x00, 0x0F, 0x00, 0xFE, 0x0C, 0x3C, 0x60, 0x39,
  0x80, 0x67, 0x80, 0xDF, 0x03, 0x1E, 0x0C, 0x10, 0x23, 0x80, 0x9F, 0x04,
  0x9E, 0x20, 0x1F, 0x00, 0x3E, 0x18, 0x33, 0xBC, 0x20, 0xEF, 0x10, 0x73,
  0xC8, 0x18, 0xF4, 0x0C, 0x39, 0xB6, 0x0C, 0x23, 0x02, 0x01, 0x81, 0x00,
  0xC0, 0x81, 0xF0, 0x81, 0x7E, 0x80, 0x1F, 0x80, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x3F, 0x81, 0x87, 0x84, 0x03, 0x8C,
  0x03, 0x1E, 0x03, 0x3E, 0x06, 0x1E, 0x0C, 0x08, 0x10, 0xE1, 0xA3, 0xE7,
  0x89, 0xE3, 0xE1, 0xFB, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x9E, 0x1F,
  0xF3, 0x88, 0x78, 0xE8, 0x1C, 0x7C, 0x06, 0x12, 0x03, 0x10, 0x81, 0xB8,
  0x3C, 0xEC, 0x00, 0x67, 0x00, 0x23, 0x83, 0x11, 0xC3, 0xD0, 0x78, 0x70,
  0x38, 0x01, 0x00, 0x1F, 0x21, 0x9F, 0x08, 0x18, 0x40, 0x01, 0x01, 0x85,
  0x1F, 0x93, 0xF2, 0x43, 0x05, 0x80, 0x17, 0x00, 0x8F, 0x06, 0x1F, 0xF0,
  0x3F, 0x80, 0x1F, 0x81, 0x8F, 0x88, 0x2F, 0xE1, 0x8C, 0x86, 0x01, 0x1E,
  0x03, 0xBC, 0x00, 0x70, 0x38, 0xC1, 0xF4, 0x01, 0xE0, 0x03, 0xC6, 0x03,
  0xE0, 0x1C, 0x19, 0x13, 0x9D, 0x38, 0xE0, 0xC3, 0x86, 0x0E, 0x30, 0x71,
  0x81, 0x0C, 0x10, 0x61, 0x83, 0x1E, 0x39, 0x3E, 0xF0, 0xE3, 0x00, 0x00,
  0x0C, 0x10, 0x3F, 0x7C, 0x67, 0x8C, 0x81, 0x8E, 0x81, 0x85, 0x80, 0x84,
  0x40, 0x8C, 0x3D, 0x8E, 0x01, 0x0F, 0x02, 0x07, 0x0F, 0x03, 0x37, 0x82,
  0x03, 0xC4, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF6, 0xF8, 0x67, 0x91, 0xC4,
  0x19, 0x0C, 0x81, 0xB0, 0xE8, 0x0B, 0x84, 0x40, 0x98, 0xC2, 0xD9, 0xCE,
  0x11, 0x0C, 0xF0, 0x20, 0xC7, 0x1E, 0x08, 0x32, 0xF0, 0xC2, 0x07, 0xBF,
  0x40, 0x3C, 0x78, 0x10, 0x01, 0xF3, 0xD9, 0xDE, 0x87, 0x08, 0x18, 0x40,
  0xC1, 0x0F, 0xC7, 0xFC, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x6B, 0x83, 0xCF,
  0xAC, 0x30, 0x0C, 0x18, 0x3F, 0x7C, 0x67, 0x8E, 0x81, 0x8E, 0x81, 0x87,
  0x80, 0x84, 0x40, 0x8C, 0x3D, 0x9C, 0x01, 0x1C, 0x02, 0x0E, 0x02, 0x0E,
  0x07, 0x66, 0x0F, 0xC6, 0x03, 0x86, 0x10, 0x0C, 0x0C, 0x08, 0x03, 0xF0,
  0x0F, 0xC1, 0x0E, 0x20, 0x62, 0x06, 0x20, 0x61, 0x88, 0x03, 0xE0, 0x4F,
  0x00, 0x70, 0x03, 0x00, 0x37, 0x03, 0xB8, 0x21, 0xE4, 0x0F, 0x80, 0x00,
  0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB8, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0xF8, 0x10, 0x30, 0xF2, 0x38,
  0x20, 0xFF, 0x80, 0xC8, 0x80, 0x08, 0x1C, 0x2F, 0x66, 0x46, 0x46, 0xE6,
  0x66, 0x77, 0x3B, 0x00, 0x18, 0xA0, 0x60, 0x64, 0x26, 0x3E, 0x23, 0x23,
  0x23, 0x23, 0x62, 0x7C, 0x18, 0x00, 0x08, 0xE4, 0xD2, 0x41, 0x06, 0x18,
  0x70, 0xF0, 0x60, 0x40, 0xF0, 0x7C, 0x1E, 0x27, 0x63, 0x21, 0x21, 0x21,
  0x72, 0x3A, 0x1C, 0x08, 0xE4, 0xD3, 0x49, 0xC6, 0x18, 0x74, 0xE0, 0x3D,
  0x64, 0x10, 0xF9, 0x86, 0x18, 0x61, 0x82, 0x08, 0x20, 0x82, 0x08, 0x40,
  0x08, 0x1C, 0x2F, 0x62, 0x42, 0x46, 0x66, 0x66, 0x67, 0x3B, 0x03, 0x03,
  0x62, 0x3C, 0x9C, 0xB0, 0x60, 0x64, 0x6E, 0x76, 0x63, 0x63, 0x63, 0x63,
  0x63, 0x7A, 0x32, 0x04, 0x08, 0x30, 0x31, 0x00, 0x86, 0x79, 0x8C, 0x21,
  0x08, 0x73, 0x00, 0x19, 0x88, 0x43, 0xB8, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xFD, 0x1E, 0xD7, 0xCC, 0x7E, 0xC3, 0x0C, 0x30, 0xC3, 0x1E, 0x10, 0x1E,
  0xC6, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x1E, 0x10, 0x44, 0x43, 0x37,
  0x2E, 0xCC, 0x66, 0x63, 0x33, 0x19, 0x98, 0xCC, 0xC6, 0x66, 0x77, 0x39,
  0x11, 0x80, 0x44, 0x33, 0x2F, 0xC6, 0x63, 0x31, 0x98, 0xCC, 0x66, 0x73,
  0x91, 0x80, 0x08, 0x79, 0xB3, 0x36, 0x6C, 0x58, 0xB2, 0xF8, 0x20, 0xC0,
  0xC4, 0xEE, 0x76, 0x23, 0x23, 0x23, 0x23, 0xE2, 0xFC, 0x38, 0x20, 0x20,
  0x20, 0x20, 0x10, 0x1C, 0x2F, 0x46, 0x46, 0xC6, 0xC6, 0x66, 0x7E, 0x36,
  0x06, 0x06, 0x04, 0x04, 0x44, 0xDA, 0xF9, 0xA3, 0x06, 0x0C, 0x18, 0x78,
  0x20, 0x0C, 0x12, 0x12, 0x3E, 0x4E, 0x44, 0xEC, 0x7E, 0x42, 0x62, 0xFC,
  0x18, 0x08, 0x8C, 0xFB, 0x18, 0xC6, 0x31, 0x9E, 0x20, 0x42, 0x31, 0xAD,
  0xC6, 0x63, 0x31, 0x98, 0xCC, 0x66, 0x7F, 0x88, 0x80, 0x40, 0x84, 0xCE,
  0xF7, 0x63, 0x33, 0x23, 0x23, 0x22, 0x7C, 0x18, 0x40, 0x02, 0x01, 0x1D,
  0xD8, 0x77, 0x63, 0x33, 0x19, 0x8C, 0xCC, 0x46, 0x62, 0x33, 0x23, 0xBE,
  0x0C, 0x20, 0x00, 0x00, 0x24, 0xEC, 0xF9, 0xA3, 0x06, 0x0C, 0x18, 0x3C,
  0xB2, 0x04, 0x04, 0xC7, 0x00, 0x40, 0x32, 0x1F, 0x86, 0xE3, 0x31, 0x98,
  0xCC, 0x62, 0x33, 0x3D, 0x8C, 0x80, 0x80, 0x80, 0x80, 0x31, 0xE1, 0x84,
  0x2D, 0xE3, 0x97, 0x4E, 0x38, 0xE2, 0x70, 0x08, 0x8C, 0x63, 0x18, 0xC8,
  0xA1, 0x8C, 0x63, 0x18, 0x60, 0xFF, 0xFF, 0xC1, 0x0C, 0x63, 0x18, 0xC3,
  0x11, 0x8C, 0x63, 0x1B, 0x80, 0xFE,
};

const GFXglyph UnifrakturMaguntia_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 7, 6, 8, 0, -14 },
  { 14, 8, 10, 10, 1, -12 },
  { 24, 6, 15, 8, 1, -14 },
  { 36, 12, 14, 14, 1, -14 },
  { 57, 9, 12, 11, 1, -12 },
  { 71, 3, 6, 4, 0, -14 },
  { 74, 5, 15, 5, 0, -15 },
  { 84, 5, 16, 5, 0, -15 },
  { 94, 6, 8, 7, 0, -14 },
  { 100, 6, 7, 8, 1, -10 },
  { 106, 3, 5, 3, 0, -3 },
  { 108, 6, 3, 6, 0, -7 },
  { 111, 3, 3, 4, 0, -3 },
  { 113, 9, 15, 10, 1, -14 },
  { 130, 9, 13, 9, 0, -13 },
  { 145, 6, 13, 6, 0, -13 },
  { 155, 8, 13, 9, 0, -13 },
  { 168, 9, 13, 9, 0, -13 },
  { 183, 8, 13, 9, 0, -13 },
  { 196, 9, 13, 9, 0, -13 },
  { 211, 8, 14, 9, 0, -14 },
  { 225, 8, 13, 8, 0, -13 },
  { 238, 8, 13, 9, 0, -13 },
  { 251, 8, 14, 9, 0, -14 },
  { 265, 3, 9, 4, 0, -9 },
  { 269, 3, 11, 3, 0, -9 },
  { 274, 5, 7, 5, 0, -9 },
  { 279, 7, 4, 7, 0, -8 },
  { 283, 5, 7, 5, 0, -9 },
  { 288, 7, 14, 9, 1, -14 },
  { 301, 11, 12, 12, 0, -9 },
  { 318, 15, 14, 15, 0, -14 },
  { 345, 16, 14, 17, 0, -14 },
  { 373, 13, 14, 13, 0, -14 },
  { 396, 15, 15, 15, 0, -14 },
  { 425, 13, 14, 13, 0, -14 },
  { 448, 14, 17, 14, 0, -14 },
  { 478, 14, 15, 15, 0, -14 },
  { 505, 14, 18, 14, 0, -15 },
  { 537, 13, 15, 13, 0, -13 },
  { 562, 13, 18, 13, 0, -13 },
  { 592, 15, 14, 15, 0, -14 },
  { 619, 10, 13, 11, 0, -13 },
  { 636, 21, 14, 21, 0, -13 },
  { 673, 16, 13, 17, 0, -13 },
  { 699, 14, 14, 14, 0, -14 },
  { 724, 17, 16, 17, 0, -13 },
  { 758, 15, 15, 15, 0, -14 },
  { 787, 17, 14, 18, 0, -14 },
  { 817, 14, 14, 14, 0, -14 },
  { 842, 14, 13, 14, 0, -13 },
  { 865, 13, 14, 14, 0, -13 },
  { 888, 16, 14, 17, 0, -14 },
  { 916, 20, 14, 20, 0, -14 },
  { 951, 13, 14, 14, 0, -14 },
  { 974, 16, 17, 16, 0, -14 },
  { 1008, 12, 16, 13, 0, -13 },
  { 1032, 3, 15, 3, 0, -14 },
  { 1038, 12, 13, 2, -4, -12 },
  { 1058, 3, 15, 3, 0, -14 },
  { 1064, 7, 5, 8, 0, -13 },
  { 1069, 9, 1, 9, 0, 2 },
  { 1071, 3, 3, 10, 3, -13 },
  { 1073, 8, 11, 9, 0, -10 },
  { 1084, 8, 14, 8, 0, -13 },
  { 1098, 6, 10, 7, 0, -10 },
  { 1106, 8, 13, 9, 0, -13 },
  { 1119, 6, 10, 7, 0, -10 },
  { 1127, 6, 17, 5, 0, -13 },
  { 1140, 8, 14, 9, 0, -10 },
  { 1154, 8, 16, 8, 0, -13 },
  { 1170, 5, 13, 5, 0, -13 },
  { 1179, 5, 16, 5, -1, -13 },
  { 1189, 6, 13, 6, 0, -13 },
  { 1199, 6, 13, 5, 0, -13 },
  { 1209, 13, 10, 13, 0, -10 },
  { 1226, 9, 10, 10, 0, -10 },
  { 1238, 7, 10, 8, 0, -10 },
  { 1247, 8, 15, 9, 0, -11 },
  { 1262, 8, 14, 8, 0, -10 },
  { 1276, 7, 10, 7, 0, -10 },
  { 1285, 8, 12, 8, 0, -12 },
  { 1297, 5, 12, 6, 0, -12 },
  { 1305, 9, 10, 10, 0, -10 },
  { 1317, 8, 11, 9, 0, -11 },
  { 1328, 13, 12, 13, 0, -11 },
  { 1348, 7, 14, 7, 0, -10 },
  { 1361, 9, 14, 9, 0, -11 },
  { 1377, 6, 13, 6, 0, -10 },
  { 1387, 5, 15, 6, 0, -15 },
  { 1397, 1, 16, 3, 1, -15 },
  { 1399, 5, 15, 6, 0, -15 },
  { 1409, 7, 1, 7, 0, -6 },
};

const GFXfont UnifrakturMaguntia_Regular19pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular19pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular19pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR19PT7B_H_
