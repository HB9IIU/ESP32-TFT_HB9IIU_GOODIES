#ifndef _UNIFRAKTURMAGUNTIA_REGULAR35PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0xC7, 0xFF, 0x79, 0xE7, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0x41,
  0x08, 0x20, 0x00, 0x00, 0x30, 0xC7, 0xCC, 0x10, 0x00, 0x20, 0x43, 0x0C,
  0x79, 0xEF, 0x9F, 0x38, 0x71, 0x86, 0x10, 0x61, 0x04, 0x20, 0x44, 0x08,
  0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06, 0x38, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x0E, 0x30, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0x60,
  0x18, 0x60, 0x18, 0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x0F, 0x81,
  0x8C, 0x30, 0x66, 0x07, 0x60, 0x77, 0x07, 0x70, 0x77, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF4, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x76,
  0x07, 0x60, 0x62, 0x0E, 0x1F, 0xC0, 0x70, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x3C, 0x00, 0x0C, 0xCC, 0x00, 0x23, 0x9C, 0x00, 0xCE,
  0x38, 0x03, 0x1C, 0x78, 0x0C, 0x38, 0xF0, 0x30, 0x71, 0xE0, 0xC0, 0xE3,
  0xC1, 0x01, 0xC7, 0x04, 0x01, 0xCE, 0x10, 0x01, 0x98, 0x60, 0x01, 0xE1,
  0x8F, 0x00, 0x06, 0x33, 0x00, 0x18, 0xE7, 0x00, 0x21, 0xCE, 0x00, 0x87,
  0x9E, 0x02, 0x0F, 0x1C, 0x0C, 0x1E, 0x38, 0x30, 0x3C, 0x70, 0xC0, 0x79,
  0xE3, 0x00, 0x73, 0x8C, 0x00, 0xE7, 0x10, 0x00, 0xCC, 0x40, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xCC, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8C, 0x00, 0xF3, 0x00, 0x3D, 0x00, 0x0F, 0x80, 0x01, 0xE3, 0xF1, 0xFC,
  0x30, 0xFF, 0x0C, 0x73, 0xE2, 0x1C, 0xF8, 0x8F, 0x3F, 0x23, 0xC7, 0xD0,
  0xF1, 0xFC, 0x3C, 0x3E, 0x07, 0x07, 0xC5, 0xE1, 0xFE, 0x3C, 0x3F, 0x87,
  0xF3, 0xC0, 0x23, 0x3E, 0xF3, 0x9C, 0x46, 0x22, 0x00, 0x02, 0x18, 0x61,
  0x83, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x70, 0x60, 0x40, 0x40, 0x60, 0xE0,
  0x60, 0x40, 0xC1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0C, 0x18, 0x60, 0x86, 0x00,
  0x04, 0x00, 0xE0, 0x2F, 0x8E, 0x6F, 0x74, 0xE7, 0xDE, 0x06, 0x27, 0xFE,
  0x75, 0xEF, 0x6E, 0x2F, 0x90, 0xE0, 0x04, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x10, 0xC7, 0xCF, 0x18, 0x61, 0x04, 0x20, 0x01,
  0xCF, 0xE3, 0xF9, 0x00, 0x0F, 0x1F, 0xCF, 0xC0, 0x10, 0xE7, 0xCE, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xC0, 0x39, 0xC0, 0x61, 0xC1, 0xC3, 0xC7, 0x83, 0x8F, 0x07, 0xBE, 0x0F,
  0x7C, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3D, 0xF0, 0x79, 0xE0, 0xF3, 0xC1,
  0xC3, 0x83, 0x83, 0x0E, 0x07, 0x18, 0x03, 0xE0, 0x03, 0x00, 0xE0, 0x3C,
  0x0F, 0x83, 0xF0, 0xFE, 0x23, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0xE3, 0xFF, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9C, 0x3E,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x10, 0x80, 0x44, 0x01, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xC0, 0x43, 0xE1, 0x01, 0xE4, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x60, 0x1F, 0xC0, 0x3B, 0xC0, 0x77, 0x81,
  0xCF, 0x03, 0x0F, 0x0C, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x02, 0xF0, 0x04, 0xF0, 0x04, 0xF0, 0x08,
  0xF0, 0x10, 0xF0, 0x10, 0xF0, 0x20, 0xF0, 0x20, 0xF0, 0x40, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x20, 0x18, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFE, 0x02, 0xF0, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x2F, 0xC0,
  0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0x07, 0xC8, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3D, 0x00, 0x7F, 0x00, 0xEF, 0x01, 0xDE, 0x03,
  0x1C, 0x0C, 0x3C, 0x30, 0x1F, 0xC0, 0x07, 0xC0, 0x31, 0xC1, 0x87, 0x8E,
  0x1E, 0x38, 0x3D, 0xE0, 0xE7, 0x01, 0x1C, 0x00, 0xF0, 0x03, 0xC7, 0x8F,
  0x3F, 0x3D, 0x1E, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x39, 0xE0, 0xE3, 0x83, 0x07, 0x18,
  0x07, 0xC0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xB0, 0x06, 0x80, 0x12, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0x00, 0x39, 0xC0,
  0xC0, 0x43, 0x00, 0xC6, 0x01, 0x9C, 0x03, 0xBC, 0x06, 0x7C, 0x0C, 0x7C,
  0x30, 0xFE, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x06, 0x7F, 0x18, 0x3F,
  0x70, 0x3E, 0xC0, 0x3D, 0x80, 0x3B, 0x00, 0x76, 0x00, 0xEC, 0x01, 0xDC,
  0x03, 0x98, 0x0E, 0x18, 0x38, 0x0F, 0xC0, 0x0F, 0x80, 0x63, 0x83, 0x07,
  0x1C, 0x1C, 0x70, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7D, 0xE2, 0xF3, 0xF3, 0xC7, 0x8F, 0x00,
  0x38, 0x00, 0xE4, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xC7, 0x86, 0x0E,
  0x30, 0x1F, 0x00, 0x00, 0x43, 0x9F, 0x38, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x10, 0xE7, 0xCE, 0x10, 0x00, 0x00, 0x43, 0x9F, 0x38, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x10, 0xC7, 0xCF, 0x18, 0x61, 0x04, 0x20, 0x00, 0xC0, 0xC0,
  0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x7C, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0x80, 0xC0, 0x00, 0x0F, 0xC1, 0x87, 0x98, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x1D, 0xC0, 0xE4, 0x0F, 0x01, 0xF8, 0x7F, 0x87,
  0xF8, 0x7E, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x87, 0x04, 0x1C, 0x40, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x70, 0x0C, 0x01, 0x83, 0x80, 0x0C,
  0x30, 0x00, 0x46, 0x07, 0xE6, 0xE1, 0xDE, 0x6E, 0x39, 0xE6, 0xC7, 0x1C,
  0x6C, 0x71, 0xC6, 0xCE, 0x1C, 0xCC, 0xE3, 0x8C, 0xCE, 0x39, 0x8C, 0xE7,
  0xB0, 0xC7, 0xBE, 0x36, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x18,
  0x01, 0x80, 0xE0, 0x60, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x81, 0xFF,
  0x00, 0x70, 0xFF, 0xF0, 0x3C, 0x30, 0x3F, 0x1F, 0x84, 0x03, 0xF7, 0xE1,
  0x00, 0x3E, 0x3C, 0x20, 0x07, 0xC7, 0x84, 0x00, 0x78, 0xF0, 0x80, 0x0F,
  0x1E, 0x1C, 0x01, 0xE3, 0xC3, 0xF0, 0x3C, 0x78, 0x3F, 0x07, 0x0F, 0x03,
  0xF0, 0xE1, 0xE0, 0x1E, 0x38, 0x3C, 0x00, 0xC6, 0x07, 0x80, 0x11, 0x80,
  0xF0, 0x00, 0x60, 0x1E, 0x00, 0x18, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x01,
  0xF0, 0x0F, 0x00, 0x7F, 0x83, 0xE0, 0x37, 0xF8, 0xFE, 0xC0, 0x3F, 0xF7,
  0xF0, 0x03, 0xF8, 0x7C, 0x00, 0x3E, 0x07, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0x80, 0x3F, 0xF0, 0xFF, 0x03, 0xFF, 0xE4, 0x7E, 0x0F, 0x0F,
  0xD0, 0xF8, 0x70, 0x1F, 0x81, 0xE1, 0x80, 0x3E, 0x07, 0xC4, 0x00, 0x78,
  0x1F, 0x30, 0x01, 0xE0, 0x3E, 0xC0, 0x03, 0x80, 0x61, 0x00, 0x0E, 0x06,
  0x06, 0x00, 0x38, 0x7E, 0x18, 0x00, 0xE7, 0xFC, 0x38, 0x63, 0x3F, 0xF8,
  0x3E, 0x18, 0x07, 0xF0, 0x00, 0x40, 0x07, 0xC0, 0x02, 0x00, 0x0F, 0x00,
  0x10, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0xC0, 0x01, 0xC0, 0xFF,
  0x80, 0x06, 0x04, 0x7F, 0x00, 0x38, 0x00, 0xFE, 0x00, 0xC0, 0x01, 0xFE,
  0x06, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE1, 0xC0, 0x38, 0x4F, 0xD1, 0xC0, 0xFF, 0xCE, 0x02, 0x7E,
  0x38, 0x30, 0x21, 0xE1, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0xF1,
  0xF0, 0x03, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xF8, 0x7F,
  0x03, 0xE0, 0xFE, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0x81,
  0xF8, 0x0E, 0x03, 0xE0, 0x70, 0x07, 0xC1, 0x00, 0x1F, 0xD8, 0x00, 0x3F,
  0x80, 0x10, 0x7F, 0xC1, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0xF8, 0x33, 0xFC, 0x1C, 0x0C, 0x1F, 0xC7, 0x03, 0x00,
  0xF8, 0xC0, 0x70, 0x0F, 0x98, 0x1E, 0x00, 0xF2, 0x03, 0xE0, 0x0F, 0x40,
  0x7E, 0x01, 0xE8, 0x07, 0xE0, 0x1D, 0x00, 0xFE, 0x03, 0x90, 0x0F, 0xC0,
  0x33, 0x00, 0xF8, 0x06, 0x18, 0x8F, 0x00, 0xC0, 0xE0, 0xE0, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x00, 0x40, 0x3E, 0x00, 0x18, 0x0F, 0xF0, 0x02,
  0x07, 0xFF, 0x80, 0x81, 0x8F, 0xFE, 0x60, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xC0, 0x1C, 0x27, 0xE8,
  0x70, 0x3F, 0xF1, 0xC0, 0x4F, 0xC3, 0x83, 0x02, 0x0F, 0x0C, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xF0, 0x61, 0xE3, 0xF1, 0xE3, 0xC3,
  0xF7, 0xFF, 0xC3, 0xFB, 0xEF, 0x87, 0xF3, 0x9F, 0x07, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFC, 0x07, 0x00, 0xF8, 0x1C,
  0x00, 0xF8, 0x20, 0x01, 0xFD, 0x80, 0x01, 0xFC, 0x00, 0x81, 0xFF, 0x07,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xB3, 0xC0, 0xFF, 0xF3, 0x80, 0x0F,
  0xE1, 0x80, 0x11, 0xE1, 0x80, 0x18, 0x60, 0xC0, 0x1C, 0x00, 0x40, 0x0E,
  0x00, 0x20, 0x0F, 0x81, 0x18, 0x07, 0xE1, 0xC4, 0x01, 0xF9, 0xF2, 0x00,
  0xFD, 0xFC, 0x80, 0x3F, 0xB8, 0x30, 0xCF, 0xCC, 0x07, 0x87, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0x00, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x70, 0x0F, 0x00,
  0x7C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x70, 0x03, 0xC0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x30,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x60, 0x03, 0x84, 0x78, 0x03, 0x81,
  0x7E, 0x03, 0x80, 0xDF, 0x83, 0xC0, 0x87, 0xE1, 0xC1, 0x81, 0xF9, 0xE1,
  0x80, 0x70, 0xF1, 0xC0, 0x30, 0x78, 0xF0, 0x30, 0x78, 0x78, 0x3E, 0x3C,
  0x3E, 0x7F, 0x9F, 0x1F, 0xCF, 0xEF, 0x87, 0xE1, 0xF7, 0xC1, 0xF0, 0x7B,
  0xE0, 0x7C, 0x3F, 0xF0, 0x3E, 0x0F, 0x78, 0x0F, 0x07, 0xBE, 0x07, 0x83,
  0xDF, 0x01, 0x81, 0xC7, 0xC1, 0x80, 0xE1, 0xE1, 0x80, 0xE0, 0xF8, 0x00,
  0x70, 0x1E, 0x00, 0x70, 0x07, 0xC0, 0x60, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x0D, 0xF8, 0x00, 0x08, 0x3F, 0x00, 0x0C, 0x0F, 0x00,
  0x0E, 0x02, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x10, 0x03, 0xE0, 0x3C,
  0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x7F, 0xC0, 0x3F, 0x67, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0xE0, 0xE0, 0x3C, 0xF8,
  0x30, 0x1C, 0xFE, 0x30, 0x1E, 0x1F, 0xF0, 0x0E, 0x07, 0xF0, 0x07, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xF0, 0x0F, 0x0F, 0xF0, 0x30, 0x0F, 0xF9, 0x80, 0x1F, 0xC6, 0x00,
  0x1E, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x38,
  0x0C, 0x01, 0xE0, 0x10, 0x07, 0xC0, 0x30, 0x5F, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x03, 0x9F, 0xE0, 0x0E,
  0x9F, 0xC0, 0x30, 0x3F, 0x80, 0xC0, 0x7F, 0x06, 0x00, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xE1, 0xFE, 0x03, 0x00, 0xFF, 0x8C, 0x00, 0xFE, 0x18, 0x00,
  0x78, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x07, 0x01, 0x80, 0x0E,
  0x01, 0x00, 0x3E, 0x03, 0x00, 0x3C, 0x01, 0x82, 0x7C, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x63, 0xF8,
  0x00, 0xCF, 0xFC, 0x01, 0x81, 0xF8, 0x06, 0x01, 0xFC, 0x18, 0x01, 0xFC,
  0x60, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x01, 0xC3, 0xE0,
  0xC0, 0x3C, 0xFF, 0x0C, 0x03, 0x8F, 0xF8, 0x60, 0x39, 0x07, 0xC6, 0x07,
  0x90, 0x3C, 0x60, 0x7D, 0x03, 0xE6, 0x07, 0xE0, 0x3F, 0x60, 0x3F, 0x01,
  0xE6, 0x03, 0xF0, 0x08, 0x40, 0x1F, 0x83, 0x08, 0x01, 0xF8, 0xF9, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x81, 0xC1, 0xE0, 0x3E, 0x1C, 0x1F, 0x07, 0xF0, 0x81, 0xF0,
  0x9F, 0x90, 0x0F, 0xF0, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x01, 0xC3, 0x80, 0xC0, 0x70, 0x70, 0x0E, 0x38,
  0x03, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xF0, 0x07, 0x7C, 0x01, 0xDF, 0x80,
  0xF3, 0xE0, 0x38, 0xFD, 0x3C, 0x1F, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x6F, 0xF8, 0x10, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x87, 0xE1, 0xF8, 0x07, 0xFE,
  0x7F, 0x9F, 0xE0, 0x7F, 0xFE, 0x7E, 0x8F, 0x86, 0x0F, 0xE1, 0xF8, 0x3C,
  0x60, 0x1F, 0x87, 0xC1, 0xF2, 0x00, 0x7C, 0x1F, 0x0F, 0x90, 0x01, 0xF0,
  0xF8, 0x7C, 0x80, 0x0F, 0x83, 0xC1, 0xFC, 0x00, 0x3C, 0x1E, 0x0F, 0x20,
  0x01, 0xE0, 0xF0, 0x21, 0x80, 0x0F, 0x07, 0x82, 0x07, 0xF8, 0x38, 0x3C,
  0x30, 0x1F, 0xC1, 0xC0, 0xE3, 0x00, 0x33, 0x0E, 0x06, 0x38, 0x00, 0x10,
  0x70, 0x31, 0xC0, 0x00, 0x03, 0x01, 0x9E, 0x00, 0x00, 0x18, 0x0C, 0xF0,
  0x00, 0x00, 0x80, 0xC7, 0xC0, 0x00, 0x0C, 0x06, 0x3E, 0x00, 0xF0, 0x5C,
  0x20, 0xF8, 0x1F, 0xC5, 0xFA, 0x07, 0xED, 0xBF, 0x6F, 0xF0, 0x1F, 0xC0,
  0xFE, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0x80, 0x08, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x08, 0x00, 0xFF, 0x81,
  0xFC, 0x0F, 0xFE, 0x1F, 0xE0, 0xFF, 0xF9, 0x8F, 0x86, 0x07, 0xE8, 0x3C,
  0x60, 0x1F, 0x81, 0xF2, 0x00, 0x7C, 0x0F, 0x90, 0x01, 0xF0, 0x3C, 0x80,
  0x0F, 0x81, 0xF4, 0x00, 0x3C, 0x07, 0x20, 0x01, 0xE0, 0x21, 0x86, 0x07,
  0x02, 0x07, 0xF8, 0x38, 0x30, 0x1F, 0xE1, 0xC3, 0x00, 0x23, 0x0E, 0x38,
  0x00, 0x10, 0x71, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0xF8, 0x00,
  0x00, 0x87, 0xC0, 0x0C, 0x0C, 0x1E, 0x01, 0xF8, 0x40, 0xF8, 0x1F, 0xC4,
  0x07, 0xFD, 0x3F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x61, 0xFF, 0x80, 0xC0, 0x1F, 0xC0,
  0xC0, 0x03, 0xF0, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0xBF, 0x00, 0x03, 0xDF, 0xE0, 0x01, 0xE7, 0xFC, 0x00, 0x71, 0xFF, 0x00,
  0x38, 0x3F, 0x80, 0x1C, 0x07, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x20,
  0x03, 0x03, 0xA0, 0x01, 0x87, 0xE0, 0x00, 0x87, 0xFC, 0x00, 0x84, 0xFF,
  0x00, 0x80, 0x1F, 0xE0, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0xFF, 0x80, 0x70, 0x0F, 0xFE,
  0x0F, 0x00, 0xFF, 0xF8, 0xF8, 0x0E, 0x07, 0xFB, 0xE0, 0x60, 0x1F, 0x1F,
  0x82, 0x00, 0xF8, 0xFE, 0x10, 0x03, 0xC3, 0xF8, 0x80, 0x1F, 0x0F, 0xE4,
  0x00, 0xF8, 0x3F, 0xA0, 0x07, 0xC0, 0xFE, 0x80, 0x1E, 0x01, 0xF2, 0x0C,
  0xF0, 0x07, 0x8F, 0x87, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x80, 0x03, 0x80, 0x04,
  0x00, 0x7C, 0x00, 0x40, 0x07, 0xF8, 0x02, 0x00, 0x7F, 0xF0, 0x20, 0x04,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x1F, 0xF8,
  0x06, 0x00, 0xFE, 0x03, 0x00, 0x0F, 0xC1, 0xC0, 0x01, 0xF8, 0xF0, 0x00,
  0x3E, 0x3C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF3, 0xFC, 0x00, 0x3C, 0x7F,
  0xC0, 0x07, 0x0F, 0xF8, 0x01, 0xC0, 0xFE, 0x00, 0x70, 0x0F, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0xE8, 0x06, 0x60, 0xFC, 0x07,
  0xF0, 0x7F, 0xC3, 0xFC, 0x67, 0xF9, 0x1F, 0xB0, 0x7F, 0x83, 0xF8, 0x0F,
  0xFF, 0x7C, 0x00, 0xFF, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0xF0, 0xFF, 0x01,
  0xFF, 0xF2, 0x3F, 0x07, 0x07, 0xF8, 0x3E, 0x1C, 0x03, 0xF0, 0x3E, 0x30,
  0x03, 0xE0, 0x7C, 0x40, 0x03, 0xC0, 0xFC, 0x80, 0x07, 0x80, 0xFD, 0x00,
  0x07, 0x00, 0xC2, 0x00, 0x0F, 0x02, 0x06, 0x00, 0x1E, 0x18, 0x04, 0x00,
  0x3C, 0x70, 0x04, 0x04, 0x7B, 0xF0, 0x07, 0xF0, 0xEB, 0xE0, 0x00, 0x01,
  0xC3, 0xE0, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x0C,
  0x1F, 0x00, 0x18, 0x18, 0x1F, 0x00, 0xF8, 0x20, 0x3E, 0x03, 0xF8, 0x80,
  0x7E, 0x0B, 0xFE, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFC, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF8, 0xC0, 0x6F, 0xFF, 0x80, 0xC0, 0x7F, 0x80, 0xC0, 0x0F, 0x80,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xF8,
  0x38, 0x01, 0xFF, 0x1C, 0x43, 0xFF, 0xCE, 0x1F, 0xFC, 0x37, 0x07, 0xF8,
  0x0B, 0x81, 0xF8, 0x05, 0xE0, 0x20, 0x02, 0xF0, 0x00, 0x01, 0x3C, 0x00,
  0x00, 0x9F, 0x00, 0x00, 0xC7, 0xE0, 0x00, 0xC3, 0xFC, 0x01, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0E, 0x0F, 0xFC,
  0x06, 0x00, 0xFF, 0x06, 0x00, 0x7F, 0xFA, 0x00, 0xC7, 0xF9, 0x00, 0xE0,
  0xF8, 0x80, 0xF0, 0x00, 0x40, 0x7C, 0x00, 0x20, 0x3F, 0x00, 0x08, 0x0F,
  0xC0, 0x03, 0x13, 0xF0, 0x00, 0x70, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0xC3, 0x80, 0x1F, 0xF1, 0x80, 0x11,
  0xFD, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x07, 0xF8, 0x30,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x0C, 0x38, 0x40,
  0x70, 0xE0, 0x83, 0xC1, 0xC1, 0x1F, 0x87, 0x84, 0x1F, 0x0F, 0x80, 0x1E,
  0x1F, 0x80, 0x3C, 0x1F, 0x80, 0x78, 0x1F, 0x80, 0xF0, 0x3F, 0x01, 0xE0,
  0x3F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x1E, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0x78, 0x04, 0x00, 0xF0, 0x18, 0x01, 0xE0, 0xF8,
  0x07, 0xC3, 0xF8, 0x17, 0x89, 0xFC, 0x4F, 0x00, 0xFF, 0x1F, 0xC0, 0xFE,
  0x3E, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xFE, 0x1F, 0xC0, 0x7F, 0xF9, 0x1F,
  0x07, 0x8F, 0xF0, 0x78, 0x70, 0x1F, 0x83, 0xE3, 0x00, 0x7C, 0x1F, 0x90,
  0x01, 0xE0, 0x7E, 0x80, 0x0F, 0x01, 0x84, 0x00, 0x38, 0x08, 0x20, 0x01,
  0xC0, 0xC1, 0x80, 0x0E, 0x0E, 0x04, 0x00, 0x70, 0x78, 0x18, 0x63, 0x03,
  0xE0, 0x3C, 0x38, 0x1F, 0x80, 0x01, 0x80, 0xFC, 0x00, 0x08, 0x03, 0xF0,
  0x00, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0xE0, 0xFF,
  0xC0, 0x06, 0x08, 0x7F, 0x00, 0x30, 0x01, 0xFE, 0x03, 0x00, 0x07, 0xF8,
  0x30, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x60, 0xF8, 0x01, 0xFF, 0x8F, 0x3F, 0xE0, 0x3F, 0xFD, 0x14,
  0x3F, 0x07, 0xFF, 0xE0, 0x81, 0xF0, 0x70, 0x3F, 0x18, 0x0F, 0x8C, 0x01,
  0xF1, 0x80, 0xF8, 0xC0, 0x0F, 0x38, 0x07, 0xC8, 0x00, 0xF3, 0xC0, 0x7E,
  0x80, 0x07, 0x3C, 0x03, 0x08, 0x00, 0x73, 0xE0, 0x20, 0xC0, 0x07, 0x3E,
  0x06, 0x04, 0x00, 0x71, 0xF0, 0xF0, 0x20, 0x46, 0x1F, 0x0F, 0x81, 0xF8,
  0x60, 0xF8, 0xFC, 0x00, 0x0C, 0x0F, 0x8F, 0xE0, 0x00, 0x80, 0x78, 0x7E,
  0x00, 0x10, 0x07, 0x03, 0xF0, 0x0A, 0x00, 0x30, 0x1F, 0x07, 0xE0, 0x02,
  0x00, 0xE0, 0xFF, 0x00, 0x78, 0x06, 0x11, 0xF8, 0x07, 0xC0, 0x40, 0x0F,
  0xE1, 0xFE, 0x08, 0x00, 0x7F, 0xF7, 0xF1, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xC0, 0x7F, 0xC1, 0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0x8F, 0xCC,
  0x0F, 0xB7, 0xB0, 0x0F, 0x40, 0x60, 0x0F, 0x00, 0x80, 0x1E, 0x01, 0x00,
  0x3C, 0x01, 0x00, 0x78, 0x02, 0x00, 0xFF, 0xC2, 0x03, 0xFF, 0x03, 0xEF,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0x78, 0x00, 0x02, 0xF8, 0x03, 0xC5, 0xF8,
  0x0F, 0xF1, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0x83, 0xF8, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xF8,
  0x7F, 0x03, 0xFF, 0xC8, 0xF8, 0x78, 0xFF, 0x07, 0xCE, 0x03, 0xF0, 0x7C,
  0xC0, 0x1F, 0x07, 0xC8, 0x00, 0xF0, 0x3E, 0x80, 0x0F, 0x03, 0xF8, 0x00,
  0x70, 0x1C, 0x80, 0x07, 0x01, 0x8C, 0x00, 0x70, 0x30, 0x40, 0x47, 0x07,
  0x03, 0x08, 0x60, 0xF0, 0x07, 0x0E, 0x0F, 0x80, 0x00, 0xC0, 0xF8, 0x00,
  0x0C, 0x0F, 0xC0, 0x01, 0x80, 0xFC, 0x00, 0x10, 0x07, 0xE0, 0x02, 0x00,
  0x3E, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x84, 0x3E, 0x01, 0xFF, 0x81, 0xE0,
  0x3F, 0xF8, 0x1E, 0x00, 0x3F, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x02, 0x00,
  0x03, 0xC0, 0x10, 0x00, 0x38, 0x00, 0x80, 0x07, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1C, 0x0F, 0xC1, 0x80, 0x1F, 0x0C, 0x00, 0x78, 0x40,
  0x03, 0xC2, 0x00, 0x1E, 0x18, 0x00, 0xE0, 0x60, 0x06, 0x01, 0xC0, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x02, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x8E, 0x00, 0x1D, 0xF8, 0x00, 0xFF, 0xF0, 0x06, 0x9F, 0x80,
  0x30, 0x7E, 0x03, 0x01, 0xFC, 0x30, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3D, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xFF, 0xF0, 0x02,
  0x00, 0x38, 0x03, 0xC0, 0x3F, 0x01, 0xDC, 0x1C, 0x71, 0x81, 0x98, 0x06,
  0x80, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x38, 0xE3, 0x08,
  0x20, 0x02, 0x00, 0x0C, 0x00, 0x7C, 0x03, 0xF8, 0x11, 0xF8, 0xC3, 0xC7,
  0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0xCE, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xC7, 0x8F, 0x5F, 0xFF, 0x3E, 0x78, 0x71, 0xE1, 0x01, 0x00, 0x03,
  0x02, 0x30, 0x09, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x84, 0x0E,
  0x18, 0x38, 0xF0, 0xEF, 0xC3, 0xC7, 0x8E, 0x1E, 0x38, 0x3C, 0xE0, 0xF3,
  0x83, 0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8F, 0x0C, 0x7E, 0x62,
  0xFE, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x01, 0x01, 0xF0, 0x5E, 0x19,
  0xE6, 0x3C, 0xC3, 0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xFB, 0x3F, 0x81, 0xC0, 0x10, 0x00, 0x70, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x17, 0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0x9F, 0x06, 0x7F, 0x10, 0x7E,
  0x80, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x01, 0xF0, 0x5E, 0x19, 0xC6,
  0x3C, 0xC3, 0xB8, 0x7F, 0x0E, 0xE6, 0x1F, 0x03, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xFB, 0x3F, 0x81, 0xC0, 0x10, 0x00, 0x0C, 0x07, 0xF1,
  0xFC, 0xDE, 0x20, 0x08, 0x02, 0x00, 0xE0, 0x7F, 0xAF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x5F, 0x81, 0x1F, 0x86, 0x1F, 0x1C,
  0x0C, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0xC1, 0xC7, 0x87, 0x8F, 0x07,
  0x0E, 0x0F, 0x1E, 0x1E, 0x1E, 0x7C, 0x3F, 0x38, 0x30, 0x78, 0x40, 0xF0,
  0x01, 0xC0, 0x03, 0x8C, 0x06, 0x1C, 0x0C, 0x1C, 0x20, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x08, 0xC0, 0x27, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x10, 0x38, 0xC0, 0xEF, 0x83, 0xDF, 0x0E, 0x3E, 0x38, 0x78, 0xE1, 0xE3,
  0x83, 0xCE, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0xCE, 0x0E, 0x38, 0x38,
  0xE0, 0xE7, 0xF3, 0x2F, 0x18, 0x18, 0x60, 0x23, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0x83, 0x80, 0x00,
  0x00, 0x40, 0x70, 0x3C, 0x3F, 0xA7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE8, 0xF8, 0x7C, 0x1C, 0x04, 0x00, 0x07,
  0x01, 0xE0, 0x70, 0x1C, 0x04, 0x00, 0x00, 0x80, 0x30, 0x0E, 0x07, 0xE2,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3A, 0x0E, 0x87,
  0x1F, 0x00, 0x03, 0xE3, 0x09, 0xC5, 0xF7, 0x3B, 0xCF, 0xF3, 0xE0, 0xF0,
  0x7F, 0xBF, 0xE3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x9F, 0xC1, 0xE0, 0x30, 0x04, 0x00, 0x07, 0xE3,
  0x09, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x9F, 0xC1, 0xE0, 0x30, 0x04, 0x00, 0x30, 0x60, 0xC0, 0xF1, 0xE3, 0xC1,
  0xF7, 0xEF, 0xC7, 0xF3, 0xE7, 0xE3, 0xC3, 0x87, 0x07, 0x87, 0x0E, 0x0F,
  0x0E, 0x1C, 0x1E, 0x1C, 0x38, 0x3C, 0x38, 0x70, 0x78, 0x70, 0xE0, 0xF0,
  0xE1, 0xC1, 0xE1, 0xC3, 0x83, 0xC3, 0x87, 0x07, 0x87, 0x0E, 0x0F, 0x1F,
  0x1E, 0xBF, 0x7E, 0x3E, 0x1C, 0x38, 0x3C, 0x30, 0x20, 0x30, 0x40, 0x40,
  0x40, 0x20, 0x40, 0x70, 0x60, 0x78, 0xF0, 0xFF, 0xFE, 0xBC, 0x78, 0x3C,
  0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C,
  0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x3E, 0x7E, 0x3F, 0x3C, 0x3E, 0x18,
  0x1C, 0x10, 0x04, 0x00, 0x40, 0x07, 0x01, 0xFE, 0x1E, 0x78, 0x79, 0xF1,
  0xE3, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0x9E, 0x0E,
  0x78, 0x39, 0xE0, 0xCF, 0xE6, 0x0F, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x07, 0x81, 0x0F, 0x87, 0x0F, 0x9E,
  0x0F, 0xFE, 0x0E, 0x3E, 0x1C, 0x3C, 0x38, 0x3C, 0x70, 0x78, 0xE0, 0x71,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x0E, 0x0E, 0x7E, 0x19, 0xFE, 0x22, 0x7F,
  0x80, 0xFE, 0x01, 0xD8, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x02, 0x00, 0x18, 0x01, 0xE0, 0x1F,
  0xC3, 0x3F, 0xB0, 0x79, 0x83, 0xDC, 0x1E, 0xE0, 0xF7, 0x07, 0xB8, 0x3D,
  0xC1, 0xEF, 0x0F, 0x78, 0x79, 0xE3, 0xCF, 0xFE, 0x3C, 0x70, 0xC3, 0x84,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x40, 0x20,
  0x8E, 0x19, 0xE7, 0x7F, 0xF3, 0xDE, 0x79, 0x8F, 0x21, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xA3, 0xF8, 0x1E, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x20, 0x40, 0x87, 0x84,
  0x7F, 0xC4, 0xFE, 0x41, 0xE6, 0x02, 0x38, 0x21, 0xE3, 0x8F, 0xBE, 0x3E,
  0xF8, 0xE3, 0xC6, 0x0E, 0x20, 0x33, 0xC1, 0x3F, 0x90, 0x7F, 0x00, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0E, 0x07, 0x83,
  0xFD, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE4, 0xFE, 0x0F, 0x01, 0x80, 0x20, 0x20, 0x10, 0x70,
  0x38, 0x78, 0x7C, 0xFC, 0x7E, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x38, 0x3C,
  0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C,
  0x38, 0x3C, 0x7D, 0x7F, 0xBE, 0x1F, 0x3E, 0x06, 0x0C, 0x04, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x87, 0x07, 0x8F, 0x1F, 0x9F, 0x8F, 0x1E, 0x0F,
  0x3E, 0x1E, 0x3C, 0x1E, 0x38, 0x3C, 0x38, 0x78, 0x60, 0x70, 0xC1, 0xC1,
  0x83, 0x82, 0x07, 0x0C, 0x0C, 0x1E, 0x30, 0x7F, 0x40, 0x3F, 0x00, 0x1C,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x38,
  0x00, 0x08, 0xF8, 0x70, 0x63, 0xF3, 0xE3, 0xC7, 0xDF, 0xFF, 0x8F, 0x8F,
  0x1E, 0x1C, 0x3C, 0x3C, 0x70, 0xF0, 0xF1, 0xC3, 0xC1, 0xC7, 0x0F, 0x07,
  0x1C, 0x3C, 0x1C, 0x70, 0xF0, 0x71, 0xC3, 0xC1, 0x87, 0x0F, 0x06, 0x3C,
  0x3C, 0x30, 0xF1, 0xFC, 0x87, 0xE1, 0xFC, 0x07, 0x01, 0xE0, 0x18, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x18, 0x43, 0xC6, 0x3C, 0xE5, 0xFF, 0x1E, 0x61,
  0xE6, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0xC3, 0xF8, 0x7F, 0x0C, 0x60, 0x84, 0x08, 0x00, 0x80, 0x04,
  0x08, 0x61, 0xC1, 0xFE, 0x07, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x07,
  0x81, 0x0F, 0x86, 0x1F, 0xBE, 0x1F, 0xBE, 0x1E, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0x71, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x0E,
  0x3C, 0x1C, 0x7A, 0x31, 0xFC, 0x61, 0xF1, 0x80, 0xC2, 0x01, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x08, 0x03, 0x01,
  0xE1, 0xFC, 0x8F, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x4E, 0x67, 0xE2, 0xFC,
  0x1F, 0x8F, 0xE2, 0x7D, 0x0F, 0x43, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xA0,
  0x64, 0x31, 0x08, 0x3C, 0x00, 0x03, 0x83, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x06, 0x01, 0xC0,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x18, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xE0,
  0x1C, 0x1C, 0x18, 0x1C, 0x0E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x1C, 0x1C, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 26, 8, 1, -25 },
  { 21, 12, 10, 14, 1, -25 },
  { 36, 16, 20, 18, 1, -22 },
  { 76, 12, 29, 15, 1, -27 },
  { 120, 23, 25, 25, 1, -25 },
  { 192, 18, 22, 20, 1, -22 },
  { 242, 5, 10, 7, 1, -25 },
  { 249, 7, 29, 9, 1, -28 },
  { 275, 7, 28, 9, 1, -27 },
  { 300, 12, 13, 12, 0, -26 },
  { 320, 12, 13, 14, 1, -18 },
  { 340, 6, 9, 6, 0, -5 },
  { 347, 10, 7, 10, 1, -14 },
  { 356, 6, 6, 7, 0, -5 },
  { 361, 17, 27, 18, 1, -26 },
  { 419, 15, 24, 17, 1, -24 },
  { 464, 11, 24, 11, 0, -24 },
  { 497, 14, 24, 16, 1, -24 },
  { 539, 15, 23, 16, 1, -23 },
  { 583, 16, 24, 16, 0, -24 },
  { 631, 15, 25, 16, 1, -25 },
  { 678, 14, 25, 16, 1, -25 },
  { 722, 14, 24, 15, 1, -24 },
  { 764, 15, 25, 16, 1, -25 },
  { 811, 14, 25, 16, 1, -25 },
  { 855, 6, 18, 7, 0, -17 },
  { 869, 6, 21, 6, 0, -17 },
  { 885, 10, 13, 10, 0, -16 },
  { 902, 12, 8, 14, 1, -14 },
  { 914, 10, 13, 10, 0, -16 },
  { 931, 13, 26, 16, 1, -25 },
  { 974, 20, 21, 21, 1, -16 },
  { 1027, 27, 26, 28, 1, -25 },
  { 1115, 30, 26, 31, 0, -25 },
  { 1213, 22, 25, 24, 1, -25 },
  { 1282, 27, 27, 28, 1, -26 },
  { 1374, 23, 25, 25, 1, -25 },
  { 1446, 25, 30, 26, 1, -26 },
  { 1540, 25, 26, 27, 1, -25 },
  { 1622, 25, 32, 26, 0, -27 },
  { 1722, 22, 30, 24, 1, -25 },
  { 1805, 23, 34, 25, 1, -25 },
  { 1903, 28, 26, 28, 0, -25 },
  { 1994, 18, 26, 20, 1, -25 },
  { 2053, 37, 27, 39, 1, -25 },
  { 2178, 29, 26, 31, 1, -25 },
  { 2273, 25, 26, 26, 1, -25 },
  { 2355, 29, 31, 31, 1, -25 },
  { 2468, 26, 27, 28, 1, -25 },
  { 2556, 31, 26, 33, 1, -25 },
  { 2657, 25, 25, 27, 1, -25 },
  { 2736, 25, 25, 26, 1, -25 },
  { 2815, 23, 26, 25, 1, -24 },
  { 2890, 29, 27, 31, 1, -26 },
  { 2988, 36, 26, 38, 1, -25 },
  { 3105, 23, 27, 25, 1, -26 },
  { 3183, 28, 32, 30, 1, -26 },
  { 3295, 21, 30, 23, 1, -25 },
  { 3374, 5, 28, 6, 1, -26 },
  { 3392, 22, 25, 4, -7, -23 },
  { 3461, 5, 28, 6, 1, -26 },
  { 3479, 13, 9, 15, 1, -25 },
  { 3494, 16, 3, 16, 0, 4 },
  { 3500, 5, 7, 18, 6, -25 },
  { 3505, 14, 19, 16, 1, -18 },
  { 3539, 14, 25, 16, 1, -24 },
  { 3583, 11, 19, 12, 1, -18 },
  { 3610, 14, 25, 16, 1, -24 },
  { 3654, 11, 19, 13, 1, -18 },
  { 3681, 10, 31, 9, 0, -25 },
  { 3720, 15, 25, 16, 1, -18 },
  { 3767, 14, 31, 16, 1, -25 },
  { 3822, 9, 25, 10, 0, -24 },
  { 3851, 10, 31, 9, -2, -25 },
  { 3890, 10, 25, 11, 1, -24 },
  { 3922, 10, 25, 10, 1, -24 },
  { 3954, 23, 19, 25, 1, -18 },
  { 4009, 16, 19, 18, 1, -18 },
  { 4047, 14, 19, 14, 0, -18 },
  { 4081, 15, 28, 16, 0, -21 },
  { 4134, 13, 25, 15, 1, -18 },
  { 4175, 11, 19, 13, 1, -18 },
  { 4202, 13, 23, 15, 1, -22 },
  { 4240, 10, 23, 11, 0, -22 },
  { 4269, 16, 19, 18, 1, -18 },
  { 4307, 15, 21, 16, 0, -20 },
  { 4347, 22, 22, 24, 1, -21 },
  { 4408, 12, 25, 14, 1, -18 },
  { 4446, 15, 27, 16, 1, -21 },
  { 4497, 10, 25, 12, 1, -19 },
  { 4529, 9, 28, 12, 1, -27 },
  { 4561, 2, 29, 6, 2, -27 },
  { 4569, 9, 28, 12, 1, -27 },
  { 4601, 11, 3, 13, 1, -12 },
};

const GFXfont UnifrakturMaguntia_Regular35pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular35pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular35pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR35PT7B_H_
