#ifndef _UNIFRAKTURMAGUNTIA_REGULAR12PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0x99, 0x24, 0x82, 0xC0, 0x0D, 0x59, 0x28, 0xA7, 0xCA, 0xF9, 0x45,
  0x00, 0x23, 0x14, 0xA6, 0x1A, 0x72, 0x71, 0x00, 0x60, 0xF3, 0xD2, 0xF4,
  0x6B, 0x15, 0x25, 0x45, 0x83, 0x30, 0x50, 0xC1, 0x27, 0x5B, 0x36, 0x3F,
  0x36, 0x6B, 0x6D, 0xB2, 0x60, 0xC9, 0xB6, 0xDA, 0xC0, 0x6D, 0xF6, 0x2F,
  0x22, 0x94, 0x70, 0xE0, 0x90, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10, 0x80,
  0x00, 0x32, 0xF3, 0x9C, 0xE7, 0x29, 0x30, 0x26, 0xE6, 0x66, 0x6F, 0x74,
  0xE2, 0x31, 0x11, 0x3F, 0x7C, 0xC2, 0x70, 0xE7, 0x2E, 0x11, 0x95, 0x29,
  0x7C, 0x47, 0x4B, 0xA0, 0xE8, 0x86, 0x39, 0x70, 0x32, 0x53, 0x8F, 0xE7,
  0x29, 0x70, 0x7C, 0x44, 0x21, 0x10, 0x8C, 0x7E, 0x5C, 0xA8, 0xC6, 0x2E,
  0x72, 0xF3, 0x97, 0x95, 0x3A, 0x70, 0x90, 0x90, 0x90, 0x94, 0x2B, 0x22,
  0xF0, 0xF0, 0x88, 0xA8, 0x74, 0x72, 0x26, 0x29, 0xC4, 0x30, 0x3C, 0x86,
  0x7D, 0x5A, 0xB7, 0xD1, 0x9C, 0x10, 0x1E, 0x68, 0xF2, 0x34, 0x6D, 0x0A,
  0x41, 0x10, 0xE4, 0x1F, 0x80, 0x31, 0x1F, 0xA8, 0xCE, 0x12, 0x97, 0xDA,
  0x11, 0x04, 0xF1, 0x0F, 0x80, 0x34, 0x4F, 0x50, 0xD8, 0xDC, 0xCC, 0x64,
  0x78, 0x3F, 0x1C, 0x3F, 0xA4, 0x73, 0x19, 0xCA, 0x64, 0xE2, 0x72, 0x5F,
  0x00, 0x34, 0x4F, 0x50, 0xDA, 0xDF, 0x4C, 0x64, 0x38, 0x1F, 0x3E, 0x23,
  0xE2, 0x11, 0x08, 0xDB, 0xB9, 0x98, 0x44, 0x22, 0x12, 0x06, 0x00, 0x12,
  0x37, 0x94, 0x7A, 0x4D, 0xD6, 0x6D, 0x12, 0xD2, 0x3E, 0x00, 0x08, 0x1F,
  0x08, 0x0C, 0xC3, 0xB0, 0xC8, 0x66, 0x92, 0xF1, 0x01, 0x03, 0x00, 0x38,
  0x4F, 0x82, 0x84, 0x46, 0x3E, 0x03, 0x43, 0xB2, 0x1C, 0x38, 0x4F, 0x82,
  0x84, 0x46, 0x3E, 0x03, 0x03, 0x01, 0x61, 0xB2, 0x0C, 0x04, 0x06, 0xC2,
  0xE8, 0xCE, 0x31, 0x87, 0xC1, 0xB1, 0x24, 0xF1, 0x80, 0x7C, 0x89, 0x9B,
  0xE2, 0x08, 0x1C, 0xDE, 0x7F, 0xF4, 0x6C, 0xA1, 0x27, 0x49, 0x45, 0x4A,
  0x02, 0x51, 0xAC, 0xC6, 0xE7, 0x00, 0x00, 0x7B, 0xA3, 0x28, 0x4D, 0x92,
  0x15, 0x01, 0x46, 0x98, 0xC3, 0x08, 0x0F, 0x19, 0xD8, 0x26, 0x19, 0x84,
  0x45, 0xE2, 0x1E, 0x00, 0x7B, 0x23, 0x68, 0xDE, 0x31, 0x7C, 0x41, 0x11,
  0xC8, 0x1C, 0x08, 0x02, 0x00, 0x08, 0x0F, 0x19, 0xD8, 0x26, 0x19, 0x84,
  0x45, 0xEF, 0x3D, 0x80, 0x00, 0x00, 0x0F, 0x72, 0x33, 0x42, 0x38, 0x58,
  0xEB, 0x01, 0x21, 0x46, 0x78, 0xE0, 0x08, 0x1F, 0x90, 0x90, 0x4A, 0xF4,
  0xC5, 0x02, 0xE2, 0x3E, 0x00, 0x3C, 0x67, 0x22, 0xF3, 0x07, 0xC0, 0x21,
  0x91, 0x70, 0x1F, 0x00, 0x73, 0x46, 0x62, 0x32, 0x22, 0x42, 0x66, 0xBB,
  0x00, 0x31, 0x1F, 0xE8, 0xCE, 0x12, 0x95, 0x9A, 0x31, 0x05, 0xF2, 0x0F,
  0x00, 0x02, 0x43, 0xEF, 0x23, 0x4D, 0x0E, 0x49, 0x5A, 0x34, 0xD8, 0x42,
  0x6F, 0x32, 0x0E, 0xE0, 0x22, 0x7B, 0x8C, 0x88, 0x6E, 0x1C, 0x0C, 0x76,
  0x77, 0x31, 0x1F, 0xE8, 0xCA, 0x13, 0x95, 0x9A, 0x61, 0x0C, 0x6B, 0x0C,
  0xC8, 0x21, 0xF0, 0x1C, 0x66, 0x42, 0x44, 0x2E, 0x17, 0x03, 0x61, 0xB2,
  0x1C, 0xEA, 0xAA, 0xB0, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x80,
  0xD5, 0x55, 0x70, 0x22, 0xA6, 0xFC, 0x90, 0x22, 0xE5, 0xAD, 0x3C, 0xE2,
  0x14, 0xF4, 0xA5, 0x54, 0x2D, 0x8C, 0x47, 0xC7, 0x0C, 0x94, 0xA5, 0x26,
  0x2D, 0xAC, 0x47, 0x6A, 0x8E, 0x44, 0x44, 0x44, 0x40, 0x22, 0xE5, 0xA5,
  0xB4, 0x2A, 0x20, 0xF2, 0x14, 0xF4, 0xA5, 0x3E, 0x22, 0x00, 0x41, 0x74,
  0x93, 0x22, 0x06, 0x22, 0x22, 0x22, 0xD0, 0xF7, 0x4F, 0x44, 0x46, 0xF4,
  0x44, 0x44, 0x46, 0x5E, 0xEB, 0x4A, 0x4A, 0x4A, 0x7B, 0x53, 0xA4, 0x92,
  0x49, 0xB0, 0x36, 0xB7, 0x9D, 0x30, 0x86, 0x9E, 0x94, 0xE5, 0xC8, 0x40,
  0x22, 0xE5, 0x2D, 0x38, 0x42, 0x5F, 0x44, 0x42, 0x3B, 0x65, 0xA7, 0xAA,
  0x80, 0x25, 0xE4, 0x93, 0x4B, 0x64, 0x92, 0x48, 0xF0, 0x84, 0xBE, 0x94,
  0xA8, 0x80, 0x80, 0xDA, 0x6F, 0x49, 0x49, 0x4A, 0x74, 0x53, 0x98, 0xC7,
  0x32, 0x1E, 0x86, 0x9A, 0x94, 0xA5, 0xA2, 0x60, 0x62, 0x5E, 0xB9, 0xAE,
  0x69, 0xA8, 0x9A, 0x20, 0xFF, 0xC0, 0xCD, 0x22, 0x93, 0xC0, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 5, 0, -9 },
  { 7, 6, 7, 6, 0, -8 },
  { 13, 5, 10, 5, 0, -9 },
  { 20, 8, 9, 9, 0, -9 },
  { 29, 7, 8, 7, 0, -8 },
  { 36, 2, 4, 2, 0, -9 },
  { 37, 3, 9, 3, 0, -9 },
  { 41, 3, 9, 3, 0, -9 },
  { 45, 4, 4, 4, 0, -9 },
  { 47, 4, 4, 5, 0, -6 },
  { 49, 2, 3, 2, 0, -2 },
  { 50, 4, 3, 4, 0, -5 },
  { 52, 2, 2, 2, 0, -2 },
  { 53, 6, 10, 6, 0, -9 },
  { 61, 5, 9, 6, 0, -9 },
  { 67, 4, 8, 4, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 6, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 5, 9, 6, 0, -9 },
  { 92, 5, 9, 5, 0, -9 },
  { 98, 5, 8, 5, 0, -8 },
  { 103, 5, 8, 6, 0, -8 },
  { 108, 5, 9, 5, 0, -9 },
  { 114, 2, 6, 2, 0, -6 },
  { 116, 2, 7, 2, 0, -6 },
  { 118, 3, 5, 3, 0, -6 },
  { 120, 4, 3, 5, 0, -5 },
  { 122, 3, 5, 3, 0, -6 },
  { 124, 5, 9, 5, 0, -9 },
  { 130, 7, 8, 7, 0, -6 },
  { 137, 10, 9, 10, 0, -9 },
  { 149, 10, 9, 11, 0, -9 },
  { 161, 8, 9, 8, 0, -9 },
  { 170, 9, 9, 10, 0, -9 },
  { 181, 8, 9, 8, 0, -9 },
  { 190, 9, 11, 9, 0, -9 },
  { 203, 9, 9, 9, 0, -9 },
  { 214, 9, 11, 9, 0, -9 },
  { 227, 8, 10, 8, 0, -9 },
  { 237, 8, 12, 9, 0, -9 },
  { 249, 10, 9, 10, 0, -9 },
  { 261, 7, 8, 7, 0, -8 },
  { 268, 13, 9, 13, 0, -8 },
  { 283, 10, 8, 11, 0, -8 },
  { 293, 9, 9, 9, 0, -9 },
  { 304, 10, 10, 11, 0, -8 },
  { 317, 9, 10, 10, 0, -9 },
  { 329, 11, 9, 11, 0, -9 },
  { 342, 9, 9, 9, 0, -9 },
  { 353, 9, 9, 9, 0, -9 },
  { 364, 8, 9, 9, 0, -8 },
  { 373, 10, 9, 11, 0, -9 },
  { 385, 13, 9, 13, 0, -9 },
  { 400, 8, 9, 9, 0, -9 },
  { 409, 10, 11, 10, 0, -9 },
  { 423, 8, 10, 8, 0, -9 },
  { 433, 2, 10, 2, 0, -9 },
  { 436, 7, 9, 1, -2, -8 },
  { 444, 2, 10, 2, 0, -9 },
  { 447, 5, 3, 5, 0, -8 },
  { 449, 6, 1, 5, 0, 1 },
  { 450, 2, 2, 6, 2, -8 },
  { 451, 5, 6, 6, 0, -6 },
  { 455, 5, 8, 5, 0, -8 },
  { 460, 4, 6, 4, 0, -6 },
  { 463, 5, 8, 5, 0, -8 },
  { 468, 4, 6, 4, 0, -6 },
  { 471, 4, 11, 3, 0, -9 },
  { 477, 5, 9, 6, 0, -6 },
  { 483, 5, 10, 5, 0, -8 },
  { 490, 3, 8, 3, 0, -8 },
  { 493, 4, 11, 3, -1, -9 },
  { 499, 4, 8, 4, 0, -8 },
  { 503, 4, 8, 3, 0, -8 },
  { 507, 8, 6, 9, 0, -6 },
  { 513, 6, 6, 6, 0, -6 },
  { 518, 5, 6, 5, 0, -6 },
  { 522, 5, 9, 5, 0, -7 },
  { 528, 5, 8, 5, 0, -6 },
  { 533, 4, 6, 4, 0, -6 },
  { 536, 5, 7, 5, 0, -7 },
  { 541, 3, 8, 4, 0, -8 },
  { 544, 6, 6, 6, 0, -6 },
  { 549, 5, 7, 5, 0, -7 },
  { 554, 8, 7, 8, 0, -7 },
  { 561, 5, 8, 5, 0, -6 },
  { 566, 5, 9, 6, 0, -7 },
  { 572, 4, 8, 4, 0, -6 },
  { 576, 3, 9, 4, 0, -9 },
  { 580, 1, 10, 2, 0, -9 },
  { 582, 3, 9, 4, 0, -9 },
  { 586, 4, 1, 4, 0, -4 },
};

const GFXfont UnifrakturMaguntia_Regular12pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular12pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular12pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR12PT7B_H_
