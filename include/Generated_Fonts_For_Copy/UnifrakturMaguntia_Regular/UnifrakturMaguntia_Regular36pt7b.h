#ifndef _UNIFRAKTURMAGUNTIA_REGULAR36PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0x30, 0x61, 0xE7, 0xE7, 0xCF, 0x1E, 0x1C, 0x38, 0x60, 0xC1, 0x83,
  0x02, 0x04, 0x08, 0x10, 0x00, 0x00, 0x00, 0x06, 0x0E, 0x7E, 0x38, 0x20,
  0x00, 0x00, 0x03, 0x04, 0x78, 0xEF, 0xDF, 0x38, 0xF1, 0x87, 0x18, 0x21,
  0x02, 0x10, 0x42, 0x04, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x30, 0x0E, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x18, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x1F, 0x01, 0x86, 0x18, 0x11, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x81,
  0x9F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF3,
  0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0x30, 0x19, 0x81, 0xC6, 0x1C, 0x1F,
  0xC0, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x02, 0x33, 0x00, 0x04, 0x73, 0x80, 0x08, 0xF3, 0xC0, 0x18, 0xF1,
  0xC0, 0x30, 0xE1, 0xC0, 0x60, 0xE1, 0xC0, 0xC0, 0xE1, 0xC1, 0x80, 0xF1,
  0xC1, 0x00, 0x73, 0xC2, 0x00, 0x73, 0x86, 0x00, 0x33, 0x0C, 0x00, 0x1E,
  0x18, 0x78, 0x00, 0x31, 0xCC, 0x00, 0x63, 0x8E, 0x00, 0x43, 0x8E, 0x00,
  0x83, 0x8F, 0x01, 0x83, 0x8F, 0x03, 0x03, 0x8F, 0x06, 0x03, 0x8F, 0x0C,
  0x03, 0x8E, 0x18, 0x03, 0x8E, 0x30, 0x01, 0xCC, 0x20, 0x00, 0xF8, 0x40,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xE6, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00,
  0xE1, 0x80, 0x1E, 0x70, 0x03, 0xCC, 0x00, 0x7B, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0xF8, 0x3F, 0x06, 0x1D, 0xE0, 0x87, 0x3E, 0x10, 0xE7, 0xC6, 0x3C,
  0x7C, 0x87, 0x8F, 0xF0, 0xF0, 0xFC, 0x1E, 0x1F, 0x81, 0xE1, 0xF9, 0xBC,
  0x1F, 0xE3, 0xC3, 0xF8, 0x3F, 0x9E, 0x00, 0x01, 0x1D, 0xF7, 0x9C, 0x42,
  0x21, 0x00, 0x0E, 0x18, 0x10, 0x30, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x70, 0x70, 0x30, 0x30, 0x18, 0x08, 0x06, 0xC0, 0x30, 0x10, 0x18, 0x1C,
  0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x18, 0x18, 0x10, 0x20, 0xC0,
  0x06, 0x00, 0xF0, 0x2F, 0x8F, 0x6F, 0x76, 0xE7, 0xDE, 0x06, 0x27, 0xBE,
  0x76, 0xEF, 0x6F, 0x1F, 0x80, 0xF0, 0x06, 0x00, 0x00, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x00, 0xC3, 0xBF, 0x3C, 0x61, 0x86, 0x10, 0x80, 0x1F,
  0xCF, 0xE3, 0xE1, 0x00, 0x1F, 0x1F, 0xCF, 0xC0, 0x00, 0x87, 0x3E, 0x70,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x18, 0xC0, 0x61, 0xC1, 0xC1, 0xC7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC7, 0x07, 0x06, 0x0C, 0x06,
  0x30, 0x07, 0xC0, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x81, 0xF0, 0x7E, 0x13,
  0xC4, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFC,
  0x7F, 0xE0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0x87, 0xE4, 0x07, 0xD8,
  0x0F, 0xA0, 0x0F, 0x40, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x10, 0xC0, 0x21, 0x00, 0x47, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0xC3, 0xE2, 0x03, 0xE8, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0xC0,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0x3C, 0x0E, 0x3C, 0x38, 0x1F, 0xC0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x02, 0xF0, 0x04, 0xF0, 0x04, 0xF0, 0x08, 0xF0, 0x10, 0xF0, 0x10, 0xF0,
  0x20, 0xF0, 0x20, 0xF0, 0x40, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xFE, 0x30, 0x18, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x02, 0x20, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x2F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF,
  0xE7, 0x07, 0xCC, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1D,
  0x80, 0x3F, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0x9C, 0x0E, 0x3C, 0x38, 0x1F,
  0xC0, 0x03, 0xE0, 0x18, 0xE0, 0x60, 0xE1, 0xC1, 0xE3, 0x83, 0xCF, 0x07,
  0x9E, 0x06, 0x38, 0x00, 0xF0, 0x01, 0xE3, 0xC3, 0xCB, 0xE7, 0xA1, 0xCF,
  0x83, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x73, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x0E, 0x0C, 0x0E, 0x30, 0x07, 0xC0,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xB0, 0x02, 0x80, 0x1A, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xE0, 0x70, 0x21, 0xC0, 0x63,
  0x00, 0x6E, 0x00, 0xDE, 0x01, 0xBC, 0x07, 0x3E, 0x0C, 0x7E, 0x30, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x86, 0x3F, 0x98, 0x1F, 0x70, 0x1E,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xDC, 0x03, 0x98,
  0x06, 0x1C, 0x18, 0x0F, 0xC0, 0x07, 0x80, 0x31, 0xC0, 0xE1, 0xC1, 0x83,
  0xC7, 0x07, 0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0xF7, 0x83, 0xEF, 0x07, 0xDF, 0x0F, 0x9F, 0x6F, 0x1F, 0x9E, 0x0E,
  0x3C, 0x00, 0x78, 0x00, 0xF3, 0x01, 0xCF, 0x03, 0x9E, 0x0E, 0x1E, 0x1C,
  0x3C, 0x30, 0x38, 0xC0, 0x3F, 0x00, 0x21, 0xCF, 0xBC, 0x20, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x21, 0xCF, 0x9C, 0x20, 0x00, 0x10, 0x71, 0xF3, 0xC1,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x07, 0x3F, 0x1E, 0x18, 0x30,
  0x60, 0x82, 0x00, 0x00, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x81,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xE0, 0x7C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0,
  0x00, 0x0F, 0xC0, 0xE1, 0xC6, 0x07, 0xB8, 0x0E, 0xE0, 0x3F, 0xC0, 0xFF,
  0x83, 0xDC, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x04, 0x18, 0x20, 0x71, 0x80, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x38, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83,
  0x00, 0x06, 0x38, 0x00, 0x31, 0x81, 0xFD, 0x9C, 0x19, 0xC6, 0xC1, 0x8E,
  0x36, 0x1C, 0x73, 0xB1, 0xC7, 0x99, 0x8E, 0x38, 0xCC, 0xF1, 0xC6, 0x67,
  0x1E, 0x63, 0x38, 0xE3, 0x1D, 0xCF, 0x30, 0x67, 0xBE, 0x3B, 0x00, 0x01,
  0x8C, 0x00, 0x18, 0x30, 0x01, 0x80, 0xE0, 0x70, 0x01, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x1F, 0xFC, 0x03, 0x83, 0x0F, 0xE0,
  0xF0, 0x40, 0x3F, 0x3F, 0x0C, 0x01, 0xF1, 0xF0, 0x80, 0x1F, 0x9F, 0x08,
  0x00, 0xF9, 0xF0, 0x80, 0x0F, 0x9F, 0x0C, 0x00, 0xF9, 0xF0, 0xF0, 0x0F,
  0x1F, 0x0F, 0xE0, 0xF1, 0xF0, 0x7F, 0x0F, 0x1F, 0x03, 0xF0, 0xE1, 0xF0,
  0x07, 0x1C, 0x1F, 0x00, 0x31, 0x81, 0xF0, 0x02, 0x30, 0x1F, 0x00, 0x06,
  0x01, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xF0, 0x0F,
  0x00, 0x7F, 0x81, 0xF0, 0x09, 0xFC, 0x2F, 0xA0, 0x0F, 0xFC, 0xFE, 0x00,
  0x7F, 0x8F, 0x80, 0x03, 0xF0, 0x70, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0x80, 0x1F, 0xF8, 0x3F, 0x80, 0x7F, 0xFC, 0x8F, 0x81, 0xFF, 0xFA,
  0x0F, 0x87, 0x81, 0xFC, 0x1F, 0x0E, 0x01, 0xF8, 0x3E, 0x18, 0x01, 0xF0,
  0x3E, 0x20, 0x03, 0xE0, 0x7E, 0xC0, 0x03, 0xC0, 0x78, 0x80, 0x07, 0x80,
  0xC1, 0x00, 0x0F, 0x07, 0x03, 0x00, 0x1C, 0x3F, 0x83, 0x02, 0x39, 0xFF,
  0x83, 0x88, 0x64, 0xFF, 0x80, 0xE1, 0x80, 0x1F, 0x80, 0x02, 0x00, 0x1F,
  0x00, 0x08, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x38,
  0x07, 0xE0, 0x00, 0x70, 0x3F, 0xF0, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0x80,
  0x0F, 0xF0, 0x06, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xC0, 0x0E, 0x23,
  0xE0, 0x30, 0x2F, 0xF8, 0xE0, 0x7F, 0xE3, 0x81, 0x87, 0x07, 0x0E, 0x00,
  0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xF0, 0x03,
  0xE3, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0x87, 0xF0, 0x1F, 0x07, 0xF0, 0x3E,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0x80, 0xF8,
  0x0E, 0x01, 0xF8, 0x18, 0x01, 0xF8, 0x60, 0x03, 0xF9, 0x00, 0x03, 0xFC,
  0x00, 0x83, 0xFE, 0x0E, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xE0, 0x1F, 0xE0, 0xF0, 0x30, 0xFE, 0x38, 0x0C, 0x07, 0xE7, 0x03, 0x80,
  0x7C, 0xC0, 0xF0, 0x07, 0xD8, 0x1F, 0x00, 0x7A, 0x03, 0xF0, 0x07, 0xC0,
  0x7F, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xD0, 0x07, 0xE0,
  0x19, 0x80, 0x7C, 0x03, 0x1F, 0xC7, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0x00, 0x06, 0x00, 0x60, 0x3F, 0x00, 0x08, 0x0F, 0xF8, 0x03,
  0x07, 0xFF, 0xC0, 0xC1, 0x8F, 0xFF, 0x70, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xC0, 0x06, 0x11, 0xF0,
  0x0C, 0x0B, 0xFE, 0x1C, 0x0F, 0xFC, 0x38, 0x18, 0x70, 0x38, 0x70, 0x00,
  0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0xF9, 0xF8, 0x70,
  0xF8, 0xFC, 0xFE, 0xF8, 0xFF, 0xFE, 0xF8, 0x7F, 0x3C, 0xF8, 0x3F, 0x98,
  0xF8, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x03, 0x80, 0x3F, 0x03, 0x00, 0x1F, 0x86, 0x00, 0x1F, 0xC8, 0x00,
  0x0F, 0xF0, 0x02, 0x07, 0xFE, 0x1C, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE9, 0xE0, 0x7F, 0xF9, 0xC0, 0x17, 0xF8, 0xC0, 0x18,
  0xF8, 0xC0, 0x1C, 0x10, 0x60, 0x0F, 0x00, 0x30, 0x07, 0xC1, 0x98, 0x03,
  0xF1, 0xEC, 0x01, 0xF9, 0xFA, 0x00, 0x7E, 0xFD, 0x00, 0x1F, 0x9C, 0x40,
  0x0F, 0xE4, 0x10, 0x23, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0x80, 0x7E, 0x00,
  0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0,
  0x20, 0x00, 0xE2, 0x1C, 0x00, 0xE0, 0x4F, 0x80, 0x70, 0x0F, 0xF0, 0x1C,
  0x04, 0x7E, 0x0E, 0x06, 0x0F, 0xC7, 0x87, 0x01, 0xF9, 0xE3, 0xC0, 0x30,
  0x78, 0xF0, 0x18, 0x3E, 0x3C, 0x0C, 0x0F, 0x8F, 0x8F, 0xE3, 0xE3, 0xF7,
  0xFC, 0xF8, 0x7E, 0x1F, 0x3E, 0x0F, 0x83, 0xEF, 0x83, 0xF0, 0x7B, 0xE0,
  0x7E, 0x1F, 0xF8, 0x0F, 0x87, 0xDF, 0x03, 0xE0, 0xF7, 0xC0, 0x70, 0x39,
  0xF8, 0x1C, 0x0E, 0x3E, 0x0E, 0x07, 0x87, 0xC2, 0x01, 0xC0, 0xF9, 0x00,
  0xE0, 0x1F, 0x00, 0x30, 0x03, 0xE0, 0x18, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x21, 0xFC, 0x00, 0x10, 0x3E,
  0x00, 0x0C, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x04, 0x00, 0xF8,
  0x03, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC1, 0xFC, 0x01, 0xF9, 0xFF, 0x80,
  0x3F, 0x87, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xE0, 0x07, 0xC0, 0x78, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0x81, 0xE1, 0xC0, 0xC0, 0x78, 0xF8, 0x30, 0x1E, 0x7F, 0x08, 0x07, 0x07,
  0xFC, 0x01, 0xC0, 0xFE, 0x00, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xE0,
  0xFE, 0x03, 0x00, 0xFF, 0x46, 0x00, 0xFF, 0x18, 0x00, 0x7C, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0F, 0x01, 0x80, 0x1E,
  0x03, 0x00, 0x3C, 0x03, 0x80, 0x7C, 0x01, 0xFE, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x0F, 0x1F, 0x80, 0x0E, 0xFF,
  0xC0, 0x19, 0x1F, 0xC0, 0x30, 0x1F, 0xC0, 0xC0, 0x1F, 0xC3, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x3C, 0x3F, 0xC0, 0x30, 0x0F, 0xFC, 0x60, 0x07, 0xF8, 0x60,
  0x01, 0xF0, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60,
  0x03, 0xC0, 0x20, 0x03, 0xC0, 0x30, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x07,
  0xFB, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0x1F, 0x00, 0x0C, 0x7F, 0x80, 0x1C, 0xFF, 0xC0, 0x18, 0x0F,
  0xE0, 0x10, 0x07, 0xF0, 0x20, 0x03, 0xFC, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0xC0, 0xC0, 0x1C, 0x7F, 0x86, 0x03,
  0xCF, 0xFC, 0x60, 0x38, 0xC7, 0xC3, 0x03, 0xD0, 0x3E, 0x30, 0x7D, 0x03,
  0xE3, 0x03, 0xD0, 0x1F, 0x30, 0x3F, 0x01, 0xFB, 0x03, 0xF0, 0x0E, 0x30,
  0x3F, 0x80, 0x86, 0x01, 0xF8, 0x30, 0xC0, 0x0F, 0xCF, 0xD0, 0x00, 0xFD,
  0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE1, 0xF0,
  0x0C, 0x1E, 0x1F, 0x03, 0xE0, 0xC0, 0xF8, 0x7F, 0x08, 0x0F, 0x89, 0xF9,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x38, 0x02, 0x00, 0x01,
  0x00, 0x03, 0xFE, 0x01, 0xC0, 0xF0, 0x70, 0x0E, 0x1E, 0x00, 0xE3, 0x80,
  0x1C, 0xF8, 0x03, 0x9F, 0x00, 0x7B, 0xE0, 0x0F, 0x7E, 0x01, 0xC7, 0xC0,
  0x38, 0xFC, 0x0E, 0x0F, 0xBF, 0x81, 0xF0, 0x80, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0,
  0x07, 0xFC, 0x03, 0x3F, 0xC0, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFE,
  0x00, 0x06, 0x00, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x7F, 0xE3, 0xFC, 0xFF,
  0x03, 0xFF, 0xDF, 0xFA, 0x3E, 0x1E, 0x7F, 0xC7, 0xF0, 0xF8, 0x40, 0x3F,
  0x0F, 0xC1, 0xE2, 0x00, 0x7C, 0x1F, 0x07, 0xC8, 0x00, 0xF8, 0x3C, 0x1F,
  0x20, 0x03, 0xE0, 0xF8, 0x7E, 0x80, 0x07, 0x81, 0xE0, 0xFE, 0x00, 0x1F,
  0x07, 0x81, 0x88, 0x00, 0x3C, 0x1E, 0x0C, 0x19, 0xE0, 0xF0, 0x78, 0x60,
  0x7F, 0xC3, 0xC1, 0xE3, 0x00, 0xFF, 0x0F, 0x07, 0x0C, 0x00, 0x04, 0x38,
  0x1C, 0x70, 0x00, 0x10, 0xE0, 0x73, 0xC0, 0x00, 0x03, 0x81, 0xCF, 0x00,
  0x00, 0x0C, 0x06, 0x3C, 0x00, 0x00, 0x30, 0x18, 0xF8, 0x00, 0x80, 0x80,
  0x43, 0xE0, 0x0F, 0x84, 0xE1, 0x07, 0xC0, 0xFF, 0x37, 0xE8, 0x1F, 0xB6,
  0xFF, 0xBF, 0xC0, 0x3F, 0x81, 0xFD, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x78,
  0x01, 0xC0, 0x02, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0xC6, 0x7C, 0x1C,
  0x3F, 0x90, 0xF8, 0x40, 0x3F, 0x81, 0xE2, 0x00, 0x7E, 0x07, 0x88, 0x00,
  0xF8, 0x1F, 0x20, 0x03, 0xE0, 0x7E, 0x80, 0x07, 0xC0, 0xF2, 0x00, 0x1F,
  0x01, 0x8C, 0x00, 0x3C, 0x08, 0x1F, 0xE0, 0xF0, 0x60, 0x7F, 0xC3, 0xC3,
  0x00, 0x7F, 0x0F, 0x0C, 0x00, 0x04, 0x38, 0x70, 0x00, 0x10, 0xE3, 0xC0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x30, 0xF8, 0x01,
  0xC0, 0x83, 0xE0, 0x1F, 0x86, 0x0F, 0xC0, 0xFF, 0x30, 0x1F, 0xF4, 0x7F,
  0x80, 0x3F, 0x01, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x60, 0x3F, 0xE0, 0xC0, 0x07, 0xF8,
  0xE0, 0x00, 0xFC, 0x70, 0x00, 0x3F, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xDF, 0xC0, 0x00, 0xF7, 0xF8, 0x00, 0x7B, 0xFF, 0x00, 0x1C, 0xFF, 0x80,
  0x0E, 0x1F, 0xE0, 0x07, 0x01, 0xE0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x10,
  0x00, 0xC3, 0xD0, 0x00, 0x43, 0xF8, 0x00, 0x67, 0xFE, 0x00, 0x20, 0x7F,
  0xC0, 0x20, 0x0F, 0xF8, 0x60, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0x00, 0xFF, 0xE0, 0x38, 0x07, 0xFF,
  0xC3, 0xE0, 0x1C, 0x3F, 0xBF, 0x80, 0xC0, 0x3F, 0x3F, 0x02, 0x00, 0xFC,
  0x7E, 0x08, 0x01, 0xF1, 0xFC, 0x20, 0x07, 0xC3, 0xF8, 0x80, 0x0F, 0x07,
  0xF2, 0x00, 0x3C, 0x0F, 0xE8, 0x00, 0xF0, 0x0F, 0xD0, 0x03, 0xC0, 0x1F,
  0x38, 0xCF, 0x00, 0x3C, 0x1C, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0x70, 0x01, 0x80, 0x0F, 0xC0, 0x04, 0x00, 0x7F, 0xC0, 0x20, 0x03, 0xFF,
  0xC1, 0x00, 0x10, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x18, 0x0F, 0xF8, 0x0C, 0x00, 0x7F, 0x83,
  0x80, 0x03, 0xF0, 0x70, 0x00, 0x3F, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3C, 0x7F, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x78, 0xFF, 0xC0, 0x07, 0x0F,
  0xF8, 0x00, 0xE0, 0x3F, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x0F, 0x40, 0x39, 0x03, 0xF8, 0x1F, 0xE1, 0xFF,
  0x87, 0xF8, 0x47, 0xFC, 0x0F, 0x90, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0xCF,
  0x80, 0x1F, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0xFC,
  0x1F, 0xC0, 0x3F, 0xFE, 0x27, 0xE0, 0x7D, 0xFF, 0x43, 0xF0, 0x60, 0x3F,
  0xC1, 0xF0, 0xC0, 0x0F, 0xC1, 0xF8, 0xC0, 0x07, 0xC0, 0xF8, 0x80, 0x07,
  0xC0, 0xFE, 0x80, 0x03, 0xC0, 0x78, 0x80, 0x03, 0xC0, 0x60, 0xC0, 0x03,
  0xC0, 0x80, 0xC0, 0x01, 0xC3, 0x00, 0x60, 0x01, 0xC7, 0x80, 0x30, 0x21,
  0xDF, 0x80, 0x0F, 0xC1, 0xC7, 0xC0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x01,
  0x83, 0xE0, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x01, 0x83, 0xE0, 0x03, 0x03,
  0x03, 0xF0, 0x0F, 0x82, 0x01, 0xF0, 0x1F, 0xC4, 0x01, 0xFA, 0x27, 0xFC,
  0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x40,
  0x3F, 0xFF, 0xC0, 0x60, 0xFF, 0xC0, 0x40, 0x1F, 0xC0, 0x40, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x78, 0x18, 0x00, 0xFF,
  0x1C, 0x40, 0xFF, 0xCE, 0x11, 0xFF, 0xF7, 0x07, 0xFE, 0x0B, 0x81, 0xFC,
  0x03, 0xC0, 0x78, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x5F, 0x00,
  0x00, 0x2F, 0xC0, 0x00, 0x23, 0xF0, 0x00, 0x31, 0xFF, 0x00, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0E, 0x07, 0xFC,
  0x06, 0x00, 0xFF, 0x86, 0x00, 0x1F, 0xFE, 0x00, 0x67, 0xFD, 0x00, 0x60,
  0xF8, 0x80, 0x70, 0x18, 0x40, 0x7C, 0x00, 0x20, 0x3F, 0x00, 0x08, 0x0F,
  0xC0, 0x02, 0x0F, 0xF0, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0x80, 0x06, 0x07, 0xC0, 0x0F, 0x81, 0xC0, 0x0F, 0xE0, 0xC0, 0x1F,
  0xF8, 0xC0, 0x00, 0xFE, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x08,
  0x01, 0xFE, 0x18, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0,
  0x06, 0x0C, 0x20, 0x1C, 0x1C, 0x10, 0x78, 0x3C, 0x11, 0xF8, 0x3C, 0x21,
  0xF8, 0x7C, 0x00, 0xF0, 0x7E, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x3F, 0x80,
  0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0x00, 0xF0, 0x06, 0x00,
  0xF0, 0x04, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x7F, 0x81,
  0xF0, 0x9F, 0xC6, 0xF8, 0x07, 0xFC, 0xFF, 0x03, 0xF8, 0x7C, 0x01, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x3F,
  0xE0, 0xFC, 0x03, 0xFF, 0xC4, 0xF8, 0x1F, 0xFF, 0xA1, 0xF0, 0x70, 0x3F,
  0x87, 0xE3, 0x00, 0x7E, 0x0F, 0x8C, 0x00, 0xF8, 0x3F, 0xA0, 0x03, 0xE0,
  0x78, 0x80, 0x07, 0x80, 0x82, 0x00, 0x1E, 0x06, 0x08, 0x00, 0x78, 0x38,
  0x10, 0x01, 0xC0, 0xE0, 0x60, 0x47, 0x07, 0xC0, 0xE6, 0x18, 0x1F, 0x80,
  0x20, 0x60, 0x7F, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x08, 0x01, 0xF8, 0x00,
  0x40, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x81, 0xFF, 0x00, 0x1E, 0x0F, 0xFE,
  0x00, 0x30, 0x43, 0xFC, 0x00, 0x80, 0x03, 0xF8, 0x04, 0x00, 0x07, 0xF8,
  0x20, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x7F, 0xC7, 0x8F, 0xF0, 0x07, 0xFF,
  0x26, 0x8F, 0xC0, 0x7F, 0xFE, 0x18, 0x3F, 0x07, 0x87, 0xF0, 0xC0, 0xF8,
  0x70, 0x0F, 0x86, 0x03, 0xE3, 0x00, 0x3E, 0x70, 0x1F, 0x10, 0x01, 0xF3,
  0x80, 0x7C, 0x80, 0x07, 0xBC, 0x01, 0xD4, 0x00, 0x3D, 0xF0, 0x0C, 0x20,
  0x01, 0xE7, 0xC0, 0xC0, 0x80, 0x0F, 0x3E, 0x0E, 0x06, 0x04, 0x71, 0xF8,
  0x78, 0x18, 0x63, 0x87, 0xC7, 0xE0, 0x1C, 0x18, 0x1E, 0x1F, 0x80, 0x01,
  0x80, 0xF8, 0xFE, 0x00, 0x08, 0x03, 0x83, 0xF0, 0x00, 0x80, 0x1C, 0x0F,
  0xC0, 0x78, 0x00, 0xE0, 0x3E, 0x0F, 0xE0, 0x06, 0x00, 0xE0, 0xFF, 0x80,
  0x3C, 0x03, 0x08, 0xFE, 0x03, 0xF0, 0x10, 0x03, 0xF8, 0x3F, 0xC1, 0x00,
  0x0F, 0xFE, 0x7F, 0x10, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x20, 0x1F, 0xF0, 0x79,
  0x3F, 0xF8, 0x7F, 0x7F, 0xFC, 0xFE, 0x70, 0x7C, 0xFE, 0xE0, 0x3F, 0x88,
  0xC0, 0x1F, 0x00, 0xC0, 0x1F, 0x00, 0x80, 0x0F, 0x00, 0xC0, 0x0E, 0x00,
  0x40, 0x0F, 0xF8, 0x60, 0x1F, 0xF8, 0x31, 0x3F, 0xF0, 0x0E, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x2F, 0x80, 0x1E, 0x27, 0xE0,
  0x1F, 0xE7, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xC1, 0xF8, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x7F, 0xC3, 0xFC, 0x0F, 0xFF,
  0x13, 0xF0, 0xFF, 0xFD, 0x0F, 0x86, 0x03, 0xF8, 0x3E, 0x60, 0x0F, 0xC1,
  0xF3, 0x00, 0x3E, 0x0F, 0x90, 0x00, 0xF0, 0x3E, 0x80, 0x07, 0x81, 0xFC,
  0x00, 0x3C, 0x06, 0x20, 0x01, 0xE0, 0x60, 0x80, 0x0E, 0x07, 0x06, 0x04,
  0x70, 0x78, 0x0E, 0xC3, 0x87, 0xC0, 0x08, 0x18, 0x3F, 0x00, 0x01, 0xC1,
  0xF8, 0x00, 0x0C, 0x07, 0xE0, 0x00, 0x40, 0x3F, 0x00, 0x04, 0x00, 0xFC,
  0x00, 0x40, 0x07, 0xE0, 0x07, 0x02, 0x1F, 0x00, 0x7E, 0x30, 0xF8, 0x07,
  0xFF, 0x07, 0xC0, 0x2F, 0xF0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x70,
  0x0F, 0x00, 0x80, 0x00, 0x70, 0x02, 0x00, 0x07, 0x80, 0x08, 0x00, 0x70,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0x81, 0xFC, 0x1C, 0x01,
  0xF0, 0x60, 0x03, 0xC1, 0x80, 0x0F, 0x06, 0x00, 0x1C, 0x18, 0x00, 0xF0,
  0x20, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0xE0, 0x40, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x73,
  0xE0, 0x01, 0xDF, 0xC0, 0x06, 0xFF, 0x80, 0x18, 0x3F, 0x00, 0xC0, 0x7E,
  0x06, 0x00, 0xFE, 0x30, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDF, 0xFF, 0x80,
  0x02, 0x00, 0x38, 0x03, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0x71, 0xC1, 0xDC,
  0x06, 0x80, 0x1C, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE7, 0x1C, 0x61, 0x84, 0x00, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0xBF, 0x86, 0x3F, 0x0C, 0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x83, 0x8F, 0x07, 0x1E, 0x0E, 0x3E, 0x1C, 0x3C, 0x39, 0x7F, 0xFC,
  0x7C, 0xF8, 0x70, 0xE0, 0x80, 0x40, 0x01, 0x82, 0x18, 0x09, 0xC0, 0x17,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x08, 0x38, 0x60, 0xE7, 0xC3,
  0xEF, 0x8E, 0x1E, 0x38, 0x3C, 0xE0, 0xF3, 0x81, 0xCF, 0x07, 0x3C, 0x1C,
  0xF0, 0x73, 0xC1, 0x8F, 0x0E, 0x3C, 0x31, 0xFC, 0x8B, 0xFC, 0x03, 0xE0,
  0x03, 0x00, 0x08, 0x00, 0x03, 0x81, 0xF0, 0x4F, 0x19, 0xE6, 0x1E, 0xC3,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xFB, 0x1F, 0x81, 0xC0, 0x10, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x13, 0xF1, 0xC1, 0xE3, 0x83, 0xC7, 0x83, 0xCF, 0x07, 0x9E,
  0x07, 0x3C, 0x0C, 0x78, 0x18, 0xF0, 0x31, 0xE0, 0xC3, 0xC1, 0x8F, 0xE2,
  0x07, 0xF8, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xCF,
  0x19, 0xE6, 0x1C, 0xC3, 0xF8, 0x7F, 0x0C, 0xEE, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xFB, 0x1F, 0x81, 0xC0, 0x10, 0x00, 0x00,
  0x01, 0xC8, 0x7F, 0x0F, 0xE3, 0x38, 0x40, 0x08, 0x01, 0x80, 0x38, 0x0F,
  0xF2, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x0E,
  0x00, 0x3F, 0x00, 0xBF, 0x86, 0x1F, 0x9C, 0x1E, 0x38, 0x08, 0xE0, 0x31,
  0xC0, 0xE3, 0xC1, 0xC7, 0x83, 0x8F, 0x07, 0x9E, 0x0F, 0x1E, 0x1E, 0x3C,
  0x3E, 0x3C, 0x7C, 0x7F, 0x78, 0x70, 0xF0, 0x81, 0xE0, 0x01, 0xC0, 0x03,
  0x18, 0x0E, 0x38, 0x18, 0x38, 0x60, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC2,
  0x38, 0x09, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x10,
  0x39, 0xE0, 0xFF, 0xC3, 0x8F, 0x8E, 0x1E, 0x38, 0x3C, 0xE0, 0xF3, 0x83,
  0xCE, 0x0F, 0x38, 0x3C, 0xE0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x38, 0xF0,
  0xE7, 0xF3, 0x2F, 0x0C, 0x1C, 0x60, 0x23, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x0E, 0x0F, 0x07, 0x83, 0x80, 0x80, 0x00,
  0x40, 0x30, 0x3C, 0x1F, 0x1F, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xE0, 0xF4, 0x7C, 0x1E, 0x06, 0x01, 0x00, 0x07,
  0x01, 0xE0, 0x78, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x10, 0x0E, 0x07, 0xC1,
  0xF8, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xA0, 0xC4, 0xE0, 0xC0, 0x00, 0x03, 0xE1, 0x88, 0xC1, 0x73, 0x3D, 0xCF,
  0xF3, 0xF0, 0xF0, 0x3C, 0x1F, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x27, 0xF0, 0x78, 0x0E,
  0x01, 0x00, 0x03, 0xE1, 0x89, 0xC1, 0x70, 0x7C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x27, 0xF0, 0x78, 0x0C, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x30, 0x70, 0xE0, 0x78, 0xF9, 0xF0, 0x7D, 0xFB, 0xFC, 0xBE,
  0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x1C, 0x3C, 0x78, 0x1C, 0x3C, 0x78, 0x1C,
  0x3C, 0x78, 0x1C, 0x3C, 0x78, 0x1C, 0x3C, 0x78, 0x1C, 0x3C, 0x78, 0x1C,
  0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3E, 0x7C, 0x79, 0x7E,
  0x7E, 0x3E, 0x1C, 0x38, 0x3C, 0x18, 0x18, 0x1C, 0x08, 0x10, 0x08, 0x30,
  0x60, 0x78, 0x70, 0x7D, 0xFC, 0xFE, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3E, 0x3D, 0x7E, 0x3F, 0x1C, 0x1E, 0x18, 0x0E, 0x08,
  0x04, 0x00, 0xC0, 0x1F, 0x87, 0x9E, 0x1E, 0x7C, 0x78, 0xF9, 0xE1, 0xE7,
  0x87, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0x77, 0x81, 0xDE, 0x06, 0x78, 0x39,
  0xF0, 0xCF, 0xE6, 0x0F, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x60, 0x00, 0xF8, 0x30, 0x7C, 0x70, 0x7D, 0xF8, 0x3E,
  0x7C, 0x1C, 0x3E, 0x1C, 0x1E, 0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1E, 0x0E, 0x3E, 0x0C, 0x7E, 0x1C, 0xFF, 0x90, 0x9F,
  0xE0, 0x1F, 0xC0, 0x1D, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xF0, 0x13, 0xF8, 0xC7, 0xF6, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xF0, 0x73, 0xC1, 0xCF, 0x87, 0x1E, 0x3C, 0x7F,
  0x70, 0xF9, 0xC1, 0x87, 0x04, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x06, 0x09, 0xE3, 0x7E, 0xFB, 0xFE,
  0x79, 0xCF, 0x31, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF4, 0x7F, 0x01, 0xC0, 0x18, 0x02, 0x00, 0x03, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x10, 0x60, 0x8F, 0xCC, 0xBF, 0xE8, 0x7E, 0xC0, 0xE6,
  0x02, 0x38, 0x31, 0xE3, 0xC7, 0xFF, 0x3C, 0xF8, 0xC1, 0xE2, 0x06, 0x20,
  0x33, 0xC1, 0x3F, 0xD0, 0x7F, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x83, 0xFD, 0xFF, 0x9E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x79,
  0x3F, 0x83, 0xC0, 0x70, 0x08, 0x00, 0x10, 0x30, 0x18, 0x78, 0x3C, 0x7C,
  0x7E, 0xBC, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x7D, 0x7F, 0xBF, 0x0F, 0x1E, 0x06, 0x0C, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x21, 0x81, 0xC7, 0x87, 0xCF, 0xBF, 0x9F, 0x8F, 0x9F, 0x0F, 0x9E, 0x0F,
  0x1E, 0x1E, 0x3C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xC0, 0xE1, 0x81, 0x82,
  0x07, 0x0E, 0x0C, 0x1F, 0x30, 0x7F, 0x40, 0x1F, 0x00, 0x1C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x81, 0x81,
  0x8F, 0xC7, 0x87, 0x0F, 0x9F, 0xBF, 0x0F, 0x4F, 0x9F, 0x0F, 0x1E, 0x1E,
  0x1C, 0x3C, 0x1E, 0x38, 0x78, 0x3C, 0x70, 0xF0, 0x78, 0xE1, 0xE0, 0x71,
  0xC3, 0xC0, 0xE3, 0x87, 0x83, 0x87, 0x0F, 0x07, 0x0E, 0x1E, 0x0C, 0x1C,
  0x3E, 0x10, 0x7C, 0xFE, 0x41, 0xF8, 0x7F, 0x00, 0xE0, 0x3C, 0x00, 0x80,
  0x38, 0x01, 0x00, 0x20, 0x00, 0x10, 0x43, 0xC6, 0x3C, 0xF7, 0xEF, 0x9F,
  0xF1, 0xE7, 0x1E, 0x21, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x41, 0xFC, 0x3F, 0x87, 0xF0, 0xC6, 0x08, 0x20, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x0E, 0x1F, 0xE0, 0x78, 0x00, 0x00, 0xC0, 0x01,
  0x00, 0x07, 0x01, 0x0F, 0x82, 0x1F, 0x9E, 0x1F, 0xFE, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF2, 0x73, 0xF8, 0xC1, 0xE3, 0x81,
  0x86, 0x02, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x0C, 0x07, 0x83, 0xF1, 0x3C, 0x07, 0x01, 0xC0, 0x60, 0x30, 0x10,
  0xCF, 0x4F, 0xE0, 0x7C, 0x17, 0x88, 0xF6, 0x3D, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xB0, 0x64, 0x31, 0x88, 0x1C, 0x00, 0x01, 0x83, 0x03,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0x83,
  0x83, 0x80, 0x60, 0x18, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0xF0, 0x38,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x18, 0x06, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x38, 0x1C,
  0x1E, 0x07, 0x03, 0x80, 0xC0, 0x38, 0x06, 0x0C, 0x0C, 0x0E, 0x07, 0x07,
  0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1C, 0x0E, 0x06, 0x0E, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 27, 8, 1, -26 },
  { 25, 12, 10, 15, 1, -26 },
  { 40, 16, 20, 19, 1, -23 },
  { 80, 13, 29, 15, 1, -27 },
  { 128, 24, 26, 26, 1, -26 },
  { 206, 19, 22, 21, 1, -22 },
  { 259, 5, 10, 7, 1, -26 },
  { 266, 8, 29, 9, 1, -28 },
  { 295, 8, 29, 9, 1, -28 },
  { 324, 12, 14, 13, 0, -26 },
  { 345, 12, 12, 14, 1, -18 },
  { 363, 6, 10, 7, 0, -6 },
  { 371, 10, 7, 11, 1, -14 },
  { 380, 6, 7, 7, 1, -6 },
  { 386, 17, 29, 19, 1, -27 },
  { 448, 15, 25, 17, 1, -25 },
  { 495, 11, 25, 12, 0, -25 },
  { 530, 15, 25, 16, 1, -25 },
  { 577, 15, 25, 17, 1, -25 },
  { 624, 16, 25, 16, 0, -25 },
  { 674, 15, 25, 17, 1, -25 },
  { 721, 15, 25, 16, 1, -25 },
  { 768, 14, 24, 15, 1, -24 },
  { 810, 15, 25, 17, 1, -25 },
  { 857, 15, 26, 16, 1, -26 },
  { 906, 6, 18, 7, 1, -17 },
  { 920, 7, 21, 6, 0, -17 },
  { 939, 10, 13, 10, 0, -17 },
  { 956, 12, 8, 14, 1, -15 },
  { 968, 10, 13, 10, 0, -17 },
  { 985, 14, 27, 16, 1, -26 },
  { 1033, 21, 22, 22, 1, -17 },
  { 1091, 28, 27, 29, 1, -26 },
  { 1186, 31, 27, 32, 0, -26 },
  { 1291, 23, 26, 25, 1, -26 },
  { 1366, 27, 27, 29, 1, -26 },
  { 1458, 24, 26, 25, 1, -26 },
  { 1536, 25, 30, 27, 1, -26 },
  { 1630, 26, 27, 28, 1, -26 },
  { 1718, 26, 33, 26, 0, -28 },
  { 1826, 23, 30, 25, 1, -26 },
  { 1913, 24, 35, 26, 1, -26 },
  { 2018, 28, 27, 29, 0, -26 },
  { 2113, 19, 26, 21, 1, -25 },
  { 2175, 38, 27, 40, 1, -25 },
  { 2304, 30, 26, 32, 1, -25 },
  { 2402, 25, 27, 27, 1, -26 },
  { 2487, 30, 31, 32, 1, -25 },
  { 2604, 27, 29, 29, 1, -26 },
  { 2702, 32, 27, 33, 1, -26 },
  { 2810, 25, 26, 27, 1, -26 },
  { 2892, 25, 26, 27, 1, -26 },
  { 2974, 24, 27, 26, 1, -25 },
  { 3055, 30, 27, 32, 1, -26 },
  { 3157, 37, 27, 39, 1, -26 },
  { 3282, 24, 27, 26, 1, -26 },
  { 3363, 29, 32, 31, 1, -26 },
  { 3479, 22, 31, 24, 1, -26 },
  { 3565, 5, 29, 7, 1, -27 },
  { 3584, 22, 25, 4, -7, -23 },
  { 3653, 5, 29, 7, 1, -27 },
  { 3672, 13, 10, 15, 1, -25 },
  { 3689, 17, 3, 16, 0, 4 },
  { 3696, 5, 6, 18, 6, -25 },
  { 3700, 15, 20, 17, 1, -19 },
  { 3738, 14, 26, 16, 1, -25 },
  { 3784, 11, 19, 13, 1, -18 },
  { 3811, 15, 26, 16, 1, -25 },
  { 3860, 11, 19, 13, 1, -18 },
  { 3887, 11, 32, 9, 0, -26 },
  { 3931, 15, 27, 17, 1, -19 },
  { 3982, 14, 31, 16, 1, -25 },
  { 4037, 9, 26, 10, 0, -25 },
  { 4067, 10, 33, 9, -2, -26 },
  { 4109, 10, 26, 12, 1, -25 },
  { 4142, 10, 26, 10, 1, -25 },
  { 4175, 24, 20, 26, 1, -19 },
  { 4235, 16, 19, 18, 1, -18 },
  { 4273, 14, 19, 15, 0, -18 },
  { 4307, 16, 28, 16, 0, -21 },
  { 4363, 14, 26, 15, 1, -19 },
  { 4409, 11, 20, 13, 1, -19 },
  { 4437, 13, 23, 15, 1, -22 },
  { 4475, 10, 24, 11, 0, -23 },
  { 4505, 16, 20, 18, 1, -19 },
  { 4545, 15, 21, 16, 0, -20 },
  { 4585, 23, 22, 25, 1, -21 },
  { 4649, 12, 26, 14, 1, -19 },
  { 4688, 15, 28, 17, 1, -22 },
  { 4741, 10, 25, 12, 1, -18 },
  { 4773, 9, 29, 12, 1, -28 },
  { 4806, 2, 30, 6, 2, -28 },
  { 4814, 9, 29, 12, 1, -28 },
  { 4847, 11, 3, 13, 1, -12 },
};

const GFXfont UnifrakturMaguntia_Regular36pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular36pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular36pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR36PT7B_H_
