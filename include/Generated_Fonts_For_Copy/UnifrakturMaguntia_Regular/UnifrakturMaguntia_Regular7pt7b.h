#ifndef _UNIFRAKTURMAGUNTIA_REGULAR7PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xDC, 0xF7, 0xE0, 0x55, 0x54, 0xDE, 0x9C, 0xB9, 0x80, 0x65,
  0xEF, 0xC0, 0x6A, 0xB0, 0x25, 0x60, 0xF0, 0x5D, 0x00, 0xC0, 0x60, 0x80,
  0x32, 0x48, 0x80, 0xD6, 0xDE, 0x75, 0xC0, 0x74, 0xAE, 0x75, 0x9E, 0x5B,
  0x76, 0x73, 0x9E, 0xF3, 0xDE, 0xF5, 0x2C, 0xF5, 0xDE, 0xF6, 0xBC, 0xA0,
  0xB0, 0xF0, 0xFC, 0xB0, 0xF7, 0x24, 0xFF, 0xFF, 0x6A, 0xA6, 0x92, 0x3C,
  0x7A, 0x9E, 0xD1, 0x38, 0xFF, 0x29, 0xA7, 0x80, 0x72, 0xAA, 0x9A, 0xF8,
  0xFF, 0x2F, 0xA7, 0x80, 0x7D, 0x2F, 0xA5, 0x30, 0x77, 0xEB, 0x57, 0x80,
  0x22, 0x9A, 0x5C, 0x98, 0x74, 0xA4, 0xE5, 0xD8, 0x74, 0xA4, 0xE0, 0xE8,
  0x80, 0x79, 0xE5, 0x8A, 0xCC, 0xE9, 0x68, 0x70, 0x7E, 0x9A, 0xDB, 0x2C,
  0xFB, 0x6A, 0x5D, 0x8A, 0xEC, 0x36, 0x72, 0x9F, 0x00, 0x6A, 0xEE, 0x49,
  0x58, 0x80, 0x36, 0x72, 0x9F, 0x80, 0x6A, 0x59, 0x96, 0x64, 0x3E, 0x3F,
  0x17, 0x00, 0x75, 0x68, 0xEB, 0x80, 0xDE, 0x95, 0x27, 0x80, 0x7A, 0xBE,
  0x89, 0x78, 0x7F, 0x57, 0xAA, 0x53, 0xE0, 0x7D, 0x1C, 0x4D, 0x80, 0x7A,
  0x9E, 0x8B, 0x75, 0xE0, 0x79, 0x53, 0xD2, 0xF8, 0x12, 0x48, 0x80, 0xF8,
  0x54, 0xE0, 0x80, 0x56, 0xF0, 0xDA, 0xD4, 0x79, 0x9A, 0xD4, 0x79, 0x6E,
  0xA0, 0x56, 0xDE, 0xDA, 0xDE, 0x80, 0xAE, 0x40, 0xAA, 0xB0, 0xFE, 0xC0,
  0xEA, 0xC0, 0xD5, 0xED, 0xD0, 0xD6, 0xF0, 0x56, 0xE0, 0xD6, 0xE8, 0x56,
  0xF4, 0xFB, 0xFA, 0xA0, 0xFB, 0xB6, 0xF0, 0xD6, 0xE0, 0x97, 0x6B, 0xE0,
  0xCD, 0x2C, 0xD6, 0xF4, 0x9F, 0xC0, 0xEA, 0xC0, 0xF8, 0xA6, 0x80, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 3, 2, 3, 0, -5 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 5, 5, 0, -5 },
  { 11, 4, 4, 4, 0, -4 },
  { 13, 1, 2, 1, 0, -5 },
  { 14, 2, 6, 2, 0, -6 },
  { 16, 2, 6, 2, 0, -6 },
  { 18, 2, 3, 2, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 1, 0, -1 },
  { 22, 2, 2, 2, 0, -3 },
  { 23, 1, 1, 1, 0, -1 },
  { 24, 4, 5, 4, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 2, 5, 2, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 1, 3, 1, 0, -3 },
  { 48, 1, 4, 1, 0, -3 },
  { 49, 2, 2, 2, 0, -3 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 2, 2, 2, 0, -3 },
  { 52, 3, 5, 3, 0, -5 },
  { 54, 4, 4, 4, 0, -3 },
  { 56, 6, 5, 6, 0, -5 },
  { 60, 6, 5, 6, 0, -5 },
  { 64, 5, 5, 5, 0, -5 },
  { 68, 6, 5, 6, 0, -5 },
  { 72, 5, 5, 5, 0, -5 },
  { 76, 5, 6, 5, 0, -5 },
  { 80, 5, 5, 5, 0, -5 },
  { 84, 5, 6, 5, 0, -5 },
  { 88, 5, 6, 5, 0, -5 },
  { 92, 5, 7, 5, 0, -5 },
  { 97, 6, 5, 6, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 8, 5, 8, 0, -5 },
  { 109, 6, 5, 6, 0, -5 },
  { 113, 5, 5, 5, 0, -5 },
  { 117, 6, 6, 6, 0, -5 },
  { 122, 5, 5, 6, 0, -5 },
  { 126, 6, 5, 7, 0, -5 },
  { 130, 5, 5, 5, 0, -5 },
  { 134, 5, 5, 5, 0, -5 },
  { 138, 5, 5, 5, 0, -5 },
  { 142, 6, 5, 6, 0, -5 },
  { 146, 7, 5, 8, 0, -5 },
  { 151, 5, 5, 5, 0, -5 },
  { 155, 6, 6, 6, 0, -5 },
  { 160, 4, 6, 5, 0, -5 },
  { 163, 1, 5, 1, 0, -5 },
  { 164, 4, 5, 1, -1, -5 },
  { 167, 1, 5, 1, 0, -5 },
  { 168, 3, 2, 3, 0, -5 },
  { 169, 3, 1, 3, 0, 1 },
  { 170, 1, 1, 4, 1, -5 },
  { 171, 3, 4, 3, 0, -4 },
  { 173, 3, 5, 3, 0, -5 },
  { 175, 2, 4, 2, 0, -4 },
  { 176, 3, 5, 3, 0, -5 },
  { 178, 2, 4, 3, 0, -4 },
  { 179, 2, 6, 2, 0, -5 },
  { 181, 3, 5, 3, 0, -4 },
  { 183, 3, 6, 3, 0, -5 },
  { 186, 2, 5, 2, 0, -5 },
  { 188, 2, 6, 2, 0, -5 },
  { 190, 2, 5, 2, 0, -5 },
  { 192, 2, 5, 2, 0, -5 },
  { 194, 5, 4, 5, 0, -4 },
  { 197, 3, 4, 4, 0, -4 },
  { 199, 3, 4, 3, 0, -4 },
  { 201, 3, 5, 3, 0, -4 },
  { 203, 3, 5, 3, 0, -4 },
  { 205, 2, 4, 3, 0, -4 },
  { 206, 3, 4, 3, 0, -4 },
  { 208, 2, 4, 2, 0, -4 },
  { 209, 3, 4, 4, 0, -4 },
  { 211, 3, 4, 3, 0, -4 },
  { 213, 5, 4, 5, 0, -4 },
  { 216, 3, 5, 3, 0, -4 },
  { 218, 3, 5, 3, 0, -4 },
  { 220, 2, 5, 2, 0, -4 },
  { 222, 2, 5, 2, 0, -5 },
  { 224, 1, 5, 1, 0, -5 },
  { 225, 2, 5, 2, 0, -5 },
  { 227, 2, 1, 3, 0, -3 },
};

const GFXfont UnifrakturMaguntia_Regular7pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular7pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular7pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR7PT7B_H_
