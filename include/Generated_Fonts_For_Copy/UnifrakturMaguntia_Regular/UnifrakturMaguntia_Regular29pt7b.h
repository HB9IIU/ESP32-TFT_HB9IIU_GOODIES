#ifndef _UNIFRAKTURMAGUNTIA_REGULAR29PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0x23, 0x3F, 0xE7, 0x39, 0xCC, 0x21, 0x08, 0x42, 0x10, 0x00, 0x01,
  0x1D, 0xF2, 0x00, 0x41, 0x18, 0x4F, 0x3D, 0xDF, 0x31, 0x88, 0x22, 0x11,
  0x04, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x19, 0x87, 0xFF, 0xBF, 0xFC, 0x63,
  0x03, 0x18, 0x18, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x03, 0x98, 0x18, 0xC0,
  0xC6, 0x06, 0x30, 0x04, 0x01, 0x00, 0x40, 0x78, 0x31, 0x18, 0x26, 0x1D,
  0x87, 0x70, 0x9E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x07, 0xC0,
  0xD0, 0x26, 0x18, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80,
  0x0D, 0x98, 0x02, 0x73, 0x00, 0xCE, 0x70, 0x31, 0xCE, 0x0C, 0x39, 0xC1,
  0x07, 0x38, 0x40, 0xE6, 0x10, 0x0C, 0xC4, 0x00, 0xF1, 0x9C, 0x00, 0x66,
  0x60, 0x19, 0xCC, 0x02, 0x39, 0xC0, 0x87, 0x38, 0x20, 0xE7, 0x08, 0x1C,
  0xE2, 0x03, 0x9C, 0xC0, 0x73, 0x30, 0x06, 0x64, 0x00, 0x78, 0x07, 0x80,
  0x19, 0x80, 0x73, 0x00, 0xE6, 0x01, 0xCC, 0x03, 0x90, 0x07, 0xC0, 0x07,
  0x1F, 0x1F, 0x1C, 0x7E, 0x11, 0x9E, 0x27, 0x3C, 0x8E, 0x3D, 0x1C, 0x7C,
  0x38, 0x78, 0x78, 0xF9, 0x78, 0xFC, 0x7E, 0x70, 0x21, 0x9E, 0x71, 0x88,
  0x44, 0x06, 0x10, 0x41, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x8F,
  0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x83, 0x02, 0x02, 0x03, 0x40, 0x60,
  0x40, 0xC1, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xC1, 0x82, 0x0C, 0x20, 0x08, 0x03, 0x03, 0xE3, 0xB7,
  0x6B, 0x9F, 0xE5, 0xE9, 0xEE, 0xED, 0x8F, 0x90, 0xC0, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x23, 0xBE, 0x61, 0x10, 0x80, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x23, 0x9E,
  0x40, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80, 0xE6, 0x06, 0x18, 0x70,
  0xE7, 0x87, 0x3C, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7F, 0xC3, 0xFE, 0x1E,
  0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0E, 0x38, 0x70, 0xC3, 0x06,
  0x30, 0x0F, 0x00, 0x04, 0x06, 0x07, 0x07, 0x87, 0xC4, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x07,
  0x8F, 0xF0, 0x0F, 0x83, 0xFE, 0x31, 0xF6, 0x0F, 0x40, 0x74, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x41, 0x08,
  0x11, 0x01, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0xC1, 0x8F, 0x10,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x38, 0x03, 0xE0, 0x7F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1D, 0x80, 0xEE, 0x07, 0x70, 0x33,
  0x83, 0x0E, 0x30, 0x3F, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x5C, 0x04, 0xE0, 0x27, 0x02, 0x38, 0x31, 0xC1, 0x0E, 0x10, 0x70, 0x83,
  0x8F, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF8,
  0x1F, 0xE0, 0x00, 0x21, 0xFF, 0x07, 0xF0, 0x3F, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x05, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x61, 0xF6, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x60, 0x3B, 0x81, 0x9C, 0x0C, 0xE0, 0xC3, 0x8C,
  0x0F, 0xC0, 0x07, 0xC0, 0x67, 0x06, 0x1C, 0x70, 0xE3, 0x87, 0x18, 0x11,
  0xC0, 0x0E, 0x00, 0x73, 0xC3, 0xA7, 0x1E, 0x1C, 0xF0, 0xE7, 0x87, 0xB8,
  0x3D, 0xC1, 0xEE, 0x0E, 0x78, 0x71, 0xC3, 0x8E, 0x18, 0x31, 0x80, 0x78,
  0x00, 0x3F, 0xF7, 0xFF, 0x40, 0x24, 0x02, 0x80, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0xC1, 0x81, 0x0C, 0x0C, 0xC0,
  0x67, 0x03, 0x3C, 0x19, 0xF1, 0x87, 0xF8, 0x1F, 0xC0, 0x7F, 0x04, 0xFC,
  0x41, 0xE6, 0x07, 0xB0, 0x1F, 0x80, 0xEC, 0x07, 0x60, 0x33, 0x01, 0x8C,
  0x18, 0x1F, 0x00, 0x0F, 0x80, 0xC6, 0x0C, 0x38, 0x61, 0xC7, 0x07, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9C, 0x3C, 0x72, 0xE1, 0xE7,
  0x00, 0x38, 0x01, 0xC4, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x30, 0x71, 0x00,
  0xF0, 0x00, 0x21, 0x9E, 0x62, 0x00, 0x00, 0x00, 0x08, 0xE7, 0x90, 0x21,
  0x9E, 0x62, 0x00, 0x00, 0x00, 0x08, 0xEF, 0x98, 0x44, 0x20, 0x00, 0x03,
  0x07, 0x0E, 0x1C, 0x78, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F,
  0x0E, 0x1C, 0x30, 0x60, 0xC0, 0x1F, 0x0C, 0x3B, 0x03, 0x60, 0x7E, 0x0F,
  0xE1, 0xD0, 0x78, 0x3E, 0x1F, 0x87, 0xC0, 0xC0, 0x18, 0x43, 0x08, 0x71,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x40, 0x01, 0xF8,
  0x03, 0x07, 0x06, 0x00, 0x86, 0x00, 0x63, 0x0F, 0x93, 0x1D, 0xCD, 0x9C,
  0xE6, 0xCC, 0x62, 0xCE, 0x33, 0x67, 0x39, 0x9B, 0xBD, 0x8C, 0xEF, 0x16,
  0x00, 0x19, 0x80, 0x18, 0x60, 0x18, 0x18, 0x18, 0x03, 0xF0, 0x00, 0x07,
  0x00, 0x08, 0x7F, 0x80, 0xC3, 0xFF, 0x0F, 0x10, 0x7C, 0xF8, 0x80, 0xF9,
  0xE2, 0x01, 0xE3, 0x88, 0x03, 0x8E, 0x20, 0x0E, 0x38, 0xE0, 0x38, 0xE3,
  0xE0, 0xE3, 0x87, 0xC3, 0x0E, 0x07, 0x18, 0x78, 0x04, 0x41, 0xE0, 0x22,
  0x07, 0x80, 0x10, 0x0E, 0x00, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x7F, 0x87,
  0x80, 0x3F, 0x6F, 0xC0, 0x7F, 0x3E, 0x00, 0xF8, 0x70, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x0F, 0xF8, 0xFC, 0x0F, 0xFE, 0x8F, 0x0E, 0x0F, 0xC7,
  0xC6, 0x03, 0xC1, 0xE6, 0x00, 0xE0, 0xF3, 0x00, 0x70, 0x3D, 0x80, 0x38,
  0x18, 0x40, 0x1C, 0x18, 0x30, 0x0E, 0x7F, 0x0C, 0x26, 0x7F, 0xC1, 0xE3,
  0x03, 0xF0, 0x03, 0x00, 0x78, 0x03, 0x00, 0x1C, 0x02, 0x00, 0x0E, 0x03,
  0xC0, 0x07, 0x07, 0xF0, 0x03, 0x00, 0x7E, 0x01, 0x80, 0x1F, 0x81, 0x80,
  0x07, 0xF3, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x84, 0x07,
  0x13, 0xD3, 0x83, 0xFC, 0xC1, 0x1C, 0x71, 0x80, 0x1C, 0xE0, 0x0F, 0x38,
  0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x1F, 0x83, 0xC1, 0xF0,
  0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0x81, 0xC1, 0xF0, 0x60, 0x3E, 0x30, 0x07,
  0xD0, 0x00, 0xFC, 0x04, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x07, 0xF0, 0x70, 0x43, 0xE3, 0x02,
  0x07, 0xCC, 0x18, 0x0F, 0xA0, 0xF0, 0x1E, 0x83, 0xE0, 0x3A, 0x07, 0xC0,
  0x68, 0x1F, 0x81, 0xF0, 0x1E, 0x03, 0x60, 0x38, 0x0C, 0x7C, 0xE0, 0x20,
  0x01, 0x00, 0x80, 0x08, 0x06, 0x07, 0x80, 0x10, 0x7F, 0x80, 0x83, 0xFF,
  0x86, 0x10, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x86,
  0x03, 0x89, 0xE8, 0xE0, 0xFF, 0x18, 0x23, 0x87, 0x18, 0x00, 0xE7, 0x00,
  0x3C, 0xE0, 0x07, 0x1E, 0x38, 0xE3, 0xE7, 0xFE, 0x3F, 0xFB, 0xC3, 0xE6,
  0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x03, 0xE0, 0xC0,
  0x3E, 0x30, 0x03, 0xE8, 0x00, 0x3F, 0x01, 0x03, 0xFF, 0xC0, 0x3F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xD3, 0x81,
  0xFF, 0x38, 0x01, 0xF1, 0x80, 0x67, 0x08, 0x02, 0x00, 0x40, 0x30, 0x02,
  0x03, 0xC1, 0x10, 0x1F, 0x1C, 0xC0, 0x7C, 0xF2, 0x03, 0xEF, 0x8C, 0x6F,
  0x98, 0x1C, 0x3E, 0x00, 0x00, 0xF0, 0x1C, 0x07, 0xC0, 0x30, 0x1E, 0x01,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0C,
  0x00, 0xE0, 0xE0, 0x03, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x82, 0x00,
  0x63, 0x38, 0x06, 0x0B, 0xE0, 0x70, 0x4F, 0x87, 0x04, 0x3F, 0x38, 0xC0,
  0xF3, 0xCE, 0x02, 0x1E, 0x78, 0x60, 0xF3, 0xC7, 0xC7, 0x8F, 0x7F, 0x3C,
  0x7C, 0x7D, 0xE1, 0xF1, 0xEF, 0x07, 0x87, 0x78, 0x3C, 0x3B, 0xE0, 0xE1,
  0xCF, 0x07, 0x0E, 0x7C, 0x30, 0x71, 0xE2, 0x03, 0x07, 0x80, 0x30, 0x1E,
  0x03, 0x00, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0x00, 0x02, 0x7C, 0x00, 0x21, 0xF0, 0x02, 0x06, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x20, 0x0E, 0x07, 0x80, 0x78, 0x7E, 0x03, 0xEF, 0xF8,
  0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xC0, 0x1E,
  0x0F, 0x00, 0x70, 0x78, 0xC3, 0x83, 0x9F, 0x08, 0x1C, 0xFC, 0x80, 0xE1,
  0xF8, 0x0E, 0x07, 0x80, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x60, 0xFC, 0x18,
  0x0F, 0xF3, 0x00, 0xF8, 0x40, 0x02, 0x08, 0x01, 0x81, 0x00, 0x30, 0x30,
  0x0E, 0x02, 0x01, 0xC0, 0x20, 0x3C, 0x03, 0xF7, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0xFC,
  0x03, 0x3F, 0xC0, 0x60, 0xFC, 0x08, 0x0F, 0xC2, 0x00, 0xFF, 0x80, 0x07,
  0x80, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xC3, 0xF0, 0x30, 0x1F, 0xE4, 0x01,
  0xF0, 0x80, 0x04, 0x10, 0x03, 0x02, 0x00, 0x60, 0x40, 0x1C, 0x04, 0x03,
  0xC0, 0x40, 0x78, 0x07, 0xEF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x70, 0x01, 0x9F, 0x80, 0x65, 0xF8, 0x0C, 0x1F, 0x81,
  0x00, 0xFC, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xE1, 0xC0, 0x07, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x31, 0xF8, 0xC0, 0xE7,
  0xF8, 0x81, 0xD0, 0xF1, 0x07, 0xA0, 0xF3, 0x0F, 0x41, 0xE6, 0x0F, 0x81,
  0xE8, 0x1F, 0x01, 0x10, 0x3E, 0x0C, 0x40, 0x3E, 0x79, 0x00, 0x3F, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x38, 0xF0, 0x18, 0x71, 0xE0, 0x78, 0x41, 0xE1,
  0xF9, 0x03, 0xE4, 0xFC, 0x03, 0xF0, 0xF0, 0x03, 0x80, 0x00, 0x04, 0x00,
  0x07, 0xF8, 0x0C, 0x0E, 0x18, 0x06, 0x38, 0x07, 0x38, 0x07, 0x3C, 0x07,
  0x3C, 0x07, 0x3E, 0x06, 0x1E, 0x0E, 0x1F, 0xF8, 0x0F, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x7F, 0x81, 0x0F, 0xE2,
  0x07, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xC3, 0xC0, 0xFF, 0xBF,
  0x97, 0x87, 0xFF, 0x9F, 0x8F, 0x30, 0x3E, 0x3E, 0x1C, 0x80, 0x78, 0x78,
  0x7A, 0x00, 0xF0, 0xE1, 0xE8, 0x03, 0xC3, 0x87, 0xE0, 0x07, 0x0E, 0x0C,
  0x80, 0x1C, 0x38, 0x21, 0xF8, 0x70, 0xE1, 0x07, 0xF1, 0xC1, 0x8C, 0x00,
  0x47, 0x06, 0x70, 0x02, 0x18, 0x19, 0xC0, 0x00, 0x60, 0x4F, 0x00, 0x01,
  0x83, 0x3C, 0x02, 0x04, 0x08, 0xF0, 0x3E, 0x2E, 0x21, 0xE1, 0xFC, 0xFF,
  0x07, 0xF0, 0xFD, 0xF8, 0x0F, 0x81, 0xE9, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x7F, 0xE3, 0xF8, 0x7F,
  0xF4, 0x38, 0xC0, 0xFC, 0x3C, 0x80, 0x78, 0x3C, 0x80, 0x3C, 0x3C, 0x80,
  0x3C, 0x1F, 0x80, 0x1C, 0x08, 0x80, 0x1C, 0x10, 0x7E, 0x1C, 0x30, 0x3F,
  0x1C, 0x60, 0x01, 0x1C, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x18, 0xF0, 0x0C, 0x10, 0xF0, 0x3E, 0x20, 0xF8, 0x7F, 0x60, 0x7F, 0x0F,
  0xC0, 0x3C, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x18, 0x1F, 0x86, 0x00, 0x7C, 0x60,
  0x03, 0xEE, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x77,
  0xF8, 0x07, 0x1F, 0x80, 0x30, 0x38, 0x02, 0x01, 0x00, 0x21, 0xA0, 0x06,
  0x7E, 0x00, 0x4F, 0xF0, 0x08, 0x1F, 0xC1, 0x00, 0x7F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x1F, 0xF8, 0x70, 0x1C, 0x7E, 0xFC,
  0x08, 0x0F, 0x9E, 0x04, 0x07, 0x8F, 0x84, 0x01, 0xE3, 0xF2, 0x00, 0xF0,
  0xFC, 0x80, 0x78, 0x3E, 0x40, 0x3C, 0x0F, 0x90, 0x5E, 0x03, 0xC7, 0x87,
  0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x08, 0x00,
  0x70, 0x04, 0x00, 0xF8, 0x04, 0x00, 0xFE, 0x02, 0x00, 0xFF, 0xE6, 0x00,
  0x87, 0xFE, 0x00, 0x03, 0x7E, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x18, 0x1F, 0x81,
  0x80, 0x1F, 0x06, 0x00, 0x3E, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0xF0,
  0x01, 0xCF, 0xF0, 0x07, 0x1F, 0xE0, 0x1C, 0x1F, 0x80, 0x30, 0x0E, 0x00,
  0x80, 0x10, 0x02, 0x06, 0x80, 0xD8, 0x7E, 0x0F, 0xC3, 0xFC, 0x7F, 0x21,
  0xFC, 0x1F, 0x81, 0xFF, 0xFC, 0x03, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xF8, 0x0F, 0xFC, 0xFE, 0x0F,
  0xFE, 0x47, 0x8C, 0x0F, 0xC3, 0xE6, 0x03, 0xE0, 0xF2, 0x00, 0xF0, 0x7D,
  0x00, 0x38, 0x1C, 0x80, 0x1C, 0x0C, 0x40, 0x06, 0x08, 0x30, 0x03, 0x18,
  0x0C, 0x11, 0xBE, 0x01, 0xF0, 0xCF, 0x80, 0x00, 0x63, 0xC0, 0x00, 0x31,
  0xE0, 0x00, 0x10, 0x78, 0x04, 0x18, 0x3C, 0x0F, 0x08, 0x1E, 0x0F, 0xC8,
  0x0F, 0xA1, 0xF8, 0x03, 0xE0, 0x78, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x60, 0xC7, 0xFC, 0x10, 0x1F, 0x82, 0x00, 0x20, 0x60,
  0x00, 0x04, 0x00, 0x20, 0xC0, 0x1F, 0x8C, 0x43, 0xFE, 0xC3, 0xFF, 0x2C,
  0x1F, 0x81, 0xE0, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x17, 0x80, 0x03,
  0x7C, 0x00, 0x63, 0xF8, 0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x60, 0xFE, 0x0C, 0x03, 0xF9, 0x80,
  0x4F, 0xE8, 0x18, 0x7C, 0x81, 0xC1, 0x08, 0x1E, 0x00, 0x81, 0xF0, 0x04,
  0x0F, 0x80, 0x3E, 0x7C, 0x00, 0x03, 0xC0, 0x0C, 0x1C, 0x03, 0xE1, 0x80,
  0xFF, 0x30, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x06, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x0F, 0x80, 0x47, 0x10, 0x30, 0xC2, 0x1E, 0x38, 0x47,
  0x87, 0x80, 0x70, 0xF8, 0x0E, 0x1F, 0x81, 0xC1, 0xF0, 0x38, 0x1F, 0x07,
  0x01, 0xE0, 0xE0, 0x3C, 0x1C, 0x03, 0x03, 0x80, 0x40, 0x70, 0x10, 0x0E,
  0x06, 0x01, 0xC1, 0xE0, 0x38, 0x7E, 0x1F, 0x13, 0xFC, 0xFC, 0x3F, 0x1F,
  0x03, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x3F,
  0xE3, 0xF0, 0x7F, 0xF4, 0xF8, 0xE1, 0xF8, 0x78, 0xC0, 0x78, 0x7C, 0x80,
  0x78, 0x3E, 0x80, 0x38, 0x18, 0x80, 0x38, 0x10, 0x80, 0x18, 0x30, 0x80,
  0x18, 0x70, 0x61, 0x30, 0x78, 0x1E, 0x30, 0x7C, 0x00, 0x20, 0x3E, 0x00,
  0x40, 0x3E, 0x03, 0x80, 0x1E, 0x07, 0xC0, 0x0E, 0x1F, 0xF0, 0x0C, 0x21,
  0xF8, 0x0C, 0x00, 0xFC, 0x08, 0x00, 0x7F, 0xB0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x02, 0x02, 0x06, 0x00, 0x7F, 0x1C, 0xFE, 0x07, 0xFF, 0x8C,
  0x7C, 0x1C, 0x7C, 0x20, 0xF8, 0xC0, 0x78, 0x81, 0xE2, 0x01, 0xE6, 0x07,
  0xC8, 0x03, 0x9C, 0x0F, 0x20, 0x0E, 0x70, 0x10, 0x80, 0x19, 0xE0, 0xC2,
  0x00, 0x67, 0xC7, 0x04, 0x11, 0x8F, 0x1E, 0x0F, 0x8C, 0x3C, 0x7C, 0x00,
  0x20, 0x71, 0xF8, 0x01, 0x01, 0xC3, 0xE0, 0x08, 0x03, 0x07, 0x83, 0xE0,
  0x08, 0x0E, 0x1F, 0xC0, 0x70, 0x19, 0x8F, 0x81, 0xE0, 0x40, 0x1F, 0x1F,
  0xE2, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x02, 0x07, 0xF0, 0x7D, 0xFF, 0x1F, 0xB9, 0xF3, 0xEC, 0x0E,
  0x89, 0x00, 0xF0, 0x20, 0x1C, 0x04, 0x03, 0x80, 0x80, 0x7F, 0x88, 0x1F,
  0xF0, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xBC, 0x07, 0x97, 0xC8, 0xFC, 0x7F, 0xBF, 0x87,
  0xC9, 0xE0, 0x70, 0x07, 0x01, 0xE0, 0x7F, 0xC7, 0xE1, 0xFF, 0xD1, 0xE7,
  0x0F, 0xC3, 0xCC, 0x07, 0x87, 0xD0, 0x07, 0x07, 0xA0, 0x0E, 0x0F, 0xC0,
  0x1C, 0x0C, 0x80, 0x18, 0x11, 0x80, 0x30, 0xE1, 0x84, 0xE3, 0xC0, 0x71,
  0x87, 0x80, 0x03, 0x0F, 0x80, 0x0C, 0x0F, 0x00, 0x10, 0x1F, 0x00, 0x40,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0xCC, 0x78, 0x1F, 0xF0, 0x70, 0x07, 0xC0,
  0xE0, 0x07, 0x01, 0xC1, 0x00, 0x07, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x70,
  0x00, 0xE7, 0x80, 0x00, 0x28, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x30,
  0x3E, 0x04, 0x03, 0xC1, 0x80, 0x38, 0x30, 0x07, 0x06, 0x00, 0xE0, 0xC0,
  0x18, 0x0C, 0x06, 0x00, 0xE1, 0x80, 0x01, 0xFC, 0x00, 0xDF, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xC3, 0x80,
  0x18, 0xF8, 0x03, 0x2F, 0x80, 0x40, 0xF8, 0x18, 0x0F, 0xC4, 0x00, 0xFF,
  0x00, 0x03, 0x00, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x7C, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00,
  0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xFC, 0x0C, 0x03, 0x01, 0xE0, 0xFC, 0x73, 0x98, 0x68, 0x06, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0xCE, 0x62, 0x10, 0x04, 0x00, 0x60, 0x0F, 0x01,
  0x7C, 0x63, 0xE6, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF,
  0x1C, 0x7B, 0xD7, 0xDE, 0x38, 0xC2, 0x04, 0x06, 0x13, 0x02, 0xC0, 0x38,
  0x07, 0x00, 0xE2, 0x1C, 0x63, 0xBE, 0x79, 0xCE, 0x3D, 0xC3, 0xB8, 0x77,
  0x06, 0xE0, 0xDC, 0x3B, 0x86, 0x78, 0x9F, 0xA0, 0x78, 0x06, 0x00, 0x40,
  0x02, 0x0F, 0x0B, 0xCC, 0xEE, 0x76, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38,
  0x1E, 0x07, 0x81, 0xFC, 0x70, 0x20, 0x60, 0x0C, 0x00, 0xC0, 0x0F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x19, 0xE7, 0x0E, 0x70, 0xF7, 0x07,
  0x70, 0x77, 0x06, 0x70, 0x67, 0x06, 0x78, 0x4F, 0xE8, 0x1F, 0x00, 0xE0,
  0x00, 0x00, 0x02, 0x0F, 0x0B, 0x8C, 0xEE, 0x76, 0x1F, 0x09, 0xF8, 0xE0,
  0x70, 0x38, 0x1E, 0x07, 0x81, 0xFC, 0x70, 0x20, 0x00, 0x1F, 0x8F, 0xC4,
  0xC4, 0x01, 0x00, 0xC1, 0xFC, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x04, 0x00, 0x60, 0x0F, 0x83, 0x7E, 0x61, 0xC6, 0x0C, 0xE0,
  0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x1C, 0x71, 0xE7, 0xEE, 0x38,
  0xE2, 0x0E, 0x00, 0xE4, 0x0C, 0x60, 0xC7, 0x10, 0x1E, 0x00, 0x0F, 0x13,
  0x02, 0xC0, 0x38, 0x07, 0x00, 0xE2, 0x1C, 0xE3, 0xFC, 0x71, 0xCE, 0x3D,
  0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x9B, 0xE2,
  0x18, 0xC1, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x1C, 0x78, 0x60,
  0x80, 0x02, 0x0E, 0x3E, 0xBC, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x7C, 0x78, 0x60, 0x00, 0x06, 0x07, 0x03, 0x80, 0x80, 0x00, 0x00, 0x30,
  0x3C, 0x1F, 0x37, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1A, 0x19, 0x78, 0x40, 0x07, 0x98,
  0xBB, 0x77, 0x7F, 0x78, 0x78, 0xFF, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x7E, 0xBC, 0x18, 0x08, 0x0F, 0x98, 0xB0, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x7E, 0xBC, 0x18, 0x10, 0x61, 0x84, 0x0E, 0x39, 0xC3, 0xFF, 0xFF, 0x5C,
  0x73, 0xC3, 0x8E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x38,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0x71, 0xC7, 0xDF, 0x3E, 0x71,
  0xC7, 0x84, 0x10, 0x61, 0x04, 0x00, 0x41, 0x03, 0x8C, 0x3C, 0xF9, 0xFB,
  0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x38,
  0x71, 0xC7, 0x8E, 0x9E, 0x78, 0xC1, 0xC4, 0x04, 0x01, 0x00, 0xF1, 0xFE,
  0x39, 0xE7, 0x3C, 0xE3, 0xDC, 0x3B, 0x87, 0x70, 0x6E, 0x0D, 0xC3, 0x3C,
  0x6F, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x38, 0x21, 0xF1,
  0x87, 0xBE, 0x1E, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0x71, 0xC1, 0x8E, 0x0C,
  0x70, 0x63, 0x87, 0x7E, 0x33, 0xFD, 0x03, 0xF0, 0x1B, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x00, 0x02, 0x00, 0x70, 0x0F,
  0x81, 0x3F, 0x31, 0xE6, 0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xC7, 0x0E, 0x70,
  0xE7, 0x8E, 0x7D, 0xE3, 0xEE, 0x18, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x42, 0x39, 0xBD, 0xDF, 0x73, 0xB1, 0xD0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xE1, 0xE0, 0x20, 0x00, 0x0E, 0x00,
  0x10, 0x01, 0x04, 0x21, 0xE4, 0xFF, 0x91, 0xE6, 0x08, 0xC2, 0x1C, 0xE3,
  0xFE, 0x39, 0xE2, 0x1C, 0x81, 0xBC, 0x27, 0xF8, 0x1E, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x0C, 0x1C, 0x38, 0x7F, 0x98, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x3F, 0x5E, 0x0C, 0x04, 0x40, 0x43, 0x87,
  0x3C, 0x7D, 0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1,
  0xC7, 0x0E, 0x38, 0x71, 0xC7, 0xDF, 0x9F, 0x78, 0x21, 0xC0, 0x00, 0x60,
  0x04, 0x08, 0xE1, 0xCF, 0x7E, 0xF8, 0xE7, 0x8F, 0x38, 0x71, 0x87, 0x18,
  0x71, 0x83, 0x18, 0x71, 0x06, 0x18, 0x43, 0xE8, 0x5F, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x23, 0xC7, 0x0C, 0xFB, 0xEF,
  0x9F, 0x3C, 0xE3, 0x8E, 0x3C, 0xE3, 0x87, 0x38, 0xE1, 0xCE, 0x38, 0x33,
  0x8E, 0x0C, 0xE3, 0x87, 0x38, 0xE1, 0x8E, 0x3C, 0x47, 0xDF, 0xE0, 0xE0,
  0xF0, 0x10, 0x18, 0x04, 0x02, 0x00, 0x31, 0x1E, 0x67, 0xBC, 0xF7, 0x19,
  0x86, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xF4, 0x3E, 0x1F, 0x08,
  0xC2, 0x20, 0x80, 0x20, 0x04, 0x30, 0xFE, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0xE0, 0x8F, 0x18, 0xFF, 0xC7, 0x9E, 0x38, 0xE3, 0x8F, 0x38, 0x73, 0x87,
  0x38, 0x73, 0x87, 0x38, 0x73, 0x86, 0x7A, 0x67, 0xCC, 0x18, 0x81, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x18, 0x3C, 0x7C, 0x8E, 0x0C, 0x18,
  0x31, 0x7E, 0xFC, 0x1E, 0x2E, 0x4F, 0xC7, 0x87, 0x87, 0x87, 0x86, 0x86,
  0x84, 0x78, 0x02, 0x18, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC7,
  0x0E, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x03, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xC1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0x60, 0x60, 0xE3, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86,
  0x18, 0x40, 0xFF, 0xFF, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 21, 7, 1, -21 },
  { 15, 10, 8, 12, 1, -21 },
  { 25, 13, 16, 15, 1, -18 },
  { 51, 10, 23, 12, 1, -22 },
  { 80, 19, 21, 21, 1, -21 },
  { 130, 15, 18, 17, 1, -18 },
  { 164, 5, 8, 6, 0, -21 },
  { 169, 7, 24, 7, 0, -23 },
  { 190, 7, 24, 7, 0, -23 },
  { 211, 10, 12, 10, 0, -22 },
  { 226, 10, 11, 11, 1, -15 },
  { 240, 5, 8, 5, 0, -4 },
  { 245, 8, 5, 9, 1, -11 },
  { 250, 5, 4, 6, 0, -4 },
  { 253, 14, 23, 15, 1, -22 },
  { 294, 13, 20, 14, 0, -20 },
  { 327, 9, 20, 9, 0, -20 },
  { 350, 12, 20, 13, 0, -20 },
  { 380, 13, 20, 14, 0, -20 },
  { 413, 13, 20, 13, 0, -20 },
  { 446, 13, 22, 14, 0, -22 },
  { 482, 13, 21, 13, 0, -21 },
  { 517, 12, 19, 12, 0, -19 },
  { 546, 13, 20, 14, 0, -20 },
  { 579, 13, 21, 13, 0, -21 },
  { 614, 5, 14, 6, 0, -14 },
  { 623, 5, 18, 5, 0, -14 },
  { 635, 8, 11, 8, 0, -14 },
  { 646, 10, 6, 11, 1, -12 },
  { 654, 8, 11, 8, 0, -14 },
  { 665, 11, 21, 13, 1, -21 },
  { 694, 17, 17, 18, 0, -13 },
  { 731, 22, 22, 24, 1, -21 },
  { 792, 25, 22, 26, 0, -21 },
  { 861, 18, 21, 20, 1, -21 },
  { 909, 22, 22, 24, 1, -21 },
  { 970, 19, 21, 20, 1, -21 },
  { 1020, 21, 26, 22, 0, -22 },
  { 1089, 21, 22, 22, 1, -21 },
  { 1147, 21, 26, 21, 0, -22 },
  { 1216, 19, 24, 20, 0, -21 },
  { 1273, 19, 28, 21, 1, -21 },
  { 1340, 23, 22, 24, 0, -21 },
  { 1404, 16, 21, 17, 0, -20 },
  { 1446, 30, 22, 32, 1, -20 },
  { 1529, 24, 21, 26, 1, -20 },
  { 1592, 20, 22, 22, 1, -21 },
  { 1647, 25, 25, 26, 0, -20 },
  { 1726, 22, 23, 23, 1, -21 },
  { 1790, 25, 21, 27, 1, -21 },
  { 1856, 20, 21, 22, 1, -21 },
  { 1909, 20, 20, 22, 1, -20 },
  { 1959, 19, 22, 21, 1, -20 },
  { 2012, 24, 22, 26, 1, -21 },
  { 2078, 30, 22, 31, 1, -21 },
  { 2161, 19, 21, 21, 1, -21 },
  { 2211, 23, 26, 25, 1, -21 },
  { 2286, 19, 24, 19, 0, -21 },
  { 2343, 5, 22, 5, 0, -21 },
  { 2357, 17, 20, 3, -5, -19 },
  { 2400, 5, 22, 5, 0, -21 },
  { 2414, 10, 8, 12, 1, -20 },
  { 2424, 13, 2, 13, 0, 3 },
  { 2428, 4, 5, 15, 5, -20 },
  { 2431, 12, 16, 13, 1, -15 },
  { 2455, 11, 21, 13, 1, -20 },
  { 2484, 9, 16, 10, 1, -15 },
  { 2502, 12, 21, 13, 1, -20 },
  { 2534, 9, 16, 11, 1, -15 },
  { 2552, 9, 26, 7, 0, -21 },
  { 2582, 12, 21, 13, 1, -15 },
  { 2614, 11, 25, 13, 1, -20 },
  { 2649, 7, 21, 8, 0, -20 },
  { 2668, 9, 26, 7, -2, -21 },
  { 2698, 8, 21, 9, 1, -20 },
  { 2719, 8, 21, 8, 1, -20 },
  { 2740, 19, 16, 21, 1, -15 },
  { 2778, 13, 16, 15, 1, -15 },
  { 2804, 11, 16, 12, 0, -15 },
  { 2826, 13, 23, 13, 0, -17 },
  { 2864, 12, 21, 12, 0, -15 },
  { 2896, 9, 16, 11, 1, -15 },
  { 2914, 11, 19, 12, 1, -18 },
  { 2941, 8, 20, 9, 0, -19 },
  { 2961, 13, 16, 15, 1, -15 },
  { 2987, 12, 17, 13, 0, -16 },
  { 3013, 18, 18, 20, 1, -17 },
  { 3054, 10, 21, 11, 1, -15 },
  { 3081, 12, 22, 14, 1, -17 },
  { 3114, 8, 20, 10, 1, -15 },
  { 3134, 7, 24, 10, 1, -23 },
  { 3155, 2, 24, 5, 1, -23 },
  { 3161, 7, 24, 10, 1, -23 },
  { 3182, 9, 2, 11, 1, -10 },
};

const GFXfont UnifrakturMaguntia_Regular29pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular29pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular29pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR29PT7B_H_
