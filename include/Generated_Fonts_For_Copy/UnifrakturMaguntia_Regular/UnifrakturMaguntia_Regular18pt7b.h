#ifndef _UNIFRAKTURMAGUNTIA_REGULAR18PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0x46, 0x76, 0x62, 0x44, 0x40, 0x46, 0x30, 0x44, 0xDC, 0x99, 0x24,
  0x40, 0x24, 0x24, 0x24, 0xFF, 0x24, 0x2C, 0x6C, 0xFE, 0x48, 0x48, 0x48,
  0x20, 0x87, 0x32, 0x8F, 0x3E, 0x1C, 0x3A, 0x38, 0xE2, 0x58, 0x82, 0x00,
  0x30, 0x14, 0x82, 0x48, 0x2C, 0xC4, 0x48, 0x84, 0x90, 0x32, 0xE0, 0x4B,
  0x09, 0x90, 0x99, 0x11, 0x92, 0x0B, 0x40, 0xE0, 0x18, 0x12, 0x19, 0x05,
  0x03, 0x03, 0x9E, 0x69, 0x34, 0xCE, 0x67, 0x5F, 0xC0, 0x4E, 0x94, 0x32,
  0x44, 0x4C, 0xCC, 0xCC, 0x44, 0x63, 0xC2, 0x23, 0x33, 0x33, 0x33, 0x33,
  0x24, 0x80, 0x20, 0xCE, 0xFF, 0xFF, 0xB3, 0x08, 0x20, 0x8F, 0xC8, 0x20,
  0x80, 0x5D, 0xA4, 0x3A, 0x7C, 0x4F, 0x00, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x00, 0x1C,
  0x26, 0x66, 0x63, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x63, 0x62, 0x26, 0x1C,
  0x10, 0xC7, 0x2C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1F, 0x3C, 0x46, 0x87,
  0x07, 0x06, 0x06, 0x0C, 0x08, 0x11, 0x21, 0x7F, 0xFE, 0x3C, 0x46, 0x07,
  0x06, 0x04, 0x1E, 0x07, 0x03, 0x43, 0xC3, 0x62, 0x3C, 0x0C, 0x0C, 0x1C,
  0x2C, 0x4C, 0x4C, 0x8C, 0xFF, 0x0C, 0x0C, 0x0C, 0x1F, 0x7E, 0x3C, 0x40,
  0x40, 0x7C, 0x7E, 0x47, 0x03, 0x03, 0x43, 0xC3, 0x66, 0x3C, 0x1C, 0x26,
  0x66, 0x63, 0x60, 0x7C, 0xE2, 0xE3, 0xE3, 0x63, 0x62, 0x66, 0x3C, 0x7F,
  0x82, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30, 0x70, 0x18,
  0x66, 0x42, 0x42, 0x72, 0x7C, 0x1E, 0x66, 0x43, 0xC3, 0xC3, 0x42, 0x3C,
  0x3C, 0x66, 0x66, 0xC7, 0xC7, 0xC7, 0x6B, 0x2B, 0x16, 0x46, 0x66, 0x64,
  0x38, 0x0F, 0x00, 0x13, 0xC0, 0x0F, 0x00, 0x17, 0x69, 0x00, 0x09, 0x99,
  0xC3, 0x04, 0xFE, 0x03, 0xF8, 0x83, 0x0C, 0x76, 0x40, 0x7A, 0x38, 0x71,
  0x0C, 0xE6, 0x12, 0x49, 0xE2, 0x0C, 0x18, 0x0F, 0x06, 0x11, 0x81, 0x23,
  0xA4, 0xB5, 0xB6, 0xB4, 0x96, 0xB4, 0x5B, 0xA8, 0x08, 0xC2, 0x0F, 0x80,
  0x1E, 0x04, 0xFC, 0x6C, 0x3F, 0xA0, 0xEC, 0x81, 0xB1, 0x86, 0xC7, 0x13,
  0x06, 0x8C, 0x14, 0x30, 0x20, 0xC1, 0xE3, 0x8B, 0xDF, 0x07, 0x98, 0x3E,
  0x38, 0x7F, 0xDC, 0x43, 0x8C, 0x81, 0x8C, 0x81, 0x86, 0x81, 0x9C, 0x45,
  0x7E, 0x3A, 0x06, 0x04, 0x07, 0x0E, 0x02, 0x3F, 0x02, 0x07, 0x84, 0x01,
  0xF8, 0x1E, 0xC3, 0x1F, 0x66, 0x46, 0xC0, 0x6E, 0x06, 0x70, 0x67, 0x86,
  0x38, 0x71, 0xC7, 0x18, 0x3A, 0x01, 0xE1, 0x0F, 0xE0, 0x0F, 0xC0, 0xFF,
  0x86, 0x27, 0x11, 0x0E, 0x86, 0x1E, 0x1C, 0x38, 0x78, 0x50, 0xE1, 0x39,
  0x84, 0x04, 0x21, 0xE0, 0x8F, 0xE4, 0x43, 0xE0, 0x00, 0x00, 0x1E, 0xC3,
  0x1F, 0x66, 0x46, 0xC0, 0x6E, 0x46, 0x7F, 0x67, 0xA6, 0x38, 0x71, 0xC7,
  0x18, 0x3A, 0x01, 0xE1, 0x0F, 0xE0, 0x1F, 0x81, 0xFF, 0x18, 0x7E, 0x86,
  0xC8, 0x31, 0x41, 0xDD, 0x07, 0xE8, 0x38, 0x3C, 0xE0, 0xC3, 0x06, 0x18,
  0x70, 0xC1, 0x84, 0x0C, 0x40, 0x3C, 0x00, 0x0E, 0x41, 0x8F, 0x08, 0x9C,
  0xC8, 0x76, 0xE2, 0x33, 0x79, 0x9C, 0xEC, 0x73, 0x61, 0x9B, 0x8C, 0xCC,
  0x86, 0x30, 0x20, 0xE6, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0xE0, 0x23,
  0x83, 0x00, 0x18, 0x60, 0xE7, 0x83, 0xCE, 0x0E, 0x38, 0x71, 0xC1, 0x86,
  0xC4, 0x3F, 0x43, 0x1C, 0x10, 0x01, 0x00, 0x70, 0x1F, 0x02, 0x3C, 0x40,
  0xF4, 0x04, 0x40, 0x84, 0x1C, 0x33, 0xC0, 0xCE, 0x00, 0xE0, 0x07, 0x00,
  0x37, 0x82, 0x9C, 0x20, 0xF4, 0x02, 0x80, 0x1F, 0x02, 0x3C, 0x40, 0xF4,
  0x04, 0x40, 0x84, 0x1C, 0x32, 0xC0, 0xCE, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x37, 0x82, 0xBC, 0x21, 0xE4, 0x07, 0x80, 0x01, 0xE0, 0x18,
  0x40, 0x9C, 0x86, 0xF9, 0x1C, 0x74, 0x71, 0xD1, 0xC2, 0x43, 0x9A, 0x0E,
  0xE0, 0x19, 0xC6, 0x23, 0x3D, 0x0E, 0x38, 0x1C, 0x0E, 0x0C, 0x66, 0x0D,
  0x83, 0x70, 0xDC, 0x23, 0xF0, 0x60, 0x10, 0x08, 0x07, 0x82, 0x7B, 0x0F,
  0x00, 0x08, 0x21, 0x07, 0xDF, 0xF9, 0x1C, 0xE3, 0x41, 0xCE, 0x68, 0x18,
  0xCF, 0x03, 0x18, 0x9E, 0x23, 0x21, 0xC4, 0x6C, 0x00, 0x89, 0x80, 0x21,
  0x70, 0x65, 0x46, 0x3D, 0x78, 0xF1, 0xF6, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x10, 0x7C, 0xF9, 0x1E, 0x34, 0x1C, 0x68, 0x18, 0xF0, 0x31, 0x1E, 0x22,
  0x1C, 0x48, 0x00, 0x90, 0x01, 0x70, 0x64, 0x63, 0xF0, 0xF1, 0xC0, 0xC0,
  0x03, 0x00, 0x3E, 0x06, 0xF8, 0xC0, 0xE4, 0x03, 0x30, 0x0D, 0xF0, 0x67,
  0x83, 0x0C, 0x08, 0xC0, 0x9E, 0x05, 0x3C, 0x40, 0xFC, 0x00, 0x1C, 0x10,
  0x7E, 0x30, 0x47, 0xF0, 0x83, 0x38, 0x83, 0x9C, 0x83, 0x8E, 0x49, 0x87,
  0x31, 0x83, 0x01, 0x02, 0x01, 0x02, 0x07, 0x84, 0x0F, 0xE4, 0x01, 0xF8,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x03, 0x00, 0x1F, 0x01, 0x9E, 0x18,
  0x1C, 0x40, 0x31, 0x80, 0x67, 0x81, 0x8F, 0x06, 0x0C, 0x08, 0x61, 0x47,
  0x8F, 0x27, 0xCF, 0x0F, 0xD8, 0x00, 0x00, 0x0C, 0x10, 0x3F, 0x3C, 0x67,
  0xCE, 0x81, 0x8E, 0x81, 0x87, 0x80, 0xC4, 0x40, 0xD8, 0x24, 0xF8, 0x18,
  0x9C, 0x00, 0x8C, 0x19, 0x0C, 0x3D, 0x0F, 0x0E, 0x06, 0x03, 0x00, 0x7E,
  0xCC, 0x78, 0x40, 0x04, 0x00, 0x20, 0xF9, 0x3F, 0x38, 0xE1, 0x60, 0x0B,
  0x80, 0x4E, 0x04, 0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0x1E, 0x20, 0x3F,
  0x04, 0xC8, 0x60, 0x23, 0x80, 0xFE, 0x00, 0x30, 0x31, 0x83, 0xC8, 0x07,
  0x00, 0x1E, 0x20, 0x3E, 0x00, 0x08, 0x03, 0x43, 0x64, 0xE7, 0x06, 0x38,
  0x63, 0x86, 0x1C, 0x60, 0x86, 0x10, 0x62, 0x06, 0x78, 0xE9, 0xF7, 0x0E,
  0x60, 0x00, 0x1C, 0x30, 0x7F, 0xD8, 0x43, 0x9C, 0x81, 0x8E, 0x81, 0x88,
  0x81, 0x88, 0x4D, 0x1C, 0x31, 0x1E, 0x02, 0x0E, 0x0E, 0x06, 0x3F, 0x04,
  0x03, 0xC8, 0x01, 0xF0, 0x1C, 0x47, 0x07, 0xF7, 0x71, 0x0E, 0x86, 0x40,
  0xD0, 0xE8, 0x1B, 0x09, 0x03, 0x73, 0x11, 0x4E, 0x61, 0xC8, 0xCE, 0x02,
  0x18, 0xE3, 0x81, 0x0C, 0xB8, 0x71, 0x03, 0x9F, 0x40, 0x3C, 0xF0, 0x1C,
  0x63, 0xF3, 0xD1, 0xED, 0x06, 0x08, 0x30, 0x21, 0xF0, 0xFF, 0x80, 0x60,
  0x03, 0x00, 0x1C, 0x0D, 0x60, 0x7B, 0xE7, 0x8E, 0x00, 0x1E, 0x78, 0xFF,
  0x39, 0x0E, 0x74, 0x0C, 0x68, 0x18, 0xF0, 0x31, 0x13, 0x46, 0x18, 0x8C,
  0x02, 0x1C, 0x08, 0x18, 0x19, 0x38, 0x7C, 0x70, 0x30, 0xC2, 0x01, 0x02,
  0x04, 0x03, 0xF0, 0x0F, 0x81, 0x0C, 0x20, 0x62, 0x06, 0x20, 0xC1, 0x90,
  0x07, 0xC0, 0x8E, 0x00, 0x60, 0x03, 0x20, 0x27, 0x82, 0x9C, 0x40, 0xF8,
  0x00, 0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xC0, 0x00, 0x40, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xB7, 0xC0, 0x10, 0x70, 0xB2, 0x28,
  0x20, 0xFF, 0xD9, 0x30, 0x08, 0x1C, 0x26, 0x46, 0x46, 0xC6, 0x66, 0x77,
  0x3E, 0x00, 0xB8, 0x60, 0x60, 0x64, 0x6E, 0x76, 0x63, 0x63, 0x62, 0x62,
  0x7C, 0x18, 0x00, 0x19, 0xA4, 0xD0, 0x41, 0x06, 0x1C, 0x3C, 0x00, 0x40,
  0xC0, 0x78, 0x3C, 0x1E, 0x63, 0x63, 0x63, 0x63, 0x62, 0x7C, 0x18, 0x19,
  0xA4, 0xD3, 0x71, 0x06, 0x1C, 0x3C, 0x3B, 0xD0, 0x8F, 0xB1, 0x8C, 0x63,
  0x08, 0x42, 0x11, 0x08, 0x08, 0x1C, 0x66, 0x42, 0xC6, 0x46, 0x66, 0x66,
  0x3A, 0x02, 0x42, 0x64, 0x38, 0x08, 0xB4, 0x60, 0x60, 0x64, 0x7E, 0x66,
  0x67, 0x63, 0x63, 0x62, 0x7A, 0x24, 0x08, 0x10, 0x20, 0x21, 0x88, 0x06,
  0x3B, 0x8C, 0x63, 0x18, 0x63, 0x00, 0x31, 0x80, 0x43, 0x3C, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xDD, 0x0C, 0x9A, 0xF6, 0x7C, 0x84, 0x21, 0x08, 0xF3,
  0x00, 0x0D, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF3, 0x00, 0x66, 0xC7,
  0xF7, 0x32, 0x63, 0x26, 0x32, 0x63, 0x26, 0x32, 0x67, 0x77, 0x22, 0x30,
  0x64, 0x37, 0xAC, 0x86, 0x43, 0x21, 0x90, 0xC8, 0xE7, 0x23, 0x00, 0x08,
  0xF9, 0x3A, 0x34, 0x68, 0xD9, 0x7C, 0x30, 0x40, 0x80, 0xE4, 0x7E, 0x66,
  0x63, 0x23, 0x22, 0x62, 0xFC, 0x38, 0x20, 0x20, 0x20, 0x20, 0x18, 0x79,
  0x3A, 0x2C, 0x58, 0xD9, 0xBF, 0x26, 0x08, 0x10, 0x20, 0x40, 0x69, 0xBB,
  0xC8, 0x20, 0x82, 0x1E, 0x10, 0x1C, 0x04, 0x4B, 0xF4, 0x99, 0x9F, 0xA3,
  0x65, 0xF0, 0x40, 0x00, 0xC4, 0x4F, 0x90, 0x84, 0x21, 0x1E, 0x60, 0x62,
  0x33, 0xAC, 0x84, 0x42, 0x21, 0x10, 0x88, 0xFF, 0x13, 0x00, 0xC0, 0xCC,
  0xFE, 0x66, 0x63, 0x23, 0x22, 0x22, 0x74, 0x18, 0x40, 0x04, 0x00, 0x66,
  0x47, 0xEE, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x27, 0x7C, 0x21,
  0x80, 0x35, 0xFC, 0xD1, 0x83, 0x06, 0x0C, 0x1E, 0x51, 0x02, 0x02, 0x63,
  0x00, 0x40, 0x40, 0x64, 0x7E, 0x33, 0x33, 0x33, 0x33, 0x33, 0x7A, 0x32,
  0x04, 0x08, 0x30, 0x20, 0xC5, 0x84, 0x25, 0xE3, 0x96, 0x4E, 0x38, 0xA2,
  0x70, 0x19, 0x88, 0x63, 0x18, 0x98, 0x21, 0x8C, 0x62, 0x0C, 0xFF, 0xFE,
  0xC1, 0x0C, 0x63, 0x10, 0x43, 0x31, 0x8C, 0x63, 0x70, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 7, 5, 7, 0, -13 },
  { 13, 8, 11, 9, 1, -12 },
  { 24, 6, 15, 8, 1, -14 },
  { 36, 12, 13, 13, 0, -13 },
  { 56, 9, 11, 10, 1, -11 },
  { 69, 3, 5, 4, 0, -13 },
  { 71, 4, 14, 4, 0, -14 },
  { 78, 4, 15, 4, 0, -14 },
  { 86, 6, 8, 6, 0, -14 },
  { 92, 6, 6, 7, 1, -9 },
  { 97, 3, 5, 3, 0, -3 },
  { 99, 5, 3, 5, 0, -7 },
  { 101, 3, 3, 4, 0, -3 },
  { 103, 9, 14, 9, 0, -13 },
  { 119, 8, 13, 8, 0, -13 },
  { 132, 6, 12, 6, 0, -12 },
  { 141, 8, 12, 8, 0, -12 },
  { 153, 8, 12, 8, 0, -12 },
  { 165, 8, 12, 8, 0, -12 },
  { 177, 8, 13, 8, 0, -13 },
  { 190, 8, 13, 8, 0, -13 },
  { 203, 8, 12, 8, 0, -12 },
  { 215, 8, 13, 8, 0, -13 },
  { 228, 8, 13, 8, 0, -13 },
  { 241, 3, 9, 4, 0, -9 },
  { 245, 3, 11, 3, 0, -9 },
  { 250, 5, 6, 5, 0, -8 },
  { 254, 7, 3, 7, 0, -7 },
  { 257, 5, 6, 5, 0, -8 },
  { 261, 6, 13, 8, 1, -13 },
  { 271, 11, 12, 11, 0, -9 },
  { 288, 14, 13, 15, 0, -13 },
  { 311, 16, 13, 16, 0, -13 },
  { 337, 12, 13, 12, 0, -13 },
  { 357, 14, 14, 15, 0, -13 },
  { 382, 12, 13, 13, 0, -13 },
  { 402, 13, 15, 14, 0, -13 },
  { 427, 13, 14, 14, 0, -13 },
  { 450, 13, 16, 13, 0, -14 },
  { 476, 12, 15, 12, 0, -13 },
  { 499, 12, 17, 13, 0, -13 },
  { 525, 14, 13, 15, 0, -13 },
  { 548, 10, 13, 10, 0, -13 },
  { 565, 19, 14, 20, 0, -13 },
  { 599, 15, 13, 16, 0, -13 },
  { 624, 13, 13, 14, 0, -13 },
  { 646, 16, 16, 16, 0, -13 },
  { 678, 14, 14, 14, 0, -13 },
  { 703, 16, 13, 17, 0, -13 },
  { 729, 13, 13, 14, 0, -13 },
  { 751, 13, 13, 13, 0, -13 },
  { 773, 12, 14, 13, 0, -13 },
  { 794, 16, 13, 16, 0, -13 },
  { 820, 19, 13, 19, 0, -13 },
  { 851, 13, 13, 13, 0, -13 },
  { 873, 15, 16, 15, 0, -13 },
  { 903, 12, 15, 12, 0, -13 },
  { 926, 3, 14, 3, 0, -13 },
  { 932, 11, 13, 2, -3, -12 },
  { 950, 3, 14, 3, 0, -13 },
  { 956, 7, 5, 8, 0, -13 },
  { 961, 8, 1, 8, 0, 2 },
  { 962, 3, 4, 9, 3, -13 },
  { 964, 8, 10, 8, 0, -9 },
  { 974, 8, 13, 8, 0, -12 },
  { 987, 6, 9, 6, 0, -9 },
  { 994, 8, 13, 8, 0, -13 },
  { 1007, 6, 9, 7, 0, -9 },
  { 1014, 5, 16, 4, 0, -13 },
  { 1024, 8, 13, 8, 0, -9 },
  { 1037, 8, 16, 8, 0, -13 },
  { 1053, 5, 13, 5, 0, -13 },
  { 1062, 5, 16, 4, -1, -13 },
  { 1072, 5, 13, 6, 0, -13 },
  { 1081, 5, 13, 5, 0, -13 },
  { 1090, 12, 9, 13, 0, -9 },
  { 1104, 9, 9, 9, 0, -9 },
  { 1115, 7, 9, 7, 0, -9 },
  { 1123, 8, 15, 8, 0, -11 },
  { 1138, 7, 13, 8, 0, -9 },
  { 1150, 6, 9, 7, 0, -9 },
  { 1157, 7, 11, 8, 0, -11 },
  { 1167, 5, 12, 6, 0, -12 },
  { 1175, 9, 9, 9, 0, -9 },
  { 1186, 8, 10, 8, 0, -10 },
  { 1196, 12, 11, 12, 0, -11 },
  { 1213, 7, 13, 7, 0, -9 },
  { 1225, 8, 14, 8, 0, -11 },
  { 1239, 6, 13, 6, 0, -10 },
  { 1249, 5, 14, 6, 0, -14 },
  { 1258, 1, 15, 3, 1, -14 },
  { 1260, 5, 14, 6, 0, -14 },
  { 1269, 6, 1, 7, 0, -6 },
};

const GFXfont UnifrakturMaguntia_Regular18pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular18pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular18pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR18PT7B_H_
