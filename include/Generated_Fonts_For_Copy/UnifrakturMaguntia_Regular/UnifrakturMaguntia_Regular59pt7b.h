#ifndef _UNIFRAKTURMAGUNTIA_REGULAR59PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x00, 0xC0, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0xDF, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xF3, 0xFE, 0x1F, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x80, 0x60, 0x0C, 0x07, 0x80, 0x70, 0x7E, 0x0F,
  0xC7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x60, 0x0C,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x01, 0x00, 0x20, 0x00, 0xF8, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0,
  0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xC0,
  0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xF0, 0x78, 0x1E, 0x01, 0xC1, 0xC0, 0x1C,
  0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7E, 0x00, 0xE7, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x70, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xF7, 0x00, 0x1E, 0x70, 0x01, 0xE3, 0x80, 0x1E, 0x18, 0x03,
  0xC0, 0xE0, 0x78, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x00, 0x70, 0xFF, 0x00, 0x00,
  0x03, 0x8F, 0x9E, 0x00, 0x00, 0x0C, 0x3C, 0x3C, 0x00, 0x00, 0x61, 0xF0,
  0xF8, 0x00, 0x03, 0x87, 0xC3, 0xE0, 0x00, 0x1C, 0x3E, 0x0F, 0xC0, 0x00,
  0xE0, 0xF8, 0x3F, 0x00, 0x07, 0x03, 0xE0, 0xFC, 0x00, 0x38, 0x0F, 0x83,
  0xF0, 0x01, 0xC0, 0x3E, 0x0F, 0xC0, 0x06, 0x00, 0xF8, 0x3F, 0x00, 0x30,
  0x03, 0xE0, 0xFC, 0x01, 0xC0, 0x0F, 0x83, 0xF0, 0x0E, 0x00, 0x3E, 0x0F,
  0xC0, 0x70, 0x00, 0x7C, 0x3E, 0x03, 0x80, 0x01, 0xF0, 0xF8, 0x1C, 0x00,
  0x03, 0xC3, 0xC0, 0x60, 0x00, 0x0F, 0x9E, 0x03, 0x00, 0x00, 0x0F, 0xF0,
  0x1C, 0x1F, 0x80, 0x1F, 0x80, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0x07, 0x9E,
  0x00, 0x00, 0x38, 0x3C, 0x3C, 0x00, 0x01, 0xC1, 0xF0, 0xF8, 0x00, 0x0E,
  0x07, 0xC3, 0xE0, 0x00, 0x30, 0x3F, 0x0F, 0xC0, 0x01, 0x80, 0xFC, 0x1F,
  0x00, 0x0E, 0x03, 0xF0, 0x7C, 0x00, 0x70, 0x0F, 0xC1, 0xF0, 0x03, 0x80,
  0x3F, 0x07, 0xC0, 0x1C, 0x00, 0xFC, 0x1F, 0x00, 0xE0, 0x03, 0xF0, 0x7C,
  0x03, 0x00, 0x0F, 0xC1, 0xF0, 0x18, 0x00, 0x3F, 0x0F, 0xC0, 0xE0, 0x00,
  0x7C, 0x3E, 0x07, 0x00, 0x01, 0xF0, 0xF8, 0x38, 0x00, 0x03, 0xC3, 0xC1,
  0xC0, 0x00, 0x07, 0x9E, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x30, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x3F, 0x07, 0x80, 0x00, 0xFC, 0x1E, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x83, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xC0, 0xF7, 0xF0,
  0x0E, 0x07, 0x9F, 0xC0, 0x30, 0x3C, 0x3F, 0x80, 0xC0, 0xF0, 0xFE, 0x03,
  0x07, 0xC3, 0xFC, 0x08, 0x1F, 0x07, 0xF0, 0x60, 0xFC, 0x1F, 0xE1, 0x83,
  0xF0, 0x3F, 0x84, 0x0F, 0xC0, 0xFF, 0x30, 0x3F, 0x01, 0xFD, 0x80, 0xFE,
  0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x81, 0x7F, 0x80, 0xFF, 0x0C, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xC7, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x08, 0x06, 0x07,
  0x87, 0xE7, 0xFF, 0xFC, 0x7E, 0x1F, 0x07, 0x83, 0x81, 0xC0, 0xC0, 0x60,
  0x60, 0x20, 0x30, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x02, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xFC, 0x01, 0xDF, 0xB0, 0xFC, 0xF3, 0xF7, 0xC6, 0x3E, 0x7E,
  0x67, 0xE7, 0xE6, 0xFC, 0x3F, 0xFF, 0xC0, 0x0F, 0x00, 0x63, 0xFC, 0xC7,
  0xF6, 0xFC, 0x7E, 0x67, 0xE7, 0xC6, 0x7E, 0xFC, 0xF3, 0xE0, 0xDF, 0xB1,
  0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x03, 0x01, 0xE0, 0xFC, 0x7F,
  0x8F, 0xF1, 0xF8, 0x3E, 0x07, 0x81, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x00, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0xFC, 0x00,
  0x08, 0x03, 0x01, 0xC0, 0xFC, 0xFF, 0x9F, 0xC3, 0xE0, 0x70, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8,
  0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x31, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xF8, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0x07, 0xFE, 0x3C, 0x03,
  0xFE, 0x78, 0x01, 0xFF, 0x70, 0x00, 0xFF, 0x60, 0x00, 0xFF, 0x60, 0x00,
  0x7F, 0x40, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0x01, 0xC0,
  0x01, 0x03, 0x80, 0x01, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x38, 0x3F, 0xF0, 0x18, 0x03, 0xFE, 0x0C, 0x00, 0x7F, 0x86,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0x3F, 0x80, 0x07, 0xCF, 0xE0, 0x01, 0xE1, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0x3C, 0x0F, 0xC0, 0x1E, 0x03, 0xF0, 0x06, 0x00, 0x3E,
  0x07, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x77, 0xE0, 0x00, 0x33,
  0xF0, 0x00, 0x31, 0xF8, 0x00, 0x38, 0xFC, 0x00, 0x18, 0x7E, 0x00, 0x18,
  0x3F, 0x00, 0x0C, 0x1F, 0x80, 0x0C, 0x0F, 0xC0, 0x0C, 0x07, 0xE0, 0x06,
  0x03, 0xF0, 0x06, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x00, 0x7E, 0x03,
  0x00, 0x3F, 0x03, 0x80, 0x1F, 0x81, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x0E,
  0x00, 0x0C, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7C, 0x0F, 0xFC, 0x3C, 0x00, 0xFF, 0x0E, 0x00, 0x1F, 0xE3, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE3, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x3F, 0x80,
  0x07, 0xCF, 0xE0, 0x01, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3C, 0x0F,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x07, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0xF8, 0x00, 0x70, 0x3E, 0x00, 0x70,
  0x1F, 0x80, 0x78, 0x07, 0xE0, 0x3C, 0x03, 0xF0, 0x3E, 0x01, 0xFC, 0x1E,
  0x00, 0xFE, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x02, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1E, 0x00,
  0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0xF8, 0x3F, 0xBF, 0xFE, 0x1F, 0xD8, 0x3F,
  0x8F, 0xF8, 0x1F, 0xCF, 0xFC, 0x07, 0xF7, 0xFC, 0x03, 0xFB, 0xFE, 0x01,
  0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC,
  0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x07,
  0xE0, 0x0F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0x80,
  0x0F, 0x03, 0x80, 0x03, 0xC3, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0x80, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x7C,
  0x00, 0x0E, 0x3E, 0x00, 0x07, 0x1F, 0x80, 0x03, 0x8F, 0xC0, 0x03, 0xC7,
  0xF0, 0x01, 0xE1, 0xFE, 0x00, 0xE0, 0xFF, 0xC0, 0xE0, 0x7F, 0xF0, 0xE0,
  0x1F, 0xFE, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1C, 0xFF, 0xF8, 0x1C, 0x1F,
  0xFC, 0x1C, 0x03, 0xFF, 0x1E, 0x00, 0xFF, 0x9E, 0x00, 0x1F, 0xCF, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xE7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0x1C, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x3E, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0xE0, 0x78, 0x03, 0xF0, 0x7C, 0x01, 0xFC, 0x3E,
  0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F,
  0xE7, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFE, 0x0D, 0xFC, 0x7F, 0xFE,
  0xFE, 0x1F, 0xFE, 0x7F, 0x07, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x10,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x3E, 0x0F,
  0xE0, 0x1E, 0x07, 0xF0, 0x0F, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x07, 0x00,
  0x3F, 0x03, 0x00, 0x0F, 0xC3, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x08, 0x03,
  0x01, 0xC0, 0xF8, 0xFF, 0x9F, 0xE3, 0xE0, 0x70, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0C,
  0x07, 0x03, 0xF3, 0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x00, 0x04,
  0x00, 0xC0, 0x38, 0x0F, 0x87, 0xFC, 0x7F, 0x87, 0xC0, 0x70, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x3C, 0x0F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF0, 0x3E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3C, 0x1F, 0x03, 0xC0, 0x1F, 0x1E,
  0x00, 0x7C, 0x70, 0x00, 0xFB, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x20,
  0x3C, 0x01, 0x80, 0xF0, 0x04, 0x01, 0xE0, 0x30, 0x03, 0xC1, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0xFB, 0xC7, 0x0F, 0x00, 0xFF, 0xF1, 0xC3, 0xC0, 0x7C, 0xFC,
  0x79, 0xE0, 0x3E, 0x3E, 0x1E, 0x78, 0x1F, 0x0F, 0x87, 0x9E, 0x0F, 0x83,
  0xE1, 0xEF, 0x07, 0xE0, 0xF8, 0x7B, 0xC1, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC,
  0x1F, 0x07, 0x3C, 0x3E, 0x07, 0xC3, 0xCF, 0x0F, 0x83, 0xE0, 0xF3, 0xC7,
  0xE1, 0xF8, 0x78, 0xF1, 0xF0, 0x7E, 0x1E, 0x3C, 0x7C, 0x3F, 0x8F, 0x0F,
  0x1F, 0x9F, 0xCF, 0x81, 0xC3, 0xFE, 0xFF, 0xC7, 0x78, 0xFF, 0x3F, 0xE3,
  0xDE, 0x0F, 0x07, 0xE0, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x20, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x3C,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0x9F, 0xFF, 0x80, 0x3F, 0x80,
  0x70, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x0C,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x60, 0x00, 0x3F, 0xE0, 0xFF, 0x01, 0x80,
  0x00, 0x7F, 0xC1, 0xFC, 0x06, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x38, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x03, 0x80, 0x00,
  0x1F, 0xC1, 0xFC, 0x0E, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x3C, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0x00, 0x1F,
  0x81, 0xFC, 0x03, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xF0,
  0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0, 0x3E, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x1F,
  0xC0, 0x00, 0x38, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0xE0, 0x01, 0xFC,
  0x00, 0x03, 0x07, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x18, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0x0F,
  0xFF, 0x06, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x70, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x88, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xFB, 0x01, 0xFE, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFC,
  0x07, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x38, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xF8, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x18, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x83, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xF8, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0x1C, 0x00, 0x00, 0xF8, 0x1F, 0xFF, 0x01, 0xC0,
  0x00, 0x1F, 0x0F, 0xFF, 0xF0, 0x3C, 0x00, 0x83, 0xC7, 0xFF, 0xFF, 0x03,
  0xE0, 0xE0, 0x78, 0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x18,
  0x00, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x07, 0xC1, 0x83, 0xF8, 0x00, 0x7C,
  0x02, 0x1F, 0xF9, 0x03, 0xE0, 0x0D, 0xFF, 0xFC, 0x0F, 0x80, 0x1F, 0xFF,
  0xE0, 0x7C, 0x00, 0x77, 0xFF, 0x03, 0xF0, 0x07, 0x03, 0xF0, 0x0F, 0x80,
  0x70, 0x03, 0x80, 0x7E, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0xE0, 0x01,
  0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x0E,
  0x00, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x00, 0xFF, 0xE3, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x07, 0xFF, 0xE0,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x04, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0x0E,
  0x00, 0x7F, 0xE0, 0xF8, 0x00, 0xE0, 0x01, 0xFF, 0x87, 0x80, 0x0F, 0x00,
  0x07, 0xFC, 0x38, 0x00, 0xF8, 0x00, 0x1F, 0xF3, 0xC0, 0x0F, 0xE0, 0x00,
  0x7F, 0x9C, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0xE0, 0x03, 0xFC, 0x00, 0x07,
  0xF7, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xB8, 0x00, 0xFF, 0xE0, 0x00, 0xFC,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF6, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xB0,
  0x00, 0x7F, 0xF0, 0x00, 0x7D, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xE6, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0x18, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xC1, 0xC0, 0x41, 0xFC, 0x00, 0x1E, 0x03, 0xFE, 0x07,
  0xE0, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x40, 0x00, 0x06,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x1C,
  0x7F, 0xFF, 0xE0, 0x70, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x7F, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x60, 0xFE, 0x00, 0x0F, 0x80, 0x43, 0xFF, 0x20, 0x3E,
  0x00, 0xDF, 0xFF, 0xC0, 0x78, 0x00, 0xFF, 0xFF, 0x01, 0xF0, 0x01, 0xDF,
  0xFC, 0x07, 0xC0, 0x0C, 0x07, 0xE0, 0x0F, 0x80, 0x70, 0x03, 0x80, 0x3F,
  0x01, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x0F,
  0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x03, 0xC0, 0x7F, 0x07, 0xFE,
  0x0F, 0xC0, 0xFE, 0x0F, 0xFE, 0x3F, 0xED, 0xFC, 0x0F, 0xFE, 0xFF, 0xFB,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0xFE, 0x7F, 0x8F, 0xF0, 0x1F,
  0xFE, 0x3E, 0x1F, 0xE0, 0x1F, 0xFC, 0x38, 0x3F, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xFC,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0xFC, 0x07, 0x00,
  0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x60, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0x80,
  0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x3F,
  0xFC, 0x0F, 0x00, 0x00, 0x63, 0xFE, 0x03, 0x80, 0x00, 0x30, 0x7E, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x08, 0x18, 0x00, 0x0F, 0xF8, 0x07,
  0x86, 0x00, 0x03, 0xFE, 0x01, 0xF1, 0x80, 0x00, 0x7F, 0xC0, 0xFE, 0x30,
  0x00, 0x1F, 0xF8, 0x7F, 0xCC, 0x00, 0x07, 0xFF, 0x3F, 0xF1, 0x80, 0x00,
  0xFF, 0xDF, 0xF8, 0x70, 0x00, 0x1F, 0xFF, 0xFC, 0x0E, 0x00, 0x07, 0xFF,
  0x0E, 0x00, 0xE0, 0x78, 0xFF, 0xC1, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x06, 0x00, 0x00, 0x0F, 0x86, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x41, 0xF8, 0x00, 0x07, 0x80, 0x09, 0xFF, 0x00, 0x03, 0xE0,
  0x02, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xCF, 0xFC, 0x00, 0xF8, 0x00, 0x61,
  0xFF, 0x80, 0x3E, 0x00, 0x60, 0x3F, 0xF8, 0x1F, 0x80, 0x30, 0x07, 0xFF,
  0x0F, 0xC0, 0x3C, 0x00, 0xFF, 0x83, 0xF0, 0x1E, 0x00, 0x1F, 0xC1, 0xFC,
  0x0F, 0x80, 0x01, 0xE0, 0x7E, 0x07, 0xE0, 0x00, 0xE0, 0x1F, 0x81, 0xF8,
  0x00, 0x70, 0x0F, 0xE0, 0xFF, 0x00, 0x30, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xFF, 0x0F,
  0xE0, 0x7F, 0xCF, 0xFF, 0xE3, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF8,
  0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xBF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFD, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xDF, 0xF0, 0x01,
  0xF8, 0x07, 0xE3, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0xFF, 0x00, 0x1E, 0x00,
  0x7E, 0x1F, 0xE0, 0x07, 0x00, 0x1F, 0x07, 0xFC, 0x03, 0x80, 0x0F, 0xC0,
  0xFF, 0x01, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0xC0, 0x00, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x1F,
  0xF8, 0x00, 0x00, 0x0C, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x01, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x70, 0x03, 0xE0,
  0x03, 0xF0, 0x7E, 0x01, 0xE0, 0x01, 0xF8, 0xFF, 0x80, 0xF0, 0x00, 0xFC,
  0xFF, 0xE0, 0x70, 0x00, 0x7C, 0xFF, 0xF8, 0x30, 0x00, 0x7E, 0x47, 0xFE,
  0x30, 0x00, 0x3E, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x07,
  0xFF, 0xC0, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0xFF, 0xF8,
  0x78, 0x00, 0x0F, 0xFF, 0xC1, 0xC0, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0x00,
  0x1F, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x07,
  0x00, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x07,
  0xF8, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x02, 0x7F, 0xC0, 0x00,
  0xFC, 0x78, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xFF,
  0x00, 0x00, 0x7C, 0x3F, 0xFE, 0x00, 0x01, 0xF1, 0xFF, 0xFE, 0x00, 0x07,
  0x8C, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0x03, 0x80, 0x01, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xF8, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x1C, 0x00,
  0x01, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00,
  0x7C, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00,
  0x0C, 0x00, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xC0, 0x08, 0xFF, 0x00, 0x00, 0xF0, 0x38, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0xFC,
  0x00, 0x00, 0x78, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0x00, 0x00,
  0xF0, 0xE7, 0xFF, 0x80, 0x00, 0xE0, 0x81, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0xFF, 0xE0, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x00, 0x3F, 0xFC,
  0x06, 0x00, 0x00, 0x1F, 0xFF, 0xBC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x02,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0xFF, 0x80, 0x78, 0x00, 0x3E, 0x07, 0xFF,
  0x80, 0xE0, 0x00, 0xF8, 0x3F, 0xFF, 0x03, 0xC0, 0x07, 0xE1, 0xFF, 0xFE,
  0x07, 0x00, 0x1F, 0x8E, 0x0F, 0xF8, 0x1C, 0x00, 0xFE, 0x30, 0x1F, 0xF0,
  0x38, 0x03, 0xF8, 0x80, 0x3F, 0xC0, 0xE0, 0x0F, 0xE6, 0x00, 0x7F, 0x83,
  0x80, 0x3F, 0x90, 0x01, 0xFE, 0x0E, 0x00, 0xFF, 0x40, 0x03, 0xFC, 0x38,
  0x03, 0xFD, 0x00, 0x0F, 0xFC, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xE3, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0xFF, 0x80, 0x03, 0x01, 0x80, 0x03, 0xFF, 0x00, 0x30, 0x0C, 0x00, 0x07,
  0xFE, 0x03, 0xE0, 0x60, 0x00, 0x1F, 0xF8, 0x3F, 0xC7, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0xFF, 0x00, 0x02, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x06, 0x00, 0x7F,
  0xC0, 0x7F, 0xF8, 0x38, 0x00, 0xFF, 0x83, 0x3F, 0xF0, 0xC0, 0x03, 0xFF,
  0x20, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x3E, 0x3F, 0xC0, 0x00, 0x3E, 0x3F, 0xE0, 0x00, 0x3E, 0x3F, 0xE0,
  0x00, 0x7E, 0x1F, 0xF0, 0x00, 0x7E, 0x1F, 0xF0, 0x00, 0x7E, 0x1F, 0xF8,
  0x00, 0x7C, 0x0F, 0xF8, 0x00, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x07, 0xFC,
  0xEF, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x04, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x02, 0xFF, 0xFF, 0xC0, 0x06, 0x83, 0xFF, 0xF0, 0x0C, 0x00, 0xFF,
  0xFE, 0x78, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0xF1, 0xFF, 0xF8, 0xE7, 0xFC, 0x00, 0xFF, 0xFF, 0xF7, 0x3F, 0xF9, 0x03,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xF8, 0x0F, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xF0, 0x1C, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x60, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0xC0, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC1, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x82, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x7F, 0x8C, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0xFF, 0x98, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x90, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x20, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xE0, 0x60, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x03, 0xF0,
  0x0F, 0xC0, 0x38, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0x00,
  0x3E, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x40, 0xC0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0x02, 0x01, 0xF0, 0x03, 0xC3, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0E,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0xFE, 0x00, 0x00, 0xFC,
  0x01, 0x80, 0x03, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x06, 0x3E, 0x04, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x0C, 0xFE, 0x18, 0x03, 0xFE, 0x10, 0x7F, 0xF8,
  0x33, 0xFF, 0x60, 0x07, 0xFF, 0xF1, 0xDF, 0xF8, 0xCF, 0xFF, 0x80, 0x07,
  0xFF, 0x82, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF1, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0xE0, 0xFF, 0x01, 0xFC, 0x7F,
  0xFE, 0x60, 0x3F, 0xC0, 0xF0, 0x07, 0xFF, 0x60, 0x1F, 0xE0, 0xE0, 0x00,
  0xFF, 0xE0, 0x07, 0xF0, 0x60, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x30, 0x00,
  0x0F, 0xF8, 0x01, 0xFE, 0x10, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x08, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xC4, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFA, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xF9, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x30,
  0x00, 0x00, 0xFE, 0x00, 0x60, 0x0E, 0x1F, 0x80, 0x3F, 0x00, 0x60, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x70, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x70, 0x00,
  0x7F, 0xFC, 0x07, 0xE0, 0x78, 0x00, 0x0F, 0xFE, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x03, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x3F, 0x00,
  0x00, 0x00, 0x80, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0x80, 0x3F,
  0xC0, 0x01, 0xFF, 0x01, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0xC0, 0x07,
  0xFC, 0x21, 0xFF, 0xF0, 0xC0, 0x03, 0xFF, 0xF9, 0x8F, 0xFD, 0xC0, 0x00,
  0xFF, 0xF0, 0x83, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0,
  0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0x3F, 0xF0,
  0x3E, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x87, 0xE0,
  0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xFF, 0x80, 0x00, 0x01,
  0xF9, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x87,
  0xFF, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x1F, 0xFF,
  0x80, 0x00, 0x1E, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C,
  0x30, 0x00, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0xFC, 0x00,
  0x00, 0x0C, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0x83, 0xBF, 0xFF, 0x80, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x3F, 0xFF, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xF9,
  0xFF, 0xE0, 0x01, 0xE0, 0x07, 0xFF, 0xE7, 0xFC, 0x00, 0x70, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0x38, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x0C, 0x00, 0x03,
  0xFC, 0x0F, 0xFE, 0x03, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0xC0, 0xC0, 0x00,
  0x1F, 0xE0, 0x7F, 0xF8, 0x30, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0C, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xE3, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0xC0,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x18, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE6,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x18, 0x01, 0x8F, 0xE0, 0x00, 0x3F, 0xC3, 0xC0, 0xC3, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x03,
  0x83, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1E, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x8C, 0x00,
  0x0C, 0x18, 0x00, 0x7F, 0x00, 0x01, 0xF9, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xEC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x05, 0x9F, 0xFF, 0xC3, 0x0F, 0xF8, 0x30, 0x3F, 0xFF, 0x00, 0x3F, 0xF7,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xCF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x1C, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x80, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0xE4,
  0x03, 0xFE, 0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x1E, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x06, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE3,
  0x80, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x9C, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x03,
  0x80, 0x08, 0x0F, 0x8F, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x7D, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x03, 0xE1, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x07, 0xF8, 0x00, 0x00, 0x80, 0x07, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0x80, 0x30, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x18, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE1, 0x80,
  0x01, 0xFF, 0x88, 0x13, 0xFF, 0x98, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF0,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x07, 0x81, 0x80, 0x7F, 0xFF, 0xE1, 0xE0,
  0x20, 0x7F, 0xFF, 0xFC, 0x78, 0x06, 0xFF, 0xFF, 0x87, 0x1E, 0x01, 0xFF,
  0xFF, 0x00, 0x67, 0x80, 0x3F, 0xFF, 0x00, 0x09, 0xF0, 0x07, 0xFF, 0x80,
  0x02, 0x7C, 0x00, 0xFF, 0x80, 0x00, 0xDF, 0x80, 0x1F, 0x80, 0x00, 0x37,
  0xE0, 0x00, 0x00, 0x00, 0x0D, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xCF, 0xF0, 0x00, 0x00, 0x00, 0x23, 0xFE, 0x00, 0x00,
  0x00, 0x18, 0x7F, 0xC0, 0x00, 0x00, 0x0E, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0x60,
  0x00, 0x0C, 0xFF, 0xFF, 0x98, 0x00, 0x0E, 0x0F, 0xFF, 0xC4, 0x00, 0x07,
  0x01, 0xFF, 0xC3, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0xC0, 0x01, 0xF8, 0x03,
  0xF0, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x0B, 0xFF,
  0xC0, 0x00, 0x07, 0x8E, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x70, 0x00, 0x07, 0xFF, 0xF8, 0x78, 0x00, 0x00,
  0x07, 0xFF, 0x90, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x38, 0x00, 0x07, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0xFC, 0x3C,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x04, 0x00, 0xF8, 0xE0, 0x00, 0x18, 0x01, 0xE0, 0x60, 0x00,
  0x70, 0x03, 0xC0, 0x30, 0x01, 0xF0, 0x07, 0xC0, 0x30, 0x07, 0xE0, 0x0F,
  0xC0, 0x30, 0x3F, 0xE0, 0x0F, 0xC0, 0x20, 0x7F, 0xC0, 0x1F, 0xC0, 0x60,
  0x7F, 0xC0, 0x1F, 0xC0, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xFF, 0x01, 0x9F, 0xC0, 0xC3, 0xFF, 0xC3, 0x9F, 0xE2, 0x00, 0xFF,
  0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x0C,
  0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xE6, 0x07, 0xF8, 0x01, 0xFE, 0x7F, 0xFD,
  0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x7C, 0x00, 0x3F,
  0xF0, 0x0F, 0xF0, 0x1C, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xE3, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0xE0, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x3F, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x60,
  0x00, 0x03, 0xF0, 0x03, 0x80, 0x18, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x06,
  0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x3F, 0x00,
  0x18, 0x00, 0x83, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x60, 0xF8, 0x07, 0xF8,
  0x00, 0x70, 0xF0, 0x3C, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x1D, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x0C, 0x0F,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x06, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x71, 0xCC, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFB, 0x07, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1C, 0x01, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xC0, 0x07, 0xF8, 0x07,
  0xC0, 0x0F, 0xFC, 0x0E, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x1F, 0xE0, 0x70,
  0x00, 0xFF, 0x03, 0x80, 0x00, 0xFF, 0x87, 0x80, 0x07, 0xF8, 0x1C, 0x00,
  0x03, 0xFC, 0x3C, 0x00, 0x1F, 0xE1, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0xFF, 0xCE, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xFE, 0x70, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0x81, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x03, 0x80, 0x60, 0x00, 0x01, 0xF1,
  0xFF, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0F, 0x8F, 0xF8, 0x03, 0xC0, 0x0C,
  0x00, 0x00, 0x7C, 0x3F, 0xE0, 0x3F, 0x00, 0x60, 0x00, 0x03, 0xC1, 0xFF,
  0x01, 0xF8, 0x01, 0x80, 0x0C, 0x3E, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0x01,
  0x81, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x07,
  0xFF, 0x00, 0x06, 0x00, 0x70, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x7E, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x03, 0xD0, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0x01, 0x83, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x18,
  0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x03, 0xFF, 0xFE,
  0x1F, 0xFF, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xE0, 0x07,
  0xE1, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0x01, 0xFF,
  0x1F, 0xFC, 0x3C, 0x00, 0xFF, 0x30, 0xF8, 0x78, 0x00, 0x7F, 0x30, 0x70,
  0x70, 0x00, 0x3F, 0xA0, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x60, 0x00,
  0x1F, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0xC0,
  0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xE0, 0x18, 0x00, 0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x3F,
  0xFF, 0xE0, 0x0E, 0x04, 0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x37, 0xF0, 0x00, 0x00, 0x00, 0x27, 0xF8, 0x00,
  0x01, 0xE0, 0x27, 0xFC, 0x00, 0x03, 0xF0, 0x63, 0xFE, 0x00, 0x07, 0xF8,
  0xC3, 0xFF, 0x86, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x11,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x0C, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x98,
  0x1F, 0xE0, 0x1F, 0xE7, 0xFF, 0xD0, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0xF0,
  0x0F, 0xF0, 0x78, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x70, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x60, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0xE0, 0x00, 0x0F, 0xF0,
  0x07, 0xFC, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0xC0, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xF0, 0x60, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xF0,
  0x01, 0xC0, 0x60, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x30, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x18, 0x00, 0x83, 0xE0, 0x1F, 0x80, 0x0C, 0x01, 0xC3, 0xE0,
  0x1F, 0x80, 0x07, 0xCE, 0x03, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xC0,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x06,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0x9C, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0xE0, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x00,
  0x00, 0xFC, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0x3E, 0x00,
  0x70, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x10,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0xE0,
  0x00, 0x07, 0xC7, 0xFF, 0x80, 0x00, 0x3C, 0x7F, 0xFE, 0x00, 0x01, 0xE6,
  0x7F, 0xF8, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0x80,
  0x07, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x06, 0x00, 0x00,
  0xFF, 0xF0, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xEF, 0x80, 0x3E, 0x1F, 0x00, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xF1, 0xE0, 0x00, 0xE6, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x3C, 0x1E, 0x0E, 0x06, 0x03,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x05, 0xFF, 0x00, 0x0C, 0x7F, 0xF0, 0x0E,
  0x1F, 0xFC, 0x0E, 0x03, 0xF8, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0x7E, 0x07,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0xC1, 0xF8, 0x8F, 0xF3, 0xFF, 0x87, 0xFF,
  0x7F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1E, 0x03, 0xE0, 0x04,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x80,
  0xE0, 0x00, 0x41, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x27, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x40, 0x0F, 0xC0, 0x60, 0x0F, 0xC1, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xCF, 0xF8, 0x0F, 0xDF, 0xF8, 0x0F, 0xE3, 0xFC, 0x0F,
  0xC1, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3C, 0x0F, 0xC0, 0x38, 0x1F, 0xC0, 0x70, 0x1F,
  0xF0, 0x60, 0x7F, 0xF8, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0x9F, 0x80,
  0x63, 0xF0, 0x1C, 0x3F, 0x07, 0x87, 0xE0, 0xE0, 0x7E, 0x3C, 0x0F, 0xC7,
  0x80, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x08, 0x3F, 0xFE, 0x83, 0xFF, 0x80, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x27, 0xFC, 0x00, 0x60, 0xFF,
  0x03, 0xF0, 0x3F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x07, 0xC3, 0xF0, 0x03, 0xC1, 0xF8, 0x01, 0xE0, 0xFC, 0x00, 0xF0, 0x7E,
  0x00, 0x78, 0x3F, 0x00, 0x38, 0x1F, 0x80, 0x1C, 0x0F, 0xC0, 0x1C, 0x0F,
  0xF0, 0x0E, 0x0F, 0xFE, 0x06, 0x07, 0xFF, 0x86, 0x00, 0x7F, 0xF6, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01,
  0x9F, 0x80, 0x63, 0xF0, 0x1C, 0x7F, 0x07, 0x87, 0xE0, 0xE0, 0xFC, 0x3C,
  0x0F, 0xC7, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x70, 0xF8,
  0x78, 0x1F, 0x38, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x08, 0x3F, 0xFE, 0x83, 0xFF, 0x80, 0x3F,
  0xC0, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x10, 0x3F,
  0xE4, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x63, 0xF0, 0x10, 0x10,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x06, 0xFF, 0xC0, 0x06, 0x3F, 0xFC, 0x07, 0x07, 0xFE, 0x07, 0x01,
  0xFE, 0x07, 0x80, 0x3F, 0x07, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x83, 0xE0,
  0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0xEF, 0xC0, 0xFF, 0xC7,
  0xE0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0xFC, 0x0C, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xC0,
  0x03, 0xC1, 0xF0, 0x03, 0xC0, 0xFC, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x0F,
  0x81, 0xC0, 0x03, 0xF7, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0xC0, 0xF0, 0x00, 0x43, 0xE0, 0x00, 0x67, 0xC0, 0x00,
  0x27, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xC0, 0x0F, 0xC1, 0xC0,
  0x0F, 0xC3, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC7, 0xF8,
  0x0F, 0xC3, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3C, 0x1F, 0xC4, 0x7C, 0x3F, 0xF8, 0x78,
  0x7F, 0xF0, 0x78, 0x0F, 0xE0, 0x70, 0x07, 0xC0, 0xE0, 0x03, 0x81, 0xC0,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xF3,
  0x7F, 0x08, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF1, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0D, 0xFE, 0x04, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xD0,
  0x03, 0xCC, 0x03, 0xC2, 0x01, 0xC0, 0x81, 0xC0, 0x0F, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x1E, 0x20, 0x3C, 0x08, 0x3C, 0x02, 0x3E, 0x09,
  0xBE, 0x1C, 0x7F, 0x1E, 0x3F, 0x9F, 0x1F, 0xDF, 0x87, 0xFF, 0xC3, 0xFF,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x83, 0xFE, 0x43, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x20,
  0x3C, 0x08, 0x3C, 0x02, 0x3C, 0x01, 0xBE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x83, 0xFE, 0xC3,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x7C,
  0x07, 0xC0, 0x78, 0x00, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xFC, 0x7F, 0xC7,
  0xFC, 0x07, 0xF9, 0xFF, 0xDF, 0xFF, 0x1F, 0xFE, 0x3F, 0xE7, 0xFE, 0x27,
  0xF0, 0x7F, 0x87, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x1F, 0xE1, 0xFE, 0x0F, 0xE4, 0x7F, 0xE7, 0xFE, 0x0F,
  0xF8, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0x80, 0x78,
  0x07, 0x80, 0x3F, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x00, 0x80, 0x0C, 0x00,
  0x18, 0x08, 0x00, 0x40, 0x01, 0xC0, 0x1C, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0xC1, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0xFF, 0x9F, 0xFF, 0x13, 0xFC, 0x3F,
  0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0x23, 0xFE, 0x0F, 0xFC, 0x3F, 0x80, 0xFF, 0x03, 0xE0, 0x1F, 0xE0,
  0x38, 0x01, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xF1, 0xFC,
  0x07, 0xE3, 0xFC, 0x0F, 0xC3, 0xFC, 0x1F, 0x87, 0xFC, 0x3F, 0x07, 0xF8,
  0x7E, 0x07, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0x87, 0xE0,
  0x0E, 0x0F, 0xE0, 0x1C, 0x3F, 0xF0, 0x70, 0xFF, 0xF9, 0xC0, 0x3F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x08, 0x07,
  0xF8, 0x06, 0x01, 0xFE, 0x07, 0xC0, 0x7F, 0xC3, 0xF8, 0x0F, 0xF3, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xC0, 0xFF, 0x01, 0xF0,
  0x1F, 0xC0, 0x7C, 0x07, 0xF8, 0x1F, 0x00, 0xFE, 0x07, 0xC0, 0x3F, 0x81,
  0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F,
  0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0x0F, 0x01, 0xF8, 0x07, 0xC3, 0xFE, 0x01, 0xE1, 0xFF, 0x80, 0x70, 0x7F,
  0xF8, 0x38, 0x3F, 0xFF, 0x8C, 0x0C, 0xFF, 0xF6, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x10,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x4F, 0xF8, 0x01, 0x8F, 0xFE,
  0x0E, 0x0F, 0xFE, 0x3C, 0x0F, 0xF0, 0x70, 0x07, 0xE1, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xE0,
  0x1F, 0x1F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x80, 0xF8, 0x7F, 0x81,
  0xF0, 0x7F, 0x87, 0xF0, 0xFF, 0xD7, 0xE0, 0xFF, 0xCF, 0xC0, 0xFF, 0x1F,
  0x80, 0xF8, 0x3F, 0x00, 0xE0, 0x7C, 0x01, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x0C, 0x01, 0x03, 0xC0, 0x70, 0x7C, 0x0E,
  0x1F, 0xC3, 0xE7, 0xFC, 0xFC, 0xFF, 0xBF, 0xE3, 0xFD, 0xF8, 0x7F, 0x3F,
  0x0F, 0xC3, 0xC1, 0xF8, 0x70, 0x3F, 0x04, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x08, 0x0F, 0xF2, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x18, 0x01, 0x00, 0xF8, 0x0C, 0x07, 0xF0, 0x30, 0x3F,
  0xFF, 0xC3, 0x3F, 0xFE, 0x18, 0x7F, 0xF8, 0xC0, 0x7F, 0xC3, 0x00, 0x7C,
  0x1C, 0x00, 0x20, 0x78, 0x01, 0x01, 0xF0, 0x0C, 0x0F, 0xE0, 0x78, 0x1F,
  0xC3, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x07, 0xE1,
  0xFE, 0x0F, 0x01, 0xF8, 0x18, 0x03, 0xE0, 0x40, 0x0F, 0x82, 0x00, 0x1E,
  0x1E, 0x00, 0x70, 0xFE, 0x01, 0x87, 0xFE, 0x0C, 0x3F, 0xFF, 0x60, 0x1F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC2, 0x0F, 0xF2, 0x3F, 0xFC,
  0x1F, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x01, 0x80, 0x03, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x80, 0x1E, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE2, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F,
  0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFC,
  0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFE,
  0x3F, 0xE4, 0xFF, 0xED, 0xFF, 0x07, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x01, 0xF0, 0x3F, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x00, 0x10, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x01, 0x00, 0xE0, 0x00, 0xC0, 0x3C,
  0x00, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F, 0xF8,
  0x7F, 0xB0, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC,
  0x03, 0xC0, 0x3F, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x0E, 0x00,
  0xF8, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x3F,
  0x01, 0x80, 0x1F, 0xF0, 0xC0, 0x07, 0xFF, 0x20, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x83, 0xF8, 0x03, 0x80, 0x0C, 0x1F, 0xE0, 0x3E,
  0x01, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF3, 0xFF, 0xFF, 0xF8, 0x3F, 0xA1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xE1, 0xF8,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0xFC, 0x07,
  0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x03, 0xC1,
  0xF8, 0x0F, 0xC0, 0x1E, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0,
  0x0F, 0x03, 0xF0, 0x1F, 0x80, 0x70, 0x1F, 0x81, 0xFE, 0x07, 0x00, 0xFC,
  0x0F, 0xF8, 0x30, 0x0F, 0xF0, 0xFF, 0xF3, 0x00, 0xFF, 0xC1, 0xFF, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x02, 0x01, 0xF0,
  0x38, 0x1F, 0xC3, 0xC1, 0xFE, 0x3F, 0x0F, 0xFB, 0xF8, 0x9F, 0xFF, 0xE0,
  0x7F, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0x00, 0xFC, 0x30, 0x07, 0xE1,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x7C, 0x01,
  0x81, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x60, 0x1F, 0x01,
  0xE3, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x80, 0x18, 0x07, 0xF8, 0x0E, 0x01, 0xFF, 0x07, 0xC0,
  0x7F, 0xC7, 0xF8, 0x0F, 0xF7, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0x1F, 0x03, 0xF8, 0x87, 0x81,
  0xFF, 0xC1, 0xE0, 0xFF, 0xE0, 0xF0, 0x07, 0xF0, 0x38, 0x00, 0xF8, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xDF, 0xE1, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x0C, 0x1C, 0x18, 0x1F, 0x98, 0x3F,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x2F, 0xF0, 0x23, 0xF8,
  0x30, 0xFE, 0x30, 0x7F, 0x18, 0x1F, 0x98, 0x0F, 0xCC, 0x07, 0xEE, 0x01,
  0xF6, 0x00, 0xFB, 0x00, 0x7D, 0x80, 0x3E, 0xC0, 0x1F, 0x60, 0x0F, 0xB0,
  0x07, 0x98, 0x03, 0xCC, 0x01, 0xC7, 0x01, 0xC1, 0x80, 0xE0, 0x60, 0xE0,
  0x18, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 11, 44, 14, 1, -43 },
  { 62, 21, 16, 24, 1, -42 },
  { 104, 26, 34, 30, 2, -38 },
  { 215, 20, 48, 25, 2, -45 },
  { 335, 38, 41, 42, 2, -42 },
  { 530, 30, 37, 34, 2, -36 },
  { 669, 9, 16, 12, 1, -42 },
  { 687, 13, 48, 15, 1, -46 },
  { 765, 13, 48, 15, 1, -46 },
  { 843, 20, 23, 21, 0, -44 },
  { 901, 20, 21, 23, 2, -30 },
  { 954, 10, 16, 11, 0, -9 },
  { 974, 16, 11, 18, 2, -23 },
  { 996, 10, 10, 12, 1, -9 },
  { 1009, 28, 47, 31, 2, -44 },
  { 1174, 26, 42, 28, 1, -41 },
  { 1311, 17, 40, 19, 1, -40 },
  { 1396, 24, 40, 27, 1, -40 },
  { 1516, 26, 41, 28, 1, -41 },
  { 1650, 25, 40, 27, 1, -40 },
  { 1775, 26, 41, 27, 1, -41 },
  { 1909, 25, 41, 27, 1, -41 },
  { 2038, 24, 40, 25, 1, -40 },
  { 2158, 25, 42, 28, 1, -42 },
  { 2290, 25, 42, 27, 1, -42 },
  { 2422, 10, 29, 12, 1, -28 },
  { 2459, 11, 35, 10, 0, -28 },
  { 2508, 16, 22, 17, 0, -28 },
  { 2552, 21, 13, 23, 1, -24 },
  { 2587, 16, 22, 17, 0, -28 },
  { 2631, 22, 43, 27, 2, -42 },
  { 2750, 34, 35, 36, 1, -27 },
  { 2899, 46, 43, 48, 1, -42 },
  { 3147, 51, 44, 53, 0, -43 },
  { 3428, 38, 44, 41, 1, -43 },
  { 3637, 45, 45, 48, 1, -43 },
  { 3891, 39, 44, 41, 1, -43 },
  { 4106, 42, 50, 45, 1, -43 },
  { 4369, 42, 44, 45, 2, -42 },
  { 4600, 41, 54, 43, 1, -46 },
  { 4877, 38, 51, 40, 1, -43 },
  { 5120, 40, 58, 42, 1, -43 },
  { 5410, 46, 43, 48, 1, -42 },
  { 5658, 32, 43, 34, 1, -42 },
  { 5830, 63, 44, 65, 1, -41 },
  { 6177, 49, 43, 52, 2, -42 },
  { 6441, 42, 43, 44, 1, -42 },
  { 6667, 50, 52, 53, 1, -42 },
  { 6992, 45, 46, 47, 1, -42 },
  { 7251, 53, 44, 55, 1, -43 },
  { 7543, 42, 43, 45, 1, -42 },
  { 7769, 42, 42, 44, 1, -41 },
  { 7990, 40, 45, 42, 1, -41 },
  { 8215, 50, 44, 52, 1, -43 },
  { 8490, 61, 43, 64, 1, -42 },
  { 8818, 40, 44, 43, 1, -43 },
  { 9038, 48, 52, 51, 1, -43 },
  { 9350, 37, 51, 39, 1, -43 },
  { 9586, 8, 47, 11, 1, -44 },
  { 9633, 36, 41, 6, -11, -38 },
  { 9818, 8, 47, 11, 1, -44 },
  { 9865, 22, 17, 25, 1, -42 },
  { 9912, 28, 4, 27, -1, 7 },
  { 9926, 8, 11, 30, 10, -41 },
  { 9937, 25, 32, 27, 1, -30 },
  { 10037, 24, 43, 26, 1, -41 },
  { 10166, 19, 31, 21, 1, -30 },
  { 10240, 25, 42, 27, 1, -41 },
  { 10372, 19, 31, 21, 1, -30 },
  { 10446, 18, 53, 14, -1, -43 },
  { 10566, 25, 43, 27, 1, -31 },
  { 10701, 24, 51, 26, 1, -41 },
  { 10854, 14, 42, 16, 1, -41 },
  { 10928, 17, 53, 14, -3, -42 },
  { 11041, 17, 42, 19, 1, -41 },
  { 11131, 17, 42, 16, 1, -41 },
  { 11221, 39, 32, 42, 1, -31 },
  { 11377, 27, 31, 30, 1, -30 },
  { 11482, 23, 31, 24, 0, -30 },
  { 11572, 26, 47, 27, 0, -35 },
  { 11725, 23, 43, 25, 1, -31 },
  { 11849, 19, 31, 21, 1, -30 },
  { 11923, 22, 38, 25, 1, -37 },
  { 12028, 16, 39, 18, 1, -38 },
  { 12106, 27, 32, 30, 1, -31 },
  { 12214, 26, 34, 27, -1, -33 },
  { 12325, 37, 37, 41, 2, -35 },
  { 12497, 21, 43, 23, 1, -31 },
  { 12610, 26, 45, 28, 1, -35 },
  { 12757, 17, 41, 20, 1, -30 },
  { 12845, 16, 47, 20, 1, -46 },
  { 12939, 3, 49, 9, 3, -46 },
  { 12958, 16, 47, 20, 1, -46 },
  { 13052, 19, 4, 22, 1, -20 },
};

const GFXfont UnifrakturMaguntia_Regular59pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular59pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular59pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR59PT7B_H_
