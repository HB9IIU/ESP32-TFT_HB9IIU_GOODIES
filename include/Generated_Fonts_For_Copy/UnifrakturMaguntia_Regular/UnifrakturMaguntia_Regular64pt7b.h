#ifndef _UNIFRAKTURMAGUNTIA_REGULAR64PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular64pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x01, 0x80, 0x78, 0x0F, 0x87, 0xF9, 0xFF, 0xDF, 0xF3, 0xFE,
  0x7F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0x80, 0xF8, 0x3F, 0x8F, 0xF8, 0xFE,
  0x0F, 0x80, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x01,
  0xC0, 0x1C, 0x07, 0x80, 0x78, 0x7F, 0x07, 0xF3, 0xFF, 0x3F, 0xF7, 0xFC,
  0x7F, 0xC7, 0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x78, 0x07,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x18, 0x01, 0x80, 0x40, 0x04, 0x03,
  0x00, 0x30, 0x08, 0x00, 0x80, 0x40, 0x04, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0xF8, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xC1,
  0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0x81, 0xC0,
  0x3C, 0x03, 0x81, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x01,
  0xE7, 0xF8, 0x07, 0x9F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xDE, 0x01, 0xFF, 0x78, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x38, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0xE0, 0x1E, 0x01, 0xF3, 0xF0,
  0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0x83, 0xFE, 0x00, 0x00, 0x00, 0xE1, 0xE3, 0xC0, 0x00,
  0x00, 0x70, 0xF8, 0x78, 0x00, 0x00, 0x38, 0x3C, 0x1F, 0x00, 0x00, 0x1C,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0x83, 0xF0,
  0x7E, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x80, 0x00, 0xE0, 0x3F, 0x07, 0xF0,
  0x00, 0x70, 0x0F, 0xC1, 0xFC, 0x00, 0x38, 0x03, 0xF0, 0x7F, 0x00, 0x1C,
  0x00, 0xFC, 0x1F, 0xC0, 0x0E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0x80, 0x0F,
  0xC1, 0xF8, 0x01, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x70, 0x00, 0x1F, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xC1, 0xF0, 0x1C,
  0x00, 0x00, 0xF8, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x3C, 0x03, 0x80, 0x00,
  0x03, 0xFE, 0x01, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0xE0, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x78, 0xF0, 0x00, 0x00, 0x38, 0x3E, 0x1E, 0x00, 0x00, 0x1C,
  0x0F, 0x07, 0xC0, 0x00, 0x0E, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0x81, 0xF0,
  0x7E, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x80, 0x00, 0xE0, 0x3F, 0x07, 0xF0,
  0x00, 0x70, 0x0F, 0xC0, 0xFC, 0x00, 0x38, 0x03, 0xF0, 0x3F, 0x00, 0x1C,
  0x00, 0xFC, 0x0F, 0xC0, 0x0E, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0x00, 0x0F,
  0xC0, 0xFC, 0x01, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x70, 0x00, 0x1F, 0x07, 0xE0, 0x38, 0x00, 0x07, 0xC1, 0xF8, 0x1C,
  0x00, 0x00, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x3E, 0x1E, 0x07, 0x00, 0x00,
  0x07, 0x8F, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x3F,
  0x87, 0x80, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0x80,
  0x7F, 0xFC, 0x03, 0x80, 0x79, 0xFE, 0x01, 0xC0, 0x78, 0xFF, 0x80, 0xC0,
  0x7C, 0x3F, 0xC0, 0x60, 0x3C, 0x1F, 0xF0, 0x30, 0x3E, 0x07, 0xF8, 0x10,
  0x1F, 0x03, 0xFE, 0x18, 0x1F, 0x81, 0xFF, 0x0C, 0x0F, 0xC0, 0x7F, 0xCC,
  0x07, 0xF0, 0x3F, 0xE6, 0x03, 0xF8, 0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xE0, 0x6F, 0xF0, 0x0F, 0xF8, 0x73, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0x87,
  0xFF, 0xF0, 0x7F, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x7C, 0x3F, 0x9F, 0xFB, 0xFC,
  0x7F, 0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x02, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x06, 0x7E, 0xE3, 0xF1, 0xE7, 0xEF, 0x8E,
  0x3F, 0x7E, 0x33, 0xF3, 0xF9, 0xBF, 0x8F, 0xEF, 0xFC, 0x41, 0xF8, 0x64,
  0x07, 0x81, 0x3F, 0xDF, 0xF9, 0xFC, 0xDF, 0xCF, 0xC6, 0x7E, 0x7E, 0x73,
  0xFF, 0xE3, 0xCF, 0xC3, 0x3F, 0x60, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x7C, 0x3F, 0x9F,
  0xF3, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x60,
  0x10, 0x0C, 0x02, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x38, 0x0F, 0x87,
  0xF9, 0xFF, 0x8F, 0xE0, 0xF0, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x81,
  0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xDF, 0xE0, 0x61,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xE1, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3E,
  0x07, 0xFF, 0x0F, 0x00, 0x3F, 0xE1, 0xC0, 0x03, 0xFC, 0x70, 0x00, 0x7F,
  0xCE, 0x00, 0x07, 0xF9, 0x80, 0x00, 0xFF, 0x30, 0x00, 0x1F, 0xE4, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x10, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x40, 0x38, 0x00,
  0x08, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xF0, 0x7F, 0xF0, 0x1C, 0x01,
  0xFF, 0x83, 0x80, 0x07, 0xF8, 0x30, 0x00, 0x7F, 0xC2, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0x80, 0x00, 0xFF,
  0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xF8, 0x7F, 0x00, 0x1F,
  0x03, 0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1B, 0xF8,
  0x00, 0x02, 0x7F, 0x00, 0x00, 0xCF, 0xE0, 0x00, 0x31, 0xFC, 0x00, 0x06,
  0x3F, 0x80, 0x01, 0x87, 0xF0, 0x00, 0x60, 0xFE, 0x00, 0x0C, 0x1F, 0xC0,
  0x03, 0x03, 0xF8, 0x00, 0xC0, 0x7F, 0x00, 0x18, 0x0F, 0xE0, 0x06, 0x01,
  0xFC, 0x00, 0x80, 0x3F, 0x80, 0x30, 0x07, 0xF0, 0x0C, 0x00, 0xFE, 0x01,
  0x00, 0x1F, 0xC0, 0x60, 0x03, 0xF8, 0x18, 0x00, 0x7F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x06, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC7, 0xFC, 0x00, 0x0D, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xC1, 0xE0, 0x03, 0xFC, 0x18,
  0x00, 0x1F, 0xE3, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0x00, 0x00, 0x7F, 0x7C, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x7C,
  0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x03, 0xF0,
  0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xC3, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0x80, 0x7F,
  0x01, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFE, 0x0F, 0x80, 0x3F, 0xC3, 0xF0,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC3, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xE0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x7F, 0xF8, 0x3F, 0x88, 0x3F, 0x87,
  0xF2, 0x03, 0xF8, 0xFE, 0xC0, 0x7F, 0x1F, 0xD0, 0x0F, 0xF3, 0xFE, 0x00,
  0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03,
  0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xCF, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xFC,
  0x07, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0x80, 0x00, 0x31, 0xC0,
  0x00, 0x1C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x3C, 0x7E, 0x00,
  0x03, 0xC7, 0xF0, 0x00, 0x78, 0x3F, 0x80, 0x07, 0x83, 0xFC, 0x00, 0x78,
  0x3F, 0xF0, 0x0F, 0x03, 0xFF, 0x81, 0xE0, 0x1F, 0xFE, 0x3C, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x30, 0xFF, 0xF0, 0x06,
  0x03, 0xFF, 0x80, 0xE0, 0x0F, 0xF8, 0x1C, 0x00, 0x7F, 0xC3, 0xC0, 0x03,
  0xFC, 0x78, 0x00, 0x1F, 0xE7, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xC0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xF8,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F,
  0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0,
  0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFC,
  0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF1, 0xFC, 0x06, 0xFE, 0x3F, 0xC0,
  0xDF, 0xC3, 0xF8, 0x33, 0xF8, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x7C, 0x1F, 0xE0, 0x1F,
  0x81, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x78, 0x03, 0xF0, 0x0F, 0x00, 0x3F,
  0x03, 0xC0, 0x03, 0xF0, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x78, 0x1F, 0x87, 0xFD, 0xFF, 0x0F, 0xC0, 0xF0,
  0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0xF8, 0x7F, 0x9F,
  0xF8, 0xFE, 0x0F, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x02, 0x00, 0x60, 0x0F,
  0x01, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0x80, 0xF0, 0x06, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x01, 0xF0, 0x3F, 0x87, 0xFC, 0x3F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x3E, 0x00, 0xFC, 0x78, 0x00,
  0x7E, 0x78, 0x00, 0x7E, 0x70, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0x7F, 0x3E, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x10, 0x0F, 0x00, 0x18, 0x0F, 0x80,
  0x10, 0x0F, 0x80, 0x30, 0x07, 0xC0, 0x60, 0x03, 0xE0, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0xBE, 0x38, 0x7C, 0x01,
  0xFF, 0xE1, 0xC3, 0xC0, 0x3E, 0x7F, 0x0F, 0x3E, 0x03, 0xE1, 0xF8, 0x79,
  0xE0, 0x3E, 0x0F, 0x83, 0xCF, 0x03, 0xF0, 0x7C, 0x1E, 0xF8, 0x1F, 0x07,
  0xE0, 0xE7, 0xC1, 0xF8, 0x3E, 0x07, 0x3C, 0x1F, 0x81, 0xF0, 0x79, 0xE0,
  0xFC, 0x0F, 0x83, 0xCF, 0x07, 0xC0, 0xFC, 0x1C, 0x78, 0x7E, 0x07, 0xC1,
  0xE3, 0xC3, 0xF0, 0x7E, 0x1F, 0x1E, 0x1F, 0x87, 0xF0, 0xF0, 0xF8, 0xFC,
  0x7F, 0x0F, 0x03, 0xC7, 0xE7, 0xF9, 0xF8, 0x1E, 0x1F, 0xFF, 0xFF, 0x8E,
  0xF0, 0xFF, 0x3F, 0xF0, 0xF3, 0xC1, 0xE0, 0x7E, 0x07, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xF8, 0x03, 0xE1, 0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xC0, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x60, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x30, 0x00,
  0x1F, 0xF8, 0x3F, 0xF0, 0x0C, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x06, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x60,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x38, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x0E,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x1E, 0x00, 0x00, 0x7F, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x07,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xC0,
  0x7F, 0x80, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0x81, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xE0, 0x78, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x7F, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x07,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x03, 0xBF, 0xE3, 0x00, 0x03, 0xFF, 0xE1, 0xCF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xC1, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF9,
  0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF9, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x3C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x70,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x00, 0x7E, 0x01, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0xC0,
  0x1C, 0x00, 0x00, 0x7C, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x30, 0x7C, 0x7F,
  0xFF, 0xF8, 0x0F, 0x80, 0xE0, 0x78, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0x00, 0x00, 0x3F, 0xBC, 0x07, 0xE0,
  0x00, 0x3E, 0x03, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x8F, 0xFF, 0xF0, 0x3E,
  0x00, 0x6F, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0x00, 0x1C,
  0x7F, 0xF0, 0x1F, 0x80, 0x18, 0x07, 0xE0, 0x1F, 0x80, 0x38, 0x00, 0xE0,
  0x0F, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x00,
  0x1F, 0xFC, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0x10, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x83, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xC0, 0x7F, 0xFC, 0x07, 0xE0,
  0x01, 0xC0, 0x0F, 0xFE, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0x83, 0xE0,
  0x01, 0xE0, 0x00, 0x7F, 0xE1, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0xE0,
  0x01, 0xF8, 0x00, 0x07, 0xFC, 0x70, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x78,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xB8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xDC,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE6, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF3,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFD, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7E,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x30, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0x98, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xC6, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xE3, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x78, 0x1E, 0x0E, 0x0F, 0xE0, 0x00, 0x3C, 0x03, 0xFE, 0x03, 0xF0, 0x00,
  0x1C, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x01, 0xC1, 0xFF, 0xFF,
  0xF1, 0xE0, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x01, 0xC0, 0x00, 0x07, 0xF7, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x30, 0xFF,
  0xC0, 0x01, 0xF0, 0x06, 0x7F, 0xFF, 0x80, 0xF8, 0x01, 0xBF, 0xFF, 0xC0,
  0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0x00, 0x1C, 0x7F, 0xF0, 0x0F, 0x80,
  0x0C, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0x80, 0x1F, 0xC1, 0xFF,
  0x80, 0xF8, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xFE, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0xCF,
  0xF0, 0x0F, 0xFF, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0xE3, 0xF8, 0xFF, 0x00,
  0x7F, 0xFC, 0x3C, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x10, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x01, 0xFF,
  0xFF, 0x81, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x19, 0xFF,
  0xC0, 0x3C, 0x00, 0x00, 0xC1, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0x00, 0x10, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x70, 0x70,
  0x00, 0x0F, 0xF8, 0x03, 0xE1, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xC7, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0x8C, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x38, 0x00,
  0x07, 0xFF, 0x1F, 0xF8, 0x60, 0x00, 0x0F, 0xFE, 0xFF, 0xE1, 0xC0, 0x00,
  0x1F, 0xFF, 0x7F, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x78, 0x07, 0x80, 0x18,
  0xFF, 0xE0, 0xC0, 0x07, 0xC7, 0xE1, 0xFF, 0xC2, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x30,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x43, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x9F,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x0C, 0x7F,
  0xE0, 0x01, 0xF0, 0x00, 0xE0, 0xFF, 0xE0, 0x0F, 0xC0, 0x06, 0x01, 0xFF,
  0xC0, 0x7E, 0x00, 0x30, 0x03, 0xFF, 0x81, 0xF8, 0x03, 0xC0, 0x07, 0xFF,
  0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x00, 0x38, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0x1C, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xC3, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x8F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF8, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x03, 0xFE,
  0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xF9, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xE7, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x9F, 0xF0, 0x00, 0xFF, 0x00,
  0xFE, 0x3F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0xFF, 0x80, 0x07, 0xC0, 0x0F,
  0xE3, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x70, 0x00, 0xFC,
  0x0F, 0xF8, 0x03, 0x80, 0x03, 0xF0, 0x3F, 0xE0, 0x1C, 0x00, 0x1F, 0x80,
  0x7F, 0xC0, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x84, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xFE, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFC, 0x00, 0x00,
  0x00, 0x38, 0x3F, 0xFA, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0x00,
  0x38, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x78, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x70, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0xF0,
  0xFF, 0x80, 0x78, 0x00, 0x3F, 0x0F, 0xFE, 0x03, 0x80, 0x01, 0xF8, 0xFF,
  0xF8, 0x18, 0x00, 0x1F, 0xCF, 0xFF, 0xE1, 0x80, 0x00, 0xFC, 0x03, 0xFF,
  0xD8, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0x80,
  0x03, 0xFF, 0xF3, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x07, 0x80, 0x00, 0x1F,
  0xFF, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x1C, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7C, 0x03, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0xC0, 0x00, 0x0F, 0xC7, 0xFF, 0xF0,
  0x00, 0x07, 0xC7, 0xFF, 0xFC, 0x00, 0x03, 0xC7, 0x1F, 0xFF, 0x00, 0x01,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x00, 0x03, 0xFF,
  0xF9, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF3, 0x01,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x0E, 0x00,
  0x00, 0x1F, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0x00, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xC1, 0xC7, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xE0, 0x38, 0x00, 0x00,
  0x3F, 0xFF, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x30, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x1C, 0x00, 0x07,
  0xE0, 0x7F, 0xF8, 0x07, 0x80, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0xE0, 0x00,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x3F, 0x0F, 0x9F, 0xFC, 0x07, 0x00,
  0x1F, 0xC3, 0x01, 0xFF, 0x81, 0xE0, 0x07, 0xF1, 0x80, 0x3F, 0xE0, 0x78,
  0x01, 0xFC, 0x60, 0x07, 0xFC, 0x1E, 0x00, 0x7F, 0x10, 0x01, 0xFF, 0x07,
  0x80, 0x1F, 0xE4, 0x00, 0x3F, 0xE0, 0xE0, 0x07, 0xF9, 0x00, 0x0F, 0xF8,
  0x38, 0x01, 0xFF, 0x40, 0x01, 0xFF, 0x9E, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE7, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xE1, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1F, 0xFC, 0x00,
  0x70, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0x87, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF3, 0x00, 0x00, 0x07, 0xFF,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE9, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x38, 0x00, 0x7F, 0xC0,
  0xFF, 0xFC, 0x0C, 0x00, 0x1F, 0xF8, 0x21, 0xFF, 0xC6, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xE3, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x1F,
  0xE0, 0x00, 0x0F, 0xC7, 0xFC, 0x00, 0x03, 0xF1, 0xFF, 0x00, 0x00, 0xFC,
  0x7F, 0xE0, 0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x1F, 0x83, 0xFF, 0x00, 0x07,
  0xE0, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x07, 0xFE, 0x73,
  0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x9F, 0xFF, 0xF8,
  0x00, 0x3E, 0xFF, 0xFF, 0x00, 0x18, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x30, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xEC,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x01, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x70, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC3,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x60, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF1, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x20, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xFE, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x18, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0x83, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x30, 0x07,
  0x01, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xE0,
  0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0x80,
  0x7E, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x7F, 0x30, 0x0F, 0xC0, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x06, 0x01, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x00,
  0x40, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x70, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1C, 0x78, 0x0C, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x03, 0x3F, 0x81, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0xCF, 0xFC, 0x60,
  0x07, 0xFF, 0x18, 0xFF, 0xFC, 0x3B, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x31,
  0xFF, 0xEE, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x84, 0x1F, 0xFF, 0x9F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE6, 0x7F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x83, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE1, 0x81, 0xFF, 0x00, 0xFE, 0x3F,
  0xFF, 0x98, 0x07, 0xF8, 0x0F, 0x00, 0x1F, 0xFE, 0xC0, 0x1F, 0xE0, 0x70,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xF8,
  0x30, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE1, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x40, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xE2, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xD0, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x86, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x70, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x07, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0x01, 0xF8,
  0x03, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x80,
  0x7E, 0x03, 0xC0, 0x00, 0x0F, 0x0C, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x20, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x38, 0x07, 0xFC, 0x00, 0x01, 0xF8,
  0x01, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x1C, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0xC0, 0x07, 0xFE, 0x08, 0x3F, 0xFE, 0x0C, 0x00, 0x1F, 0xFD,
  0xE3, 0xFF, 0xF8, 0xE0, 0x00, 0x7F, 0xFE, 0x30, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x87,
  0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0x82, 0x00,
  0x00, 0x03, 0x80, 0x1F, 0xD0, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x00, 0x00,
  0x0C, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x10, 0xFF, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x0F,
  0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x3F, 0xF0,
  0x00, 0x70, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xF0, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x18,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x30, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xF0, 0x60, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF1, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xE3, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE3,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC3, 0x80, 0x08, 0x7F, 0x00, 0x00,
  0xFF, 0x83, 0xC0, 0x70, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x06, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x70, 0x00,
  0x7F, 0x40, 0x00, 0xFE, 0x70, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xB0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0xC7, 0xFE, 0x05, 0x07, 0xFF, 0xF0, 0x81, 0xFF, 0x86,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF1, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC3, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0x00, 0xFF, 0x80, 0x1F,
  0x00, 0xFF, 0xF9, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC1, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF8, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x18, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0xFC,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x8F, 0xF8, 0x00,
  0x07, 0x80, 0x18, 0x0F, 0xCF, 0xFE, 0x00, 0x00, 0xF8, 0x78, 0x07, 0xEB,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0x80, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x01,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xF0, 0xC0, 0x00, 0x3F, 0xF9, 0x82, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0x81,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0x81, 0x80, 0x3F, 0xFF, 0xF8, 0x7C,
  0x06, 0x07, 0xFF, 0xFF, 0xE3, 0xE0, 0x19, 0xFF, 0xFF, 0xCF, 0x9F, 0x00,
  0xFF, 0xFF, 0xE0, 0x0C, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x37, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0x05, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x2F, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xF0, 0x00, 0x00, 0x00,
  0x06, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x33, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0x8F, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xC1,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xFC, 0x17, 0x00, 0x00, 0x37, 0xFF, 0xFF, 0xB0, 0x00,
  0x03, 0x0F, 0xFF, 0xF9, 0x80, 0x00, 0x70, 0x1F, 0xFF, 0x0C, 0x00, 0x07,
  0x80, 0x7F, 0xF0, 0x60, 0x00, 0x7C, 0x00, 0xFF, 0x02, 0x00, 0x07, 0xF0,
  0x01, 0xE0, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x18, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x83, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x0E, 0x00,
  0x00, 0x20, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x01, 0xE0, 0xE0, 0x00,
  0x1C, 0x00, 0xF8, 0x0C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x18, 0x03, 0xF8, 0x01, 0xF8, 0x02, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x38, 0x1F, 0xF8, 0x01, 0xFC, 0x04,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0x80, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x67, 0xF0, 0x18, 0xFF, 0xF8,
  0x18, 0xFF, 0x02, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x0C, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x20, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0xFD,
  0x80, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0xF0, 0x00,
  0x7F, 0xF0, 0x07, 0xFC, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x1C,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xE3, 0x80, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x0E, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xF0, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x30, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x01, 0x80, 0x04, 0x0F, 0x80, 0x1F, 0xC0, 0x03, 0x00, 0x18, 0x3E,
  0x00, 0x7F, 0x80, 0x07, 0x01, 0xC0, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x18, 0x3F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x40, 0x3F, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE1, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC6, 0x1C, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFB, 0x03, 0xE0, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x1C,
  0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x1F, 0xF8, 0x0E, 0x00, 0x1F, 0xF8, 0x1F,
  0x00, 0x03, 0xFF, 0x03, 0x80, 0x03, 0xFE, 0x07, 0x80, 0x00, 0x7F, 0xC1,
  0xE0, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x1F, 0xF0,
  0x70, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x07, 0xFE, 0x18, 0x00, 0x00, 0x7F,
  0x8F, 0xC0, 0x00, 0xFF, 0xC6, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC1, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x3C, 0x00, 0xC0, 0x00,
  0x01, 0xF0, 0xFF, 0xC0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x1F, 0xF0,
  0x07, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xC0,
  0x02, 0x07, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x38, 0x03, 0x03, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0x38, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0x00, 0xC1, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x18, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFC, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xC2, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x80, 0xFF,
  0xC7, 0xFF, 0x83, 0xE0, 0x03, 0xFC, 0x63, 0xF0, 0x7C, 0x00, 0x1F, 0xEC,
  0x0E, 0x07, 0x80, 0x00, 0xFE, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x18, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x06, 0x02, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x09, 0xFE, 0x00,
  0x00, 0x04, 0x01, 0x9F, 0xF0, 0x00, 0x01, 0xF8, 0x19, 0xFF, 0x80, 0x00,
  0x3F, 0xC3, 0x0F, 0xFE, 0x04, 0x07, 0xFF, 0x70, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x30, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF6, 0x03, 0xFE, 0x01, 0xFE,
  0x1F, 0xFF, 0x60, 0x1F, 0xF0, 0x3E, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x03,
  0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x87, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x60, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xCE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x60, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC6, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x60, 0x00,
  0x00, 0x7E, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x18, 0x00, 0x20, 0xFC, 0x03, 0xF8, 0x00, 0xC0, 0x04, 0x0F, 0x80, 0x3F,
  0x80, 0x07, 0x83, 0x80, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x04, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x18, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0C,
  0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0x00,
  0x07, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0x80, 0x00, 0x03, 0xF8,
  0x03, 0x80, 0x00, 0x03, 0xF8, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x03,
  0xF0, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x00,
  0x3E, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x7F,
  0xFF, 0x00, 0x00, 0x3C, 0xE7, 0xFF, 0x80, 0x00, 0x38, 0x03, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x00, 0xE0,
  0x00, 0x3F, 0xFC, 0x01, 0x80, 0x00, 0x1F, 0xFE, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0,
  0x07, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x3F, 0x0F, 0xE1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x37, 0xFE, 0x00, 0x0C,
  0x7F, 0xF8, 0x03, 0x87, 0xFF, 0x80, 0xE0, 0x7F, 0xC0, 0x3C, 0x03, 0xF8,
  0x0F, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xE0, 0x7C, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x8F, 0xF0, 0xFF, 0xB1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0x81, 0xF8, 0x01,
  0xE0, 0x1F, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x04, 0x0F, 0x00, 0x01, 0x87, 0x80, 0x00, 0x23,
  0xE0, 0x00, 0x0D, 0xF8, 0x00, 0x01, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x10, 0x03, 0xF0, 0x0C, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x07, 0xF0, 0x0F, 0xC7, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFE, 0x00, 0xF8, 0x3F, 0x80, 0x3E, 0x0F, 0xE0, 0x0F, 0x83, 0xF8, 0x03,
  0xC0, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x70, 0x1F, 0xF0, 0x18, 0x0F, 0xFF,
  0x0C, 0x03, 0xFF, 0xF6, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x39, 0xFC, 0x07, 0x1F, 0xC0, 0xF0, 0xFE, 0x1E, 0x0F, 0xE1, 0xE0, 0x7F,
  0x3E, 0x07, 0xF3, 0xE0, 0x38, 0x3E, 0x02, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xE3, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x06, 0x7F, 0xF0, 0x03, 0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0x87,
  0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x03, 0xE1, 0xFC, 0x00, 0x78, 0x7F, 0x00, 0x1E, 0x1F,
  0xC0, 0x07, 0x87, 0xF0, 0x03, 0xC1, 0xFC, 0x00, 0xF0, 0x7F, 0x00, 0x38,
  0x1F, 0xC0, 0x0E, 0x0F, 0xFC, 0x03, 0x07, 0xFF, 0xC1, 0xC0, 0xFF, 0xF8,
  0x60, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x39, 0xF8, 0x03, 0x8F,
  0xE0, 0x3C, 0x3F, 0x03, 0xC1, 0xFC, 0x1E, 0x0F, 0xE1, 0xF0, 0x3F, 0x0F,
  0x81, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0xBF, 0x01, 0xF1, 0xF8, 0x1C,
  0x0F, 0xC7, 0x80, 0x7E, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE3, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0x01, 0xFF, 0x20, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0x3F, 0x80, 0x60, 0xF0, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x37,
  0xFF, 0x00, 0x0C, 0x7F, 0xFC, 0x03, 0x83, 0xFF, 0x80, 0xE0, 0x3F, 0xE0,
  0x3C, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xE0, 0x7C, 0x00,
  0x3C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x7C, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x7F, 0x01, 0xFF, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xC0, 0x1F, 0xC0, 0x60, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1E, 0x03, 0xF0, 0x07, 0x80,
  0x7E, 0x01, 0xE0, 0x07, 0xE0, 0x70, 0x00, 0x7F, 0x78, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xC0, 0x01, 0x03, 0xC0, 0x00, 0x61, 0xF0, 0x00, 0x08, 0xF8, 0x00,
  0x03, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x03,
  0xF0, 0x18, 0x00, 0xFC, 0x0F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0,
  0xFF, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F,
  0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xC0, 0xFE, 0x01, 0xF0,
  0x7F, 0x98, 0x78, 0x3F, 0xFC, 0x1E, 0x0F, 0xFE, 0x0F, 0x00, 0xFF, 0x03,
  0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0x3F, 0x84, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x43, 0xFD, 0x83, 0xFE, 0x07, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0xC1, 0x9F, 0xE0, 0x47, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0x20, 0x07, 0x84, 0x03, 0xE1, 0x80, 0xE0, 0x30, 0xF0, 0x03,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0xF0, 0x03, 0xC3,
  0x01, 0xE0, 0x60, 0xF0, 0x08, 0x78, 0x11, 0x3E, 0x1C, 0x7F, 0x8F, 0x1F,
  0xE7, 0xC3, 0xFB, 0xF0, 0xFE, 0xFC, 0x3F, 0xFF, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x18, 0x7F, 0xEC, 0x3F,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF0, 0x03, 0xC3, 0x01, 0xC0,
  0x61, 0xF0, 0x08, 0xF8, 0x01, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x18, 0x7F, 0xFC, 0x3F, 0xFE, 0x03,
  0xFF, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0xFC, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x83, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0xFF, 0xF7, 0xFF, 0xE3,
  0x7F, 0xE3, 0xFF, 0x1F, 0xFC, 0x8F, 0xF0, 0x7F, 0x83, 0xFC, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x81, 0xFE,
  0x07, 0xF2, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0xCF, 0xFC, 0x7F, 0xF0, 0x7F,
  0xE0, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0xE0, 0x03, 0x00, 0x0F, 0x00, 0x10, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x8F,
  0xFE, 0x07, 0xFE, 0x6F, 0xFE, 0x13, 0xFF, 0x1F, 0xF0, 0x87, 0xF0, 0x3F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0xF3,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x00,
  0xF0, 0x01, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F,
  0xE0, 0x7F, 0x0F, 0xF8, 0x3F, 0x87, 0xFC, 0x1F, 0xC1, 0xFF, 0x0F, 0xE0,
  0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF,
  0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF1, 0xFC, 0x00, 0xF8,
  0xFE, 0x00, 0x78, 0x7F, 0x00, 0x38, 0x3F, 0xC0, 0x3C, 0x3F, 0xF0, 0x1C,
  0x3F, 0xFE, 0x1C, 0x07, 0xFF, 0x9C, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x18, 0x07, 0xFC, 0x03, 0x80, 0x7F, 0xC0, 0xFC, 0x07, 0xFE, 0x1F,
  0xE0, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x01, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0x7C, 0x1F, 0xF0, 0x07, 0x87, 0xFF, 0x00, 0x70, 0x7F,
  0xF8, 0x0F, 0x0F, 0xFF, 0xE0, 0xC0, 0xFF, 0xFF, 0x98, 0x08, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3E, 0x70, 0x00, 0x03, 0xE1, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x06, 0x7F, 0xE0, 0x07,
  0x1F, 0xFE, 0x07, 0x07, 0xFF, 0x87, 0x01, 0xFF, 0x07, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0xC0, 0x7E, 0x0F, 0xF0,
  0x3F, 0x07, 0xFC, 0x3F, 0x81, 0xFF, 0xEF, 0xC0, 0x7F, 0xE7, 0xE0, 0x1F,
  0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xC0, 0x7C, 0x00, 0x80, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x70, 0x06, 0x07, 0xE0, 0x70, 0x3F, 0x83, 0xC3,
  0xFC, 0x3E, 0x1F, 0xF3, 0xF9, 0xFF, 0xBF, 0xF9, 0xFF, 0x7F, 0x07, 0xF3,
  0xF0, 0x3F, 0x0F, 0x01, 0xF8, 0x78, 0x0F, 0xC1, 0x80, 0x7E, 0x08, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x20,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x10, 0x01, 0x00, 0x38, 0x03, 0x00, 0xFC,
  0x03, 0x01, 0xFF, 0x07, 0x03, 0xFF, 0xFF, 0x04, 0x7F, 0xFE, 0x08, 0x3F,
  0xFE, 0x18, 0x0F, 0xF8, 0x30, 0x03, 0xF0, 0x70, 0x00, 0x60, 0x78, 0x00,
  0x40, 0x7C, 0x00, 0x80, 0x7E, 0x03, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x8F,
  0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xC1,
  0xFE, 0x07, 0x80, 0xFE, 0x07, 0x00, 0x7E, 0x06, 0x00, 0x3E, 0x04, 0x00,
  0x3E, 0x0E, 0x00, 0x1C, 0x1F, 0x80, 0x18, 0x3F, 0xE0, 0x30, 0x7F, 0xFC,
  0x60, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFC,
  0x21, 0xFF, 0x23, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x18, 0x01, 0xF8, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x13, 0xF8, 0x0F, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x87, 0xFC, 0x83,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x01,
  0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x8F, 0xFF, 0x83, 0xFE,
  0xC3, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0x00, 0x3E,
  0x00, 0x30, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0xF0, 0x01,
  0xFE, 0x07, 0x00, 0x1F, 0xFC, 0x70, 0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xC0, 0x01, 0x81, 0xFF, 0x00, 0xF0, 0x01, 0xC0, 0xFF, 0xC0,
  0xFE, 0x03, 0xE0, 0x3F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7,
  0xFE, 0x07, 0xFC, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0xC7, 0xF8, 0x3F, 0xC0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xC0,
  0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0xF8, 0x1F, 0x80,
  0xFE, 0x00, 0x7C, 0x0F, 0xC0, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x3F, 0x80,
  0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80,
  0xFC, 0x07, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0x80, 0x3F, 0x80, 0xFF, 0x81, 0x80, 0x1F, 0xE1, 0xFF, 0xF1,
  0x80, 0x1F, 0xF0, 0x7F, 0xFD, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x60,
  0x1F, 0x00, 0xC0, 0x3F, 0x03, 0xC0, 0xFF, 0x0F, 0x81, 0xFF, 0x3F, 0x87,
  0xFE, 0xFF, 0x19, 0xFF, 0xFF, 0x03, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE1, 0xE0, 0x0F, 0xC1, 0x80, 0x1F, 0x82, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x80,
  0x1F, 0xFA, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x38, 0x7C, 0x00, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x40, 0x30, 0x03, 0xE0, 0x38, 0x0F, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x7F, 0x80, 0x38, 0x07, 0xFC,
  0x07, 0x80, 0x7F, 0xE0, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xEF, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x07, 0xC0, 0x7F,
  0x00, 0x78, 0x0F, 0xF3, 0x0F, 0x81, 0xFF, 0xE0, 0xF0, 0x0F, 0xFC, 0x0F,
  0x00, 0x3F, 0x81, 0xE0, 0x01, 0xF0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x06, 0x7F, 0xC1, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x10, 0x1C, 0x07, 0x07, 0x83, 0x01, 0xFC, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xDF, 0xE0, 0x11, 0xFE, 0x04,
  0x3F, 0xC1, 0x83, 0xF8, 0x60, 0x7F, 0x0C, 0x07, 0xF3, 0x80, 0xFE, 0x60,
  0x1F, 0xDC, 0x01, 0xFB, 0x80, 0x3F, 0x70, 0x07, 0xEE, 0x00, 0xFD, 0x80,
  0x1F, 0x30, 0x03, 0xE6, 0x00, 0x7C, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80,
  0x38, 0x30, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x70, 0x07, 0x38, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 11, 47, 15, 2, -46 },
  { 66, 22, 18, 26, 2, -46 },
  { 116, 29, 37, 33, 2, -41 },
  { 251, 22, 52, 27, 2, -49 },
  { 394, 42, 44, 46, 2, -45 },
  { 625, 33, 41, 37, 2, -40 },
  { 795, 10, 18, 13, 1, -46 },
  { 818, 14, 52, 16, 1, -50 },
  { 909, 14, 52, 16, 1, -50 },
  { 1000, 21, 24, 23, 0, -47 },
  { 1063, 21, 22, 25, 2, -32 },
  { 1121, 10, 18, 12, 0, -10 },
  { 1144, 17, 12, 19, 2, -25 },
  { 1170, 11, 11, 13, 1, -10 },
  { 1186, 31, 51, 33, 2, -48 },
  { 1384, 28, 46, 30, 1, -45 },
  { 1545, 19, 44, 21, 1, -44 },
  { 1650, 27, 43, 29, 1, -43 },
  { 1796, 28, 44, 30, 1, -44 },
  { 1950, 27, 44, 29, 1, -44 },
  { 2099, 28, 46, 30, 1, -46 },
  { 2260, 27, 45, 29, 1, -45 },
  { 2412, 26, 44, 28, 1, -44 },
  { 2555, 28, 45, 30, 1, -45 },
  { 2713, 27, 46, 29, 1, -46 },
  { 2869, 11, 31, 13, 1, -30 },
  { 2912, 12, 38, 11, 0, -30 },
  { 2969, 18, 24, 18, 0, -30 },
  { 3023, 23, 14, 25, 1, -26 },
  { 3064, 18, 24, 18, 0, -30 },
  { 3118, 24, 47, 29, 2, -46 },
  { 3259, 37, 39, 39, 1, -30 },
  { 3440, 50, 47, 52, 1, -46 },
  { 3734, 56, 48, 57, 0, -47 },
  { 4070, 41, 47, 44, 2, -46 },
  { 4311, 49, 49, 52, 1, -47 },
  { 4612, 42, 48, 45, 2, -47 },
  { 4864, 46, 55, 48, 1, -47 },
  { 5181, 46, 48, 49, 2, -46 },
  { 5457, 45, 59, 47, 1, -50 },
  { 5789, 41, 55, 44, 1, -47 },
  { 6071, 43, 63, 45, 1, -47 },
  { 6410, 50, 47, 52, 1, -46 },
  { 6704, 34, 46, 37, 1, -45 },
  { 6900, 67, 48, 71, 2, -45 },
  { 7302, 53, 46, 57, 2, -45 },
  { 7607, 46, 47, 48, 1, -46 },
  { 7878, 55, 56, 57, 1, -45 },
  { 8263, 49, 50, 51, 1, -46 },
  { 8570, 57, 47, 60, 1, -46 },
  { 8905, 45, 47, 49, 2, -46 },
  { 9170, 45, 46, 48, 2, -45 },
  { 9429, 43, 49, 46, 1, -45 },
  { 9693, 54, 48, 57, 1, -47 },
  { 10017, 66, 47, 69, 1, -46 },
  { 10405, 44, 48, 46, 1, -47 },
  { 10669, 52, 57, 55, 1, -47 },
  { 11040, 40, 55, 43, 1, -47 },
  { 11315, 9, 50, 12, 1, -47 },
  { 11372, 39, 45, 7, -12, -42 },
  { 11592, 9, 50, 12, 1, -47 },
  { 11649, 24, 17, 27, 1, -45 },
  { 11700, 31, 5, 29, -1, 7 },
  { 11720, 10, 12, 32, 10, -45 },
  { 11735, 27, 35, 29, 1, -33 },
  { 11854, 26, 46, 28, 1, -44 },
  { 12004, 20, 33, 23, 1, -32 },
  { 12087, 26, 46, 29, 2, -45 },
  { 12237, 21, 34, 23, 1, -33 },
  { 12327, 20, 57, 16, -1, -47 },
  { 12470, 27, 47, 30, 1, -33 },
  { 12629, 26, 56, 28, 1, -45 },
  { 12811, 15, 45, 17, 1, -44 },
  { 12896, 18, 57, 16, -3, -45 },
  { 13025, 18, 47, 21, 1, -45 },
  { 13131, 18, 46, 17, 1, -45 },
  { 13235, 42, 35, 45, 2, -34 },
  { 13419, 30, 35, 32, 1, -33 },
  { 13551, 25, 34, 26, 0, -33 },
  { 13658, 28, 51, 29, 0, -38 },
  { 13837, 25, 46, 28, 1, -33 },
  { 13981, 21, 34, 23, 1, -33 },
  { 14071, 24, 41, 27, 1, -40 },
  { 14194, 17, 43, 20, 1, -41 },
  { 14286, 30, 34, 32, 1, -33 },
  { 14414, 29, 37, 29, -1, -36 },
  { 14549, 41, 40, 44, 2, -38 },
  { 14754, 23, 47, 25, 1, -34 },
  { 14890, 28, 49, 30, 1, -38 },
  { 15062, 19, 45, 21, 1, -33 },
  { 15169, 17, 51, 21, 1, -50 },
  { 15278, 4, 53, 10, 3, -50 },
  { 15305, 17, 51, 21, 1, -50 },
  { 15414, 21, 5, 23, 1, -22 },
};

const GFXfont UnifrakturMaguntia_Regular64pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular64pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular64pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR64PT7B_H_
