#ifndef _UNIFRAKTURMAGUNTIA_REGULAR10PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0x7A, 0x8C, 0x6F, 0xA0, 0x53, 0xD5, 0xF5, 0x00, 0x46, 0xA5, 0x29,
  0xA4, 0x67, 0x4A, 0xA3, 0xA2, 0xA9, 0x61, 0x00, 0x32, 0x98, 0xDB, 0xE9,
  0xE0, 0xD8, 0x6A, 0xA9, 0x95, 0x57, 0x5F, 0x80, 0x4F, 0x40, 0x38, 0x78,
  0x30, 0x08, 0x88, 0x44, 0x22, 0x00, 0x62, 0xB5, 0xBD, 0x29, 0x80, 0x59,
  0x24, 0xB8, 0x79, 0x11, 0x25, 0xF0, 0x74, 0x84, 0xE9, 0x49, 0xC0, 0x22,
  0xEA, 0xF2, 0x30, 0x74, 0x1D, 0x29, 0xC9, 0xC0, 0x65, 0xFD, 0xDD, 0x70,
  0xF9, 0x22, 0x24, 0x40, 0x79, 0x5B, 0x99, 0x70, 0x69, 0x99, 0x7D, 0x60,
  0xB0, 0xC0, 0xB0, 0xE0, 0x6B, 0x30, 0xFF, 0x89, 0xC0, 0x79, 0xD6, 0x76,
  0x02, 0x39, 0xFB, 0x75, 0xBD, 0x27, 0x80, 0x73, 0x9E, 0x8A, 0x72, 0x62,
  0x32, 0x5F, 0x7F, 0x44, 0xA2, 0x8D, 0xE1, 0x19, 0x88, 0x78, 0x7E, 0xE3,
  0xC6, 0xC4, 0x8E, 0x0F, 0x80, 0x7C, 0x96, 0x93, 0x99, 0x69, 0x32, 0xDC,
  0x7E, 0xE3, 0xD6, 0xF4, 0x8E, 0x0F, 0x80, 0x7D, 0x2E, 0x44, 0xD6, 0xCC,
  0x99, 0x14, 0x38, 0x74, 0xBF, 0xD6, 0xDC, 0xAA, 0x4F, 0x00, 0x00, 0x71,
  0x13, 0x63, 0x66, 0x54, 0xF1, 0x1C, 0x39, 0x9A, 0x24, 0x47, 0xC0, 0x91,
  0x52, 0x18, 0x79, 0x1A, 0x24, 0x47, 0xC0, 0x81, 0x81, 0xE4, 0x70, 0x3E,
  0x3D, 0x25, 0x26, 0x3C, 0x56, 0xE3, 0x79, 0x24, 0x9C, 0x41, 0x8B, 0x80,
  0x76, 0xD3, 0x6A, 0x25, 0xB4, 0xC0, 0xA8, 0xA5, 0x0F, 0x18, 0x00, 0x76,
  0x4C, 0xA2, 0x4D, 0x40, 0xA2, 0x90, 0xCE, 0x18, 0xDA, 0x0B, 0x13, 0x2C,
  0x6F, 0x00, 0x72, 0x4F, 0x22, 0xD5, 0x34, 0x88, 0xC8, 0xB8, 0x20, 0x10,
  0x00, 0x18, 0x6C, 0x82, 0x62, 0x22, 0x66, 0xBF, 0x00, 0x77, 0x4C, 0xA2,
  0x71, 0x46, 0xF1, 0x49, 0xC6, 0x3A, 0x8A, 0x15, 0xD8, 0x2C, 0x4F, 0x00,
  0x79, 0x1E, 0x54, 0xC6, 0x9C, 0x07, 0x80, 0x66, 0xF9, 0x91, 0x24, 0x48,
  0xAF, 0x80, 0x7E, 0x45, 0xA2, 0x95, 0x65, 0x13, 0x88, 0x38, 0x7F, 0x93,
  0x9A, 0x3A, 0x55, 0x65, 0x24, 0xE4, 0x87, 0x60, 0x77, 0x32, 0x23, 0xE1,
  0x8D, 0x1B, 0x80, 0x7E, 0x8B, 0x8A, 0x6A, 0x13, 0x15, 0x39, 0x22, 0x1C,
  0x39, 0x16, 0x42, 0x3C, 0x14, 0x69, 0x18, 0xEA, 0xAC, 0x04, 0x10, 0x84,
  0x21, 0x08, 0x00, 0xD5, 0x5C, 0x46, 0x90, 0xF8, 0xC0, 0x2D, 0x99, 0x70,
  0xE4, 0x57, 0x55, 0xE0, 0x76, 0x66, 0x8C, 0x35, 0x55, 0xA0, 0x77, 0x66,
  0x73, 0xA4, 0x94, 0x80, 0x2D, 0x99, 0x71, 0x60, 0xE4, 0x65, 0x55, 0xF2,
  0x40, 0x41, 0x64, 0x90, 0x21, 0x92, 0x49, 0xC0, 0xED, 0xE4, 0xB8, 0xE9,
  0x24, 0xB8, 0x7D, 0xA9, 0x52, 0xA5, 0x60, 0x57, 0x94, 0xA5, 0x80, 0x6B,
  0x99, 0x60, 0x8E, 0x55, 0xD6, 0x44, 0x2D, 0x99, 0x71, 0x20, 0x7D, 0x26,
  0x37, 0xA7, 0x96, 0x6F, 0x24, 0xC0, 0x56, 0x94, 0xA7, 0x80, 0x8B, 0xD5,
  0x96, 0x81, 0xA9, 0xFA, 0x95, 0x49, 0x00, 0x56, 0x44, 0x68, 0x60, 0x87,
  0x94, 0xA5, 0x38, 0x88, 0x4E, 0xFB, 0x70, 0x29, 0x28, 0x93, 0xFF, 0x89,
  0x26, 0x96, 0xE0,
};

const GFXglyph UnifrakturMaguntia_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 4, 3, 4, 0, -7 },
  { 5, 5, 5, 5, 0, -6 },
  { 9, 4, 8, 4, 0, -8 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 5, 7, 6, 0, -7 },
  { 25, 2, 3, 2, 0, -7 },
  { 26, 2, 8, 2, 0, -8 },
  { 28, 2, 8, 2, 0, -8 },
  { 30, 3, 3, 4, 0, -7 },
  { 32, 4, 3, 4, 0, -5 },
  { 34, 2, 3, 2, 0, -2 },
  { 35, 3, 2, 3, 0, -4 },
  { 36, 2, 2, 2, 0, -2 },
  { 37, 5, 7, 5, 0, -7 },
  { 42, 5, 7, 5, 0, -7 },
  { 47, 3, 7, 3, 0, -7 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 4, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 4, 7, 5, 0, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 4, 7, 5, 0, -7 },
  { 80, 4, 7, 5, 0, -7 },
  { 84, 2, 5, 2, 0, -5 },
  { 86, 2, 6, 2, 0, -5 },
  { 88, 3, 4, 3, 0, -5 },
  { 90, 4, 2, 4, 0, -4 },
  { 91, 3, 4, 3, 0, -5 },
  { 93, 4, 8, 5, 0, -8 },
  { 97, 6, 7, 6, 0, -5 },
  { 103, 8, 7, 8, 0, -7 },
  { 110, 9, 7, 9, 0, -7 },
  { 118, 7, 7, 7, 0, -7 },
  { 125, 8, 7, 8, 0, -7 },
  { 132, 7, 7, 7, 0, -7 },
  { 139, 7, 9, 8, 0, -7 },
  { 147, 7, 7, 8, 0, -7 },
  { 154, 7, 9, 7, 0, -8 },
  { 162, 7, 9, 7, 0, -7 },
  { 170, 7, 10, 7, 0, -7 },
  { 179, 8, 7, 8, 0, -7 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 11, 8, 11, 0, -7 },
  { 203, 9, 7, 9, 0, -7 },
  { 211, 7, 7, 8, 0, -7 },
  { 218, 9, 9, 9, 0, -7 },
  { 229, 8, 8, 8, 0, -7 },
  { 237, 9, 7, 9, 0, -7 },
  { 245, 7, 7, 8, 0, -7 },
  { 252, 7, 7, 7, 0, -7 },
  { 259, 7, 8, 7, 0, -7 },
  { 266, 9, 7, 9, 0, -7 },
  { 274, 11, 7, 11, 0, -7 },
  { 284, 7, 7, 7, 0, -7 },
  { 291, 8, 9, 9, 0, -7 },
  { 300, 6, 9, 7, 0, -7 },
  { 307, 2, 7, 2, 0, -7 },
  { 309, 6, 7, 1, -2, -7 },
  { 315, 2, 7, 2, 0, -7 },
  { 317, 4, 3, 4, 0, -7 },
  { 319, 5, 1, 5, 0, 1 },
  { 320, 1, 2, 5, 2, -7 },
  { 321, 4, 5, 5, 0, -5 },
  { 324, 4, 7, 4, 0, -7 },
  { 328, 3, 5, 4, 0, -5 },
  { 330, 4, 7, 5, 0, -7 },
  { 334, 3, 5, 4, 0, -5 },
  { 336, 3, 9, 2, 0, -7 },
  { 340, 4, 7, 5, 0, -5 },
  { 344, 4, 9, 4, 0, -7 },
  { 349, 3, 7, 3, 0, -7 },
  { 352, 3, 9, 2, -1, -7 },
  { 356, 3, 7, 3, 0, -7 },
  { 359, 3, 7, 3, 0, -7 },
  { 362, 7, 5, 7, 0, -5 },
  { 367, 5, 5, 5, 0, -5 },
  { 371, 4, 5, 4, 0, -5 },
  { 374, 4, 8, 5, 0, -6 },
  { 378, 4, 7, 4, 0, -5 },
  { 382, 3, 5, 4, 0, -5 },
  { 384, 4, 6, 4, 0, -6 },
  { 387, 3, 6, 3, 0, -6 },
  { 390, 5, 5, 5, 0, -5 },
  { 394, 4, 6, 5, 0, -6 },
  { 397, 7, 6, 7, 0, -6 },
  { 403, 4, 7, 4, 0, -5 },
  { 407, 5, 8, 5, 0, -6 },
  { 412, 3, 7, 3, 0, -5 },
  { 415, 3, 8, 3, 0, -8 },
  { 418, 1, 8, 2, 0, -8 },
  { 419, 3, 8, 3, 0, -8 },
  { 422, 3, 1, 4, 0, -3 },
};

const GFXfont UnifrakturMaguntia_Regular10pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular10pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular10pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR10PT7B_H_
