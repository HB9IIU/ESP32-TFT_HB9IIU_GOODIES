#ifndef _UNIFRAKTURMAGUNTIA_REGULAR11PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0x75, 0x89, 0xA5, 0x90, 0x3B, 0xD5, 0xF5, 0x28, 0x65, 0x96, 0x39,
  0x96, 0x20, 0x62, 0xA2, 0xA4, 0xA8, 0x76, 0x2E, 0x4F, 0x86, 0x30, 0xC2,
  0x1B, 0x9B, 0x47, 0xC0, 0x98, 0x2A, 0x49, 0x24, 0x40, 0x89, 0x36, 0xD2,
  0xC0, 0x4B, 0xE5, 0x44, 0xF4, 0x98, 0x7C, 0x90, 0x0C, 0x21, 0x04, 0x21,
  0x04, 0x20, 0x72, 0xB7, 0x9C, 0xED, 0x4E, 0x4B, 0x24, 0x9F, 0x74, 0xC6,
  0x21, 0x11, 0x3F, 0x74, 0xC4, 0x61, 0xC7, 0x2E, 0x13, 0xA5, 0x2F, 0x88,
  0xE0, 0x03, 0xA0, 0xE8, 0xC7, 0x2E, 0x32, 0xB3, 0xEC, 0xE5, 0x6E, 0x7C,
  0x84, 0x42, 0x11, 0x00, 0x74, 0x74, 0xC9, 0x46, 0x2E, 0x76, 0xA7, 0x35,
  0xDD, 0x4C, 0xE2, 0x40, 0xE2, 0x60, 0x2B, 0x10, 0xF0, 0xF0, 0x89, 0xC0,
  0x74, 0xF4, 0x45, 0x30, 0x84, 0x38, 0xBA, 0xB5, 0xAB, 0xE8, 0x8E, 0x00,
  0x31, 0x6D, 0xA2, 0xD9, 0x62, 0xB0, 0x98, 0xCC, 0xBB, 0x73, 0x23, 0x68,
  0x9A, 0x26, 0x6A, 0x84, 0x37, 0x88, 0x3C, 0x34, 0xBD, 0x46, 0xCC, 0xC8,
  0x9E, 0x1F, 0x3C, 0x23, 0xA4, 0x53, 0x28, 0x8B, 0x48, 0xC4, 0xBC, 0x34,
  0x5E, 0x50, 0xDE, 0xCC, 0x44, 0x78, 0x3E, 0x3C, 0xC7, 0x88, 0x89, 0x5F,
  0x26, 0x66, 0x26, 0x64, 0x18, 0x34, 0x5A, 0x53, 0xD7, 0xD9, 0x49, 0x71,
  0x3E, 0x00, 0x18, 0x6C, 0x64, 0x2E, 0x33, 0x13, 0x59, 0xE2, 0x04, 0x08,
  0x38, 0x9E, 0x14, 0x27, 0xC0, 0xC0, 0xB1, 0xBC, 0x38, 0x4E, 0x84, 0x84,
  0x74, 0x06, 0x02, 0x02, 0x62, 0xB4, 0x18, 0x0E, 0x1A, 0x8F, 0xA6, 0x73,
  0x50, 0xD1, 0x49, 0xC7, 0x39, 0x14, 0x59, 0x39, 0x06, 0x2F, 0x32, 0x4D,
  0xFA, 0x8D, 0x28, 0xDB, 0x65, 0x40, 0x94, 0x2D, 0x47, 0xE3, 0x00, 0x00,
  0x33, 0x6E, 0xE3, 0x70, 0xA6, 0x50, 0x58, 0xA4, 0xE3, 0x18, 0x3E, 0xC2,
  0xC1, 0x71, 0x11, 0x62, 0xBC, 0x31, 0x37, 0xC8, 0xBA, 0x26, 0x68, 0xC2,
  0x21, 0xC8, 0xBC, 0x08, 0x04, 0x00, 0x18, 0x17, 0x30, 0x98, 0x27, 0x10,
  0x89, 0x99, 0x7E, 0x00, 0x00, 0x33, 0x17, 0x68, 0xCE, 0x14, 0x57, 0x09,
  0x42, 0x99, 0xC3, 0x18, 0x6F, 0x80, 0x8E, 0xB9, 0xC1, 0x61, 0x3E, 0x78,
  0x8E, 0x93, 0x98, 0x6C, 0x64, 0xB8, 0x1E, 0x22, 0x56, 0x66, 0x66, 0x26,
  0x46, 0x66, 0xBF, 0x00, 0x73, 0x27, 0x48, 0x9A, 0x24, 0x69, 0x84, 0x27,
  0x88, 0x3C, 0x35, 0xC5, 0xA6, 0x8A, 0x28, 0xB4, 0x69, 0x61, 0x12, 0x71,
  0x21, 0xFC, 0x73, 0x9E, 0x88, 0x8E, 0x78, 0x08, 0x5C, 0x66, 0x73, 0x4E,
  0xA2, 0x71, 0x26, 0xB0, 0x8C, 0x56, 0x73, 0x21, 0x0F, 0x00, 0x3C, 0x89,
  0x19, 0x41, 0xC0, 0xC0, 0xF1, 0x3C, 0xEA, 0xAA, 0xC0, 0x06, 0x10, 0x20,
  0x82, 0x08, 0x20, 0x00, 0xD5, 0x55, 0xC0, 0x26, 0x90, 0xF8, 0xC0, 0x21,
  0xB5, 0x2D, 0x3C, 0x26, 0x14, 0xE5, 0xA5, 0x54, 0x2E, 0x98, 0xC7, 0x84,
  0x18, 0xA4, 0xA5, 0x54, 0x2E, 0x9E, 0xC7, 0x0E, 0x74, 0x92, 0x52, 0x00,
  0x23, 0xA7, 0x2D, 0x3C, 0x2E, 0x26, 0x18, 0xA5, 0xA5, 0x5E, 0x22, 0x00,
  0x4A, 0x64, 0x93, 0x20, 0x4A, 0x22, 0x22, 0x2D, 0x3D, 0x74, 0x93, 0x39,
  0x24, 0x93, 0x94, 0xFE, 0x52, 0x52, 0x52, 0x7A, 0xA7, 0xD4, 0xA5, 0x34,
  0x2F, 0xDD, 0xD6, 0x84, 0x9C, 0xB4, 0xE9, 0x88, 0x40, 0x27, 0x99, 0xD7,
  0x11, 0xAF, 0x44, 0x46, 0x75, 0xBA, 0x55, 0xA0, 0x2B, 0xA4, 0x98, 0x96,
  0xD4, 0xA5, 0x34, 0x97, 0x96, 0x95, 0x30, 0x84, 0xFD, 0x6A, 0x55, 0xAD,
  0x80, 0x57, 0x44, 0x46, 0x8F, 0x86, 0x9C, 0x94, 0xA5, 0xC4, 0x40, 0x55,
  0x7B, 0x6F, 0x29, 0x25, 0x92, 0x60, 0xFF, 0xC0, 0x89, 0x22, 0x92, 0xC0,
  0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 8, 3, 0, -8 },
  { 3, 4, 3, 4, 0, -8 },
  { 5, 5, 6, 6, 0, -7 },
  { 9, 4, 9, 5, 0, -8 },
  { 14, 8, 8, 8, 0, -8 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 2, 3, 2, 0, -8 },
  { 29, 3, 9, 3, 0, -9 },
  { 33, 3, 9, 3, 0, -9 },
  { 37, 4, 4, 4, 0, -8 },
  { 39, 4, 4, 4, 0, -6 },
  { 41, 2, 3, 2, 0, -2 },
  { 42, 3, 2, 3, 0, -4 },
  { 43, 2, 2, 2, 0, -2 },
  { 44, 6, 8, 6, 0, -8 },
  { 50, 5, 8, 5, 0, -8 },
  { 55, 3, 8, 4, 0, -8 },
  { 58, 5, 8, 5, 0, -8 },
  { 63, 5, 8, 5, 0, -8 },
  { 68, 5, 7, 5, 0, -7 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 5, 8, 5, 0, -8 },
  { 83, 5, 7, 5, 0, -7 },
  { 88, 5, 8, 5, 0, -8 },
  { 93, 5, 8, 5, 0, -8 },
  { 98, 2, 5, 2, 0, -5 },
  { 100, 2, 6, 2, 0, -5 },
  { 102, 3, 4, 3, 0, -5 },
  { 104, 4, 3, 4, 0, -5 },
  { 106, 3, 4, 3, 0, -5 },
  { 108, 5, 8, 5, 0, -8 },
  { 113, 7, 7, 7, 0, -5 },
  { 120, 9, 8, 9, 0, -8 },
  { 129, 10, 8, 10, 0, -8 },
  { 139, 7, 8, 8, 0, -8 },
  { 146, 9, 8, 9, 0, -8 },
  { 155, 8, 8, 8, 0, -8 },
  { 163, 8, 10, 8, 0, -8 },
  { 173, 8, 8, 8, 0, -8 },
  { 181, 8, 11, 8, 0, -9 },
  { 192, 7, 9, 8, 0, -8 },
  { 200, 8, 11, 8, 0, -8 },
  { 211, 9, 8, 9, 0, -8 },
  { 220, 6, 8, 6, 0, -8 },
  { 226, 12, 9, 12, 0, -8 },
  { 240, 9, 8, 10, 0, -8 },
  { 249, 8, 8, 8, 0, -8 },
  { 257, 10, 10, 10, 0, -8 },
  { 270, 9, 9, 9, 0, -8 },
  { 281, 10, 8, 10, 0, -8 },
  { 291, 8, 8, 8, 0, -8 },
  { 299, 8, 8, 8, 0, -8 },
  { 307, 8, 9, 8, 0, -8 },
  { 316, 10, 8, 10, 0, -8 },
  { 326, 12, 8, 12, 0, -8 },
  { 338, 8, 8, 8, 0, -8 },
  { 346, 9, 10, 9, 0, -8 },
  { 358, 7, 9, 7, 0, -8 },
  { 366, 2, 9, 2, 0, -8 },
  { 369, 7, 8, 1, -2, -7 },
  { 376, 2, 9, 2, 0, -8 },
  { 379, 4, 3, 5, 0, -8 },
  { 381, 5, 1, 5, 0, 1 },
  { 382, 1, 2, 6, 2, -8 },
  { 383, 5, 6, 5, 0, -6 },
  { 387, 5, 8, 5, 0, -8 },
  { 392, 4, 6, 4, 0, -6 },
  { 395, 5, 8, 5, 0, -8 },
  { 400, 4, 6, 4, 0, -6 },
  { 403, 3, 11, 3, 0, -9 },
  { 408, 5, 8, 5, 0, -6 },
  { 413, 5, 10, 5, 0, -8 },
  { 420, 3, 8, 3, 0, -8 },
  { 423, 4, 10, 3, -1, -8 },
  { 428, 3, 8, 4, 0, -8 },
  { 431, 3, 8, 3, 0, -8 },
  { 434, 8, 6, 8, 0, -6 },
  { 440, 5, 6, 6, 0, -6 },
  { 444, 4, 6, 5, 0, -6 },
  { 447, 5, 9, 5, 0, -7 },
  { 453, 4, 8, 5, 0, -6 },
  { 457, 4, 6, 4, 0, -6 },
  { 460, 4, 7, 5, 0, -7 },
  { 464, 3, 7, 3, 0, -7 },
  { 467, 5, 6, 6, 0, -6 },
  { 471, 5, 6, 5, 0, -6 },
  { 475, 7, 6, 8, 0, -6 },
  { 481, 4, 8, 4, 0, -6 },
  { 485, 5, 9, 5, 0, -7 },
  { 491, 3, 8, 4, 0, -6 },
  { 494, 3, 9, 4, 0, -9 },
  { 498, 1, 10, 2, 0, -9 },
  { 500, 3, 9, 4, 0, -9 },
  { 504, 4, 1, 4, 0, -4 },
};

const GFXfont UnifrakturMaguntia_Regular11pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular11pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular11pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR11PT7B_H_
