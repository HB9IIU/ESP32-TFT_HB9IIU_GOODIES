#ifndef _UNIFRAKTURMAGUNTIA_REGULAR51PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x03, 0x01, 0xC0, 0xF8, 0x7F, 0x9F, 0xE7, 0xF0, 0xFC, 0x3F,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x78, 0x3F, 0x1F, 0xE3, 0xE0, 0x70, 0x0C, 0x00,
  0x00, 0x08, 0x02, 0x07, 0x01, 0x83, 0xE0, 0xF1, 0xFC, 0xFF, 0x7F, 0x1F,
  0xC7, 0xC3, 0xF0, 0xF0, 0x78, 0x38, 0x0E, 0x06, 0x03, 0x81, 0x00, 0xC0,
  0xC0, 0x20, 0x20, 0x08, 0x08, 0x04, 0x04, 0x02, 0x00, 0x01, 0xE1, 0xE0,
  0x07, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F,
  0x07, 0x00, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xC0, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xF0, 0x70,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x03,
  0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x3C,
  0x38, 0x3C, 0x06, 0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x3D, 0xF0, 0x1E, 0xFC, 0x0E, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x60,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1E, 0xC0, 0x0E, 0x30, 0x0F, 0x0C, 0x0F, 0x03, 0xFF, 0x00, 0x7E,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x83, 0xF8, 0x00, 0x00, 0x61, 0xC7, 0x00, 0x00,
  0x30, 0xF1, 0xE0, 0x00, 0x18, 0x7C, 0x7C, 0x00, 0x0E, 0x1E, 0x0F, 0x00,
  0x07, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0, 0xF8, 0x00, 0xC0, 0xF8, 0x3E,
  0x00, 0x60, 0x3E, 0x0F, 0x80, 0x30, 0x0F, 0x83, 0xE0, 0x18, 0x01, 0xE0,
  0xF8, 0x0C, 0x00, 0x78, 0x3C, 0x07, 0x00, 0x1E, 0x0F, 0x03, 0x80, 0x07,
  0xC7, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x60, 0x00, 0x1C, 0x70, 0x30, 0x00,
  0x03, 0xF8, 0x18, 0x3E, 0x00, 0x7C, 0x0C, 0x1F, 0xE0, 0x00, 0x07, 0x0F,
  0x3C, 0x00, 0x03, 0x87, 0x8F, 0x00, 0x01, 0xC1, 0xE1, 0xE0, 0x00, 0x60,
  0xF8, 0x78, 0x00, 0x30, 0x3E, 0x1F, 0x00, 0x18, 0x0F, 0x87, 0xC0, 0x0C,
  0x03, 0xE1, 0xF0, 0x07, 0x00, 0xF8, 0x7C, 0x03, 0x80, 0x3E, 0x1F, 0x01,
  0xC0, 0x0F, 0x87, 0xC0, 0xE0, 0x03, 0xE1, 0xF0, 0x30, 0x00, 0xF8, 0x78,
  0x18, 0x00, 0x1E, 0x1E, 0x0C, 0x00, 0x07, 0x8F, 0x06, 0x00, 0x00, 0xF3,
  0xC3, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1,
  0xC0, 0x01, 0xF0, 0x70, 0x00, 0x7C, 0x1C, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0xE3, 0x80, 0x01, 0xF9, 0xC0, 0x00, 0x7E, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x3F, 0x81, 0xF0, 0x3F, 0xE0,
  0x38, 0x1D, 0xFC, 0x0E, 0x0E, 0x3F, 0x03, 0x07, 0x8F, 0xE0, 0xC1, 0xE1,
  0xF8, 0x30, 0xF8, 0x7F, 0x08, 0x3E, 0x1F, 0xC6, 0x0F, 0x83, 0xF9, 0x03,
  0xE0, 0xFF, 0xC0, 0xF8, 0x1F, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x0B, 0xF8, 0x1F, 0xE3, 0x7E, 0x03, 0xFF, 0x8F, 0xE1, 0xFF, 0xC1, 0xFF,
  0xCF, 0xE0, 0x1F, 0xC1, 0xF0, 0x08, 0x18, 0x3C, 0x7F, 0xFF, 0x3F, 0x1E,
  0x0E, 0x0E, 0x0C, 0x0C, 0x08, 0x10, 0x20, 0x00, 0xE0, 0x70, 0x18, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xBE, 0xC7,
  0xCE, 0x7D, 0xE3, 0x3C, 0xF9, 0x3E, 0x7E, 0xBF, 0x31, 0xF1, 0x90, 0x70,
  0x4F, 0xD7, 0xE7, 0xC9, 0xF3, 0xE6, 0xFB, 0xE7, 0x3E, 0x37, 0xD8, 0x07,
  0xF0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x08,
  0x08, 0x1C, 0x3E, 0x7F, 0x3F, 0x1F, 0x0F, 0x0E, 0x06, 0x0C, 0x0C, 0x08,
  0x10, 0x00, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xF8, 0x00, 0x10, 0x18, 0x3C, 0x7E, 0xFF,
  0x7C, 0x18, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xC0, 0x7C,
  0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC1, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xC1, 0xFE, 0x38, 0x03, 0xF9, 0x80, 0x1F,
  0xCC, 0x00, 0x7E, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x40, 0xE0, 0x02, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00,
  0x0C, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xC1, 0xFE, 0x0C, 0x03,
  0xF8, 0x60, 0x07, 0xF1, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF7, 0x80, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03,
  0xCF, 0xC0, 0x0E, 0x1F, 0x00, 0x70, 0x3E, 0x03, 0x80, 0x7C, 0x1C, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x37, 0xC0, 0x00, 0xCF, 0x80, 0x01, 0x9F, 0x00, 0x06, 0x3E, 0x00, 0x08,
  0x7C, 0x00, 0x30, 0xF8, 0x00, 0xC1, 0xF0, 0x01, 0x03, 0xE0, 0x06, 0x07,
  0xC0, 0x18, 0x0F, 0x80, 0x30, 0x1F, 0x00, 0xC0, 0x3E, 0x01, 0x00, 0x7C,
  0x06, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x78,
  0x03, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x11, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x3F, 0xC3, 0x80, 0x3F,
  0x8C, 0x00, 0x7E, 0x40, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x1E, 0xF8, 0x00, 0x7B, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x1F, 0x00, 0x38,
  0x7C, 0x01, 0xC0, 0xF8, 0x0E, 0x01, 0xF0, 0x70, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x0C, 0x3C, 0x00, 0xC0, 0xF8, 0x0E, 0x07, 0xC0, 0xF0, 0x3F,
  0x07, 0x01, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x81,
  0xF1, 0xFF, 0x1F, 0x9F, 0xFC, 0xFD, 0x87, 0xF7, 0xEC, 0x1F, 0xBF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x83, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x78, 0x1C, 0x00, 0xE1, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x60, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0xC8, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1C,
  0x78, 0x00, 0x71, 0xF0, 0x01, 0xC7, 0xE0, 0x0F, 0x1F, 0xE0, 0x38, 0x3F,
  0xC1, 0xC0, 0xFF, 0xCE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0x9F, 0xFC, 0x1C, 0x1F, 0xF0,
  0xE0, 0x1F, 0xE7, 0x00, 0x3F, 0xBC, 0x00, 0x7E, 0xF0, 0x00, 0xFB, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0x70, 0x07, 0x00,
  0xE0, 0x78, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x18, 0x70, 0x01, 0x81,
  0xE0, 0x1C, 0x0F, 0x81, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x8F,
  0x80, 0x7E, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFB, 0xF0, 0x3F, 0xDF, 0x81, 0x7E, 0xFE, 0x1B, 0xF3, 0xFF, 0x9F,
  0x8F, 0xF8, 0xFC, 0x1F, 0x87, 0xC0, 0x20, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x70, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x01, 0xE1,
  0xF8, 0x0F, 0x0F, 0xC0, 0x70, 0x3E, 0x07, 0x01, 0xF0, 0x30, 0x07, 0xC3,
  0x00, 0x07, 0xE0, 0x00, 0x10, 0x18, 0x3C, 0x7E, 0xFF, 0x3C, 0x18, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x18, 0x3C, 0x7E,
  0xFF, 0x7C, 0x18, 0x18, 0x00, 0x08, 0x06, 0x07, 0x87, 0xE7, 0xF8, 0xF0,
  0x30, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x04, 0x07, 0x07, 0xC7, 0xF1, 0xF8, 0x7C, 0x1E, 0x0E, 0x03, 0x03, 0x01,
  0x80, 0x80, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x07, 0xFC, 0x03, 0x83, 0xE1, 0xC0, 0x3E, 0x30, 0x03, 0xEE, 0x00, 0x7D,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xFC,
  0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x02, 0x07, 0x80, 0xC0, 0x70, 0x10, 0x07, 0x0C, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x3C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x03,
  0xFE, 0x71, 0xE0, 0x3F, 0xF1, 0xC7, 0x81, 0xE7, 0xC7, 0x3C, 0x0F, 0x1F,
  0x1C, 0xF0, 0x78, 0x78, 0x73, 0xC3, 0xE1, 0xE1, 0xCE, 0x1F, 0x07, 0x87,
  0x38, 0x7C, 0x3C, 0x1C, 0xE1, 0xE0, 0xF0, 0xE3, 0x8F, 0x87, 0xC3, 0x8E,
  0x3E, 0x1F, 0x1C, 0x38, 0xF8, 0xF8, 0xF0, 0xF3, 0xE7, 0xE7, 0x81, 0xC7,
  0xFF, 0xFC, 0x67, 0x0F, 0x8F, 0xC3, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x1F,
  0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0x80, 0x7F, 0xC1,
  0xFE, 0x06, 0x00, 0x7F, 0xC7, 0xFC, 0x18, 0x00, 0x7F, 0x83, 0xF8, 0x30,
  0x00, 0x7F, 0x87, 0xE0, 0xC0, 0x00, 0x7F, 0x0F, 0xC1, 0x80, 0x00, 0xFE,
  0x1F, 0x83, 0x00, 0x00, 0xFC, 0x3F, 0x06, 0x00, 0x01, 0xF8, 0x7E, 0x0E,
  0x00, 0x03, 0xF0, 0xFC, 0x1E, 0x00, 0x07, 0xE1, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x3F, 0xE0, 0x1F, 0x07, 0xE0, 0x3F, 0xE0, 0x3E, 0x0F, 0xC0,
  0x3F, 0xC0, 0x78, 0x1F, 0x80, 0x3F, 0xC1, 0xE0, 0x3F, 0x00, 0x0F, 0x83,
  0xC0, 0x7E, 0x00, 0x07, 0x0F, 0x00, 0xFC, 0x00, 0x0C, 0x1C, 0x01, 0xF8,
  0x00, 0x10, 0x70, 0x03, 0xF0, 0x00, 0x41, 0xC0, 0x07, 0xE0, 0x00, 0x06,
  0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x77,
  0xFF, 0x00, 0x0F, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xC7, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFE, 0x40, 0xFE, 0x01, 0xF8, 0x7F, 0xEC, 0x0F, 0xE0, 0x3E,
  0x00, 0xFF, 0x80, 0x7F, 0x03, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x70, 0x00,
  0x3F, 0x80, 0x7F, 0x07, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x60, 0x00, 0x1F,
  0x80, 0x3F, 0xC6, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x60, 0x00, 0x0F, 0x80,
  0x1F, 0x86, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x60, 0x00, 0x0F, 0x80, 0x38,
  0x07, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x0F, 0x83, 0xFF, 0x03,
  0x80, 0x00, 0xF1, 0xFF, 0xF8, 0x1C, 0x03, 0x0F, 0x3F, 0xFF, 0xC0, 0xF8,
  0xC0, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x00,
  0x7F, 0xC0, 0xF0, 0x00, 0x78, 0x10, 0xFE, 0x00, 0x78, 0x0D, 0xFF, 0xF0,
  0x78, 0x03, 0xFF, 0xF0, 0x7C, 0x01, 0x9F, 0xE0, 0x3C, 0x03, 0x01, 0xE0,
  0x3E, 0x07, 0x00, 0x20, 0x3F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x00, 0xFC, 0x1F, 0xF0,
  0x00, 0x7E, 0x0F, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0xFF,
  0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xE0, 0x03, 0xFC,
  0x01, 0xC0, 0x00, 0xFF, 0x01, 0xC0, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x1F,
  0xF1, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0x80,
  0x7F, 0xFC, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x30, 0x7F, 0xE0, 0x3C,
  0x00, 0xC0, 0x3F, 0xE0, 0xF0, 0x03, 0x00, 0x3F, 0xE1, 0xC0, 0x0E, 0x00,
  0x1F, 0xC7, 0x00, 0x3C, 0x00, 0x1F, 0xCE, 0x00, 0xFC, 0x00, 0x1F, 0x9C,
  0x01, 0xFC, 0x00, 0x3F, 0xB0, 0x03, 0xFC, 0x00, 0x3F, 0x60, 0x07, 0xFC,
  0x00, 0x3E, 0xC0, 0x0F, 0xFC, 0x00, 0x3C, 0x80, 0x0F, 0xFC, 0x00, 0x7D,
  0x80, 0x0F, 0xF8, 0x00, 0xFB, 0x00, 0x0F, 0xF8, 0x00, 0xF3, 0x00, 0x0F,
  0xF0, 0x01, 0xE7, 0x00, 0x0F, 0xE0, 0x03, 0xC3, 0x00, 0x0F, 0xC0, 0x07,
  0x83, 0xFE, 0x0F, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0xE2, 0x00, 0x01, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x7F,
  0xFC, 0x00, 0x08, 0x01, 0xFF, 0xFC, 0x00, 0x20, 0x07, 0xFF, 0xFE, 0x00,
  0xC0, 0x38, 0x3F, 0xFF, 0xCF, 0x00, 0x40, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x00,
  0x3F, 0xE0, 0x78, 0x00, 0x1E, 0x04, 0x3F, 0x90, 0x0F, 0x01, 0xBF, 0xFE,
  0x07, 0x80, 0x3F, 0xFF, 0x03, 0xC0, 0x0C, 0xFF, 0x80, 0xF0, 0x0C, 0x07,
  0x80, 0x7C, 0x0E, 0x00, 0x40, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x1F, 0x87, 0xF8, 0x3E, 0x07, 0xE1, 0xFF, 0x1F, 0xC1, 0xF8,
  0x3F, 0xEF, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF, 0x9F, 0xC7,
  0xE0, 0x3F, 0xF1, 0xE1, 0xF8, 0x07, 0xFE, 0x30, 0x7F, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0xF8, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0x01, 0xFE,
  0x0E, 0x00, 0x00, 0x7F, 0xC6, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0xE3, 0xE0, 0x00, 0xFF,
  0xFC, 0x3C, 0x00, 0x0D, 0xFF, 0x07, 0x80, 0x01, 0x87, 0xE0, 0x70, 0x00,
  0x30, 0x3C, 0x06, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0xFC, 0x01, 0x06, 0x00, 0x1F, 0xE0,
  0x18, 0x60, 0x00, 0xFE, 0x03, 0xC6, 0x00, 0x0F, 0xF0, 0x7E, 0x60, 0x00,
  0xFF, 0x8F, 0xF3, 0x00, 0x07, 0xFD, 0xFF, 0x30, 0x00, 0x3F, 0xFF, 0xE1,
  0x80, 0x03, 0xFE, 0x3C, 0x0E, 0x03, 0x1F, 0xF1, 0x80, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x00,
  0x03, 0xFC, 0x00, 0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x01, 0xFE, 0x03, 0x80, 0x00, 0x3C, 0x0C, 0x3E, 0x00, 0x03, 0xC0, 0x23,
  0xF8, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x04, 0xFF, 0x80, 0x3E,
  0x00, 0xC3, 0xFE, 0x01, 0xE0, 0x0C, 0x0F, 0xF8, 0x1F, 0x01, 0xC0, 0x3F,
  0xE1, 0xF8, 0x1C, 0x00, 0x7E, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x7C, 0x1F,
  0x00, 0x0C, 0x07, 0xE0, 0xF8, 0x01, 0xC0, 0x3F, 0x07, 0xE0, 0x1C, 0x01,
  0xF8, 0x3F, 0x03, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0xF0, 0x7E, 0x0F, 0xF3,
  0xFF, 0xC3, 0xF0, 0x3F, 0xE1, 0xFF, 0x3F, 0x81, 0xFF, 0x03, 0xF9, 0xFC,
  0x07, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xE0, 0x7F, 0x3F, 0x80, 0x7F, 0x81,
  0xF9, 0xFC, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0x0F, 0xE0, 0x3F, 0x7F, 0x00,
  0x3F, 0x01, 0xF9, 0xFC, 0x01, 0xF8, 0x0F, 0xCF, 0xE0, 0x07, 0xC0, 0x7C,
  0x7F, 0x80, 0x3C, 0x03, 0xE1, 0xFC, 0x01, 0xC0, 0x1F, 0x07, 0xF0, 0x1C,
  0x00, 0xF0, 0x3F, 0x81, 0x80, 0x0F, 0x80, 0xFE, 0x18, 0x00, 0x78, 0x03,
  0xF8, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x70, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC7,
  0xFC, 0x00, 0x00, 0x20, 0x7F, 0xE0, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0x03,
  0x00, 0x7E, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x7F, 0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xEE, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x20, 0x0F, 0x80, 0x3F, 0x1F,
  0x01, 0xE0, 0x07, 0xE7, 0xF0, 0x1C, 0x00, 0xF9, 0xFF, 0x03, 0x00, 0x1F,
  0x7F, 0xF0, 0xC0, 0x03, 0xC0, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x00,
  0x1E, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x40,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x38, 0x00,
  0x7F, 0xFE, 0x1C, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x03, 0xFC, 0x0E, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x04, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0x70, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x01, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0x0F, 0xFE, 0x00, 0x07, 0x8F, 0xFF, 0x80, 0x03, 0xCC, 0x7F, 0xE0,
  0x01, 0xC0, 0x1F, 0xF8, 0x00, 0xC0, 0x07, 0xFE, 0x00, 0xC0, 0x01, 0xFF,
  0x80, 0xC0, 0x00, 0x3F, 0xFB, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0xF0, 0x01, 0xE0, 0x07, 0xFE,
  0x00, 0x70, 0x00, 0xFF, 0xFC, 0x38, 0x00, 0x1F, 0xFC, 0x0E, 0x00, 0x01,
  0xFE, 0x03, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x7C, 0x00, 0xC0,
  0x00, 0x1F, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x03, 0xF0, 0x00,
  0xC0, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x47, 0xF0,
  0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x03, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x3C, 0x1F, 0xF0, 0x00,
  0x0E, 0x1F, 0xFF, 0x00, 0x03, 0x8E, 0xFF, 0xE0, 0x01, 0xC2, 0x0F, 0xFC,
  0x00, 0x60, 0x01, 0xFF, 0x80, 0x38, 0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x07,
  0xFF, 0x0C, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x1E, 0x07,
  0xF8, 0x0E, 0x00, 0x7C, 0x3F, 0xFC, 0x0C, 0x00, 0xF8, 0xFF, 0xFC, 0x1C,
  0x03, 0xE1, 0xC7, 0xF8, 0x18, 0x07, 0xE6, 0x07, 0xF8, 0x38, 0x0F, 0xC8,
  0x07, 0xF0, 0x70, 0x1F, 0x90, 0x07, 0xF0, 0xE0, 0x3F, 0x20, 0x0F, 0xE1,
  0xC0, 0x7F, 0x40, 0x0F, 0xE3, 0x80, 0xFF, 0x80, 0x1F, 0xE7, 0x01, 0xFF,
  0x00, 0x1F, 0x0C, 0x01, 0xFE, 0x00, 0x1C, 0x38, 0x03, 0xFE, 0x00, 0x60,
  0x60, 0x03, 0xFE, 0x03, 0x81, 0x80, 0x07, 0xFC, 0x1F, 0x8E, 0x00, 0x07,
  0xFC, 0xFF, 0x90, 0x00, 0x07, 0xFB, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0xF0, 0x1E, 0x03,
  0xF8, 0x07, 0xF0, 0x1C, 0x03, 0xF8, 0x1F, 0xF0, 0x30, 0x07, 0xF0, 0x7F,
  0xF0, 0x40, 0x07, 0xF0, 0x0F, 0xF3, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x3F, 0x00, 0x03, 0xE7,
  0xF0, 0x00, 0x7C, 0xFE, 0x00, 0x0F, 0x9F, 0xE0, 0x01, 0xF3, 0xFC, 0x00,
  0x3C, 0x7F, 0xC0, 0x0F, 0x87, 0xF8, 0x01, 0xF0, 0xFF, 0x80, 0x7C, 0x0F,
  0xF3, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x18, 0x1F, 0xFC, 0x06, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x20, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0xFF, 0xF9, 0xDF,
  0xE0, 0x1F, 0xFF, 0xFB, 0x3F, 0xE4, 0x1F, 0xC0, 0xFC, 0xFF, 0xF8, 0x3F,
  0xE0, 0x7F, 0x03, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0xFC, 0x18, 0x00, 0x7F,
  0x80, 0xFE, 0x03, 0xF8, 0x40, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xE3, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x8C, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x7F,
  0x20, 0x00, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0xC0, 0x00, 0x1F, 0x80, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0x8C, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x18, 0x18, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0xC0, 0x60, 0x70,
  0x0F, 0xC0, 0x7C, 0x06, 0x00, 0xFF, 0xF0, 0x3F, 0x01, 0xF0, 0x38, 0x03,
  0xFF, 0xC0, 0x78, 0x07, 0xC1, 0xC0, 0x07, 0xFF, 0x01, 0xE0, 0x1F, 0x07,
  0x00, 0x07, 0xEC, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0x00, 0x10, 0x1E, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0x40, 0x78, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x1E, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x78, 0xFC, 0x00, 0x00,
  0x00, 0x38, 0x01, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x3F, 0x80, 0x01, 0xE0, 0x0C, 0x00, 0x60,
  0xFE, 0x00, 0x0F, 0xE0, 0x67, 0x83, 0x01, 0xFC, 0x00, 0xFF, 0xC3, 0x3F,
  0x88, 0x07, 0xF8, 0x47, 0xFF, 0x09, 0xFF, 0xE0, 0x0F, 0xFE, 0x31, 0xFF,
  0xEF, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF9, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0x8C, 0x1F,
  0xC0, 0x78, 0x3F, 0xF9, 0x01, 0xF8, 0x1C, 0x00, 0xFF, 0xE0, 0x3F, 0x83,
  0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x40, 0x00, 0xFF, 0x00, 0x7E, 0x18, 0x00,
  0x0F, 0xE0, 0x0F, 0xE3, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x60, 0x00, 0x1F,
  0xC0, 0x1F, 0xEC, 0x00, 0x01, 0xF8, 0x03, 0xF9, 0x80, 0x00, 0x3F, 0x00,
  0x3C, 0x10, 0x00, 0x03, 0xF0, 0x07, 0x03, 0x00, 0x00, 0x7E, 0x01, 0x80,
  0x70, 0xF8, 0x0F, 0xC0, 0x30, 0x07, 0xFF, 0x81, 0xF8, 0x0C, 0x00, 0x7F,
  0xF0, 0x1E, 0x03, 0x80, 0x07, 0xFE, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x40,
  0x78, 0x3C, 0x00, 0x00, 0x08, 0x0F, 0x07, 0x80, 0x00, 0x01, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x80, 0x00,
  0x00, 0x06, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xC0, 0x7F, 0x00, 0x0F, 0xF0,
  0x30, 0x0F, 0xF0, 0x03, 0xFF, 0x0C, 0x00, 0xFF, 0x18, 0xFF, 0xE1, 0x80,
  0x1F, 0xFE, 0x31, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x18, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0x07, 0xFF, 0x00, 0xC0, 0x00,
  0x3F, 0xF0, 0x1C, 0x00, 0x00, 0xFF, 0x83, 0xC0, 0x00, 0x07, 0xFC, 0x7C,
  0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0xC0, 0x00, 0x03, 0xE7, 0xFF, 0x80,
  0x00, 0x3E, 0x3F, 0xFC, 0x00, 0x01, 0xE3, 0xFF, 0xF0, 0x00, 0x1F, 0x0F,
  0xFF, 0x00, 0x01, 0xF0, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x00,
  0xE0, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x3C, 0x80, 0x00, 0x1C, 0x0F,
  0xF0, 0x00, 0x01, 0x81, 0xFF, 0x80, 0x00, 0x10, 0x7F, 0xFE, 0x00, 0x03,
  0x0C, 0xFF, 0xF0, 0x00, 0x60, 0x03, 0xFF, 0xC0, 0x0C, 0x00, 0x1F, 0xFF,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x40, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00,
  0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x87, 0xF8, 0x00, 0xF0,
  0x1F, 0xF3, 0xFF, 0x80, 0x1C, 0x00, 0xFF, 0xCF, 0xF0, 0x07, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x18, 0x00, 0x1F, 0xC1,
  0xFF, 0x83, 0x00, 0x03, 0xF8, 0x3F, 0xF8, 0x40, 0x00, 0x3F, 0x03, 0xFF,
  0x8C, 0x00, 0x07, 0xE0, 0x3F, 0xF9, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x30,
  0x00, 0x1F, 0x80, 0x1F, 0xF3, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x20, 0x00,
  0x7E, 0x00, 0x1F, 0xE7, 0x00, 0x8F, 0xC0, 0x01, 0xFC, 0x3C, 0x71, 0xF8,
  0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xC0,
  0x00, 0x30, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x1F, 0xFF,
  0x00, 0x06, 0x00, 0x07, 0xFF, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0xF0,
  0x00, 0x03, 0xFE, 0x01, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0xFF, 0xF0, 0x00, 0x07, 0x81, 0xFF, 0xF8, 0x00, 0x0F, 0x00,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0xE0,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x1E, 0x40,
  0x03, 0xCC, 0x00, 0xFF, 0x00, 0x1F, 0xD8, 0x07, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xC1, 0x67, 0xFF, 0x84, 0x3F, 0xC6, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xBF,
  0xC0, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x3C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x30, 0xFF, 0x00, 0xFF, 0xFF, 0xF9, 0x03, 0xFC, 0x07, 0x80, 0x7F,
  0xF8, 0x0F, 0xE0, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0x83, 0x80, 0x03, 0xFC,
  0x01, 0xFC, 0x18, 0x00, 0x0F, 0xE0, 0x0F, 0xE1, 0xC0, 0x00, 0x3F, 0x00,
  0x7F, 0xCC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x60, 0x00, 0x07, 0xE0, 0x07,
  0xC3, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xF8, 0x01, 0x80,
  0x60, 0x00, 0x07, 0xC0, 0x30, 0x03, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x60, 0x00, 0x0F, 0x8F, 0xE0, 0x01, 0xC0,
  0x30, 0x3C, 0xFF, 0x00, 0x07, 0xCF, 0x01, 0xEB, 0xFC, 0x00, 0x07, 0xC0,
  0x0F, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0x81, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0xE0, 0x00, 0x7C, 0x03, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x30, 0x01, 0xFC,
  0x00, 0xFF, 0x81, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x18, 0x00, 0x7F, 0xC8,
  0x4F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x06, 0x00, 0x1F,
  0xFF, 0xF9, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x3F, 0xFF, 0x00,
  0x38, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x07,
  0x00, 0x00, 0xFF, 0xF0, 0x70, 0x40, 0x3F, 0xFF, 0x87, 0x02, 0x0F, 0xFF,
  0xFC, 0xF0, 0x1F, 0xFF, 0xF0, 0xEF, 0x00, 0xFF, 0xFC, 0x02, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x03, 0x78, 0x01, 0xF0, 0x00, 0x17,
  0xC0, 0x00, 0x00, 0x01, 0x7E, 0x00, 0x00, 0x00, 0x17, 0xE0, 0x00, 0x00,
  0x03, 0x7F, 0x00, 0x00, 0x00, 0x33, 0xFC, 0x00, 0x00, 0x06, 0x3F, 0xE0,
  0x00, 0x00, 0xE1, 0xFF, 0x80, 0x00, 0x3C, 0x0F, 0xFE, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1E, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0x70, 0x00,
  0x3F, 0xFC, 0x16, 0x00, 0x02, 0xFF, 0xFF, 0x40, 0x00, 0xC3, 0xFF, 0xCC,
  0x00, 0x1C, 0x1F, 0xF8, 0xC0, 0x03, 0x80, 0x7F, 0x0C, 0x00, 0x7C, 0x03,
  0xE0, 0xC0, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x0F,
  0xF8, 0x00, 0x06, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x07, 0xFE, 0x00, 0x01,
  0x80, 0xBF, 0xF0, 0x00, 0x07, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xC0,
  0x1F, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x03,
  0xFF, 0x80, 0xE0, 0x00, 0x7F, 0xFE, 0x1C, 0x00, 0x04, 0x7F, 0xF3, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x18, 0x00, 0x1F, 0xFE, 0x07, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x3C, 0x10,
  0x00, 0xF0, 0x1E, 0x06, 0x00, 0xF8, 0x0F, 0x00, 0x80, 0xFC, 0x03, 0xC0,
  0x20, 0xFF, 0x01, 0xF0, 0x10, 0x7F, 0xC0, 0x7C, 0x0C, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x7F, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x1F, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00,
  0x60, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0xDF,
  0xC2, 0x0F, 0xFC, 0xE7, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x67, 0xF8, 0x01, 0xFF, 0xFF, 0x88,
  0x3F, 0x80, 0x7F, 0x3F, 0xFA, 0x07, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0x7F,
  0x03, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x60, 0x00, 0xFF, 0x00, 0xFE, 0x1C,
  0x00, 0x0F, 0xE0, 0x1F, 0xF3, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x60, 0x00,
  0x1F, 0x80, 0x1C, 0x0C, 0x00, 0x01, 0xF0, 0x01, 0x01, 0x80, 0x00, 0x3E,
  0x00, 0xE0, 0x10, 0x00, 0x07, 0xC0, 0x18, 0x03, 0x00, 0x00, 0xF8, 0x07,
  0x00, 0x60, 0x00, 0x1F, 0x01, 0xF0, 0x06, 0x00, 0x43, 0xC0, 0x3E, 0x00,
  0x60, 0x10, 0x78, 0x0F, 0xE0, 0x07, 0xFC, 0x0E, 0x00, 0xFF, 0x00, 0x1E,
  0x01, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x07,
  0xFF, 0xF8, 0x00, 0x0E, 0x01, 0x83, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0xFE,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xFB, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x3E, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0x39,
  0x8F, 0xF8, 0x01, 0xFF, 0xFF, 0xB0, 0x70, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0x80, 0x7F, 0x00, 0xF8, 0x0F, 0xF8, 0x18, 0x03, 0xFC, 0x0F, 0x00,
  0x3F, 0xC1, 0xC0, 0x0F, 0xE0, 0x70, 0x00, 0xFF, 0x0E, 0x00, 0x7F, 0x87,
  0x00, 0x03, 0xF8, 0xF0, 0x01, 0xFC, 0x38, 0x00, 0x0F, 0xC7, 0x80, 0x0F,
  0xF1, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xCC, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0xF0, 0x60, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0x01, 0x00, 0x00, 0x7C,
  0x7F, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xE3, 0xF8, 0x03, 0x80, 0x60, 0x00,
  0x1F, 0x1F, 0xE0, 0x3C, 0x01, 0x80, 0x00, 0xF0, 0x7F, 0x83, 0xF0, 0x06,
  0x00, 0x87, 0x83, 0xFC, 0x1F, 0xC0, 0x1C, 0x38, 0x38, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x01, 0xC0, 0x3F, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x01, 0xFC,
  0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x07, 0xE0, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x3E, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0x04,
  0x00, 0x07, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0xFC, 0x01,
  0xFF, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x0F,
  0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x70, 0x30, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x18, 0x00, 0x07, 0xFE, 0x0F,
  0xFF, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xCF, 0xFE, 0x18, 0x00, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x1F, 0xFE, 0x01,
  0xF9, 0x07, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0x1F, 0x01, 0xFC, 0x7F, 0xE3, 0xC0, 0x1F, 0xC8, 0x78, 0x70,
  0x01, 0xFA, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x01, 0x80, 0x03, 0xF8, 0x00,
  0x30, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x18, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xF0, 0x30, 0x00,
  0xFF, 0xFC, 0x03, 0x82, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x5F, 0x80, 0x00, 0x00, 0x0B, 0xF8, 0x00, 0x03, 0x02, 0x7F, 0x00, 0x01,
  0xF0, 0x47, 0xF0, 0x00, 0x7F, 0x98, 0xFF, 0xCC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x11, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0xF8,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x19, 0xFF, 0x01, 0xFF, 0xFF, 0xD8, 0x3F,
  0x81, 0xFC, 0xFF, 0xE8, 0x0F, 0xE1, 0xE0, 0x0F, 0xFC, 0x07, 0xF0, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x70, 0x00, 0x3F,
  0x80, 0x7F, 0x30, 0x00, 0x0F, 0xC0, 0x3F, 0xD8, 0x00, 0x07, 0xE0, 0x0F,
  0xFC, 0x00, 0x01, 0xF0, 0x03, 0xF6, 0x00, 0x00, 0xF8, 0x00, 0xE1, 0x00,
  0x00, 0x7C, 0x00, 0xC0, 0xC0, 0x00, 0x3E, 0x00, 0xE0, 0x60, 0x00, 0x1F,
  0x01, 0xE0, 0x18, 0x01, 0x0F, 0x01, 0xF0, 0x06, 0x01, 0x07, 0x80, 0xFC,
  0x00, 0xFF, 0x03, 0xC0, 0xFE, 0x00, 0x0C, 0x01, 0xC0, 0x7F, 0x00, 0x00,
  0x01, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x60,
  0x07, 0xF8, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x1F, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x01, 0x03, 0xF8, 0x00, 0x3F, 0xC1,
  0x81, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x00, 0x13, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xE0,
  0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x1F, 0xF0, 0x07, 0x80, 0x07, 0xF8, 0x07, 0x00, 0x03, 0xF8, 0x06, 0x00,
  0x01, 0xF8, 0x06, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00, 0xF8, 0x06, 0x00,
  0x00, 0xF8, 0x06, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00, 0xF0, 0x03, 0x00,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xC0,
  0x00, 0x1E, 0x3F, 0xE0, 0x00, 0x1E, 0x7F, 0xF0, 0x00, 0x1C, 0xDF, 0xF8,
  0x00, 0x1C, 0x07, 0xFC, 0x00, 0x38, 0x03, 0xFE, 0x00, 0x30, 0x01, 0xFF,
  0x00, 0x60, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0xFF, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1E,
  0x0F, 0x07, 0x00, 0xF1, 0xC0, 0x07, 0x70, 0x00, 0x6C, 0x00, 0x07, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0xF8, 0xF8, 0x7C, 0x3C, 0x1C, 0x1E, 0x0E, 0x06, 0x03,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x00, 0x09, 0xFF, 0x00, 0xE3, 0xFE, 0x07, 0x03, 0xF0, 0x3C, 0x07,
  0xC0, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x81, 0xF0, 0x7F, 0x07, 0xC0, 0xFE, 0x3F,
  0x23, 0xFF, 0x7F, 0x87, 0xF9, 0xFC, 0x0F, 0xC3, 0xE0, 0x1C, 0x07, 0x80,
  0x20, 0x04, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0xE0, 0x00, 0x8E,
  0x00, 0x02, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x08, 0x07, 0xC0, 0xC0, 0x3E, 0x0E, 0x01, 0xF1,
  0xF8, 0x0F, 0x9F, 0xE0, 0x7F, 0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xF0,
  0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x87,
  0xC0, 0x78, 0x3E, 0x03, 0x81, 0xF8, 0x18, 0x1F, 0xE1, 0x81, 0xFF, 0xC8,
  0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8, 0x06,
  0xFC, 0x0C, 0x7C, 0x1C, 0x7E, 0x38, 0x3E, 0x38, 0x3F, 0x78, 0x18, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xF3, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0x80, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x06, 0x3F, 0xC3, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xE3,
  0xE0, 0x0F, 0x1F, 0x00, 0x70, 0xF8, 0x03, 0x87, 0xC0, 0x1C, 0x3E, 0x00,
  0xC1, 0xF8, 0x0E, 0x1F, 0xF0, 0x61, 0xFF, 0xE6, 0x00, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0xF8, 0x03, 0xF8, 0x06, 0xFC, 0x0C, 0x7C, 0x1C, 0x7E, 0x38, 0x3E,
  0x38, 0x3E, 0x78, 0x3F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x30, 0xF9, 0xC0,
  0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x0F, 0xFC, 0x07, 0xF0,
  0x03, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x84, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC1, 0x1F, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xF0, 0x03, 0xFF, 0x9F, 0xFF, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x19, 0xFF, 0xC0, 0xE1, 0xFF,
  0x07, 0x03, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x1C, 0x1E,
  0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x81, 0xF8,
  0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xFE, 0xFC, 0x0F,
  0xC1, 0xF0, 0x3C, 0x07, 0xC0, 0x40, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC1, 0x80, 0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0x80,
  0xF8, 0x0C, 0x01, 0xF0, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x20, 0x70, 0x00, 0x8F, 0x00, 0x04, 0xF8, 0x00,
  0x17, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x80, 0x3E, 0x0C, 0x01, 0xF1, 0xF0, 0x0F, 0xBF, 0xC0,
  0x7F, 0xFF, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0,
  0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xE3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x87, 0xE2, 0x3C, 0x7F,
  0xE1, 0xC1, 0xFE, 0x1C, 0x03, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x20, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x87, 0xFC, 0xDF, 0x89, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xB1, 0xFE, 0x0F, 0xC0,
  0x7C, 0x03, 0x80, 0x18, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFF, 0x02, 0xFF, 0x09, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xC8, 0x07, 0x18, 0x1C,
  0x10, 0x70, 0x17, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1C, 0x30, 0xE0,
  0x47, 0x84, 0xBE, 0x33, 0xF3, 0xC7, 0xCF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x87,
  0xF6, 0x7F, 0xF0, 0x3F, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x80, 0x00, 0x04,
  0x01, 0xE8, 0x1C, 0x30, 0xE0, 0x47, 0x80, 0xBE, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x8F, 0xF4, 0x7F, 0xF0, 0x3F, 0x80, 0x3C, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x30, 0x01,
  0xE0, 0x7C, 0x1E, 0x00, 0xFC, 0x3F, 0x8F, 0xC0, 0x3F, 0x9F, 0xE7, 0xFC,
  0x1F, 0xE9, 0xFF, 0x7F, 0xC9, 0xFC, 0x3F, 0x0F, 0xE0, 0x3E, 0x0F, 0xC1,
  0xF0, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x1F,
  0x07, 0xC0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F,
  0x81, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x07, 0xC0,
  0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x7C, 0x07, 0xF0, 0xFC, 0x1F,
  0x01, 0xFC, 0x7F, 0x87, 0xEC, 0xFF, 0x9F, 0xE0, 0xFE, 0x0F, 0x83, 0xF0,
  0x3F, 0x01, 0xC0, 0x78, 0x07, 0xC0, 0x70, 0x0C, 0x00, 0xE0, 0x08, 0x01,
  0x00, 0x18, 0x10, 0x02, 0x00, 0x1C, 0x03, 0x00, 0x3E, 0x07, 0x80, 0x3F,
  0x0F, 0xC0, 0x7F, 0xBF, 0xF8, 0x5F, 0xE7, 0xFC, 0x8F, 0xC3, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0xC1, 0xFA, 0x3F, 0xE1, 0xFE, 0x0F,
  0x80, 0xFC, 0x07, 0x00, 0xFC, 0x07, 0x00, 0x78, 0x02, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x01, 0xF7, 0xF0, 0x3E, 0x3F, 0x03,
  0xE3, 0xF8, 0x3E, 0x1F, 0xC3, 0xE1, 0xFC, 0x3E, 0x0F, 0xE3, 0xE0, 0x7E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xC7, 0xF0,
  0x38, 0xFF, 0xC3, 0x07, 0xFE, 0x60, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x01,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x81, 0xFC, 0x0E, 0x07,
  0xF0, 0x78, 0x1F, 0xE7, 0xF0, 0x3F, 0xBF, 0xE0, 0x7F, 0x1F, 0xC0, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE3, 0xF8, 0x07, 0x1F, 0xF0,
  0x38, 0xFF, 0xE0, 0xC3, 0xFF, 0xE6, 0x08, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x07, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x67, 0xFC,
  0x0C, 0x3F, 0xF1, 0xC1, 0xFC, 0x38, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07,
  0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80,
  0x78, 0xF8, 0x07, 0x8F, 0xC0, 0x7C, 0xFC, 0x07, 0xC7, 0xE0, 0x7C, 0x7E,
  0x07, 0xC3, 0xF8, 0xFC, 0x3F, 0xF7, 0xC1, 0xFC, 0x7C, 0x0F, 0x87, 0xC0,
  0x70, 0x7C, 0x04, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x18, 0x04, 0x0E, 0x06, 0x0F, 0x87, 0x8F, 0xE7, 0xC7,
  0xFB, 0xF4, 0xFF, 0xF8, 0x3E, 0x7C, 0x1F, 0x1C, 0x0F, 0x8C, 0x07, 0xC4,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x30, 0x08, 0x0F, 0x01, 0x07, 0xF8, 0x61, 0xFF,
  0xFC, 0x47, 0xFF, 0x18, 0x3F, 0xC6, 0x01, 0xF0, 0xC0, 0x0C, 0x3C, 0x01,
  0x07, 0xC0, 0x60, 0xFC, 0x3E, 0x0F, 0xCF, 0xE1, 0xFF, 0xFE, 0x1F, 0xDF,
  0xE1, 0xF0, 0xFC, 0x1C, 0x0F, 0x83, 0x00, 0xF0, 0x40, 0x1E, 0x1C, 0x01,
  0x87, 0xE0, 0x21, 0xFF, 0x08, 0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80,
  0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE2, 0x1F, 0xD8, 0xFF,
  0xC0, 0xFE, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x80, 0x18,
  0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x3E, 0x01, 0xE0, 0x3F, 0x03, 0xF8, 0x7F,
  0x87, 0xFC, 0x9F, 0x83, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xF0, 0x1F, 0xE7, 0xFA, 0x3F, 0xF9, 0xFC, 0x07, 0xF0, 0xFC, 0x01,
  0xE0, 0xF8, 0x00, 0xC0, 0x38, 0x00, 0x80, 0x10, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x02, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x3C, 0x0F, 0x81,
  0xFC, 0x1F, 0x87, 0xF8, 0x3F, 0xBB, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x1F, 0x81, 0xE0, 0x1F, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0C, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x60, 0x0E, 0x00,
  0xE0, 0x1C, 0x03, 0xF0, 0x70, 0x07, 0xF8, 0x80, 0x1F, 0xFA, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x03, 0xF0, 0x1C, 0x01, 0x81,
  0xFC, 0x0F, 0x81, 0xE0, 0xFF, 0x1F, 0xE3, 0xF8, 0x3F, 0x9F, 0xF7, 0xFC,
  0x0F, 0xD9, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0x1F, 0xC1, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xC0,
  0x3E, 0x1F, 0x03, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0xF8,
  0x07, 0xC3, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x1F,
  0x00, 0xF0, 0x7C, 0x0F, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0x70, 0x1F, 0x03,
  0xF0, 0x30, 0x0F, 0xC3, 0xFE, 0x30, 0x0F, 0xE3, 0xFF, 0xD0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x03, 0x80, 0xC0,
  0xF8, 0x70, 0x7E, 0x3E, 0x1F, 0xCF, 0x8F, 0xFF, 0xF4, 0x7E, 0xFC, 0x1F,
  0x1E, 0x07, 0xC7, 0x01, 0xF0, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFD, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1C, 0xF8, 0x06, 0x0E, 0x01, 0x01, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x0E, 0x06, 0x07, 0xC0,
  0xE7, 0xF0, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x04, 0x0F, 0xF0, 0x38, 0x1F, 0xC3, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0xBF,
  0x81, 0xF8, 0x7F, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC1, 0xF9, 0x8F, 0x0F,
  0xFC, 0x38, 0x1F, 0xE1, 0xC0, 0x1F, 0x07, 0x00, 0x38, 0x38, 0x00, 0x40,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x06, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0xE1,
  0xE2, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x4F,
  0xE1, 0x8F, 0xC6, 0x0F, 0x8C, 0x1F, 0xB0, 0x3F, 0x60, 0x3E, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0x98, 0x0E, 0x30, 0x1C, 0x60,
  0x30, 0x40, 0xC0, 0x41, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x01, 0xF0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x7C, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 38, 12, 1, -37 },
  { 49, 18, 14, 21, 1, -36 },
  { 81, 22, 30, 26, 2, -33 },
  { 164, 17, 41, 21, 2, -39 },
  { 252, 34, 36, 36, 1, -36 },
  { 405, 26, 32, 29, 2, -31 },
  { 509, 8, 14, 10, 1, -36 },
  { 523, 11, 41, 13, 1, -40 },
  { 580, 11, 41, 13, 1, -40 },
  { 637, 17, 20, 18, 0, -38 },
  { 680, 17, 18, 20, 2, -26 },
  { 719, 8, 14, 9, 0, -8 },
  { 733, 14, 10, 15, 1, -20 },
  { 751, 8, 9, 10, 1, -8 },
  { 760, 25, 40, 27, 1, -38 },
  { 885, 22, 36, 24, 1, -36 },
  { 984, 15, 35, 16, 1, -35 },
  { 1050, 21, 35, 23, 1, -35 },
  { 1142, 22, 35, 24, 1, -35 },
  { 1239, 23, 35, 23, 0, -35 },
  { 1340, 22, 36, 24, 1, -36 },
  { 1439, 21, 36, 23, 1, -36 },
  { 1534, 20, 35, 22, 1, -35 },
  { 1622, 22, 36, 24, 1, -36 },
  { 1721, 21, 36, 23, 1, -36 },
  { 1816, 8, 25, 10, 1, -24 },
  { 1841, 9, 30, 9, 0, -24 },
  { 1875, 14, 19, 15, 0, -24 },
  { 1909, 18, 11, 20, 1, -21 },
  { 1934, 14, 19, 15, 0, -24 },
  { 1968, 19, 37, 23, 2, -36 },
  { 2056, 30, 31, 31, 1, -24 },
  { 2173, 39, 37, 42, 1, -36 },
  { 2354, 44, 38, 46, 0, -37 },
  { 2563, 33, 38, 35, 1, -37 },
  { 2720, 39, 39, 41, 1, -37 },
  { 2911, 34, 38, 36, 1, -37 },
  { 3073, 36, 44, 39, 1, -38 },
  { 3271, 37, 38, 39, 1, -37 },
  { 3447, 35, 47, 37, 1, -40 },
  { 3653, 33, 44, 35, 1, -37 },
  { 3835, 34, 50, 36, 1, -37 },
  { 4048, 39, 37, 41, 1, -36 },
  { 4229, 27, 37, 29, 1, -36 },
  { 4354, 54, 39, 56, 1, -36 },
  { 4618, 43, 37, 45, 1, -36 },
  { 4817, 36, 38, 38, 1, -37 },
  { 4988, 43, 45, 45, 1, -36 },
  { 5230, 39, 41, 41, 1, -37 },
  { 5430, 45, 38, 47, 1, -37 },
  { 5644, 36, 38, 39, 1, -37 },
  { 5815, 36, 36, 38, 1, -36 },
  { 5977, 34, 39, 36, 1, -36 },
  { 6143, 43, 38, 45, 1, -37 },
  { 6348, 53, 38, 55, 1, -37 },
  { 6600, 35, 38, 37, 1, -37 },
  { 6767, 41, 45, 44, 1, -37 },
  { 6998, 32, 44, 34, 1, -37 },
  { 7174, 7, 40, 9, 1, -38 },
  { 7209, 32, 35, 5, -10, -33 },
  { 7349, 7, 40, 9, 1, -38 },
  { 7384, 19, 14, 21, 1, -36 },
  { 7418, 24, 4, 23, 0, 6 },
  { 7430, 8, 10, 26, 8, -36 },
  { 7440, 22, 27, 23, 1, -26 },
  { 7515, 21, 37, 23, 1, -35 },
  { 7613, 16, 27, 18, 1, -26 },
  { 7667, 21, 36, 23, 1, -35 },
  { 7762, 16, 27, 18, 1, -26 },
  { 7816, 15, 45, 12, 0, -37 },
  { 7901, 22, 37, 24, 1, -26 },
  { 8003, 21, 45, 23, 1, -36 },
  { 8122, 12, 36, 14, 1, -35 },
  { 8176, 15, 45, 12, -3, -36 },
  { 8261, 14, 37, 17, 1, -36 },
  { 8326, 14, 37, 14, 1, -36 },
  { 8391, 34, 28, 36, 1, -27 },
  { 8510, 24, 27, 26, 1, -26 },
  { 8591, 20, 27, 21, 0, -26 },
  { 8659, 22, 40, 23, 0, -30 },
  { 8769, 20, 36, 22, 1, -26 },
  { 8859, 17, 27, 19, 1, -26 },
  { 8917, 19, 33, 21, 1, -32 },
  { 8996, 14, 34, 16, 1, -33 },
  { 9056, 24, 28, 26, 1, -27 },
  { 9140, 23, 30, 23, -1, -29 },
  { 9227, 33, 31, 35, 1, -30 },
  { 9355, 18, 38, 20, 1, -27 },
  { 9441, 22, 40, 24, 1, -31 },
  { 9551, 15, 36, 17, 1, -27 },
  { 9619, 14, 41, 17, 1, -40 },
  { 9691, 4, 42, 8, 2, -40 },
  { 9712, 14, 41, 17, 1, -40 },
  { 9784, 17, 4, 19, 1, -17 },
};

const GFXfont UnifrakturMaguntia_Regular51pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular51pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular51pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR51PT7B_H_
