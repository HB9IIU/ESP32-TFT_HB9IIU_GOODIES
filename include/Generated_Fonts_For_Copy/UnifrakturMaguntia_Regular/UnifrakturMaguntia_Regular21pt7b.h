#ifndef _UNIFRAKTURMAGUNTIA_REGULAR21PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0x27, 0x77, 0x22, 0x22, 0x22, 0x00, 0x27, 0x20, 0x24, 0x76, 0x33,
  0x22, 0x22, 0x44, 0x13, 0x19, 0x3F, 0xFF, 0xF3, 0x21, 0xB0, 0x99, 0xFF,
  0xFF, 0x93, 0x19, 0x0C, 0x80, 0x10, 0x20, 0xE2, 0x2C, 0x78, 0xF9, 0x38,
  0x7C, 0x3E, 0x3C, 0x38, 0x70, 0x9E, 0x08, 0x10, 0x70, 0x0E, 0xC0, 0xB6,
  0x05, 0xB0, 0x4D, 0x84, 0x6C, 0x43, 0x64, 0x0E, 0x4E, 0x04, 0xD8, 0x26,
  0xC2, 0x76, 0x23, 0xB2, 0x0D, 0xA0, 0x6E, 0x01, 0xC0, 0x1C, 0x0C, 0x83,
  0x20, 0xC8, 0x34, 0x0E, 0x77, 0xCB, 0x72, 0xCF, 0x33, 0xCC, 0x77, 0x9F,
  0x7B, 0x80, 0x46, 0xB2, 0x24, 0x08, 0x88, 0xC6, 0x33, 0x9C, 0xE7, 0x39,
  0xC6, 0x31, 0x84, 0x10, 0x40, 0x61, 0x0C, 0x21, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x18, 0x84, 0xC0, 0x10, 0x73, 0x5B, 0xEF, 0xFA, 0xCE, 0x08, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x08, 0x5C, 0x94, 0x80, 0x7C, 0x0D, 0xE0,
  0x4F, 0x40, 0x00, 0x80, 0x30, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00,
  0x1E, 0x0C, 0xC3, 0x31, 0x8E, 0x61, 0xB8, 0x6E, 0x1F, 0x87, 0xE1, 0xF8,
  0x66, 0x19, 0x86, 0x33, 0x0C, 0xC1, 0xE0, 0x18, 0x63, 0xBE, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x39, 0xF0, 0x1E, 0x1F, 0x91, 0xE8, 0x78, 0x38,
  0x1C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x24, 0x17, 0xFF, 0xFC, 0x1E, 0x33,
  0xA0, 0xE0, 0x70, 0x30, 0x30, 0x7C, 0x07, 0x01, 0x80, 0xF8, 0x6C, 0x36,
  0x31, 0xF0, 0x06, 0x03, 0x07, 0x82, 0xC2, 0x61, 0x31, 0x19, 0x0C, 0xFF,
  0xFF, 0xC1, 0x80, 0xC0, 0x60, 0xFC, 0x21, 0x1F, 0x8F, 0x88, 0x04, 0x01,
  0xF1, 0xFC, 0xC7, 0x01, 0x80, 0xC0, 0x7C, 0x36, 0x1B, 0x18, 0xF8, 0x1E,
  0x19, 0x8C, 0xEC, 0x76, 0x03, 0x01, 0xFC, 0xE7, 0x61, 0xB0, 0xD8, 0x6C,
  0x36, 0x11, 0x98, 0x78, 0x7F, 0xBF, 0xA0, 0x50, 0x20, 0x20, 0x10, 0x18,
  0x08, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x83, 0x80, 0x1E, 0x10, 0x98, 0x6C,
  0x36, 0x13, 0xC8, 0xF8, 0x5E, 0x43, 0xA0, 0xF0, 0x78, 0x34, 0x1B, 0x08,
  0xF8, 0x1E, 0x11, 0x98, 0xCC, 0x7E, 0x3F, 0x1F, 0x8E, 0xC7, 0x37, 0x85,
  0xC0, 0xEC, 0x66, 0x33, 0x10, 0xF0, 0x46, 0xF0, 0x00, 0x04, 0xF4, 0x46,
  0xF0, 0x00, 0x04, 0xE2, 0x24, 0x40, 0x0C, 0x63, 0x18, 0xE0, 0xC1, 0x83,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0x83, 0x06, 0x1C, 0xC6, 0x20, 0x7C,
  0xC6, 0x87, 0xC3, 0xC6, 0x1E, 0x38, 0x60, 0x44, 0x64, 0x38, 0x00, 0x10,
  0x3C, 0x10, 0x0F, 0x80, 0xC3, 0x08, 0x08, 0xC7, 0xA4, 0xD9, 0x66, 0xCB,
  0x66, 0x5B, 0x34, 0x5B, 0x62, 0xEE, 0xD8, 0x0C, 0x60, 0xC0, 0xF8, 0x00,
  0x1F, 0x01, 0x1F, 0xC3, 0x10, 0xF7, 0x90, 0x39, 0xC8, 0x0C, 0xE2, 0x06,
  0x71, 0xC3, 0x38, 0x71, 0x1C, 0x09, 0x8E, 0x04, 0x87, 0x00, 0x83, 0x81,
  0xC1, 0xC1, 0xF1, 0xE0, 0x3F, 0x7C, 0x0F, 0x18, 0x1F, 0x1E, 0x0F, 0xE9,
  0xC6, 0x1C, 0x73, 0x07, 0x0E, 0x80, 0xC3, 0xE0, 0x30, 0x84, 0x0C, 0xF1,
  0x9B, 0x7E, 0x18, 0x81, 0xC0, 0x40, 0x30, 0x20, 0x0C, 0x3E, 0x03, 0x13,
  0xC0, 0x80, 0x78, 0x40, 0x0F, 0xE0, 0x1E, 0x63, 0x0F, 0xD8, 0x89, 0x88,
  0x0C, 0xC0, 0x67, 0x03, 0x3C, 0x1C, 0xF0, 0xE3, 0xC7, 0x0E, 0x3C, 0x30,
  0xE3, 0x03, 0xE0, 0x0F, 0x8C, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x0E,
  0x1F, 0x0C, 0x23, 0xC4, 0x30, 0x74, 0x38, 0x1A, 0x0E, 0x0D, 0x07, 0x82,
  0x41, 0xC1, 0x1E, 0x60, 0x80, 0x30, 0x40, 0xE0, 0x41, 0xF8, 0x21, 0x3F,
  0x20, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x63, 0x0F, 0xD8, 0x89, 0x88, 0x0C,
  0xC0, 0x67, 0x33, 0x3F, 0xF8, 0xF2, 0xE3, 0xC7, 0x0E, 0x3C, 0x30, 0xE3,
  0x03, 0xE0, 0x0F, 0x8C, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0xF0, 0xC1, 0xFA,
  0x04, 0xC4, 0x08, 0x10, 0x30, 0x10, 0x71, 0xA0, 0xF7, 0x20, 0xF6, 0x3C,
  0xE0, 0x81, 0xE0, 0xC1, 0xC1, 0xC3, 0x83, 0x83, 0x06, 0x0C, 0x0C, 0x18,
  0x0C, 0x60, 0x0F, 0x00, 0x1E, 0x20, 0x63, 0xE1, 0x84, 0xE3, 0x30, 0xEC,
  0xC1, 0x19, 0xC6, 0x33, 0xFE, 0x63, 0x8E, 0xE3, 0x8D, 0xC3, 0x1F, 0x86,
  0x33, 0x88, 0x67, 0x20, 0xC7, 0x03, 0x03, 0x88, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x17, 0x00, 0x47, 0x81, 0x80, 0x03, 0x02, 0x06, 0x1E, 0x0E,
  0x7C, 0x0F, 0x1C, 0x1E, 0x3C, 0x1C, 0x38, 0x1C, 0x72, 0x10, 0xEE, 0x21,
  0xAF, 0x83, 0x0E, 0x04, 0x00, 0x10, 0x00, 0x40, 0x07, 0x00, 0x0F, 0x80,
  0x7F, 0x03, 0x1E, 0x18, 0x3E, 0x40, 0x11, 0x00, 0x86, 0x06, 0x08, 0x18,
  0x19, 0x70, 0x19, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0xE0, 0x67, 0xC0,
  0xA7, 0x84, 0x0F, 0xA0, 0x0F, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0x1E, 0x18,
  0x3E, 0x40, 0x11, 0x00, 0x84, 0x06, 0x08, 0x18, 0x11, 0x70, 0x39, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x38, 0x0B,
  0xF8, 0x20, 0xF1, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x01, 0x82, 0x03,
  0x18, 0x81, 0xBF, 0x21, 0xE3, 0x90, 0xF0, 0xE8, 0x78, 0x7C, 0x1C, 0x12,
  0x0F, 0x32, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x33, 0x87, 0x11, 0xC5, 0xD0,
  0x7C, 0x70, 0x18, 0x07, 0x81, 0x84, 0x30, 0x67, 0x06, 0x70, 0x67, 0x86,
  0x38, 0x63, 0xB8, 0x1C, 0x00, 0x80, 0x10, 0x03, 0x80, 0x7E, 0x39, 0xFE,
  0x07, 0xC0, 0x1C, 0x30, 0xC1, 0xFD, 0xF7, 0xCC, 0xF9, 0xE7, 0x20, 0xE3,
  0x8C, 0x81, 0xCE, 0x3A, 0x07, 0x18, 0xF8, 0x0C, 0x62, 0x3E, 0x31, 0x88,
  0x78, 0xC6, 0x40, 0x22, 0x1B, 0x00, 0x08, 0x4C, 0x00, 0x21, 0x38, 0x79,
  0x68, 0xE2, 0xFB, 0xE1, 0xF1, 0xF7, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x1C,
  0x3F, 0x9F, 0x33, 0xF1, 0x90, 0x70, 0xE8, 0x1C, 0x74, 0x0E, 0x1E, 0x03,
  0x11, 0xF1, 0x88, 0x38, 0xCC, 0x04, 0x6E, 0x00, 0x27, 0x00, 0x13, 0x87,
  0x90, 0xE5, 0xF0, 0x7C, 0x70, 0x18, 0x01, 0x80, 0x07, 0xC0, 0x3F, 0xE1,
  0x83, 0xE6, 0x01, 0xCC, 0x01, 0xDE, 0x01, 0xBF, 0x03, 0x3E, 0x06, 0x0C,
  0x0C, 0x10, 0x19, 0xC0, 0x27, 0xE0, 0x83, 0xF2, 0x01, 0xF8, 0x00, 0x0E,
  0x04, 0x0F, 0xC3, 0x06, 0x3B, 0xC2, 0x07, 0x78, 0x81, 0xCF, 0x20, 0x71,
  0xE8, 0x1C, 0x3D, 0x93, 0x07, 0x18, 0xC0, 0xC0, 0x30, 0x10, 0x0C, 0x04,
  0x07, 0x02, 0x03, 0xE1, 0x03, 0x3F, 0xC0, 0x0F, 0xC0, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x0F, 0xF8,
  0x30, 0x7C, 0x60, 0x1C, 0x60, 0x0E, 0x78, 0x06, 0x7E, 0x06, 0x3E, 0x06,
  0x06, 0x06, 0x04, 0x04, 0x38, 0x3C, 0x7E, 0x7D, 0x1F, 0x9F, 0x07, 0xEE,
  0x00, 0x00, 0x0E, 0x06, 0x07, 0xF3, 0xE1, 0xDF, 0x8E, 0x20, 0xF1, 0xC8,
  0x0E, 0x1D, 0x00, 0xC1, 0x20, 0x18, 0xC2, 0x03, 0x30, 0x32, 0x6F, 0x01,
  0x8C, 0xE0, 0x01, 0x9C, 0x00, 0x21, 0xC1, 0xC8, 0x38, 0xFD, 0x07, 0xC3,
  0xC0, 0x60, 0x03, 0x00, 0x3F, 0x93, 0x1F, 0x90, 0x18, 0x40, 0x02, 0x01,
  0x89, 0x1F, 0xA3, 0xF9, 0x87, 0x87, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0x7E,
  0x38, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0x80, 0x7F, 0xC1, 0x87, 0xC2, 0x0B,
  0xF8, 0x33, 0xD0, 0x60, 0x21, 0xE0, 0x23, 0xE0, 0x38, 0xE0, 0x11, 0xC0,
  0xF1, 0x06, 0xF4, 0x00, 0xF0, 0x00, 0xF9, 0x80, 0x7C, 0x00, 0x0C, 0x04,
  0x48, 0x23, 0x27, 0x9C, 0x0C, 0x78, 0x30, 0xF0, 0xC1, 0xC3, 0x03, 0x8C,
  0x0C, 0x30, 0x20, 0xC1, 0x03, 0x0E, 0x0C, 0x7C, 0x7A, 0x7E, 0xF0, 0xF1,
  0x80, 0x00, 0x1F, 0x1E, 0x0F, 0xE9, 0xC6, 0x3C, 0x71, 0x07, 0x0E, 0x80,
  0xC3, 0x20, 0x30, 0x84, 0x0C, 0x60, 0x9B, 0x1C, 0x18, 0x87, 0x80, 0x40,
  0xF0, 0x70, 0x1C, 0x7E, 0x06, 0x23, 0xC1, 0x00, 0x7C, 0x80, 0x0F, 0xC0,
  0x1E, 0x31, 0xC0, 0xFF, 0x3B, 0xC6, 0x3C, 0x87, 0x10, 0x72, 0x0E, 0x80,
  0xDC, 0x3A, 0x03, 0x70, 0x44, 0x0C, 0xE2, 0x09, 0xB3, 0x9C, 0x18, 0x86,
  0x78, 0x04, 0x18, 0xF0, 0x60, 0x21, 0xC7, 0xC1, 0x83, 0x67, 0x87, 0x08,
  0x0F, 0xFE, 0x40, 0x1E, 0x3E, 0x00, 0x1E, 0x1A, 0x7E, 0x79, 0x8E, 0xF2,
  0x0E, 0x08, 0x1C, 0x08, 0x38, 0x10, 0x7E, 0x1F, 0xF8, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x17, 0x03, 0xAF, 0x47, 0xCF, 0x17, 0x0E, 0x00, 0x1F,
  0x1E, 0x0F, 0xE9, 0xC6, 0x3C, 0x71, 0x07, 0x1E, 0x80, 0xC3, 0xA0, 0x30,
  0x44, 0x0C, 0x60, 0x9B, 0x18, 0x18, 0x8F, 0x00, 0x21, 0xC0, 0x10, 0x78,
  0x08, 0x0E, 0x07, 0xB3, 0x82, 0xF8, 0xE0, 0x1C, 0x30, 0x20, 0x0C, 0x04,
  0x06, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0xFF, 0x04, 0x1C, 0x40, 0x62, 0x03,
  0x08, 0x18, 0x30, 0x80, 0x1C, 0x07, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x9C, 0x05, 0xF0, 0x73, 0xC2, 0x0F, 0x60, 0x1C, 0x00, 0xFB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xE0, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0xE0, 0x08, 0x1C, 0x3C, 0x26, 0x41, 0x81, 0xFF, 0xFF, 0xF0, 0xC6, 0x23,
  0x08, 0x06, 0x0F, 0xC4, 0x66, 0x33, 0x19, 0x8C, 0xC6, 0x63, 0x3F, 0xCC,
  0xC0, 0x00, 0x9C, 0x38, 0x1C, 0x06, 0x43, 0x61, 0xF8, 0xCE, 0x63, 0x31,
  0x98, 0xCC, 0x46, 0x43, 0xC0, 0x40, 0x20, 0x08, 0x78, 0xBB, 0x24, 0x0C,
  0x18, 0x30, 0x70, 0x74, 0x70, 0x40, 0x80, 0x80, 0xF0, 0xF8, 0x3E, 0x2E,
  0x63, 0x63, 0x63, 0x63, 0x63, 0xF2, 0x7C, 0x18, 0x04, 0x78, 0xB3, 0x34,
  0x6F, 0x18, 0x30, 0x70, 0x74, 0x70, 0x30, 0xF4, 0x90, 0x63, 0xE7, 0x1C,
  0x71, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x08, 0x06, 0x0F,
  0xC4, 0x76, 0x13, 0x19, 0x8C, 0xC6, 0x63, 0x19, 0xCF, 0x60, 0x30, 0x13,
  0x08, 0xF8, 0x06, 0x4C, 0x1C, 0x0E, 0x03, 0x21, 0xB0, 0xFC, 0x66, 0x33,
  0x98, 0xCC, 0x66, 0x33, 0x13, 0xD8, 0xC8, 0x08, 0x08, 0x08, 0x08, 0x00,
  0x11, 0x8C, 0x02, 0x3B, 0xE6, 0x31, 0x8C, 0x63, 0x1C, 0xC0, 0x18, 0x61,
  0x00, 0x30, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x9C,
  0x00, 0x06, 0x67, 0x4F, 0x30, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xF1,
  0x80, 0x06, 0x67, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xF1,
  0x00, 0x44, 0x47, 0x77, 0x3D, 0xDE, 0xCE, 0x66, 0x73, 0x33, 0x99, 0x9C,
  0xCC, 0xE6, 0x67, 0x37, 0xB9, 0xD8, 0x84, 0x42, 0x1D, 0xC7, 0xB8, 0xCE,
  0x33, 0x8C, 0xE3, 0x38, 0xCE, 0x33, 0x9E, 0x73, 0x18, 0x00, 0x04, 0x1C,
  0x6E, 0x67, 0x63, 0x63, 0x63, 0x63, 0xF2, 0x7C, 0x10, 0x00, 0x60, 0x30,
  0x9C, 0xC7, 0xF1, 0x9C, 0xC6, 0x63, 0x31, 0x98, 0xBC, 0x57, 0xC3, 0xC1,
  0x80, 0x80, 0x40, 0x20, 0x00, 0x08, 0x06, 0x0F, 0xCC, 0xE4, 0x36, 0x1B,
  0x8D, 0xC6, 0x63, 0x3F, 0x8C, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x44, 0xEE,
  0xF9, 0xB3, 0x06, 0x0C, 0x18, 0x30, 0xF8, 0x60, 0x0E, 0x01, 0x11, 0x3D,
  0x4E, 0x44, 0x64, 0x7E, 0x23, 0x43, 0x72, 0xBC, 0x08, 0x0C, 0x63, 0x1F,
  0xB0, 0xC3, 0x0C, 0x30, 0xC3, 0x1F, 0x18, 0x00, 0x41, 0x1C, 0xEB, 0x38,
  0xCE, 0x33, 0x8C, 0xE3, 0x38, 0xCE, 0x33, 0x9F, 0x71, 0x98, 0x40, 0x41,
  0x33, 0x9E, 0x67, 0x39, 0x8C, 0xC6, 0x63, 0x21, 0x19, 0x1F, 0x03, 0x00,
  0x80, 0x04, 0x01, 0x39, 0x98, 0xFF, 0x66, 0x33, 0xB1, 0x8D, 0x8C, 0x6C,
  0x63, 0x63, 0x13, 0x39, 0x3C, 0xF0, 0xC1, 0x04, 0x00, 0x00, 0x22, 0x36,
  0xFF, 0x1A, 0x18, 0x18, 0x18, 0x18, 0x1A, 0x3C, 0x58, 0x80, 0x80, 0x46,
  0x3E, 0x40, 0x20, 0x18, 0x8E, 0xE3, 0xB1, 0x8C, 0xC6, 0x63, 0x31, 0x98,
  0xCC, 0x6F, 0xA1, 0x10, 0x10, 0x10, 0x30, 0x20, 0x00, 0x10, 0x71, 0x60,
  0x41, 0x04, 0x9E, 0x0E, 0x6C, 0x99, 0x14, 0x24, 0x49, 0x0C, 0x00, 0x0C,
  0x43, 0x0C, 0x30, 0xC3, 0x18, 0xE0, 0xC3, 0x0C, 0x30, 0xC3, 0x07, 0xFF,
  0xFF, 0x80, 0xE0, 0xC3, 0x0C, 0x30, 0xC1, 0x02, 0x0C, 0x43, 0x0C, 0x30,
  0xC3, 0x38, 0xFF, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 15, 5, 0, -15 },
  { 9, 8, 6, 8, 0, -15 },
  { 15, 9, 12, 11, 1, -13 },
  { 29, 7, 17, 9, 1, -16 },
  { 44, 13, 15, 15, 1, -15 },
  { 69, 10, 13, 12, 1, -13 },
  { 86, 4, 6, 4, 0, -15 },
  { 89, 5, 18, 5, 0, -17 },
  { 101, 5, 17, 5, 0, -16 },
  { 112, 7, 8, 7, 0, -16 },
  { 119, 7, 8, 8, 1, -11 },
  { 126, 3, 6, 4, 0, -3 },
  { 129, 5, 4, 6, 1, -8 },
  { 132, 4, 3, 4, 0, -3 },
  { 134, 10, 17, 11, 1, -16 },
  { 156, 10, 15, 10, 0, -15 },
  { 175, 6, 14, 7, 0, -14 },
  { 186, 9, 14, 9, 0, -14 },
  { 202, 9, 14, 10, 0, -14 },
  { 218, 9, 14, 10, 0, -14 },
  { 234, 9, 15, 10, 0, -15 },
  { 251, 9, 15, 10, 0, -15 },
  { 268, 9, 14, 9, 0, -14 },
  { 284, 9, 15, 10, 0, -15 },
  { 301, 9, 15, 10, 0, -15 },
  { 318, 4, 10, 4, 0, -10 },
  { 323, 4, 13, 4, 0, -10 },
  { 330, 6, 8, 6, 0, -10 },
  { 336, 8, 5, 8, 0, -9 },
  { 341, 6, 8, 6, 0, -10 },
  { 347, 8, 15, 10, 1, -15 },
  { 362, 13, 13, 13, 0, -10 },
  { 384, 17, 15, 17, 0, -15 },
  { 416, 18, 15, 19, 0, -15 },
  { 450, 13, 15, 14, 1, -15 },
  { 475, 17, 16, 17, 0, -15 },
  { 509, 13, 15, 15, 1, -15 },
  { 534, 15, 18, 16, 0, -15 },
  { 568, 15, 16, 16, 1, -15 },
  { 598, 15, 19, 15, 0, -16 },
  { 634, 14, 18, 14, 0, -15 },
  { 666, 14, 21, 15, 0, -15 },
  { 703, 17, 15, 17, 0, -15 },
  { 735, 12, 15, 12, 0, -15 },
  { 758, 22, 16, 23, 1, -15 },
  { 802, 17, 15, 19, 1, -15 },
  { 834, 15, 15, 16, 0, -15 },
  { 863, 18, 19, 19, 0, -15 },
  { 906, 16, 16, 17, 0, -15 },
  { 938, 19, 15, 20, 0, -15 },
  { 974, 14, 15, 16, 1, -15 },
  { 1001, 15, 15, 16, 0, -15 },
  { 1030, 14, 16, 15, 0, -15 },
  { 1058, 18, 15, 19, 0, -15 },
  { 1092, 22, 15, 23, 0, -15 },
  { 1134, 15, 15, 15, 0, -15 },
  { 1163, 18, 18, 18, 0, -15 },
  { 1204, 13, 18, 14, 0, -15 },
  { 1234, 3, 17, 4, 0, -16 },
  { 1241, 13, 15, 2, -4, -14 },
  { 1266, 3, 17, 4, 0, -16 },
  { 1273, 8, 6, 9, 0, -15 },
  { 1279, 10, 2, 10, 0, 2 },
  { 1282, 4, 4, 11, 3, -15 },
  { 1284, 9, 12, 10, 0, -11 },
  { 1298, 9, 15, 9, 0, -14 },
  { 1315, 7, 11, 7, 0, -11 },
  { 1325, 8, 15, 10, 1, -15 },
  { 1340, 7, 11, 8, 0, -11 },
  { 1350, 6, 19, 5, 0, -15 },
  { 1365, 9, 15, 10, 0, -11 },
  { 1382, 9, 19, 9, 0, -15 },
  { 1404, 5, 15, 6, 0, -15 },
  { 1414, 6, 19, 5, -1, -15 },
  { 1429, 6, 16, 7, 0, -15 },
  { 1441, 6, 15, 6, 0, -15 },
  { 1453, 13, 11, 15, 1, -11 },
  { 1471, 10, 12, 11, 0, -11 },
  { 1486, 8, 11, 9, 0, -11 },
  { 1497, 9, 17, 9, 0, -13 },
  { 1517, 9, 15, 9, 0, -11 },
  { 1534, 7, 11, 8, 0, -11 },
  { 1544, 8, 13, 9, 0, -13 },
  { 1557, 6, 14, 6, 0, -13 },
  { 1568, 10, 11, 11, 0, -11 },
  { 1582, 9, 12, 9, 0, -12 },
  { 1596, 13, 13, 14, 1, -12 },
  { 1618, 8, 15, 8, 0, -11 },
  { 1633, 9, 17, 10, 0, -13 },
  { 1653, 7, 15, 7, 0, -11 },
  { 1667, 6, 16, 7, 0, -16 },
  { 1679, 1, 17, 3, 1, -16 },
  { 1682, 6, 16, 7, 0, -16 },
  { 1694, 7, 2, 8, 0, -7 },
};

const GFXfont UnifrakturMaguntia_Regular21pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular21pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular21pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR21PT7B_H_
