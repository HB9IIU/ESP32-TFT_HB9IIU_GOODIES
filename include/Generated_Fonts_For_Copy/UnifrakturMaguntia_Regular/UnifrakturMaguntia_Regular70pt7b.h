#ifndef _UNIFRAKTURMAGUNTIA_REGULAR70PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x1E, 0x01, 0xF8, 0x1F, 0xE3, 0xFF,
  0xCF, 0xFE, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x1E,
  0x01, 0xF8, 0x3F, 0xF1, 0xFF, 0xC3, 0xF8, 0x0F, 0x00, 0x38, 0x01, 0x80,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x0E, 0x00, 0x70, 0x1F,
  0x00, 0xF8, 0x3F, 0x81, 0xFC, 0xFF, 0xE3, 0xFF, 0x7F, 0xE7, 0xFF, 0x3F,
  0xE0, 0xFF, 0x0F, 0xC0, 0x7F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x03,
  0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x08, 0x00, 0x40, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xE0, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E,
  0x3F, 0xC0, 0x1E, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x38, 0x01, 0xFF, 0x7C, 0x00, 0xFF,
  0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x07, 0xC1, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0x83, 0xC7, 0xC0, 0x00,
  0x00, 0x1C, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0xF8, 0x3E, 0x00, 0x00,
  0x07, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3C, 0x1F, 0x83, 0xF0, 0x00, 0x01,
  0xE0, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x38,
  0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xC0, 0x3F, 0x81, 0xF8, 0x00, 0x0E, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x70, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x38, 0x00, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0xF8,
  0x0F, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x38, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x0E, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x70,
  0x3E, 0x3C, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xF8, 0x00, 0x00, 0x1C, 0x0F,
  0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF8,
  0x1F, 0x80, 0x00, 0x1C, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xE0, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x38, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x78, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x70, 0x00, 0x1F, 0x81, 0xF8, 0x03,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x1C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x3C, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x3E, 0x3C, 0x07, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0xF1, 0xE0, 0x00,
  0x00, 0xFF, 0x3C, 0x00, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x00, 0xF8,
  0x07, 0x9F, 0xF0, 0x07, 0x00, 0xF1, 0xFF, 0x00, 0x70, 0x1F, 0x0F, 0xF8,
  0x06, 0x03, 0xE0, 0xFF, 0x80, 0x60, 0x3E, 0x0F, 0xFC, 0x0E, 0x07, 0xE0,
  0x7F, 0xC0, 0xC0, 0x7E, 0x07, 0xFE, 0x0C, 0x07, 0xE0, 0x3F, 0xE1, 0xC0,
  0xFE, 0x03, 0xFF, 0x18, 0x0F, 0xE0, 0x1F, 0xF3, 0x80, 0xFF, 0x01, 0xFF,
  0xB0, 0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x03,
  0x3F, 0xC0, 0x1F, 0xF8, 0x73, 0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x3C, 0x0F, 0x83, 0xFC, 0xFF, 0xDF,
  0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x80, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0E,
  0x70, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x03,
  0x9F, 0x9C, 0x7F, 0x1E, 0x3F, 0x7E, 0x3C, 0xFE, 0xFE, 0x71, 0xF9, 0xFC,
  0x67, 0xF1, 0xFC, 0xDF, 0xE3, 0xFF, 0xFF, 0xC4, 0x0F, 0xC1, 0x90, 0x0F,
  0x01, 0x1D, 0xFF, 0xFE, 0x3F, 0xDB, 0xFC, 0xFF, 0x33, 0xF9, 0xFC, 0x67,
  0xF3, 0xF1, 0xC7, 0xFF, 0xE3, 0xCF, 0xE1, 0xCF, 0xDC, 0x00, 0xBF, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x1C, 0x07, 0x81, 0xFC, 0xFF, 0xDF, 0xF8, 0xFF, 0x0F,
  0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x0E, 0x01, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xE3,
  0xF8, 0x1F, 0x00, 0xE0, 0x06, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xEF, 0xF8, 0x0C, 0x3F,
  0xC0, 0x40, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x78, 0x01, 0xFF, 0x87, 0x80,
  0x07, 0xFE, 0x38, 0x00, 0x1F, 0xF3, 0x80, 0x00, 0xFF, 0x9C, 0x00, 0x03,
  0xFC, 0xC0, 0x00, 0x1F, 0xF6, 0x00, 0x00, 0xFF, 0xB0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x04, 0x00, 0xF8, 0x00, 0x30, 0x0F, 0x80, 0x01, 0x80,
  0x78, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x60, 0x78, 0x00, 0x03, 0x07, 0x80,
  0x00, 0x18, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3C, 0x0F, 0xFE, 0x00, 0xE0, 0x07, 0xFE, 0x03, 0x80,
  0x07, 0xFC, 0x0E, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7E, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF0, 0xFF, 0x00, 0x07, 0xE1, 0xFE, 0x00,
  0x0F, 0x81, 0xFC, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xF8, 0x03,
  0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x06, 0x7F, 0x80, 0x00, 0x39,
  0xFE, 0x00, 0x00, 0xC7, 0xF8, 0x00, 0x06, 0x1F, 0xE0, 0x00, 0x38, 0x7F,
  0x80, 0x00, 0xC1, 0xFE, 0x00, 0x07, 0x07, 0xF8, 0x00, 0x38, 0x1F, 0xE0,
  0x00, 0xC0, 0x7F, 0x80, 0x07, 0x01, 0xFE, 0x00, 0x18, 0x07, 0xF8, 0x00,
  0xC0, 0x1F, 0xE0, 0x07, 0x00, 0x7F, 0x80, 0x18, 0x01, 0xFE, 0x00, 0xC0,
  0x07, 0xF8, 0x07, 0x00, 0x1F, 0xE0, 0x18, 0x00, 0x7F, 0x80, 0xE0, 0x01,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x3F, 0xE0, 0x00, 0x1B, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0x00,
  0x1F, 0xF8, 0x38, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x1F, 0xF0, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x40, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0xFC,
  0x7F, 0x80, 0x01, 0xF0, 0xFF, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x0F, 0x81,
  0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3C,
  0x07, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0x07, 0x80, 0x3F, 0x80, 0x3E, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F,
  0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xE0,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x81, 0xFE, 0x39, 0xFF, 0x07, 0xF9, 0x81,
  0xFE, 0x1F, 0xEC, 0x07, 0xF8, 0x7F, 0xB0, 0x0F, 0xF1, 0xFF, 0x80, 0x3F,
  0xC7, 0xFE, 0x00, 0x7F, 0x9F, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9,
  0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F,
  0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0x9F, 0xF0,
  0x00, 0xFE, 0x7F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F,
  0x81, 0xFE, 0x00, 0x7C, 0x03, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x80, 0x3C, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0x80, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0F,
  0x0F, 0xC0, 0x00, 0x3C, 0x3F, 0x80, 0x01, 0xF0, 0xFF, 0x00, 0x07, 0x83,
  0xFE, 0x00, 0x1E, 0x0F, 0xFE, 0x00, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x7F,
  0xFC, 0x1C, 0x00, 0xFF, 0xFD, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0E, 0x1F, 0xFF, 0x80, 0x70, 0x1F, 0xFE,
  0x03, 0xC0, 0x1F, 0xFC, 0x1E, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0x7F, 0xE3,
  0xC0, 0x00, 0x7F, 0x9F, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x78,
  0x0F, 0x80, 0x03, 0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFE, 0xFF,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x01,
  0xFF, 0x9F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x00, 0xFF,
  0xE3, 0xFC, 0x06, 0xFF, 0x87, 0xF8, 0x1B, 0xFE, 0x0F, 0xFF, 0xCF, 0xF8,
  0x1F, 0xFE, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0x7E,
  0x03, 0xFC, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x1E, 0x00,
  0x7F, 0x00, 0xF0, 0x00, 0xFE, 0x07, 0x80, 0x01, 0xFC, 0x3C, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x60, 0x0F, 0x01,
  0xF8, 0x3F, 0xCF, 0xFE, 0x3F, 0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x01, 0xF0, 0x3F, 0x87,
  0xFE, 0xFF, 0xE3, 0xF8, 0x1F, 0x00, 0xE0, 0x06, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x3F, 0xF8, 0x7F, 0x81, 0xF8, 0x07,
  0x80, 0x18, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x78, 0x07, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x83, 0xC0, 0x03, 0xF8, 0xF0,
  0x00, 0x3F, 0x9E, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xFE, 0xF8, 0x00, 0x0F,
  0xDF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF7, 0xF8,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x60, 0x1F, 0x00, 0x0C, 0x01,
  0xF0, 0x01, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x18, 0x00, 0x3F, 0x0F,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x03, 0xEF, 0x87, 0x03, 0xC0, 0x0F, 0xFF, 0xC3,
  0xC3, 0xE0, 0x0F, 0x9F, 0xE1, 0xE1, 0xF0, 0x0F, 0x87, 0xF0, 0xF1, 0xF0,
  0x0F, 0x83, 0xF0, 0x78, 0xF8, 0x0F, 0xC1, 0xF8, 0x3C, 0x7C, 0x0F, 0xC0,
  0xFC, 0x1E, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0x9F, 0x07, 0xF0, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x1F, 0x03, 0xC7, 0xC3,
  0xF8, 0x1F, 0x81, 0xE3, 0xE1, 0xF8, 0x0F, 0xC1, 0xF1, 0xF0, 0xFC, 0x0F,
  0xE0, 0xF0, 0xF8, 0x7E, 0x0F, 0xE0, 0xF8, 0x7C, 0x3F, 0x07, 0xF0, 0xF8,
  0x1E, 0x1F, 0x87, 0xF8, 0xF8, 0x0F, 0x0F, 0xCF, 0xFC, 0xF8, 0x07, 0xC3,
  0xFF, 0xFF, 0xF8, 0x79, 0xE1, 0xFF, 0x3F, 0xF8, 0x78, 0xF8, 0x3E, 0x07,
  0xE0, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xE0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x30, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x06, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x38, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0xC0, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0x00, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x30,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFE,
  0x03, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xE0, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x38,
  0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0x06, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x1E, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x80, 0x40, 0xFF, 0xFC,
  0x0E, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x0C, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xC0,
  0x7F, 0xE0, 0x01, 0xFF, 0xDF, 0xFF, 0xE4, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x0E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x70,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x01, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0xFF, 0xE0,
  0x1E, 0x00, 0x08, 0x0F, 0x87, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x60, 0xF8,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x0E, 0x07, 0xC3, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xC3,
  0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xE3,
  0x80, 0xFE, 0x00, 0x00, 0xF8, 0x06, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x18,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x4F, 0xFF, 0xF8, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x03, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x03, 0x00,
  0x3F, 0x80, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x70, 0x00,
  0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x60, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x60, 0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x7F, 0xFC, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC3,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF8, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC7, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xCE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x70, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFB, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xD8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xF7, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x98, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF3, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x38, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xC0, 0xF0, 0x08, 0x1F, 0xE0, 0x00, 0x1E, 0x01,
  0xFF, 0xE0, 0x7F, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xC0, 0x03, 0xC7, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0xF8, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0xC1, 0xFF, 0x80,
  0x00, 0xF8, 0x01, 0x8F, 0xFF, 0xF8, 0x07, 0xC0, 0x02, 0x7F, 0xFF, 0xC0,
  0x3F, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xE0, 0x03, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0xF8, 0x01, 0xFC,
  0x01, 0xE0, 0x00, 0xC0, 0x07, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0xC0, 0x07, 0xF8, 0x3F, 0xF8,
  0x07, 0xC0, 0x1F, 0xE0, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xE1,
  0xFF, 0xC9, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFE, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x78,
  0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x87,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7C, 0x00, 0x00,
  0x13, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x0C, 0x3F, 0xE0, 0x0F, 0x00, 0x00,
  0x06, 0x07, 0xF0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x08, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFE, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xE0,
  0xC0, 0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0x8E, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF1, 0x80, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x70, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x3C, 0x00, 0x63, 0xFF,
  0xC1, 0xE0, 0x03, 0xE1, 0xF8, 0x7F, 0xF8, 0x30, 0x00, 0x3F, 0xF0, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0C, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x01, 0x87, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x33, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x05, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0x9F, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xC3, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xC0, 0x7F, 0xF8, 0x03,
  0xF8, 0x00, 0xE0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x70, 0x01, 0xFF, 0xF0,
  0x7F, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1E,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x03,
  0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xDF, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF3,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFE,
  0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x0F, 0x00, 0x0F,
  0xE0, 0xFF, 0x80, 0x07, 0x80, 0x03, 0xF0, 0x3F, 0xF0, 0x03, 0xC0, 0x01,
  0xFC, 0x07, 0xFE, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0xF0, 0x20, 0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x7C, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x78, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x60, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x3C, 0x00, 0x0F, 0xF1, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xF1, 0xFF, 0xF8,
  0x0E, 0x00, 0x03, 0xF9, 0xFF, 0xFE, 0x06, 0x00, 0x01, 0xF8, 0x8F, 0xFF,
  0x86, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE1, 0x83, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xC0, 0x1C, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0x83, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xE3,
  0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x38, 0x7F, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8,
  0x60, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x01, 0xFF, 0xFE,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0x80, 0x1C, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7C, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x06, 0x07, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xF9, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0x1F, 0xC1,
  0xFF, 0xFF, 0x80, 0x78, 0x00, 0x7E, 0x0F, 0x0F, 0xFF, 0x01, 0xE0, 0x03,
  0xF8, 0x38, 0x0F, 0xFE, 0x07, 0x80, 0x0F, 0xE1, 0x80, 0x1F, 0xF8, 0x0E,
  0x00, 0x3F, 0xC6, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0xFF, 0x10, 0x00, 0xFF,
  0xC0, 0xF0, 0x03, 0xFC, 0x40, 0x01, 0xFF, 0x03, 0xC0, 0x0F, 0xF9, 0x00,
  0x07, 0xFE, 0x0F, 0x00, 0x3F, 0xE4, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0xE0, 0x0C, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0x60, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFE, 0x38, 0x00, 0x00,
  0x1F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0xCF, 0xFF, 0x07,
  0x00, 0x01, 0xFF, 0xC4, 0x0F, 0xFF, 0x78, 0x00, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x00, 0x7E,
  0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xE1, 0xFF, 0x80,
  0x00, 0x1F, 0x87, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xF9, 0xFF, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x70, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0B, 0xFF, 0xFF, 0xF0, 0x00, 0x68, 0x1F,
  0xFF, 0xF0, 0x07, 0x00, 0x1F, 0xFF, 0xF0, 0x78, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x38, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCC, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x06, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x08, 0x00,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE2, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFF, 0xB0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x8C,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x83, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xE0,
  0x07, 0x81, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0,
  0x07, 0xF0, 0x1E, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x03, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0xC3, 0xC0, 0x30, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x73, 0xF8, 0x0C, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x19,
  0xFF, 0x86, 0x00, 0x3F, 0xF8, 0x20, 0xFF, 0xFE, 0x0C, 0xFF, 0xFB, 0x00,
  0x07, 0xFF, 0xF8, 0x77, 0xFF, 0xC7, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x10, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE6, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x1C, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x8E,
  0x01, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0xF3, 0x00, 0x7F, 0xC0, 0x78, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xF8, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFE,
  0x0E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x83, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x30, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x0C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE2, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x30, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x0C, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0xE0, 0x07, 0xC7, 0xF8, 0x01, 0xFE, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x1E,
  0x00, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE1, 0x80, 0x3F, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x60, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x18, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x00, 0x02, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xE0, 0x03, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xE0, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x70, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x18, 0x00, 0x3F, 0xFC, 0x70, 0xFF, 0xFE, 0x0C, 0x00, 0x07, 0xFF, 0xF8,
  0x73, 0xFF, 0xC7, 0x00, 0x00, 0xFF, 0xFC, 0x10, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x87, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x18, 0x06, 0x3F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xFF,
  0xDE, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0x80, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x80, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x0E,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x60, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x86, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x70, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFE, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xE0, 0x03, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x07, 0x80, 0x70, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xEF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x86, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xCE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x60,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xD0, 0xFF, 0xFF, 0x82,
  0x07, 0xFE, 0x0E, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x0E, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x30, 0x1F, 0xFC, 0x00, 0xFF, 0x07, 0xFF,
  0xF9, 0x80, 0x3F, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0xF4, 0x00, 0xFF, 0xE0,
  0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x38, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE3, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x30, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7E, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x02, 0x01, 0xF8, 0x7F, 0xE0, 0x00,
  0x0F, 0x00, 0x18, 0x07, 0xE7, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x1F,
  0xBF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x01, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0E,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x70, 0x00, 0x07, 0xFF, 0x08,
  0x1F, 0xFF, 0xE3, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xE0, 0x10, 0x07,
  0xFF, 0xFF, 0xE1, 0xF0, 0x0C, 0x0F, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x1E, 0x7C, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0x3F, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xDF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x6F, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xDF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x63, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0x81, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x63,
  0xFF, 0xFF, 0x98, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0x8C, 0x00, 0x00, 0xE0,
  0x1F, 0xFF, 0x86, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x83, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0x81, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x18, 0x01, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC7,
  0x8F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC6, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x70, 0x01, 0xF8, 0x38, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x30, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x60, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x01, 0x01, 0xFF,
  0xC0, 0x07, 0xF0, 0x06, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x18, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x20, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x06, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x19, 0xFF, 0x01, 0x83, 0xFF, 0xF0,
  0xE1, 0xFF, 0x18, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x38, 0x7F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x88, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF6, 0x01, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x38, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x8C, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x10, 0x3E,
  0x00, 0x7F, 0xC0, 0x07, 0x00, 0x18, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0x70,
  0x1C, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0,
  0xEF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x9C, 0x38, 0xC0, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xEC, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xFC, 0x00,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0x00,
  0x00, 0xFF, 0xE0, 0x78, 0x00, 0x1F, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0xF0,
  0x7C, 0x00, 0x0F, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x03,
  0xFF, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x01, 0xFF, 0xC1, 0xC0,
  0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x1F, 0xE0, 0x60, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xC0, 0x30, 0x00, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0xF8, 0xFF, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0xF0,
  0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x7E, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x3E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x18, 0x1F, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0x80, 0x38, 0x0F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x01, 0xC3, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x01, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xC3, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0xE7,
  0xF8, 0x3E, 0x00, 0x0F, 0xF9, 0x83, 0xF0, 0x3C, 0x00, 0x07, 0xF9, 0x80,
  0xC0, 0x78, 0x00, 0x03, 0xFD, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0x80, 0x8F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xFF, 0xFF,
  0x00, 0x00, 0x18, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x20, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x06, 0x3F, 0xF0,
  0x00, 0x01, 0xFE, 0x0C, 0x3F, 0xF8, 0x04, 0x03, 0xFF, 0x9C, 0x1F, 0xFF,
  0x1C, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0D, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x18, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF9, 0x80,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFD, 0x80, 0x7F, 0xE0, 0x3F, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x78,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x18, 0x00, 0x30, 0x3E, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x60, 0x3E,
  0x00, 0xFF, 0x00, 0x07, 0x83, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x7C, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x38, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x70,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x04, 0x3F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC3, 0xFF, 0xFC,
  0x00, 0x00, 0x7C, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0x8C, 0x3F, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xBC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x8F, 0xFF, 0xC0, 0x38,
  0x1F, 0xFC, 0x03, 0xC0, 0x7F, 0xC0, 0x3C, 0x00, 0xFE, 0x03, 0xE0, 0x07,
  0xF0, 0x1F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0x8C, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xEF, 0xFC, 0x0F, 0xFE,
  0x7F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xC0, 0x3F,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x10, 0x0E, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0x02, 0x1F,
  0x00, 0x00, 0x19, 0xF8, 0x00, 0x00, 0x4F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x02, 0x00, 0x3F,
  0xC0, 0x30, 0x01, 0xFE, 0x07, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x8F,
  0xF8, 0x01, 0xFD, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x03, 0xFE,
  0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x3C, 0x03, 0xF8,
  0x03, 0xE0, 0x3F, 0xC0, 0x1E, 0x01, 0xFF, 0x01, 0xE0, 0x1F, 0xFE, 0x0E,
  0x01, 0xFF, 0xF8, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x39, 0xFC, 0x03,
  0x8F, 0xF0, 0x3C, 0x3F, 0x83, 0xC1, 0xFE, 0x1E, 0x07, 0xF1, 0xF0, 0x3F,
  0xCF, 0x80, 0xFE, 0xF8, 0x07, 0x87, 0xC0, 0x10, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x37, 0xFF, 0x80, 0x03, 0x0F, 0xFC, 0x00, 0xF0, 0x3F, 0xF0, 0x3F, 0x80,
  0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3E, 0x0F, 0xE0,
  0x01, 0xF0, 0x7F, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x78, 0x1F, 0xC0, 0x03,
  0xC0, 0xFE, 0x00, 0x1E, 0x07, 0xF0, 0x01, 0xE0, 0x7F, 0x80, 0x0F, 0x03,
  0xFC, 0x00, 0x70, 0x1F, 0xF8, 0x03, 0x83, 0xFF, 0xF0, 0x38, 0x1F, 0xFF,
  0xC1, 0x80, 0x1F, 0xFF, 0x98, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x03, 0x9F, 0xC0, 0x1C, 0x7F, 0x00, 0xF1, 0xFE, 0x07,
  0x83, 0xF8, 0x1E, 0x0F, 0xF0, 0xF8, 0x1F, 0xC3, 0xE0, 0x7F, 0x1F, 0x01,
  0xFE, 0x7C, 0x03, 0xF9, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0x3F, 0x00, 0xF0,
  0xFC, 0x1E, 0x03, 0xF1, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x7F, 0xF2, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xEF, 0xF8, 0x03, 0x07, 0xC0, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0x7F, 0xF0, 0x00, 0x31, 0xFF, 0xF0, 0x03, 0x87, 0xFF,
  0xE0, 0x38, 0x1F, 0xFE, 0x03, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x3C, 0x0F, 0xC0,
  0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFF, 0x9F, 0xE0, 0x3F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0x80, 0x1F, 0xC0, 0x30, 0x00, 0xFE, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x07, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF0, 0x1F,
  0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xF8, 0x0E, 0x00, 0x07, 0xF3,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0xF8, 0x00, 0x06,
  0x0F, 0x80, 0x00, 0x10, 0xF8, 0x00, 0x00, 0xCF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x04, 0x00,
  0x3F, 0x80, 0x60, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F,
  0x1F, 0xF0, 0x03, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xF0,
  0x07, 0xE0, 0x7F, 0x80, 0x3E, 0x03, 0xFC, 0x41, 0xF0, 0x3F, 0xF7, 0x0F,
  0x83, 0xFF, 0xE0, 0xF8, 0x0F, 0xFE, 0x07, 0x80, 0x1F, 0xE0, 0x38, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x86, 0xFF, 0x86,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x40, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x06, 0xFF, 0x80, 0xCF, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC8, 0x00, 0xFC,
  0xC0, 0x0F, 0x86, 0x01, 0xF0, 0x20, 0x1E, 0x01, 0x07, 0x80, 0x07, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x1F, 0x04,
  0x03, 0xC0, 0x60, 0x78, 0x03, 0x0F, 0x80, 0x11, 0xF0, 0x71, 0xBF, 0x0F,
  0x0F, 0xF1, 0xF0, 0xFF, 0x3F, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF,
  0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x04, 0x0F, 0xFC, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1E, 0x04, 0x03, 0xC0, 0x60, 0xF8,
  0x03, 0x1F, 0x80, 0x11, 0xF0, 0x01, 0xBF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x04, 0x0F, 0xFC, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0xC0, 0xFF, 0x83, 0xFC,
  0x00, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xFE,
  0x1F, 0xFD, 0x9F, 0xF6, 0x7F, 0xF8, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC2,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0xCF, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0,
  0x3E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x01,
  0xC0, 0x03, 0x00, 0x03, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xF8, 0x8F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE2, 0x3F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xE3,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0xFE, 0x00,
  0xFF, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01,
  0xF0, 0xFE, 0x00, 0x3E, 0x1F, 0xC0, 0x07, 0x87, 0xF8, 0x01, 0xF0, 0xFF,
  0x00, 0x3C, 0x1F, 0xF8, 0x0F, 0x0F, 0xFF, 0x81, 0xC1, 0xFF, 0xFC, 0x70,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0xFF,
  0xC0, 0x7E, 0x01, 0xFF, 0xC1, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF,
  0x7F, 0xFC, 0x01, 0xFF, 0xCF, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF8,
  0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x1F, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7C,
  0x0F, 0xFC, 0x00, 0xF8, 0x3F, 0xF8, 0x01, 0xE0, 0xFF, 0xF8, 0x07, 0x81,
  0xFF, 0xFC, 0x0E, 0x07, 0xFF, 0xFC, 0x38, 0x0F, 0xFF, 0xFE, 0x60, 0x10,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x07, 0xC2, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x0C, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xE0, 0x78, 0x1F, 0xFC,
  0x0F, 0x00, 0xFF, 0x81, 0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x3F, 0x0F, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07,
  0xFC, 0x03, 0xF0, 0x3F, 0xE0, 0x3F, 0x83, 0xFF, 0x07, 0xF8, 0x1F, 0xFD,
  0xFF, 0x80, 0xFF, 0xF3, 0xF8, 0x0F, 0xFE, 0x3F, 0x80, 0x7F, 0x83, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x80, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x1E,
  0x00, 0x60, 0x3E, 0x01, 0xC0, 0xFE, 0x07, 0xC1, 0xFE, 0x1F, 0x87, 0xFE,
  0x7F, 0x9F, 0xFC, 0xFF, 0x27, 0xFF, 0xFF, 0x47, 0xFD, 0xFE, 0x0F, 0xF1,
  0xF8, 0x1F, 0xC3, 0xE0, 0x3F, 0x83, 0x80, 0x7F, 0x07, 0x00, 0xFE, 0x04,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x86, 0x00, 0xFF, 0xD8, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x80, 0x08, 0x01, 0xFC, 0x03, 0x00, 0x7F, 0xC0, 0x60,
  0x1F, 0xFF, 0xFC, 0x06, 0xFF, 0xFF, 0x81, 0x8F, 0xFF, 0xE0, 0x60, 0x7F,
  0xF8, 0x18, 0x03, 0xFE, 0x07, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x60, 0x3C,
  0x00, 0x18, 0x07, 0xC0, 0x06, 0x00, 0xFC, 0x01, 0xE0, 0x1F, 0xC0, 0x7E,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0x80, 0x7F,
  0x00, 0xE0, 0x07, 0xE0, 0x18, 0x00, 0x7C, 0x06, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0xE0, 0x7F, 0x00, 0x18, 0x1F, 0xF8, 0x06, 0x07, 0xFF, 0xC0, 0x80,
  0xFF, 0xFF, 0x70, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x81, 0xFF, 0x18,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF8, 0xDF,
  0xE0, 0x3F, 0xF0, 0x8F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE2, 0x0F, 0xFC, 0x7F, 0xF2, 0x3F, 0xFE, 0xCF, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x10, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0x3C, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0xF0, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x07, 0xC0,
  0x07, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xFC, 0x01, 0xE0, 0x01, 0xFE, 0x03, 0x80, 0x07, 0xFF, 0x0E, 0x00, 0x0F,
  0xFF, 0x18, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x87, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x30, 0x00, 0x30, 0x1F, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0xFF,
  0xC0, 0x3F, 0x80, 0x3E, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0x33,
  0xFF, 0x87, 0xFC, 0x07, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0,
  0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x3E, 0x03, 0xF8, 0x07,
  0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1E, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0E, 0x00, 0x3F, 0xC0, 0xFF, 0xF0,
  0x60, 0x03, 0xFE, 0x0F, 0xFF, 0xC6, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0xF8,
  0x07, 0x00, 0xFE, 0x07, 0xC0, 0x7F, 0x83, 0xE0, 0x7F, 0xE3, 0xF8, 0x3F,
  0xF3, 0xFC, 0x3F, 0xFF, 0xFF, 0x11, 0xFF, 0x7F, 0x80, 0xFF, 0x1F, 0x80,
  0x7F, 0x8F, 0xC0, 0x1F, 0x83, 0xC0, 0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0x40,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x80, 0x0F,
  0xFC, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0x07, 0xC0, 0x03, 0x01, 0xE0, 0x03,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x07,
  0x80, 0xE0, 0x07, 0xE0, 0x3C, 0x07, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x1F, 0xF0, 0x03, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0xC1, 0xFC,
  0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0x01, 0xFE,
  0x30, 0xFC, 0x0F, 0xFD, 0x83, 0xE0, 0x7F, 0xFC, 0x0F, 0x00, 0x7F, 0xE0,
  0x3C, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x02, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x70, 0x18, 0x0F, 0xE3, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x67, 0xFC, 0x0C, 0x3F, 0xE0, 0xC1, 0xFE, 0x18, 0x1F, 0xE3, 0x80,
  0xFE, 0x30, 0x0F, 0xE7, 0x00, 0xFF, 0x70, 0x07, 0xF6, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xEE, 0x00, 0x7E, 0xE0, 0x07, 0xEE,
  0x00, 0x7E, 0xE0, 0x07, 0xCE, 0x00, 0x7C, 0xE0, 0x07, 0x87, 0x00, 0x70,
  0x70, 0x0F, 0x03, 0x00, 0xE0, 0x18, 0x1C, 0x00, 0xE7, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 13, 52, 16, 2, -51 },
  { 86, 24, 19, 28, 2, -50 },
  { 143, 32, 40, 36, 2, -45 },
  { 303, 24, 56, 29, 2, -53 },
  { 471, 46, 49, 50, 2, -50 },
  { 753, 36, 44, 40, 2, -43 },
  { 951, 11, 19, 14, 1, -50 },
  { 978, 16, 57, 17, 1, -55 },
  { 1092, 16, 57, 17, 1, -55 },
  { 1206, 23, 28, 25, 0, -53 },
  { 1287, 23, 24, 28, 3, -35 },
  { 1356, 11, 19, 13, 0, -11 },
  { 1383, 19, 14, 21, 2, -28 },
  { 1417, 12, 12, 14, 1, -11 },
  { 1435, 34, 55, 37, 2, -52 },
  { 1669, 31, 50, 33, 1, -49 },
  { 1863, 21, 48, 22, 1, -48 },
  { 1989, 29, 48, 31, 1, -48 },
  { 2163, 31, 49, 33, 1, -49 },
  { 2353, 30, 48, 32, 1, -48 },
  { 2533, 31, 49, 33, 1, -49 },
  { 2723, 30, 50, 32, 1, -49 },
  { 2911, 28, 48, 30, 1, -48 },
  { 3079, 30, 49, 33, 1, -49 },
  { 3263, 30, 50, 32, 1, -50 },
  { 3451, 12, 34, 14, 1, -33 },
  { 3502, 13, 41, 12, 0, -33 },
  { 3569, 19, 26, 20, 0, -33 },
  { 3631, 24, 15, 27, 2, -28 },
  { 3676, 19, 26, 20, 0, -33 },
  { 3738, 27, 51, 32, 2, -50 },
  { 3911, 41, 41, 43, 1, -32 },
  { 4122, 54, 52, 57, 2, -50 },
  { 4473, 61, 52, 63, 0, -51 },
  { 4870, 45, 52, 48, 2, -51 },
  { 5163, 53, 54, 57, 2, -51 },
  { 5521, 46, 52, 49, 2, -51 },
  { 5820, 50, 60, 53, 1, -52 },
  { 6195, 50, 52, 54, 2, -50 },
  { 6520, 49, 64, 51, 1, -54 },
  { 6912, 45, 60, 48, 1, -51 },
  { 7250, 47, 69, 50, 1, -51 },
  { 7656, 54, 52, 57, 1, -50 },
  { 8007, 38, 50, 40, 1, -49 },
  { 8245, 74, 53, 77, 2, -49 },
  { 8736, 58, 50, 62, 2, -49 },
  { 9099, 50, 52, 53, 1, -50 },
  { 9424, 60, 61, 62, 1, -49 },
  { 9882, 53, 55, 56, 1, -50 },
  { 10247, 62, 52, 65, 2, -51 },
  { 10650, 49, 51, 53, 2, -50 },
  { 10963, 49, 50, 52, 2, -49 },
  { 11270, 47, 53, 50, 1, -49 },
  { 11582, 58, 53, 62, 2, -51 },
  { 11967, 73, 51, 75, 1, -50 },
  { 12433, 48, 52, 50, 1, -51 },
  { 12745, 56, 62, 60, 2, -51 },
  { 13179, 44, 61, 47, 1, -51 },
  { 13515, 10, 55, 13, 1, -52 },
  { 13584, 43, 49, 7, -13, -46 },
  { 13848, 10, 55, 13, 1, -52 },
  { 13917, 26, 19, 29, 1, -49 },
  { 13979, 33, 5, 32, -1, 8 },
  { 14000, 11, 13, 35, 11, -49 },
  { 14018, 29, 38, 32, 2, -36 },
  { 14156, 29, 50, 31, 1, -48 },
  { 14338, 21, 38, 25, 2, -36 },
  { 14438, 29, 50, 32, 2, -49 },
  { 14620, 22, 37, 25, 2, -36 },
  { 14722, 22, 63, 17, -1, -51 },
  { 14896, 29, 51, 33, 2, -36 },
  { 15081, 29, 61, 31, 1, -49 },
  { 15303, 17, 50, 19, 1, -49 },
  { 15410, 20, 63, 17, -4, -50 },
  { 15568, 20, 51, 23, 1, -49 },
  { 15696, 20, 51, 19, 1, -49 },
  { 15824, 46, 38, 50, 2, -37 },
  { 16043, 32, 38, 35, 2, -36 },
  { 16195, 27, 37, 29, 0, -36 },
  { 16320, 31, 56, 32, 0, -42 },
  { 16537, 28, 50, 30, 1, -36 },
  { 16712, 23, 37, 25, 1, -36 },
  { 16819, 27, 45, 29, 1, -44 },
  { 16971, 19, 47, 22, 1, -45 },
  { 17083, 32, 37, 35, 2, -36 },
  { 17231, 31, 41, 32, -1, -40 },
  { 17390, 45, 43, 48, 2, -41 },
  { 17632, 25, 52, 28, 1, -37 },
  { 17795, 30, 54, 33, 1, -42 },
  { 17998, 20, 49, 23, 2, -36 },
  { 18121, 19, 56, 23, 1, -54 },
  { 18254, 5, 58, 11, 3, -55 },
  { 18291, 19, 56, 23, 1, -54 },
  { 18424, 22, 5, 26, 2, -23 },
};

const GFXfont UnifrakturMaguntia_Regular70pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular70pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular70pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR70PT7B_H_
