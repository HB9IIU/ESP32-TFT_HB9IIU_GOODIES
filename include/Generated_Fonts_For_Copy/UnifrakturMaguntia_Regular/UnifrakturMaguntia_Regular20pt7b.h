#ifndef _UNIFRAKTURMAGUNTIA_REGULAR20PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0x27, 0x76, 0x22, 0x22, 0x20, 0x02, 0x72, 0x24, 0xFC, 0x89, 0x14,
  0x40, 0x32, 0x19, 0x0D, 0x9F, 0xF2, 0x61, 0x30, 0x91, 0xFE, 0x64, 0x32,
  0x1B, 0x0D, 0x80, 0x10, 0x71, 0x16, 0x2C, 0x58, 0xBC, 0x3C, 0x1D, 0x1E,
  0x1C, 0x28, 0x4F, 0x04, 0x08, 0x70, 0x16, 0xC1, 0x36, 0x09, 0x30, 0x8D,
  0x88, 0x6C, 0x81, 0xCB, 0x80, 0x92, 0x09, 0x98, 0x4C, 0xC4, 0x66, 0x43,
  0x34, 0x09, 0x40, 0x70, 0x1C, 0x0D, 0x83, 0x20, 0xD8, 0x34, 0x0E, 0x07,
  0x9F, 0x62, 0xDD, 0x33, 0x4C, 0xE3, 0x98, 0x7B, 0xC0, 0x4F, 0x22, 0x40,
  0x19, 0x08, 0xC6, 0x33, 0x9C, 0xE7, 0x38, 0xC6, 0x30, 0x84, 0x10, 0x41,
  0x08, 0x63, 0x18, 0xE7, 0x39, 0xCE, 0x63, 0x18, 0x84, 0xC0, 0x10, 0x73,
  0x5B, 0xEF, 0xDA, 0x8E, 0x88, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x5D,
  0x94, 0x7B, 0xAD, 0xE0, 0x4E, 0x50, 0x00, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x1C, 0x19, 0x18, 0xCC, 0x76, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xB1, 0xD8,
  0xEC, 0x63, 0x20, 0xE0, 0x10, 0xC7, 0x2C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x39, 0xF0, 0x3E, 0x23, 0xA0, 0xD0, 0x60, 0x30, 0x18, 0x18, 0x18,
  0x08, 0x08, 0x48, 0x2F, 0xEF, 0xF0, 0x3E, 0x23, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x7C, 0x07, 0x03, 0x80, 0xF8, 0x6C, 0x26, 0x31, 0xE0, 0x06, 0x07,
  0x03, 0x82, 0xC1, 0x61, 0x31, 0x18, 0x8C, 0x86, 0x7F, 0xC1, 0x80, 0xC0,
  0xE0, 0xFC, 0x01, 0x1F, 0x0F, 0x08, 0x04, 0x03, 0xF1, 0xFC, 0x87, 0x01,
  0x80, 0xF8, 0x6C, 0x36, 0x31, 0xE0, 0x1E, 0x19, 0x88, 0xCC, 0x66, 0x03,
  0x21, 0xED, 0xC6, 0x63, 0xB1, 0xD8, 0xEC, 0x63, 0x20, 0xE0, 0x7F, 0x81,
  0x83, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x70, 0x1E,
  0x30, 0x90, 0x4C, 0x27, 0x13, 0xF0, 0xF8, 0x8E, 0x43, 0xE0, 0xF0, 0x78,
  0x36, 0x31, 0xF0, 0x1C, 0x13, 0x18, 0xCC, 0x6E, 0x3F, 0x1D, 0x8E, 0xC7,
  0x3F, 0x01, 0x98, 0xCC, 0x46, 0x61, 0xE0, 0x06, 0xF4, 0x00, 0x04, 0xE5,
  0x06, 0xF4, 0x00, 0x04, 0xE6, 0x24, 0x08, 0x46, 0x38, 0x60, 0x40, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x81, 0x83, 0x07, 0x31, 0x88, 0x00, 0x7D, 0x8E,
  0x1E, 0x3C, 0x63, 0xDE, 0x30, 0x44, 0xC8, 0xE0, 0x01, 0x07, 0x04, 0x00,
  0x0F, 0x81, 0x84, 0x27, 0xA4, 0xDA, 0x49, 0xAD, 0x92, 0xDB, 0x2D, 0xB4,
  0x5F, 0xD6, 0x02, 0x30, 0x40, 0xF8, 0x1F, 0x06, 0x27, 0x9C, 0x43, 0xDC,
  0x81, 0xDC, 0x81, 0xDC, 0x61, 0xDC, 0x79, 0x9C, 0x19, 0x1C, 0x0B, 0x1C,
  0x04, 0x1C, 0x0E, 0x1C, 0x1F, 0x1C, 0x07, 0xEF, 0x03, 0xCC, 0x00, 0x00,
  0x1F, 0x9F, 0x1F, 0xF1, 0x88, 0x38, 0xE8, 0x1C, 0x74, 0x06, 0x1E, 0x03,
  0x18, 0x89, 0x7E, 0x38, 0x87, 0x80, 0x80, 0xC1, 0x80, 0x61, 0xE0, 0x31,
  0x78, 0x10, 0x1F, 0x10, 0x03, 0xF0, 0x04, 0x00, 0xDB, 0x8C, 0x7E, 0x44,
  0x46, 0x60, 0x33, 0x01, 0x9C, 0x0C, 0x70, 0x71, 0xC3, 0x87, 0x1C, 0x30,
  0x71, 0x03, 0xD0, 0x0F, 0x84, 0x1F, 0xC0, 0x01, 0x00, 0x1F, 0xF0, 0x3F,
  0xF8, 0x61, 0x3C, 0x42, 0x1E, 0xC6, 0x06, 0x87, 0x06, 0x83, 0x83, 0x41,
  0xC3, 0x24, 0xC2, 0x18, 0x82, 0x01, 0x02, 0x1F, 0x04, 0x2F, 0xC8, 0x01,
  0xF0, 0x00, 0x00, 0x08, 0x01, 0xB7, 0x98, 0xFC, 0x88, 0x8C, 0xC0, 0x66,
  0x23, 0x3F, 0xF8, 0xFE, 0xC3, 0x87, 0x0E, 0x38, 0x60, 0xE2, 0x03, 0xA0,
  0x1F, 0x08, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0x83, 0xFA, 0x01, 0x84,
  0x18, 0x10, 0x20, 0x10, 0xE2, 0x20, 0xE6, 0x23, 0xFE, 0x39, 0xD0, 0x01,
  0xC1, 0xC3, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x10, 0x08, 0x40,
  0x0F, 0x00, 0x1E, 0x61, 0x87, 0xC6, 0x27, 0xB3, 0x04, 0xCC, 0x23, 0x39,
  0xCC, 0xFB, 0xB1, 0xC7, 0xE3, 0x9F, 0x86, 0x3E, 0x10, 0x9C, 0x86, 0x38,
  0x10, 0x79, 0x80, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xDE, 0x04, 0x30,
  0x10, 0x00, 0xE1, 0x81, 0xCF, 0x87, 0xCE, 0x0E, 0x1C, 0x1C, 0x70, 0x70,
  0xC0, 0xC3, 0x71, 0x0E, 0xE8, 0x21, 0xC1, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x1F, 0x81, 0x0F, 0x18, 0x3E, 0x80, 0x44, 0x04, 0x20, 0x60, 0x83,
  0x83, 0xFC, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x37, 0x81, 0xCE, 0x08,
  0x3C, 0x80, 0xF8, 0x1F, 0x80, 0x87, 0x84, 0x0F, 0x90, 0x08, 0x40, 0x41,
  0x03, 0x82, 0x0E, 0x07, 0xD8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x63, 0x80, 0x9F, 0x04, 0x9E, 0x10, 0x3F, 0x80, 0x30,
  0x00, 0x03, 0xF8, 0x04, 0x04, 0x0C, 0xE2, 0x19, 0x72, 0x1A, 0x39, 0x1E,
  0x39, 0x1E, 0x1E, 0x0E, 0x24, 0x07, 0xF0, 0x07, 0x38, 0x03, 0x18, 0x71,
  0x1C, 0xBA, 0x1F, 0x1C, 0x0C, 0x0F, 0x86, 0x18, 0xC1, 0xB8, 0x37, 0x06,
  0xF0, 0x8E, 0xF0, 0xC0, 0x18, 0x02, 0x00, 0xE0, 0x3E, 0x19, 0xFC, 0x1F,
  0x00, 0x1E, 0x38, 0xE0, 0xFF, 0xFD, 0xC4, 0x38, 0xE3, 0x20, 0x71, 0x8C,
  0x80, 0xC6, 0x3A, 0x03, 0x18, 0x45, 0x8C, 0x62, 0x0F, 0x11, 0x90, 0x04,
  0x42, 0xC0, 0x03, 0x1B, 0x00, 0x08, 0x4E, 0x06, 0x39, 0x38, 0x7D, 0xF8,
  0x7C, 0x3C, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0xFF, 0x5C, 0x87,
  0x8E, 0x83, 0x8E, 0x81, 0x87, 0x81, 0x84, 0xF9, 0x88, 0x78, 0x88, 0x08,
  0x98, 0x01, 0x98, 0x01, 0x18, 0x79, 0x1C, 0xBA, 0x0F, 0x1C, 0x0C, 0x03,
  0xC0, 0x0F, 0xC0, 0x63, 0xE3, 0x01, 0xC6, 0x01, 0xCC, 0x01, 0x9F, 0x03,
  0x1F, 0x02, 0x0E, 0x04, 0x08, 0x08, 0xE0, 0x23, 0xE0, 0x49, 0xF1, 0x00,
  0xFC, 0x00, 0x1E, 0x0C, 0x3F, 0x9C, 0x10, 0xF7, 0x10, 0x33, 0xC8, 0x18,
  0xF4, 0x0C, 0x3D, 0x06, 0x0E, 0x7B, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x40, 0xF8, 0x20, 0x9F, 0xE0, 0x07, 0xE0, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x18, 0xF8, 0x60, 0x38, 0x60,
  0x1C, 0x60, 0x0C, 0x7C, 0x0C, 0x3E, 0x04, 0x0E, 0x04, 0x04, 0x04, 0x38,
  0x38, 0x7C, 0xFA, 0x9F, 0x1E, 0x07, 0xEC, 0x00, 0x00, 0x1F, 0x1E, 0x0F,
  0xEB, 0xC6, 0x3C, 0x71, 0x07, 0x0E, 0x80, 0xC3, 0xE0, 0x38, 0x84, 0x06,
  0x40, 0x89, 0xF8, 0x1C, 0x4E, 0x00, 0x11, 0x80, 0x04, 0x70, 0x72, 0x1C,
  0x7F, 0x03, 0xC3, 0x80, 0xE0, 0x03, 0xC0, 0x1F, 0xF8, 0x43, 0xC1, 0x00,
  0x04, 0x00, 0x08, 0x1F, 0x12, 0xFF, 0x23, 0xE2, 0x63, 0x02, 0xC0, 0x09,
  0xC0, 0x11, 0xF0, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xC3, 0xE2,
  0x03, 0xF4, 0x19, 0xC8, 0x60, 0x08, 0xE0, 0x0A, 0xF0, 0x08, 0xE0, 0x00,
  0xC0, 0x71, 0x83, 0xF2, 0x00, 0x78, 0x00, 0x78, 0x80, 0x7E, 0x00, 0x1E,
  0x08, 0xC8, 0xC3, 0x27, 0x1C, 0x1C, 0x38, 0x70, 0xF1, 0xC1, 0xC7, 0x03,
  0x0C, 0x08, 0x30, 0x40, 0xC3, 0x03, 0x1E, 0x3C, 0x9F, 0x3C, 0x38, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x9E, 0x1F, 0xF3, 0x88, 0x38, 0xE8, 0x1C,
  0x74, 0x06, 0x12, 0x03, 0x10, 0x89, 0x1C, 0x38, 0x8F, 0x00, 0x83, 0xC1,
  0x80, 0xE3, 0xE0, 0x22, 0x78, 0x10, 0x1F, 0x10, 0x03, 0xF0, 0x1F, 0x37,
  0xC3, 0xFE, 0x47, 0x10, 0xF6, 0x39, 0x03, 0xB0, 0xE8, 0x0D, 0x82, 0x40,
  0x6E, 0x21, 0x13, 0x73, 0x87, 0x11, 0xDE, 0x01, 0x06, 0x78, 0x10, 0x21,
  0xC7, 0x81, 0x06, 0x4E, 0x1C, 0x20, 0x3D, 0xFA, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xF8, 0xF7, 0xF3, 0x90, 0xF6, 0x81, 0x82, 0x06, 0x04, 0x1F, 0x0A,
  0xFC, 0x11, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x3A, 0xE0, 0xF3, 0xE5,
  0xC7, 0x00, 0x00, 0x00, 0x1F, 0x9E, 0x1F, 0xF3, 0x88, 0x38, 0xE8, 0x1C,
  0x74, 0x06, 0x1E, 0x03, 0x10, 0x89, 0x18, 0x38, 0x8E, 0x00, 0x87, 0x00,
  0x43, 0xC0, 0x40, 0xE0, 0x72, 0x70, 0x7E, 0x18, 0x06, 0x0C, 0x20, 0x0C,
  0x0C, 0x0C, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x83, 0x88, 0x0C, 0x40, 0x63,
  0x02, 0x0C, 0x20, 0x07, 0x80, 0xFE, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x20,
  0x37, 0x81, 0x4E, 0x08, 0x39, 0x80, 0xF0, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB7, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDF, 0x08, 0x18, 0x3C, 0x66, 0xC1, 0xFF, 0x80, 0xC9,
  0x90, 0x08, 0x0F, 0x09, 0xCC, 0xC4, 0x63, 0x31, 0x98, 0xCC, 0x77, 0x9D,
  0x80, 0x00, 0x0C, 0x58, 0x1C, 0x0E, 0x03, 0x21, 0xF0, 0xCC, 0x66, 0x31,
  0x18, 0x8C, 0x4E, 0x43, 0xC0, 0xC0, 0x00, 0x18, 0x59, 0x32, 0x14, 0x0C,
  0x18, 0x30, 0x7A, 0x78, 0x60, 0x20, 0x38, 0x0F, 0x03, 0xE0, 0x78, 0xCC,
  0x63, 0x31, 0x98, 0xCC, 0x4E, 0x23, 0xE0, 0x60, 0x18, 0x59, 0x32, 0x34,
  0x8E, 0x18, 0x30, 0x7A, 0x78, 0x00, 0xF5, 0x90, 0x43, 0xE7, 0x1C, 0x61,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x08, 0x0F, 0x09, 0xCC, 0x64,
  0x23, 0x11, 0x9C, 0xC6, 0x73, 0x1F, 0x80, 0xC0, 0x66, 0x21, 0xE0, 0x0C,
  0x58, 0x1C, 0x0E, 0x03, 0x41, 0xF0, 0xCC, 0x66, 0x33, 0x19, 0x8C, 0xC6,
  0x67, 0xB1, 0x90, 0x10, 0x10, 0x30, 0x00, 0x31, 0x88, 0x06, 0x3A, 0xC6,
  0x31, 0x8C, 0x63, 0x98, 0x18, 0xE1, 0x08, 0x31, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0E, 0x2B, 0x10, 0x0E, 0x47, 0xCF, 0x31, 0xFB, 0x0C,
  0x30, 0xC3, 0x0C, 0x7C, 0x40, 0x0E, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x7C, 0x40, 0xCC, 0xC7, 0xFF, 0x99, 0x98, 0xCC, 0xC6, 0x66,
  0x33, 0x31, 0x99, 0x8C, 0xCC, 0xFF, 0x7B, 0x31, 0x80, 0x62, 0x1D, 0xE3,
  0xB0, 0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x7B, 0xCC, 0x60, 0x0C, 0x7C,
  0x6E, 0x67, 0x63, 0x63, 0x62, 0x62, 0xFC, 0x10, 0x40, 0x40, 0x39, 0x8D,
  0xC3, 0x31, 0x98, 0xC6, 0x62, 0x31, 0x79, 0x3F, 0x07, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x08, 0x1C, 0x27, 0x46, 0x46, 0xC6, 0xE6, 0x66, 0x76, 0x3E,
  0x02, 0x02, 0x02, 0x02, 0x64, 0xFE, 0xD9, 0xA3, 0x06, 0x0C, 0x18, 0x7C,
  0x20, 0x0E, 0x01, 0x19, 0x7F, 0x44, 0x44, 0x6E, 0x36, 0x43, 0x72, 0xFC,
  0x08, 0x08, 0x21, 0x0C, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x1F, 0x10, 0x61,
  0x1C, 0xE3, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x7F, 0xC6, 0x60,
  0xC0, 0x63, 0x3F, 0xDC, 0x67, 0x31, 0x88, 0xC4, 0x46, 0x22, 0x3E, 0x06,
  0x00, 0x80, 0x08, 0x00, 0xC4, 0x6E, 0xEE, 0x77, 0x76, 0x63, 0x66, 0x36,
  0x63, 0x66, 0x36, 0x72, 0xF3, 0xC6, 0x18, 0x00, 0x00, 0x00, 0x65, 0xD9,
  0xD3, 0x06, 0x0C, 0x18, 0x34, 0x79, 0x64, 0x08, 0x08, 0xCF, 0x00, 0x40,
  0x20, 0x18, 0x8F, 0xE3, 0x31, 0x9C, 0xC6, 0x63, 0x31, 0x98, 0x9E, 0x42,
  0x40, 0x40, 0x40, 0x40, 0x10, 0xE5, 0x86, 0x25, 0xE3, 0x93, 0x4E, 0x38,
  0xE3, 0x48, 0xC0, 0x04, 0x63, 0x0C, 0x30, 0xC3, 0x08, 0xC0, 0x83, 0x0C,
  0x30, 0xC3, 0x07, 0xFF, 0xFF, 0x80, 0x81, 0x83, 0x0C, 0x30, 0xC3, 0x04,
  0x0C, 0x43, 0x0C, 0x30, 0xC3, 0x38, 0xFE,
};

const GFXglyph UnifrakturMaguntia_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 14, 5, 0, -14 },
  { 8, 7, 5, 8, 0, -14 },
  { 13, 9, 12, 10, 1, -13 },
  { 27, 7, 16, 8, 1, -15 },
  { 41, 13, 14, 14, 1, -14 },
  { 64, 10, 13, 11, 1, -13 },
  { 81, 4, 5, 4, 0, -14 },
  { 84, 5, 17, 5, 0, -16 },
  { 95, 5, 17, 5, 0, -16 },
  { 106, 7, 8, 7, 0, -15 },
  { 113, 6, 7, 8, 1, -10 },
  { 119, 3, 5, 4, 0, -3 },
  { 121, 5, 4, 6, 1, -8 },
  { 124, 4, 3, 4, 0, -3 },
  { 126, 9, 16, 10, 1, -15 },
  { 144, 9, 14, 9, 0, -14 },
  { 160, 6, 14, 6, 0, -14 },
  { 171, 9, 13, 9, 0, -13 },
  { 186, 9, 14, 9, 0, -14 },
  { 202, 9, 14, 9, 0, -14 },
  { 218, 9, 14, 9, 0, -14 },
  { 234, 9, 14, 9, 0, -14 },
  { 250, 8, 13, 9, 0, -13 },
  { 263, 9, 14, 9, 0, -14 },
  { 279, 9, 14, 9, 0, -14 },
  { 295, 4, 10, 4, 0, -10 },
  { 300, 4, 12, 3, 0, -10 },
  { 306, 6, 7, 6, 0, -9 },
  { 312, 7, 4, 8, 0, -8 },
  { 316, 6, 7, 6, 0, -9 },
  { 322, 7, 15, 9, 1, -15 },
  { 336, 12, 12, 12, 0, -9 },
  { 354, 16, 14, 16, 0, -14 },
  { 382, 17, 15, 18, 0, -15 },
  { 414, 13, 15, 14, 0, -15 },
  { 439, 16, 16, 16, 0, -15 },
  { 471, 13, 15, 14, 1, -15 },
  { 496, 15, 18, 15, 0, -15 },
  { 530, 14, 15, 15, 1, -14 },
  { 557, 14, 18, 15, 0, -15 },
  { 589, 13, 16, 14, 0, -14 },
  { 615, 14, 19, 14, 0, -14 },
  { 649, 16, 14, 16, 0, -14 },
  { 677, 11, 14, 11, 0, -14 },
  { 697, 22, 15, 22, 0, -14 },
  { 739, 16, 14, 18, 1, -14 },
  { 767, 15, 14, 15, 0, -14 },
  { 794, 17, 17, 18, 0, -14 },
  { 831, 16, 15, 16, 0, -14 },
  { 861, 18, 14, 19, 0, -14 },
  { 893, 15, 14, 15, 0, -14 },
  { 920, 15, 14, 15, 0, -14 },
  { 947, 14, 15, 14, 0, -14 },
  { 974, 17, 15, 18, 0, -15 },
  { 1006, 21, 14, 22, 0, -14 },
  { 1043, 14, 15, 14, 0, -15 },
  { 1070, 17, 18, 17, 0, -15 },
  { 1109, 13, 16, 13, 0, -14 },
  { 1135, 3, 16, 4, 0, -15 },
  { 1141, 12, 14, 2, -4, -13 },
  { 1162, 3, 16, 4, 0, -15 },
  { 1168, 8, 5, 8, 0, -14 },
  { 1173, 9, 1, 9, 0, 2 },
  { 1175, 3, 4, 10, 3, -14 },
  { 1177, 9, 11, 9, 0, -10 },
  { 1190, 9, 15, 9, 0, -14 },
  { 1207, 7, 10, 7, 0, -10 },
  { 1216, 9, 14, 9, 0, -14 },
  { 1232, 7, 10, 7, 0, -10 },
  { 1241, 6, 18, 5, 0, -15 },
  { 1255, 9, 14, 9, 0, -10 },
  { 1271, 9, 17, 9, 0, -14 },
  { 1291, 5, 14, 5, 0, -14 },
  { 1300, 6, 18, 5, -1, -14 },
  { 1314, 6, 14, 7, 0, -14 },
  { 1325, 6, 14, 5, 0, -14 },
  { 1336, 13, 10, 14, 1, -10 },
  { 1353, 10, 10, 10, 0, -10 },
  { 1366, 8, 10, 8, 0, -10 },
  { 1376, 9, 16, 9, 0, -12 },
  { 1394, 8, 14, 9, 0, -10 },
  { 1408, 7, 10, 7, 0, -10 },
  { 1417, 8, 12, 8, 0, -12 },
  { 1429, 6, 13, 6, 0, -13 },
  { 1439, 10, 10, 10, 0, -10 },
  { 1452, 9, 11, 9, 0, -11 },
  { 1465, 12, 13, 14, 1, -12 },
  { 1485, 7, 15, 8, 0, -11 },
  { 1499, 9, 15, 9, 0, -12 },
  { 1516, 6, 14, 7, 0, -10 },
  { 1527, 6, 16, 7, 0, -16 },
  { 1539, 1, 17, 3, 1, -16 },
  { 1542, 6, 16, 7, 0, -16 },
  { 1554, 7, 1, 7, 0, -6 },
};

const GFXfont UnifrakturMaguntia_Regular20pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular20pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular20pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR20PT7B_H_
