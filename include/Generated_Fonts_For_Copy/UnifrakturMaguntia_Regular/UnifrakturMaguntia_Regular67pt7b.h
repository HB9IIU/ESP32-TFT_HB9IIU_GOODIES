#ifndef _UNIFRAKTURMAGUNTIA_REGULAR67PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0x60, 0x0F, 0x01, 0xF8, 0x3F, 0xCF, 0xFE, 0x7F, 0xF7,
  0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x60, 0x0F, 0x01, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0x81, 0xF0, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x38, 0x03, 0x80,
  0xF8, 0x0F, 0x83, 0xF8, 0x3F, 0x9F, 0xF8, 0xFF, 0xDF, 0xF1, 0xFF, 0x8F,
  0xE0, 0xFF, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x1E, 0x00, 0xF0, 0x3C,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x40, 0x10, 0x01, 0x80, 0x40, 0x02, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xC1, 0xE0, 0x1E,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC3, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00,
  0xF8, 0xFC, 0x00, 0xF1, 0xFE, 0x00, 0xC3, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x78, 0x03, 0xFE, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDE, 0x00,
  0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3C, 0x70, 0x00, 0xF8, 0x70, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x60, 0x7F, 0xC0, 0x00, 0x00, 0x0E, 0x1F, 0x1E, 0x00, 0x00,
  0x01, 0xC1, 0xE1, 0xF0, 0x00, 0x00, 0x38, 0x3E, 0x0F, 0x80, 0x00, 0x07,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x0E, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x38, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xE0, 0x0F, 0xC0, 0xFE,
  0x00, 0x1C, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0xFE, 0x00,
  0x78, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x1C, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x70, 0x00, 0x03, 0xE0, 0xF8, 0x0E, 0x00, 0x00, 0x1E,
  0x1F, 0x01, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0xFC,
  0x03, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0x70, 0x3F, 0xE0, 0x00, 0x00, 0x0E,
  0x07, 0x8F, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x3F, 0x07,
  0xE0, 0x00, 0x0E, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xC0, 0x7F, 0x07, 0xF0,
  0x00, 0x38, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1C, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x38, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x1C, 0x00, 0x03, 0xF0,
  0x7E, 0x03, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x70, 0x00, 0x01, 0xF0, 0x7C,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x1C,
  0x00, 0x00, 0x03, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF8, 0x1E, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x01, 0xFC, 0x0F,
  0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0xFE,
  0x0F, 0x00, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x01, 0xFC, 0x70, 0x00, 0x00,
  0x3F, 0x9C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xE0, 0x0F, 0x7F, 0xC0, 0x3C, 0x03, 0xC7,
  0xF8, 0x07, 0x00, 0xF0, 0xFF, 0x80, 0xE0, 0x3E, 0x0F, 0xF0, 0x18, 0x07,
  0xC1, 0xFF, 0x03, 0x01, 0xF8, 0x3F, 0xE0, 0x60, 0x3F, 0x03, 0xFE, 0x18,
  0x0F, 0xE0, 0x7F, 0xC3, 0x01, 0xFC, 0x07, 0xFC, 0xE0, 0x3F, 0x80, 0xFF,
  0x98, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x27,
  0xFC, 0x03, 0xFF, 0x1E, 0x7F, 0xC0, 0x3F, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0xDF, 0xF8,
  0xFF, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x78, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x33,
  0xF3, 0x8F, 0xC7, 0xCF, 0xDF, 0x8E, 0x3F, 0x7E, 0x39, 0xF9, 0xFC, 0xCF,
  0xE3, 0xF9, 0x7F, 0x8E, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x83, 0xF8, 0x63,
  0xF9, 0x7F, 0x9F, 0xCC, 0xFE, 0x7F, 0x31, 0xF9, 0xF8, 0xE7, 0xFF, 0xE7,
  0x8F, 0xC3, 0x9F, 0x30, 0x05, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0xC0, 0x3C, 0x0F, 0xC3, 0xFC, 0xFF, 0xC7,
  0xF8, 0x7F, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x01,
  0xC0, 0x78, 0x1F, 0x87, 0xFD, 0xFF, 0xCF, 0xE0, 0xF8, 0x0E, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07,
  0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00,
  0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0E, 0x3F, 0xC0, 0x83, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x3E, 0x00, 0xFF, 0xC3,
  0xC0, 0x07, 0xFE, 0x38, 0x00, 0x3F, 0xE7, 0x00, 0x03, 0xFE, 0x60, 0x00,
  0x1F, 0xE6, 0x00, 0x01, 0xFE, 0x60, 0x00, 0x1F, 0xE4, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x30, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00, 0x02,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1E, 0x07, 0xFF, 0x01, 0xC0, 0x0F, 0xFC, 0x0C, 0x00, 0x3F, 0xE0, 0xC0,
  0x00, 0xFF, 0x84, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF9, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xEF,
  0xF0, 0x00, 0x3F, 0x7F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0xF8, 0x7F, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x78, 0x07, 0xE0, 0x07,
  0x80, 0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xCF, 0xE0,
  0x00, 0x06, 0x7F, 0x00, 0x00, 0x63, 0xF8, 0x00, 0x06, 0x1F, 0xC0, 0x00,
  0x30, 0xFE, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x30, 0x3F, 0x80, 0x01, 0x81,
  0xFC, 0x00, 0x18, 0x0F, 0xE0, 0x01, 0x80, 0x7F, 0x00, 0x0C, 0x03, 0xF8,
  0x00, 0xC0, 0x1F, 0xC0, 0x06, 0x00, 0xFE, 0x00, 0x60, 0x07, 0xF0, 0x06,
  0x00, 0x3F, 0x80, 0x30, 0x01, 0xFC, 0x03, 0x00, 0x0F, 0xE0, 0x30, 0x00,
  0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x06,
  0x00, 0x01, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x87, 0xF8, 0x00, 0x0D, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0x83, 0xC0,
  0x07, 0xFE, 0x1C, 0x00, 0x0F, 0xF0, 0xC0, 0x00, 0x7F, 0x84, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xCF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0x7F, 0x80, 0x01, 0xFB, 0xFC, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xFC,
  0x7F, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xC0, 0x3F,
  0x80, 0x3C, 0x00, 0xFE, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x7E,
  0x00, 0x0F, 0x03, 0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x07,
  0xC0, 0x1F, 0xC0, 0x7C, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0x83,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x87, 0xFE, 0x07, 0xF8, 0xEF, 0xF0,
  0x7F, 0x98, 0x3F, 0x87, 0xFB, 0x01, 0xFC, 0x7F, 0xA0, 0x1F, 0xC7, 0xFE,
  0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xE7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F,
  0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00,
  0x7F, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0xE3,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xC0,
  0x01, 0xF8, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C,
  0x60, 0x00, 0x03, 0x88, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x03, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x78, 0x7E, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x3C, 0x1F, 0xE0,
  0x01, 0xE0, 0xFF, 0x80, 0x1E, 0x07, 0xFF, 0x00, 0xF0, 0x1F, 0xFE, 0x0F,
  0x00, 0xFF, 0xF8, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0x87, 0xFF, 0x80, 0x38, 0x0F, 0xFE, 0x03, 0x80, 0x3F,
  0xF8, 0x38, 0x00, 0x7F, 0xC3, 0xC0, 0x01, 0xFF, 0x3E, 0x00, 0x07, 0xF9,
  0xE0, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x3F, 0x81, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE7,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xF7, 0xF8,
  0x02, 0xFF, 0x3F, 0x80, 0x6F, 0xF3, 0xFC, 0x04, 0xFF, 0x1F, 0xE0, 0xCF,
  0xE0, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00,
  0x78, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83,
  0xF8, 0x01, 0xF8, 0x7F, 0x80, 0x1F, 0x87, 0xF8, 0x03, 0xF0, 0x3F, 0x80,
  0x3E, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x3C, 0x01, 0xFC, 0x07, 0x80,
  0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xF9, 0xFF, 0x9F, 0xF8,
  0xF8, 0x0E, 0x01, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x70, 0x1E,
  0x07, 0xE1, 0xFF, 0x7F, 0xF3, 0xF8, 0x3E, 0x03, 0x80, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x07, 0x00, 0xF8, 0x1F, 0xC7, 0xFE, 0x3F, 0xF0, 0xF8,
  0x07, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60,
  0x0F, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0xF8, 0x1F, 0xC0, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x7F, 0x1E, 0x00, 0x0F,
  0xC7, 0x80, 0x03, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBF, 0xC0,
  0x07, 0xEF, 0xF0, 0x01, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xE1, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x30,
  0x0F, 0x80, 0x0C, 0x03, 0xE0, 0x02, 0x00, 0x7C, 0x01, 0x80, 0x1F, 0x80,
  0xC0, 0x03, 0xF0, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x70,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x00,
  0x7D, 0xF1, 0xE1, 0xF0, 0x03, 0xFF, 0xE3, 0xC3, 0xE0, 0x1F, 0x3F, 0x87,
  0x8F, 0x80, 0x7C, 0x3F, 0x07, 0x1F, 0x01, 0xF0, 0x7E, 0x0E, 0x3C, 0x07,
  0xE0, 0xFC, 0x3C, 0x78, 0x1F, 0x81, 0xF0, 0x79, 0xF0, 0x3E, 0x07, 0xE0,
  0xF3, 0xE0, 0xFC, 0x0F, 0xC1, 0xE7, 0xC1, 0xF8, 0x1F, 0x03, 0xCF, 0x87,
  0xE0, 0x7E, 0x0F, 0x1F, 0x0F, 0xC0, 0xFC, 0x1E, 0x3E, 0x1F, 0x83, 0xF0,
  0x7C, 0x7C, 0x7E, 0x07, 0xE0, 0xF0, 0xF8, 0xFC, 0x1F, 0xC3, 0xC0, 0xF1,
  0xF8, 0x7F, 0x8F, 0x81, 0xE1, 0xF9, 0xFF, 0x3E, 0x03, 0xC3, 0xFF, 0xFF,
  0xF8, 0xF7, 0xC3, 0xFC, 0xFF, 0xE1, 0xE7, 0x83, 0xE0, 0x7E, 0x07, 0x8F,
  0x80, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x7F, 0xFF,
  0x80, 0x3F, 0xE0, 0x0E, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xC0, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x38, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x70, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x06,
  0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x60, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x06, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x60, 0x00, 0x01, 0xFF, 0x07,
  0xF8, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x70, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0xF0,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0x07, 0xFF, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x7F, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x7F, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x01,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x0C, 0x7F, 0xFE, 0x03, 0x3F, 0xE7, 0x00, 0x01, 0xFF,
  0xF9, 0xE3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x1C,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC4, 0x03, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0xFB, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x78, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x07, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF1, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFC, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x1C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x80, 0x78, 0x00, 0x40, 0xFC, 0x3F, 0xFF,
  0xF0, 0x0F, 0x00, 0x18, 0x3E, 0x3F, 0xFF, 0xFE, 0x01, 0xF0, 0x1C, 0x0F,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0xFC, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0xE7, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xFE, 0xF0,
  0x1F, 0x80, 0x00, 0x7E, 0x03, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x31, 0xFF,
  0xFE, 0x07, 0xE0, 0x06, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0x00, 0x0E, 0xFF, 0xF8, 0x0F, 0xC0, 0x07, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x40, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x38, 0x00, 0x00, 0x3F, 0xFC, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xC3,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x0C, 0x07, 0xFF,
  0xE0, 0x3F, 0x80, 0x07, 0x00, 0x3F, 0xFC, 0x07, 0xC0, 0x01, 0xC0, 0x01,
  0xFF, 0xC1, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x87, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF3, 0x80, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x60, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xCC, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFD, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xB0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF6, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xCC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xF9, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x18, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xE3, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0x81, 0xE0, 0x30, 0x7F, 0x80, 0x00, 0xF0, 0x0F, 0xFC, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x3F,
  0x3C, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x60, 0xFF, 0x80, 0x01, 0xF0, 0x03,
  0x1F, 0xFF, 0xE0, 0x3F, 0x00, 0x37, 0xFF, 0xFC, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x1D, 0xFF, 0xF0, 0x0F, 0xC0, 0x07, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0x10, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xE0,
  0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xF8, 0x3F,
  0xE2, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xCF, 0xF8, 0xFF,
  0x80, 0x7F, 0xFC, 0x3F, 0x8F, 0xF8, 0x03, 0xFF, 0xE1, 0xE0, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x1C, 0x00, 0x00, 0x03, 0xFF, 0xC3, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0x00,
  0x00, 0x13, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x38, 0xFF, 0x80, 0x3C, 0x00,
  0x00, 0x70, 0x3F, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x70, 0x00,
  0x07, 0xFC, 0x00, 0xF0, 0x70, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x30, 0x00,
  0x07, 0xFF, 0x01, 0xFC, 0x38, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x38, 0x00,
  0x03, 0xFF, 0xC7, 0xFF, 0x1C, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x0E, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0xFF, 0xF9, 0xFC, 0x03, 0x80,
  0x0C, 0x7F, 0xF0, 0x78, 0x01, 0xF8, 0xFC, 0x7F, 0xF8, 0x30, 0x00, 0x3F,
  0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x01, 0x81, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xC3, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x47, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x73, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0xC1, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0xFF, 0xF0, 0x0F, 0xC0,
  0x07, 0x00, 0x7F, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0x3F, 0xFC, 0x1F, 0x80,
  0x3C, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x7C, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x00, 0x03, 0xC0, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x0E, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x80,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xFC, 0x01, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x3F, 0xF0,
  0x00, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x0F, 0xF8,
  0x01, 0xE0, 0x00, 0xFC, 0x0F, 0xFC, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0xFC,
  0x07, 0x80, 0x01, 0xF8, 0x03, 0xFE, 0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x07,
  0xFF, 0x20, 0x00, 0x00, 0x18, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xDE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x3F,
  0xC0, 0x1E, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x3C, 0x00, 0x0F, 0xC3, 0xFF,
  0xC0, 0x70, 0x00, 0x3F, 0x8F, 0xFF, 0xC0, 0xC0, 0x00, 0x7F, 0x33, 0xFF,
  0xC3, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x18, 0x3C, 0x00, 0x01,
  0xFF, 0xFF, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0x81, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0x8F, 0xF8, 0x00, 0x03, 0xFF,
  0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0xE1, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0xC3, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xC6, 0x03,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xE0, 0x06, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0x00, 0x00,
  0x7C, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x1E,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x73, 0xFF, 0xF0, 0x00, 0x0F, 0x06,
  0x07, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0x0F, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0x80, 0x78, 0x00, 0x1F, 0x81, 0xFF,
  0xFC, 0x03, 0x80, 0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0x3C, 0x00, 0x3F, 0x87,
  0xFF, 0xFF, 0x01, 0xC0, 0x03, 0xF8, 0x70, 0x3F, 0xF0, 0x1E, 0x00, 0x3F,
  0x8E, 0x01, 0xFF, 0x81, 0xE0, 0x07, 0xF8, 0xC0, 0x0F, 0xF8, 0x0E, 0x00,
  0x7F, 0x88, 0x00, 0x7F, 0xC0, 0xE0, 0x07, 0xF8, 0x80, 0x07, 0xFC, 0x0E,
  0x00, 0x7F, 0xC8, 0x00, 0x7F, 0xE0, 0xE0, 0x07, 0xFC, 0x80, 0x03, 0xFF,
  0x0E, 0x00, 0x7F, 0xE8, 0x00, 0x3F, 0xF8, 0xE0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x1E, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE1, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x78, 0x1C, 0x00, 0x1F, 0xFC, 0x00, 0x06, 0x03, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0x80, 0x30, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x06, 0x00, 0x00,
  0xFF, 0xF0, 0x1F, 0xC1, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0xFE, 0x30, 0x00,
  0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xDB, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x70, 0x00, 0xFF, 0xC0,
  0xFF, 0xFE, 0x06, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF9, 0xC0, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x7F,
  0x80, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x7E, 0x1F, 0xE0, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0xF0,
  0x00, 0x07, 0xE1, 0xFF, 0x00, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x07, 0xE1,
  0xFF, 0x80, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xC0, 0x00,
  0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x37,
  0xFF, 0xFF, 0x00, 0x06, 0xC3, 0xFF, 0xFC, 0x00, 0xE0, 0x0F, 0xFF, 0xF0,
  0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8E, 0x3F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFD, 0xEF, 0xFF, 0xB0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xC0, 0x78, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x10,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x20, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x40, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xFE, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF1, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x83, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xC0, 0x0E, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x38,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xF7, 0x00, 0x7C, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x00, 0x06, 0x00, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x08,
  0x03, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x0C,
  0x30, 0x07, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x39, 0xF8, 0x0C, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x67, 0xF8, 0x30, 0x03, 0xFF, 0x02, 0x0F,
  0xFF, 0xC1, 0x9F, 0xFC, 0x60, 0x03, 0xFF, 0xBC, 0x3F, 0xFF, 0x87, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0xC3, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xCC, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF1, 0x80,
  0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0xFB, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xC0, 0x60, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xE0, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x00, 0x60, 0x00, 0x00,
  0x3F, 0x80, 0x0E, 0x00, 0x78, 0x7F, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0x80, 0x38, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x80, 0x78,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0x80, 0xF0, 0x00, 0x01, 0xF0, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x70,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0xC0, 0x03, 0xFF, 0x82, 0x0F, 0xFF, 0xC1, 0x80, 0x01, 0xFF, 0xFE,
  0x1D, 0xFF, 0xE3, 0x80, 0x00, 0xFF, 0xFC, 0x30, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1E, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7E, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0xFC, 0xC0, 0x00, 0x00,
  0x30, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x60, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3C,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x07, 0xFF, 0xC7,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0x3F, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x06, 0x00, 0x00,
  0x1F, 0xF0, 0x1F, 0xFF, 0x03, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xC1,
  0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x18, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x8C, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE3,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF1, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x70, 0x00, 0x87, 0xF8, 0x00, 0x03, 0xFE, 0x0E, 0x01, 0xC3,
  0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x3E, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0xC3, 0xC0,
  0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x7E, 0x60, 0x00, 0x3E, 0x18, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE7, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x02, 0x6F, 0xFF,
  0xF8, 0x18, 0x7F, 0xE0, 0x60, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x38, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x18, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC6, 0x03, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0xFC,
  0x80, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0xB0, 0x03, 0xFE, 0x01, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC6,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x38, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0x80, 0x02, 0x01, 0xF8, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xC0,
  0x3F, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x07, 0xCF, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x70, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFC, 0x0C, 0x00, 0x03, 0xFF, 0x08, 0x1F, 0xFF, 0xC3, 0x00, 0x00,
  0x7F, 0xFB, 0x84, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x40, 0x00,
  0x1F, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x1F, 0x01, 0x80, 0x3F, 0xFF, 0xFC, 0x3E, 0x01, 0x03, 0xFF,
  0xFF, 0xFC, 0x7C, 0x03, 0xBF, 0xFF, 0xFC, 0x3C, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x19, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1B, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x37, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x2F, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x19, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x31, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE3, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0x83, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFE, 0x04, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xBF, 0x80, 0x00,
  0x1C, 0x7F, 0xFF, 0xE6, 0x00, 0x00, 0x70, 0x3F, 0xFF, 0x8C, 0x00, 0x03,
  0xC0, 0x3F, 0xFE, 0x18, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x30, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x60, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x4F, 0xFF,
  0x80, 0x00, 0x03, 0x83, 0x8F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xC0, 0x00,
  0x02, 0x1F, 0xFF, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x1E, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x70, 0x01, 0xF0,
  0x18, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x40, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x18, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x80,
  0xFF, 0xC0, 0x0F, 0xE0, 0x0C, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x37, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0x3F, 0xC0, 0x61, 0xFF, 0xF0, 0x71, 0xFF, 0x04, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x86, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE6, 0x07, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0xF2, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xC3, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x81, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0x80, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x00,
  0x30, 0x00, 0x20, 0x7C, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x30, 0x7C, 0x00,
  0xFF, 0x80, 0x03, 0xC0, 0xE0, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xC7, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x80, 0x3F, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFC, 0x3B, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x38, 0x73, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFB,
  0x01, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x3F,
  0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x38, 0x00, 0xFF, 0xC0, 0x3F, 0x00,
  0x1F, 0xFE, 0x03, 0x80, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x3C,
  0x00, 0x1F, 0xF8, 0x1E, 0x00, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0x7F, 0xC0,
  0xF0, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x03, 0xFF, 0x07, 0x00, 0x00, 0x1F,
  0xF0, 0xF8, 0x00, 0x0F, 0xF8, 0x38, 0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00,
  0x7F, 0xF1, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFF, 0x8C, 0x00,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x0F, 0xC7, 0xFE, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x1F, 0xF0, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xC0,
  0x0F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x00, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0x80, 0x06, 0x07, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0x00, 0x60, 0x3C, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xC0,
  0x1E, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x02,
  0x20, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0x80, 0x60, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xC3, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE0, 0xF8, 0x00, 0xFF, 0x8E,
  0x7F, 0x83, 0xC0, 0x01, 0xFF, 0x30, 0x7C, 0x1E, 0x00, 0x03, 0xFC, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xF6, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x47, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x9F, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x04,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x13, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xF8, 0x00,
  0x00, 0x3E, 0x03, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x08, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x61, 0xFF, 0xE0, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x04, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x38, 0x3F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x60, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x7F, 0xE0, 0x3F,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xC1, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x0C, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x38, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x70,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xF8, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0E,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x08, 0x1F, 0x00, 0x7F,
  0x00, 0x0E, 0x00, 0x60, 0x7E, 0x01, 0xFE, 0x00, 0x0F, 0x07, 0x80, 0xF8,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x18, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x70, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xE3, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x63, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xF8,
  0x01, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x18,
  0x00, 0x00, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x3E,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC7, 0xFF,
  0xF8, 0x00, 0x00, 0xE3, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xE0,
  0x00, 0x1C, 0x00, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x01, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xBF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xBF,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x03, 0xF1, 0xF8,
  0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x3F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x38,
  0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0x9F, 0xFC, 0x00, 0x38, 0xFF, 0xF8, 0x07, 0x07, 0xFF, 0x00, 0xE0,
  0x3F, 0xE0, 0x1E, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x3C, 0x00, 0xFE,
  0x07, 0xC0, 0x0F, 0xE0, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80,
  0xFE, 0x07, 0xFC, 0x0F, 0xE2, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0xEF, 0xFC,
  0x1F, 0xFC, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3C,
  0x01, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x40, 0x78, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x21,
  0xE0, 0x00, 0x03, 0x3E, 0x00, 0x00, 0x17, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x00, 0xFE, 0x01, 0x80, 0x0F, 0xE0,
  0x38, 0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x07, 0x80,
  0xFE, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xF8,
  0x1C, 0x03, 0xFF, 0xE1, 0x80, 0x1F, 0xFF, 0xB0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1B, 0xF8, 0x07, 0x3F, 0xC0, 0xE1, 0xFC,
  0x1E, 0x1F, 0xE1, 0xE0, 0xFE, 0x3C, 0x0F, 0xF7, 0xC0, 0x7F, 0x7C, 0x07,
  0x87, 0xC0, 0x20, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0xFF, 0xC0, 0x1C, 0x0F, 0xF8,
  0x3F, 0x80, 0xFF, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0x1F, 0xC0, 0x03, 0xC3, 0xF8, 0x00, 0x78, 0x7F, 0x00, 0x0F, 0x0F,
  0xE0, 0x03, 0xC1, 0xFC, 0x00, 0x78, 0x3F, 0x80, 0x0E, 0x07, 0xFC, 0x01,
  0xC1, 0xFF, 0xC0, 0x70, 0x7F, 0xFE, 0x0C, 0x03, 0xFF, 0xF3, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0x7F, 0x00, 0x73, 0xF8, 0x07, 0x0F, 0xE0, 0x78,
  0x7F, 0x03, 0xC1, 0xFC, 0x3C, 0x0F, 0xE3, 0xE0, 0x7F, 0x1F, 0x01, 0xFC,
  0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xF3, 0xF0, 0x1E, 0x1F, 0x87,
  0x80, 0xFC, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x86, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x63, 0xF8,
  0x02, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x19, 0xFF, 0xE0, 0x03, 0x0F, 0xFF,
  0xC0, 0x70, 0x3F, 0xF8, 0x0E, 0x01, 0xFF, 0x01, 0xE0, 0x07, 0xF0, 0x3E,
  0x00, 0x1E, 0x07, 0xE0, 0x00, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0xF3, 0xFC, 0x0F, 0xFC, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0x60, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x10, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03,
  0xF0, 0x03, 0xC0, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x07, 0x00, 0x0F, 0xC1,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x0F, 0x80, 0x00, 0x61,
  0xF0, 0x00, 0x02, 0x3F, 0x00, 0x00, 0x33, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0x00, 0x0F, 0xE0,
  0x70, 0x00, 0xFE, 0x0F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFE, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x81, 0xFF, 0x30, 0xF8,
  0x3F, 0xFE, 0x1F, 0x01, 0xFF, 0xC1, 0xE0, 0x07, 0xF8, 0x1C, 0x00, 0x3F,
  0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xFC, 0xCF, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF1, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xB0, 0x03, 0xE2, 0x00, 0x78, 0x20, 0x1E,
  0x06, 0x07, 0x80, 0x43, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x78, 0x20, 0x3C, 0x06, 0x0F, 0x80, 0x63, 0xE0, 0x44,
  0xFC, 0x38, 0xDF, 0x8F, 0x0F, 0xE3, 0xE1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87,
  0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x83, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0xF0, 0x60, 0x3C, 0x06, 0x0F, 0x00, 0x43, 0xE0, 0x04, 0xFC, 0x00, 0xDF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x04, 0x0F, 0xF8, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x7F, 0xF9, 0xFF, 0xE0,
  0x7F, 0xEE, 0xFF, 0xB7, 0xFF, 0x8D, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x8F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x01,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x33, 0xFF, 0x8F, 0xFE, 0x07, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0x80,
  0x06, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x08, 0x00, 0x20,
  0x00, 0x78, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0xE0, 0x3F, 0x00,
  0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0x8F, 0xFE, 0xCF, 0xFF, 0x23,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFF,
  0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF1, 0x3F, 0xF8, 0x1F, 0xEC, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0x81, 0xF8, 0x03, 0xFC, 0x03, 0xC0, 0x07,
  0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xCF, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0xC0, 0xFE,
  0x0F, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xE3,
  0xF8, 0x00, 0xF8, 0xFE, 0x00, 0x3C, 0x3F, 0x80, 0x1E, 0x0F, 0xF8, 0x07,
  0x07, 0xFF, 0x03, 0x83, 0xFF, 0xF0, 0xC0, 0x3F, 0xFF, 0x60, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x10, 0x0F, 0xF8, 0x03, 0x80, 0x7F,
  0xE0, 0x3C, 0x03, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xEF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x80, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80,
  0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x3E, 0x03, 0xF8, 0x01, 0xF0, 0xFF, 0xC0, 0x0F, 0x0F, 0xFF,
  0x00, 0xF0, 0x7F, 0xFE, 0x07, 0x07, 0xFF, 0xF8, 0x70, 0x3F, 0xFF, 0xF3,
  0x01, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x01, 0xF1, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x02, 0x7F, 0xF8, 0x03, 0x8F, 0xFF,
  0xC1, 0xC0, 0xFF, 0xE0, 0xF0, 0x1F, 0xF0, 0x78, 0x01, 0xFC, 0x1E, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xE0, 0x1F, 0x87, 0xF8, 0x07, 0xE0, 0xFF,
  0x01, 0xF8, 0x3F, 0xE0, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0xE7, 0xE0,
  0x3F, 0xF1, 0xF8, 0x07, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1C, 0x07,
  0xE0, 0x06, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x80, 0xF0, 0x06, 0x07, 0xF0, 0x3C, 0x1F, 0xC1,
  0xF0, 0xFF, 0x8F, 0xE3, 0xFF, 0x7F, 0x9F, 0xFF, 0xFF, 0x47, 0xFB, 0xFC,
  0x1F, 0xE7, 0xE0, 0x7F, 0x0F, 0x01, 0xFC, 0x38, 0x07, 0xF0, 0x60, 0x1F,
  0xC1, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x10, 0x07, 0xFC, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x80, 0x0F, 0x00, 0x60, 0x0F,
  0xF0, 0x18, 0x07, 0xFF, 0x1E, 0x03, 0xFF, 0xFF, 0x81, 0x1F, 0xFF, 0xC0,
  0xC1, 0xFF, 0xE0, 0x60, 0x1F, 0xF0, 0x38, 0x01, 0xF8, 0x1E, 0x00, 0x0C,
  0x07, 0x80, 0x06, 0x01, 0xF0, 0x03, 0x00, 0x7E, 0x01, 0xE0, 0x1F, 0xC0,
  0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFC, 0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x1F, 0x03, 0xFC, 0x07, 0x80, 0x7F,
  0x00, 0xC0, 0x0F, 0xC0, 0x60, 0x01, 0xF0, 0x10, 0x00, 0x78, 0x1F, 0x00,
  0x0E, 0x0F, 0xF8, 0x07, 0x07, 0xFF, 0x81, 0x81, 0xFF, 0xF8, 0xC0, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x18, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x03, 0xC0, 0x3F, 0x80, 0x1F, 0x81, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x3F, 0xF8, 0x8F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC4, 0xFF, 0xF3, 0x7F, 0xE3, 0xFF, 0xF9, 0xFF,
  0x81, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x03, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x01, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0xE0, 0x7F, 0x83, 0xFF, 0x81, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00,
  0x1F, 0xC0, 0x70, 0x00, 0xFF, 0xC1, 0x80, 0x03, 0xFF, 0x8C, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xC0, 0x0F, 0x00, 0x0C, 0x07,
  0xFE, 0x01, 0xF0, 0x03, 0xC0, 0xFF, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x8F, 0xFF, 0x3F, 0xF8, 0x0F, 0xF3, 0xBF,
  0xF8, 0xFF, 0x80, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xFE,
  0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0x80, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x01,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3E, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3C, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0x00, 0x7F, 0x81, 0xFF,
  0xC1, 0xC0, 0x0F, 0xF0, 0x7F, 0xFE, 0x30, 0x03, 0xFF, 0x83, 0xFF, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x10, 0x03, 0xC0, 0x18, 0x07, 0xE0, 0x38,
  0x07, 0xF0, 0x7C, 0x0F, 0xF8, 0xFC, 0x0F, 0xF9, 0xFE, 0x1F, 0xFD, 0xFE,
  0x13, 0xFF, 0xFF, 0x01, 0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x3C,
  0x01, 0xFC, 0x38, 0x01, 0xFC, 0x10, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x20,
  0x01, 0xFE, 0x30, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x1C, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xF0,
  0x0C, 0x01, 0xF8, 0x07, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x0F, 0xF8, 0x03, 0x80, 0x7F,
  0xE0, 0x7E, 0x03, 0xFF, 0x07, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x80,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE,
  0x00, 0x7C, 0x07, 0xF0, 0x03, 0xE0, 0x3F, 0x84, 0x3F, 0x03, 0xFE, 0x61,
  0xF0, 0x3F, 0xFC, 0x0F, 0x00, 0xFF, 0xE0, 0x78, 0x01, 0xFE, 0x07, 0x80,
  0x03, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x20, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x03, 0x07, 0x01, 0x81, 0xF0, 0xC0, 0x7F, 0xB0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x06, 0x7F, 0x81, 0x8F,
  0xF8, 0x60, 0xFF, 0x0C, 0x0F, 0xE3, 0x01, 0xFC, 0xE0, 0x1F, 0xDC, 0x03,
  0xFB, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xEE, 0x00, 0x7D, 0xC0, 0x0F, 0xB8, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x0F,
  0x0C, 0x01, 0xE1, 0x80, 0x38, 0x18, 0x06, 0x01, 0x01, 0x80, 0x10, 0x60,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 12, 49, 16, 2, -48 },
  { 75, 23, 19, 27, 2, -48 },
  { 130, 30, 38, 35, 2, -43 },
  { 273, 23, 54, 28, 2, -51 },
  { 429, 44, 46, 48, 2, -47 },
  { 682, 35, 42, 38, 2, -41 },
  { 866, 11, 19, 13, 1, -48 },
  { 893, 15, 55, 17, 1, -53 },
  { 997, 15, 55, 17, 1, -53 },
  { 1101, 22, 26, 24, 0, -49 },
  { 1173, 22, 24, 27, 3, -34 },
  { 1239, 11, 18, 12, 0, -10 },
  { 1264, 18, 13, 20, 2, -26 },
  { 1294, 11, 11, 13, 1, -10 },
  { 1310, 32, 53, 35, 2, -50 },
  { 1522, 29, 48, 32, 1, -47 },
  { 1696, 20, 46, 22, 1, -46 },
  { 1811, 28, 45, 30, 1, -45 },
  { 1969, 29, 46, 31, 1, -46 },
  { 2136, 29, 46, 31, 1, -46 },
  { 2303, 29, 47, 31, 1, -47 },
  { 2474, 28, 47, 30, 1, -47 },
  { 2639, 27, 46, 29, 1, -46 },
  { 2795, 29, 47, 31, 1, -47 },
  { 2966, 28, 48, 30, 1, -48 },
  { 3134, 11, 33, 13, 1, -32 },
  { 3180, 12, 40, 11, 0, -32 },
  { 3240, 18, 24, 19, 0, -31 },
  { 3294, 23, 14, 26, 2, -27 },
  { 3335, 18, 24, 19, 0, -31 },
  { 3389, 26, 49, 31, 2, -48 },
  { 3549, 39, 40, 41, 1, -31 },
  { 3744, 52, 49, 55, 1, -48 },
  { 4063, 58, 50, 60, 0, -49 },
  { 4426, 43, 50, 46, 2, -49 },
  { 4695, 51, 52, 54, 2, -49 },
  { 5027, 44, 50, 47, 2, -49 },
  { 5302, 48, 57, 51, 1, -49 },
  { 5644, 48, 50, 52, 2, -48 },
  { 5944, 47, 61, 49, 1, -52 },
  { 6303, 43, 58, 46, 1, -49 },
  { 6615, 45, 66, 48, 1, -49 },
  { 6987, 52, 50, 54, 1, -48 },
  { 7312, 36, 48, 38, 1, -47 },
  { 7528, 71, 51, 74, 2, -47 },
  { 7981, 56, 48, 59, 2, -47 },
  { 8317, 48, 50, 51, 1, -48 },
  { 8617, 57, 58, 60, 1, -47 },
  { 9031, 51, 53, 53, 1, -48 },
  { 9369, 59, 49, 62, 2, -48 },
  { 9731, 47, 49, 51, 2, -48 },
  { 10019, 47, 48, 50, 2, -47 },
  { 10301, 45, 51, 48, 1, -47 },
  { 10588, 57, 50, 59, 1, -49 },
  { 10945, 69, 49, 72, 1, -48 },
  { 11368, 46, 50, 48, 1, -49 },
  { 11656, 55, 60, 57, 1, -49 },
  { 12069, 42, 58, 45, 1, -49 },
  { 12374, 10, 53, 12, 1, -50 },
  { 12441, 41, 47, 7, -13, -44 },
  { 12682, 10, 53, 12, 1, -50 },
  { 12749, 25, 18, 28, 1, -47 },
  { 12806, 32, 5, 31, -1, 7 },
  { 12826, 10, 13, 34, 11, -47 },
  { 12843, 28, 36, 31, 2, -34 },
  { 12969, 28, 48, 30, 1, -46 },
  { 13137, 20, 35, 24, 2, -34 },
  { 13225, 27, 48, 30, 2, -47 },
  { 13387, 21, 35, 24, 2, -34 },
  { 13479, 21, 60, 16, -1, -49 },
  { 13637, 28, 49, 31, 2, -35 },
  { 13809, 28, 59, 30, 1, -47 },
  { 14016, 16, 48, 18, 1, -47 },
  { 14112, 19, 59, 16, -3, -47 },
  { 14253, 19, 49, 22, 1, -47 },
  { 14370, 19, 49, 18, 1, -47 },
  { 14487, 44, 36, 48, 2, -35 },
  { 14685, 30, 36, 34, 2, -34 },
  { 14820, 26, 35, 28, 0, -34 },
  { 14934, 29, 53, 30, 0, -40 },
  { 15127, 26, 49, 29, 1, -35 },
  { 15287, 22, 36, 24, 1, -35 },
  { 15386, 26, 43, 28, 1, -42 },
  { 15526, 18, 45, 21, 1, -43 },
  { 15628, 30, 36, 34, 2, -35 },
  { 15763, 30, 39, 30, -1, -38 },
  { 15910, 43, 41, 46, 2, -39 },
  { 16131, 24, 49, 26, 1, -35 },
  { 16278, 29, 51, 31, 1, -40 },
  { 16463, 19, 47, 22, 2, -35 },
  { 16575, 18, 53, 22, 1, -52 },
  { 16695, 4, 55, 11, 3, -52 },
  { 16723, 18, 53, 22, 1, -52 },
  { 16843, 21, 5, 25, 2, -22 },
};

const GFXfont UnifrakturMaguntia_Regular67pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular67pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular67pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR67PT7B_H_
