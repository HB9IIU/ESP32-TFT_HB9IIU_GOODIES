#ifndef _UNIFRAKTURMAGUNTIA_REGULAR44PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x18, 0x3C, 0x7E, 0xFF, 0x7E, 0x7E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x18, 0x3C, 0x7E, 0x7F, 0x18, 0x18, 0x00, 0x10, 0x10,
  0x70, 0x31, 0xF0, 0xF7, 0xF3, 0xF3, 0xE3, 0xE3, 0xC3, 0xC3, 0x03, 0x06,
  0x06, 0x08, 0x08, 0x10, 0x10, 0x40, 0x41, 0x00, 0x80, 0x01, 0xC3, 0x80,
  0x3C, 0x38, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x38, 0x70, 0x07, 0x87,
  0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0E,
  0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7C, 0x03, 0xFC, 0x0F,
  0x0C, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x01,
  0xDF, 0x81, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xD8, 0x1F, 0xB8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3B, 0x80, 0x77, 0x00, 0xE6, 0x03, 0x86, 0x0E, 0x07, 0xF8, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0x10,
  0xFE, 0x00, 0x01, 0xCE, 0x78, 0x00, 0x18, 0xF1, 0xC0, 0x01, 0x87, 0x8F,
  0x00, 0x0C, 0x7C, 0x78, 0x00, 0xC3, 0xE3, 0xC0, 0x0C, 0x1E, 0x1F, 0x00,
  0xC0, 0xF0, 0xF8, 0x0C, 0x07, 0xC7, 0x80, 0xC0, 0x3E, 0x3C, 0x0C, 0x00,
  0xF1, 0xE0, 0x60, 0x07, 0x8E, 0x06, 0x00, 0x1C, 0xF0, 0x60, 0x00, 0x7F,
  0x06, 0x1E, 0x01, 0xF0, 0x63, 0xF8, 0x00, 0x06, 0x1C, 0xE0, 0x00, 0x61,
  0xC7, 0x80, 0x06, 0x1E, 0x1C, 0x00, 0x30, 0xF0, 0xF0, 0x03, 0x07, 0x87,
  0x80, 0x30, 0x3C, 0x3C, 0x03, 0x01, 0xE1, 0xE0, 0x30, 0x0F, 0x0F, 0x03,
  0x00, 0x78, 0x78, 0x30, 0x03, 0xC3, 0xC1, 0x80, 0x1E, 0x1C, 0x18, 0x00,
  0x71, 0xE1, 0x80, 0x01, 0xCE, 0x18, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xF1, 0xC0, 0x03, 0xE3, 0x00,
  0x07, 0xCE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0,
  0x7F, 0x07, 0xC1, 0xBE, 0x07, 0x06, 0x7E, 0x0C, 0x1C, 0x7C, 0x18, 0x78,
  0xFC, 0x20, 0xF0, 0xF8, 0x41, 0xE1, 0xF9, 0x87, 0xC1, 0xF2, 0x0F, 0x83,
  0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xE0, 0xBF, 0x07, 0xE3, 0x3F, 0x0F,
  0xFC, 0x3F, 0xF7, 0xF0, 0x1F, 0x83, 0xC0, 0x10, 0x71, 0xF7, 0xF3, 0xE3,
  0x87, 0x0C, 0x18, 0x20, 0x41, 0x00, 0x00, 0x81, 0x83, 0x01, 0x81, 0x81,
  0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x70, 0x80,
  0x30, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x18, 0x0C,
  0x0C, 0x0C, 0x1C, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1F, 0x00, 0xFE, 0x8F,
  0x3B, 0xEF, 0x27, 0x9E, 0x5F, 0x3F, 0xFE, 0x03, 0x80, 0xFF, 0xF9, 0xF5,
  0xF3, 0xC9, 0xEF, 0x3B, 0xC2, 0xFE, 0x43, 0xF0, 0x01, 0xC0, 0x01, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x10, 0x30, 0xF3, 0xFF, 0xE3, 0xC3, 0x86, 0x0C, 0x10,
  0x20, 0x80, 0x0F, 0xF1, 0xFF, 0x3F, 0xE4, 0x00, 0x00, 0xC7, 0xFC, 0x7F,
  0xCF, 0xC0, 0x20, 0x61, 0xE7, 0xE7, 0xE7, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3C, 0x78,
  0x0F, 0x07, 0x01, 0xE0, 0xF0, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E,
  0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0x87, 0x81, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x00,
  0xF1, 0xE0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1B, 0xF0, 0x87, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE1, 0xFF, 0xF0,
  0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xE1, 0xFE, 0x60, 0x1F, 0x98,
  0x03, 0xEC, 0x00, 0xFB, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x10, 0x60, 0x04, 0x30, 0x01, 0x08, 0x00, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0xE1, 0xFC, 0x30, 0x0F, 0xC4, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xDC, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x73, 0xE0, 0x1C,
  0x3C, 0x03, 0x03, 0xC1, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xBE, 0x00, 0x1B, 0xE0, 0x03, 0x3E, 0x00, 0x23, 0xE0, 0x06, 0x3E, 0x00,
  0xC3, 0xE0, 0x0C, 0x3E, 0x01, 0x83, 0xE0, 0x10, 0x3E, 0x03, 0x03, 0xE0,
  0x60, 0x3E, 0x04, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x10,
  0x01, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x27,
  0xC0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xCF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xC0,
  0xFE, 0x30, 0x0F, 0xCC, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFB, 0x80, 0x1E, 0xF8, 0x03, 0xDF, 0x00,
  0x7B, 0xE0, 0x0E, 0x3C, 0x03, 0x87, 0xC0, 0x60, 0x78, 0x38, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0xC7, 0x80, 0x60, 0xF0, 0x38, 0x3E, 0x1C, 0x0F,
  0x87, 0x03, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF1, 0xF0, 0xF8, 0xFE, 0x3E, 0x67, 0xCF, 0xB0, 0xFB, 0xE8,
  0x3E, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0x9F, 0x01, 0xE3,
  0xC0, 0x70, 0x70, 0x38, 0x1E, 0x0E, 0x01, 0xC6, 0x00, 0x1F, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEE, 0x00, 0x16, 0x00, 0x1A,
  0x00, 0x09, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xC1, 0x80, 0x70, 0x1C, 0x1C, 0x01,
  0x87, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0x63, 0xC0, 0x1C, 0x78, 0x03,
  0x8F, 0xC0, 0x61, 0xFC, 0x1C, 0x1F, 0xE7, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1C, 0xFF, 0x87, 0x07, 0xF1, 0xC0, 0x7F,
  0x38, 0x07, 0xEE, 0x00, 0x7D, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x0E,
  0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x70,
  0x38, 0x18, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0x8E, 0x01, 0xC1, 0xE0,
  0x60, 0x78, 0x38, 0x0F, 0x1E, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0x7C, 0x1F, 0xCF, 0xDB, 0xF1, 0xFC, 0xFC,
  0x3E, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF9, 0xC0, 0x3C, 0x78,
  0x0F, 0x1F, 0x03, 0x87, 0xC0, 0xE1, 0xF0, 0x70, 0x3C, 0x18, 0x07, 0x8C,
  0x00, 0xFE, 0x00, 0x20, 0x61, 0xE7, 0xE7, 0xE7, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x18, 0x79, 0xF9, 0xF9, 0xC1, 0x00, 0x00, 0x10,
  0x18, 0x3C, 0x7E, 0x3F, 0x1C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x18, 0x3C, 0x7E, 0xFE, 0x1E, 0x0E, 0x0C, 0x0C, 0x08, 0x08,
  0x10, 0x00, 0x10, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0,
  0x3F, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x00,
  0x07, 0xF8, 0x0E, 0x0F, 0x0C, 0x03, 0xCC, 0x01, 0xE6, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00,
  0x0E, 0x01, 0x07, 0x01, 0x01, 0xC0, 0x80, 0x70, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x38, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xE1,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0xF0, 0x3F, 0xCE, 0x70, 0x3F, 0xE3,
  0x78, 0x3D, 0xF1, 0xB8, 0x3C, 0x70, 0xDC, 0x3C, 0x78, 0x6E, 0x3C, 0x3C,
  0x77, 0x1E, 0x1C, 0x3B, 0x9E, 0x1E, 0x19, 0xCF, 0x0F, 0x1C, 0xE7, 0x8F,
  0x9C, 0x73, 0xCF, 0x9C, 0x38, 0xFD, 0xFE, 0x6E, 0x3C, 0xFC, 0x77, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0x01, 0xFF, 0xE0, 0x03, 0x81, 0xFF, 0xFC, 0x03, 0xC0, 0xE0, 0xFF,
  0x83, 0xF0, 0x20, 0x0F, 0xE3, 0xFC, 0x18, 0x01, 0xFC, 0x3F, 0x04, 0x00,
  0x3F, 0x0F, 0xC3, 0x00, 0x0F, 0xC3, 0xF0, 0xC0, 0x01, 0xF8, 0xFC, 0x30,
  0x00, 0x7E, 0x3F, 0x0C, 0x00, 0x1F, 0x8F, 0xC3, 0x80, 0x07, 0xC3, 0xF0,
  0xFE, 0x01, 0xF0, 0xFC, 0x1F, 0xC0, 0x7C, 0x3F, 0x03, 0xF8, 0x1E, 0x0F,
  0xC0, 0x7F, 0x07, 0x83, 0xF0, 0x07, 0xC3, 0xC0, 0xFC, 0x00, 0x70, 0xE0,
  0x3F, 0x00, 0x08, 0x70, 0x0F, 0xC0, 0x06, 0x18, 0x03, 0xF0, 0x00, 0x0C,
  0x00, 0xFC, 0x00, 0x06, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0x00,
  0x7F, 0xF8, 0x3F, 0xC4, 0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x1F, 0xFC, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x87, 0xE0, 0x3F, 0xFF, 0xF4, 0x0F,
  0xC0, 0xF0, 0x1F, 0xF0, 0x3F, 0x07, 0x80, 0x1F, 0xC0, 0xFC, 0x1C, 0x00,
  0x7F, 0x01, 0xF8, 0x60, 0x00, 0xFC, 0x07, 0xE1, 0x80, 0x03, 0xF0, 0x0F,
  0xE6, 0x00, 0x07, 0xC0, 0x3F, 0x18, 0x00, 0x1F, 0x00, 0x70, 0x60, 0x00,
  0x7C, 0x07, 0x01, 0x80, 0x01, 0xF0, 0x7E, 0x07, 0x00, 0x07, 0x87, 0xFE,
  0x0E, 0x01, 0x1E, 0x7F, 0xFC, 0x1C, 0x18, 0x73, 0xFF, 0xF8, 0x1F, 0x81,
  0x80, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x3F,
  0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x00, 0x38,
  0x07, 0xFF, 0x80, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x0C, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x1E, 0xE1, 0xF0, 0x07, 0x83, 0x3F,
  0xD0, 0xF0, 0x17, 0xFF, 0x0E, 0x01, 0xFF, 0xE1, 0xE0, 0x30, 0x78, 0x3E,
  0x0E, 0x01, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x7C, 0x7F, 0x80, 0x07,
  0xC3, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xC1, 0xFF, 0x00, 0xFC, 0x0F,
  0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0x78, 0x03, 0xF8,
  0x07, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0xFE, 0x0C, 0x00, 0x0F, 0xF1, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x70, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFE, 0x03,
  0xE0, 0x10, 0xFF, 0x81, 0xE0, 0x18, 0x0F, 0xF0, 0x70, 0x0E, 0x00, 0xFE,
  0x38, 0x07, 0x80, 0x1F, 0x8E, 0x01, 0xE0, 0x03, 0xF3, 0x00, 0xFC, 0x00,
  0x7C, 0xC0, 0x3F, 0x80, 0x0F, 0xB0, 0x0F, 0xF0, 0x03, 0xEC, 0x01, 0xFE,
  0x00, 0x7B, 0x00, 0x7F, 0xC0, 0x1E, 0x40, 0x0F, 0xF0, 0x03, 0x98, 0x01,
  0xFE, 0x00, 0xE3, 0x00, 0x3F, 0x80, 0x38, 0x60, 0x07, 0xE0, 0x0E, 0x07,
  0xF0, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x31, 0x00, 0x02, 0x00, 0x7F, 0x80, 0x01,
  0x80, 0x3F, 0xF8, 0x00, 0x40, 0x1F, 0xFF, 0x80, 0x20, 0x1D, 0xFF, 0xF8,
  0x30, 0x04, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x0C, 0x00, 0x0F, 0x30, 0xF8, 0x01, 0xE0, 0x4F, 0xF4, 0x1E, 0x02,
  0xFF, 0xE0, 0xE0, 0x1F, 0xFE, 0x0F, 0x01, 0x83, 0xC0, 0xF0, 0x38, 0x04,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0xF8, 0xFE, 0x0E, 0x07, 0xC7, 0xF8, 0xFC, 0x3E, 0x1F,
  0xEF, 0xFD, 0xF0, 0x7F, 0xFF, 0xDF, 0x83, 0xFE, 0x7C, 0x7C, 0x0F, 0xF9,
  0xC3, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFE, 0x01, 0xE0, 0x03, 0xF0,
  0x0E, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x7F, 0x06, 0x00, 0x03, 0xFE, 0x40,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x67, 0xE0, 0x3F, 0xFF, 0x8F, 0x00,
  0x0F, 0xFE, 0x38, 0x00, 0x27, 0xF0, 0x60, 0x00, 0xC3, 0xC0, 0xC0, 0x03,
  0x03, 0x03, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x7E,
  0x01, 0x18, 0x00, 0xFE, 0x07, 0x10, 0x00, 0xFE, 0x1F, 0x20, 0x01, 0xFC,
  0x7F, 0x60, 0x03, 0xFD, 0xFE, 0x60, 0x03, 0xFF, 0xF8, 0x60, 0x03, 0xFC,
  0xE0, 0x70, 0xE7, 0xF8, 0x80, 0x3F, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x03, 0x00, 0x01,
  0xC0, 0x8F, 0x80, 0x07, 0x80, 0x5F, 0xC0, 0x0F, 0x00, 0x6F, 0xE0, 0x0F,
  0x00, 0x87, 0xF0, 0x1E, 0x03, 0x03, 0xFC, 0x3E, 0x06, 0x01, 0xFC, 0x3C,
  0x1E, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0x60, 0x7C, 0x3E, 0x00, 0xC0, 0x7C,
  0x3E, 0x01, 0x80, 0x7C, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x0F, 0xF8, 0xFC,
  0x1F, 0xBF, 0xF8, 0xFC, 0x1F, 0xC1, 0xFC, 0xFC, 0x0F, 0xE0, 0xFE, 0xFC,
  0x0F, 0xF0, 0x7E, 0xFC, 0x07, 0xF0, 0x3E, 0x7E, 0x03, 0xF8, 0x3E, 0x7E,
  0x01, 0xF8, 0x3F, 0x7E, 0x01, 0xF8, 0x1F, 0x7F, 0x00, 0xF8, 0x1E, 0x3F,
  0x00, 0xF0, 0x1E, 0x3F, 0x00, 0xE0, 0x3E, 0x1F, 0x81, 0xC0, 0x3C, 0x0F,
  0xC3, 0x00, 0x3C, 0x07, 0xE2, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x70, 0x01,
  0xF8, 0x00, 0xE0, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xDF,
  0xE0, 0x00, 0x04, 0x3F, 0xF0, 0x00, 0x60, 0x7F, 0x80, 0x01, 0x80, 0xF8,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x80,
  0x0F, 0x80, 0x07, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xFC, 0x01,
  0xF8, 0x3F, 0xF8, 0x07, 0xF1, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC7, 0x81, 0xC0, 0x1F,
  0x7F, 0x03, 0x00, 0x7B, 0xFE, 0x18, 0x01, 0xEB, 0xFC, 0x40, 0x0F, 0x03,
  0xFE, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x07, 0x00, 0x10,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0x07, 0xFC, 0x01, 0xC0, 0x1F, 0xF2, 0x38, 0x00, 0xFF, 0xE3, 0x00, 0x07,
  0xF8, 0x30, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x3C, 0x03, 0x00, 0x07, 0xC0, 0x38, 0x00,
  0x7C, 0x01, 0x80, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0x78, 0x37, 0xF0,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x1F,
  0xC0, 0x01, 0xE3, 0xFE, 0x00, 0x1E, 0x7F, 0xF0, 0x01, 0xC8, 0x7F, 0x80,
  0x1C, 0x03, 0xFC, 0x01, 0x80, 0x1F, 0xE0, 0x30, 0x00, 0xFF, 0xCC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF0, 0x7F,
  0xC0, 0x0E, 0x00, 0xFF, 0x90, 0xE0, 0x03, 0xFF, 0x86, 0x00, 0x0F, 0xF0,
  0x30, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x38, 0x03, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0xC0, 0x01,
  0xF0, 0x03, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x7E, 0x00, 0x38, 0x19, 0xF8,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x0F, 0xF0,
  0x00, 0x38, 0xFF, 0xE0, 0x01, 0x8C, 0xFF, 0x80, 0x0C, 0x03, 0xFE, 0x00,
  0xC0, 0x0F, 0xF8, 0x0C, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x3F, 0x81, 0xC0, 0x1E, 0x1F, 0xF8,
  0x30, 0x07, 0x8F, 0xFF, 0x0E, 0x03, 0xE6, 0x1F, 0xC1, 0x80, 0xF9, 0x01,
  0xF8, 0x60, 0x3E, 0x40, 0x7E, 0x18, 0x0F, 0xA0, 0x0F, 0xC6, 0x03, 0xF8,
  0x03, 0xF9, 0x80, 0xFF, 0x00, 0x7E, 0x60, 0x3F, 0xC0, 0x0E, 0x18, 0x07,
  0xF0, 0x03, 0x0C, 0x01, 0xFE, 0x03, 0x06, 0x00, 0x3F, 0x83, 0xE3, 0x00,
  0x07, 0xF3, 0xFD, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x1E, 0x07, 0x81, 0xF8, 0x0F, 0xC0, 0xC0, 0x7E, 0x07, 0xF8, 0x20,
  0x1F, 0xC2, 0xFF, 0x18, 0x03, 0xFA, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0x80, 0x03, 0x83, 0xC0, 0x1E, 0x01, 0xE0, 0x78, 0x01, 0xE1, 0xE0,
  0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3E, 0x00,
  0x1E, 0x7E, 0x00, 0x3C, 0xFC, 0x00, 0x79, 0xFC, 0x01, 0xE3, 0xFC, 0x03,
  0xC3, 0xF8, 0x0F, 0x03, 0xF3, 0xFC, 0x07, 0xF1, 0xE0, 0x07, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x18, 0x3F, 0xF8, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x0C,
  0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xE3, 0xFF,
  0x00, 0xFF, 0xFE, 0xFF, 0xE4, 0x7F, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0x7E,
  0x0E, 0x03, 0xFC, 0x0F, 0xE0, 0x7C, 0x18, 0x01, 0xFC, 0x0F, 0xC0, 0xFC,
  0x60, 0x01, 0xFC, 0x1F, 0x81, 0xF8, 0x80, 0x01, 0xF8, 0x1F, 0x83, 0xF1,
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF2, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xF4,
  0x00, 0x07, 0xE0, 0x7C, 0x07, 0x8C, 0x00, 0x07, 0xC0, 0xF8, 0x04, 0x08,
  0x00, 0x0F, 0x81, 0xF0, 0x10, 0x1C, 0xF8, 0x1F, 0x03, 0xE0, 0x40, 0x1F,
  0xF8, 0x1E, 0x03, 0xC1, 0x80, 0x1F, 0xF0, 0x3C, 0x07, 0x87, 0x00, 0x1F,
  0xE0, 0x78, 0x0E, 0x1C, 0x00, 0x00, 0x40, 0xE0, 0x1C, 0x78, 0x00, 0x00,
  0x81, 0xC0, 0x38, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x71, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0xC7, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x8F, 0xC0, 0x00, 0x00,
  0x30, 0x06, 0x1F, 0x80, 0x03, 0xC0, 0x40, 0x0C, 0x1F, 0x80, 0x0F, 0xC1,
  0x9E, 0x10, 0x3F, 0x00, 0x7F, 0xC2, 0xFE, 0x40, 0x3F, 0x91, 0xFF, 0xC9,
  0xFF, 0x80, 0x7F, 0xE2, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xD1,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F,
  0xFF, 0x8C, 0x7F, 0x03, 0xE7, 0xFE, 0x41, 0xF8, 0x38, 0x07, 0xFC, 0x07,
  0xC1, 0x00, 0x1F, 0xE0, 0x3F, 0x18, 0x00, 0x7F, 0x01, 0xF8, 0x80, 0x01,
  0xF8, 0x0F, 0xC4, 0x00, 0x0F, 0xC0, 0x3F, 0x20, 0x00, 0x3F, 0x01, 0xFD,
  0x00, 0x01, 0xF8, 0x07, 0x8C, 0x00, 0x07, 0xC0, 0x30, 0x20, 0x00, 0x3E,
  0x03, 0x01, 0xFF, 0x81, 0xF0, 0x30, 0x07, 0xFE, 0x07, 0x81, 0x80, 0x1F,
  0xF0, 0x3C, 0x1C, 0x00, 0x3C, 0x81, 0xE1, 0xC0, 0x00, 0x04, 0x0E, 0x0E,
  0x00, 0x00, 0x20, 0x70, 0xF0, 0x00, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x00,
  0x18, 0x3E, 0x00, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x00, 0x0C, 0x0F, 0x80,
  0x03, 0xC0, 0x60, 0x7E, 0x00, 0x7F, 0x06, 0x03, 0xF8, 0x07, 0xFC, 0x20,
  0x0F, 0xEE, 0x6F, 0xF2, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xC0, 0x7F, 0xF0, 0x06, 0x00, 0x1F, 0xF0, 0x18, 0x00, 0x0F, 0xF0,
  0x70, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0x0F, 0x3F,
  0xF0, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x3C, 0x3F,
  0xF0, 0x00, 0x70, 0x0F, 0xE0, 0x00, 0xE0, 0x07, 0xC0, 0x01, 0xC0, 0x03,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x06, 0x01, 0x98, 0x00, 0x0C, 0x0F, 0xC0,
  0x00, 0x10, 0x7F, 0xC0, 0x00, 0x61, 0xFF, 0xE0, 0x00, 0x84, 0x7F, 0xE0,
  0x02, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x08, 0x00, 0x7F, 0xF0, 0x01, 0x80, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x7F,
  0xFF, 0x07, 0xE0, 0x07, 0x83, 0xFC, 0xFF, 0x80, 0x70, 0x0F, 0xFC, 0xFC,
  0x03, 0x00, 0x3F, 0x87, 0xF0, 0x18, 0x00, 0xFC, 0x3F, 0xC0, 0x80, 0x03,
  0xF0, 0xFF, 0x84, 0x00, 0x1F, 0x83, 0xFE, 0x20, 0x00, 0xFC, 0x0F, 0xF9,
  0x00, 0x03, 0xE0, 0x3F, 0xCC, 0x00, 0x1F, 0x00, 0xFF, 0x20, 0x00, 0xF8,
  0x03, 0xF9, 0x80, 0x07, 0xC0, 0x0F, 0xE3, 0x06, 0x3E, 0x00, 0x3F, 0x0F,
  0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00,
  0xF8, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x04,
  0x00, 0x0F, 0xF0, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x0F, 0xFF,
  0xC0, 0x60, 0x00, 0xE7, 0xFF, 0xCE, 0x00, 0x04, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0x9F, 0xC0, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0C, 0x07, 0xFF, 0x00, 0x18, 0x00,
  0x7F, 0xC0, 0x18, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0x03, 0xFC, 0x1E, 0x00,
  0x00, 0xFE, 0x0F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x03, 0xE1, 0xFE, 0x00, 0x00, 0xF0, 0xFF, 0xC0, 0x00, 0x78, 0x3F,
  0xF8, 0x00, 0x3C, 0x0F, 0xFE, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0x07, 0x00,
  0x3F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x0E, 0x60, 0x06, 0x30, 0x0F, 0xC0, 0x0F, 0xD0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFE, 0x0F, 0xF8, 0x31, 0xFF, 0x88, 0x7E,
  0x30, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF1,
  0xF0, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xFE, 0x33, 0xF8, 0x07, 0xFF, 0xFC, 0x81, 0xF8, 0x1E,
  0x03, 0xFD, 0x03, 0xF8, 0x38, 0x01, 0xFE, 0x03, 0xF0, 0xE0, 0x01, 0xFC,
  0x07, 0xE1, 0x80, 0x01, 0xF8, 0x0F, 0xE3, 0x00, 0x03, 0xF0, 0x0F, 0xF6,
  0x00, 0x03, 0xE0, 0x0F, 0x8C, 0x00, 0x07, 0xC0, 0x0C, 0x18, 0x00, 0x07,
  0x80, 0x30, 0x30, 0x00, 0x0F, 0x01, 0x80, 0x30, 0x00, 0x1E, 0x0C, 0x00,
  0x60, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x08, 0x79, 0xFC, 0x00, 0x78, 0xE0,
  0xF7, 0xFC, 0x00, 0x1E, 0x01, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xC3, 0xF8,
  0x00, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x00,
  0x1C, 0x0F, 0xC0, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x03, 0xC0, 0x60, 0x1F,
  0x80, 0x1F, 0xC1, 0x80, 0x3F, 0x80, 0x7F, 0x82, 0x00, 0x7F, 0x01, 0xFF,
  0xC8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x60, 0x0F, 0xFF, 0xFF, 0x80, 0x30, 0x3F, 0xFE, 0x01, 0x80,
  0x1F, 0xF8, 0x06, 0x00, 0x0F, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x10, 0x07, 0x00, 0x01,
  0xFC, 0x0E, 0x00, 0x0F, 0xFC, 0x3C, 0x20, 0x7F, 0xFE, 0x78, 0x23, 0xFF,
  0xFC, 0xF0, 0x3F, 0xFE, 0x0D, 0xE0, 0x7F, 0xF0, 0x0B, 0xC0, 0x7F, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x2F, 0x80, 0x00, 0x00,
  0x5F, 0x80, 0x00, 0x01, 0xBF, 0x80, 0x00, 0x02, 0x3F, 0x80, 0x00, 0x0C,
  0x7F, 0xC0, 0x00, 0x70, 0x7F, 0xF0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xE0, 0x7F, 0xF0, 0x07, 0x00,
  0x3F, 0xF8, 0x0C, 0x00, 0x1F, 0xFC, 0x70, 0x00, 0x4F, 0xFF, 0x60, 0x03,
  0x0F, 0xFC, 0x80, 0x0E, 0x07, 0xF1, 0x00, 0x3C, 0x03, 0x82, 0x00, 0x7C,
  0x00, 0x06, 0x01, 0xF8, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x0C, 0x03, 0xFC,
  0x00, 0x0C, 0x0B, 0xFC, 0x00, 0x07, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x03, 0xE0,
  0x00, 0xFC, 0x07, 0x80, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xFC, 0x18, 0x00,
  0x27, 0xFC, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x20, 0x03, 0xFF, 0x01, 0x80, 0x01, 0xFF, 0xDE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0xE0, 0x01, 0x81, 0xC1, 0x00, 0x38, 0x1C, 0x08, 0x07, 0x81, 0xE0,
  0x60, 0xFC, 0x1F, 0x02, 0x1F, 0xC0, 0xF8, 0x20, 0x7E, 0x07, 0xE0, 0x01,
  0xF0, 0x3F, 0x80, 0x0F, 0x81, 0xFE, 0x00, 0x7C, 0x07, 0xF0, 0x03, 0xE0,
  0x3F, 0xC0, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x0F,
  0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80,
  0x7C, 0x00, 0x38, 0x03, 0xE0, 0x01, 0x80, 0x1F, 0x00, 0x18, 0x00, 0xF8,
  0x01, 0x80, 0x07, 0xC0, 0x18, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0xC0, 0x1F, 0x81, 0xFF, 0x01, 0x7C, 0x33, 0xFC, 0x13, 0xF0, 0x0F, 0xFF,
  0x9F, 0xF0, 0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0x83, 0xF0, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0xFF, 0xE1,
  0xFF, 0x80, 0x3F, 0xFF, 0x98, 0xFC, 0x03, 0xFF, 0xFE, 0x83, 0xF0, 0x3C,
  0x07, 0xFC, 0x1F, 0xC1, 0xC0, 0x1F, 0xC0, 0x7E, 0x1C, 0x00, 0x7F, 0x03,
  0xF8, 0xC0, 0x01, 0xF8, 0x0F, 0xE6, 0x00, 0x07, 0xC0, 0x3C, 0x30, 0x00,
  0x3E, 0x00, 0xC1, 0x80, 0x01, 0xF0, 0x0C, 0x0C, 0x00, 0x07, 0x80, 0xC0,
  0x20, 0x00, 0x38, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x78, 0x04, 0x01, 0x1E,
  0x07, 0xE0, 0x18, 0x30, 0xE0, 0x3F, 0x80, 0x3E, 0x07, 0x01, 0xFE, 0x00,
  0x00, 0x30, 0x07, 0xF8, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00,
  0xFF, 0x00, 0x01, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0xE0, 0x00, 0x3E, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x06,
  0x01, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x00, 0x7F,
  0xE0, 0x30, 0x00, 0x01, 0xFF, 0xC2, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x38, 0x1F, 0xC0, 0x03, 0xFF, 0xC3, 0xE3,
  0xFF, 0x80, 0x3F, 0xFF, 0xB1, 0xA0, 0xFE, 0x03, 0xFF, 0xFF, 0x06, 0x03,
  0xF8, 0x3F, 0x0F, 0xF0, 0x30, 0x0F, 0xC1, 0xC0, 0x1F, 0xC3, 0x80, 0x7E,
  0x1C, 0x00, 0x7E, 0x1C, 0x01, 0xF8, 0xC0, 0x01, 0xF9, 0xE0, 0x0F, 0xC6,
  0x00, 0x0F, 0xCF, 0x00, 0x3F, 0xB0, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0x80,
  0x01, 0xF3, 0xE0, 0x02, 0x0C, 0x00, 0x07, 0x9F, 0x80, 0x30, 0x20, 0x00,
  0x3C, 0xFE, 0x03, 0x01, 0x80, 0x01, 0xC7, 0xF0, 0x3C, 0x04, 0x01, 0x0E,
  0x1F, 0xC3, 0xE0, 0x18, 0x10, 0xF0, 0x7E, 0x1F, 0x80, 0x7F, 0x07, 0x03,
  0xF0, 0xFF, 0x00, 0x00, 0x30, 0x0F, 0x87, 0xFC, 0x00, 0x03, 0x00, 0x7C,
  0x1F, 0xE0, 0x00, 0x10, 0x01, 0xE0, 0x7F, 0x80, 0x01, 0x00, 0x0F, 0x01,
  0xFC, 0x00, 0x50, 0x00, 0x70, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0x80, 0x1F,
  0x03, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x7F, 0xF8, 0x00, 0xF8, 0x03, 0x82,
  0x1F, 0xE0, 0x0F, 0xE0, 0x18, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x80, 0x01,
  0xFF, 0x1F, 0xFE, 0x08, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0xFF,
  0xE0, 0x7F, 0xC7, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0x8F, 0xF9, 0xF0, 0x7E,
  0x3F, 0xC7, 0x00, 0xFD, 0x8E, 0x18, 0x01, 0xF4, 0x00, 0xC0, 0x03, 0xF0,
  0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x10, 0x00, 0xF8, 0x00,
  0x40, 0x01, 0xE0, 0x01, 0x80, 0x0F, 0xFF, 0x03, 0x00, 0x7F, 0xFC, 0x07,
  0x1B, 0xFF, 0xE0, 0x07, 0x9F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x05, 0xF8,
  0x00, 0x08, 0x13, 0xF0, 0x00, 0xF8, 0xCF, 0xE0, 0x07, 0xFE, 0x3F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x82, 0xFF, 0x01, 0xFC, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xFC, 0xC7,
  0xF0, 0x3F, 0xFF, 0xE8, 0x3F, 0x07, 0x80, 0xFF, 0x81, 0xF8, 0x60, 0x07,
  0xF0, 0x1F, 0x8E, 0x00, 0x3F, 0x81, 0xF8, 0xC0, 0x01, 0xF8, 0x1F, 0xCC,
  0x00, 0x0F, 0x80, 0xFE, 0xC0, 0x00, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0x80,
  0x38, 0xC0, 0x00, 0x78, 0x02, 0x04, 0x00, 0x07, 0x00, 0xC0, 0x60, 0x00,
  0x70, 0x1C, 0x03, 0x00, 0x8F, 0x03, 0xC0, 0x1C, 0x70, 0xF0, 0x7E, 0x00,
  0x7C, 0x0E, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0x00, 0x1C, 0x07,
  0xF0, 0x00, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x30, 0x03, 0xF8, 0x00, 0x03,
  0x00, 0x1F, 0xC0, 0x00, 0x60, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x20, 0xFE, 0x00, 0x3F, 0x86, 0x0F, 0xE0, 0x07, 0xFF, 0xC0,
  0x7E, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x07,
  0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x01, 0x00, 0x00, 0x0F, 0x80,
  0x08, 0x00, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x78, 0x0F, 0xF0, 0x0E, 0x00, 0x7F, 0x03,
  0x80, 0x07, 0xE0, 0x60, 0x00, 0x7C, 0x0C, 0x00, 0x0F, 0x81, 0x80, 0x01,
  0xF0, 0x30, 0x00, 0x3E, 0x06, 0x00, 0x07, 0x80, 0x60, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x87, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF3, 0xFC, 0x00, 0x1C, 0xFF, 0xC0, 0x03, 0xA7, 0xFC, 0x00, 0x60,
  0x3F, 0xC0, 0x18, 0x03, 0xFC, 0x03, 0x00, 0x3F, 0xC0, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xC0,
  0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x71,
  0xE3, 0xE3, 0xC3, 0x83, 0x83, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x03, 0xFC, 0x03, 0x3F, 0xC1, 0x87, 0xF8, 0xE0, 0x78,
  0x38, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E,
  0x07, 0x8F, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x1F, 0x07, 0x87, 0xE1,
  0xE4, 0xFC, 0xFF, 0x3F, 0xDF, 0x87, 0xC3, 0xE0, 0xE0, 0xF0, 0x10, 0x0C,
  0x01, 0xE0, 0x21, 0xC0, 0x04, 0xE0, 0x01, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x0C, 0x0F, 0x87, 0x03, 0xE3,
  0xE0, 0xFB, 0xFC, 0x3F, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x1E,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x0E, 0x3E, 0x03, 0x8F,
  0x81, 0xE3, 0xE0, 0x70, 0xF8, 0x1C, 0x3E, 0x06, 0x1F, 0xE3, 0x03, 0xFF,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0xE0,
  0x1F, 0x80, 0xDF, 0x06, 0x3C, 0x38, 0xF9, 0xC1, 0xE7, 0x07, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xE0, 0x1E,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0x7F, 0x01, 0x87, 0xE3, 0xE0,
  0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x78, 0x0E, 0x3E, 0x03, 0x0F,
  0xC0, 0xC7, 0xFC, 0x20, 0x7F, 0xD0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x04, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0xDF, 0x06, 0x7C, 0x38, 0xF1,
  0xC3, 0xE7, 0x07, 0x9C, 0x1F, 0xF0, 0x3B, 0xC3, 0x0F, 0x70, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF8,
  0x07, 0xFF, 0x0F, 0xE0, 0x1E, 0x00, 0x30, 0x00, 0x06, 0x00, 0x7F, 0x47,
  0xFC, 0x3F, 0xE1, 0x1E, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x01, 0xE0,
  0x0F, 0xF9, 0xFF, 0xC3, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x19, 0xFF, 0x06, 0x0F, 0xE1, 0xC0, 0xF8, 0x78, 0x07, 0x0F, 0x00, 0xC3,
  0xC0, 0x38, 0x78, 0x07, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0xC3,
  0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xC1,
  0xFF, 0xF8, 0x3F, 0x0F, 0x03, 0x81, 0xE0, 0x40, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x1C, 0x03, 0x87, 0x80, 0xE0, 0x78, 0x18, 0x07,
  0x8C, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x70, 0x08, 0x70, 0x01, 0x38,
  0x00, 0x5E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x08,
  0x0F, 0x86, 0x03, 0xE3, 0xC0, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x78, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x07,
  0x8F, 0x81, 0xE3, 0xE0, 0x70, 0xFF, 0x1C, 0x7F, 0x8E, 0x07, 0xC3, 0x00,
  0xE1, 0x80, 0x10, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x04, 0x07, 0xC1, 0xF0,
  0x7C, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x10, 0x06, 0x03, 0xC1, 0xF8, 0x7F,
  0x2F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE4, 0x7F, 0x1F, 0x83, 0xC0, 0x70, 0x08,
  0x01, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x0F, 0x81, 0xFE, 0x1F, 0xC2, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF2, 0x0E, 0x11, 0xC0, 0xE0, 0x00, 0x00,
  0x30, 0x1C, 0x83, 0x04, 0x70, 0x4E, 0x33, 0xE7, 0x3E, 0xF3, 0xEF, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x23, 0xFC, 0x7F, 0xC0, 0x78, 0x03, 0x00, 0x10, 0x00,
  0x30, 0x1C, 0x87, 0x04, 0xF0, 0x4E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3F, 0x27, 0xFC, 0x3F, 0x80, 0x78, 0x03, 0x00, 0x10, 0x10,
  0x08, 0x04, 0x01, 0xC0, 0xF0, 0x70, 0x0F, 0x8F, 0xC7, 0xC0, 0xFC, 0xFE,
  0x7F, 0x87, 0xFD, 0xFE, 0xFF, 0x4F, 0x87, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F,
  0x03, 0xE1, 0xF0, 0x78, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x1E, 0x07,
  0xC1, 0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x3C, 0x0F, 0x83,
  0xC1, 0xE0, 0x7C, 0x1E, 0x0F, 0x03, 0xE1, 0xF0, 0x78, 0x1F, 0x0F, 0x83,
  0xC0, 0xF8, 0x7C, 0x1E, 0x07, 0xC3, 0xE0, 0xF2, 0x7F, 0x3F, 0x87, 0xF1,
  0xF0, 0xF8, 0x3F, 0x07, 0x03, 0x80, 0xF0, 0x10, 0x0C, 0x03, 0x80, 0x80,
  0x40, 0x08, 0x00, 0x00, 0x01, 0x80, 0x80, 0x3C, 0x1C, 0x07, 0xE3, 0xF0,
  0x7E, 0x7F, 0xCB, 0xF9, 0xFE, 0x1F, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x07,
  0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0,
  0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F,
  0x07, 0x83, 0xF8, 0x7F, 0x1F, 0x07, 0xE0, 0xE0, 0x3E, 0x0C, 0x01, 0xC0,
  0x40, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x03, 0xFF, 0x07, 0xCF,
  0xC1, 0xE3, 0xF0, 0xF1, 0xFC, 0x78, 0x7E, 0x3C, 0x1F, 0x1E, 0x07, 0xCF,
  0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0E,
  0x3C, 0x06, 0x3F, 0x07, 0x3F, 0xE3, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x40, 0xFC, 0x1C, 0x1F, 0x8F, 0xC1, 0xFF, 0xF8,
  0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xF0, 0xF0, 0x3E,
  0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38,
  0x3C, 0x07, 0x1F, 0x81, 0xC7, 0xF0, 0x39, 0xFF, 0x84, 0x3F, 0xFD, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x5F, 0xC0, 0x47, 0xFC, 0x61, 0xFC, 0x70, 0x3C, 0x70, 0x1E,
  0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x7E, 0x0F, 0x1F, 0x8F, 0x8F, 0xEF, 0xC3,
  0xF9, 0xE0, 0xF8, 0xF0, 0x38, 0x78, 0x10, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x00, 0xE0, 0x43, 0xC3, 0x9F, 0x9E, 0x7E, 0xFE, 0x7D, 0xF1,
  0xF3, 0x87, 0x8E, 0x1E, 0x10, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF2, 0x0F, 0xF0,
  0x5F, 0xC0, 0x1E, 0x00, 0x30, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x01, 0x01, 0x03, 0x81, 0x07, 0xC1, 0x0F, 0xFF, 0x33,
  0xFE, 0x60, 0xFC, 0x60, 0x38, 0xE0, 0x10, 0xF0, 0x30, 0xF8, 0x78, 0xFC,
  0xFC, 0x7F, 0xFE, 0x3E, 0x7E, 0x1C, 0x3F, 0x18, 0x1F, 0x10, 0x0E, 0x38,
  0x06, 0x7E, 0x0C, 0xFF, 0x88, 0x7F, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x70,
  0x0E, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xF2, 0x3F, 0xC7, 0xFC, 0x07, 0x80, 0x30, 0x01, 0x00, 0x00,
  0x02, 0x03, 0x80, 0x30, 0x3C, 0x07, 0x07, 0xE0, 0xF8, 0x7E, 0x1F, 0xC9,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78,
  0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07,
  0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x93, 0xFB,
  0x7F, 0x5F, 0xE7, 0xE0, 0x7C, 0x3C, 0x03, 0x81, 0xC0, 0x10, 0x08, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x02, 0x03, 0x00, 0x60, 0x78, 0x1F, 0x07,
  0xC3, 0xF8, 0x7E, 0xCF, 0xC7, 0xF0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0x83, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x38, 0x1F, 0x03, 0x81,
  0xE0, 0x38, 0x1E, 0x03, 0x01, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0xC0, 0x70,
  0x38, 0x07, 0xC3, 0x00, 0xFF, 0x60, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x04, 0x01, 0x0F, 0xE0, 0xF0,
  0x78, 0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xFB, 0xFC, 0x1F, 0xCF, 0xC7, 0xE1,
  0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x0F, 0x07,
  0xC0, 0xF0, 0xF0, 0x7C, 0x0F, 0x0F, 0x07, 0xC0, 0xF0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x07, 0xC0, 0xF0, 0xF0, 0x7C, 0x0E, 0x0F, 0x07, 0xC0, 0xE1, 0xF0,
  0x7C, 0x1C, 0x1F, 0x07, 0xC1, 0x81, 0xF0, 0xFF, 0x30, 0x3F, 0x97, 0xFE,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x60, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x08, 0x08, 0x3C, 0x18, 0x7C, 0x71, 0xF9, 0xF3, 0xFF,
  0xE9, 0xF3, 0xC3, 0xE7, 0x07, 0xC4, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x10, 0x3F, 0x40, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x10, 0x60, 0x60, 0x40,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x83, 0x03, 0x83, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x78, 0x02,
  0x0F, 0xC0, 0xC1, 0xFC, 0x3C, 0x1F, 0x9F, 0xC1, 0xFD, 0xF8, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x0F,
  0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x0F, 0xD8, 0xE1, 0xFC, 0x38,
  0x0F, 0x06, 0x00, 0xE1, 0x80, 0x08, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x38, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x21, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x06, 0x38, 0xC3, 0xF8, 0x7F, 0xE0, 0x3F,
  0x81, 0xFC, 0x1B, 0xF1, 0x8F, 0x88, 0x3C, 0xC1, 0xE6, 0x0F, 0xA0, 0x7F,
  0x01, 0xF8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x18, 0x81, 0xC6, 0x0C, 0x10,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 33, 10, 1, -32 },
  { 34, 15, 12, 18, 1, -31 },
  { 57, 20, 25, 23, 1, -28 },
  { 120, 15, 36, 18, 2, -34 },
  { 188, 29, 31, 31, 1, -31 },
  { 301, 23, 27, 25, 1, -27 },
  { 379, 7, 12, 9, 1, -31 },
  { 390, 9, 36, 11, 1, -35 },
  { 431, 9, 36, 11, 1, -35 },
  { 472, 15, 17, 15, 0, -33 },
  { 504, 14, 15, 17, 2, -22 },
  { 531, 7, 12, 8, 0, -7 },
  { 542, 12, 8, 13, 1, -17 },
  { 554, 7, 8, 9, 1, -7 },
  { 561, 21, 35, 23, 1, -33 },
  { 653, 19, 31, 21, 1, -31 },
  { 727, 14, 30, 14, 0, -30 },
  { 780, 18, 30, 20, 1, -30 },
  { 848, 19, 30, 21, 1, -30 },
  { 920, 20, 30, 20, 0, -30 },
  { 995, 19, 31, 21, 1, -31 },
  { 1069, 18, 31, 20, 1, -31 },
  { 1139, 17, 30, 19, 1, -30 },
  { 1203, 19, 31, 21, 1, -31 },
  { 1277, 18, 31, 20, 1, -31 },
  { 1347, 7, 22, 9, 1, -21 },
  { 1367, 8, 26, 8, 0, -21 },
  { 1393, 12, 17, 13, 0, -21 },
  { 1419, 15, 10, 17, 1, -18 },
  { 1438, 12, 17, 13, 0, -21 },
  { 1464, 17, 32, 20, 1, -31 },
  { 1532, 25, 27, 27, 1, -21 },
  { 1617, 34, 32, 36, 1, -31 },
  { 1753, 38, 33, 39, 0, -32 },
  { 1910, 28, 33, 30, 1, -32 },
  { 2026, 34, 34, 36, 1, -32 },
  { 2171, 29, 33, 31, 1, -32 },
  { 2291, 31, 38, 33, 1, -32 },
  { 2439, 32, 33, 34, 1, -32 },
  { 2571, 30, 40, 32, 1, -34 },
  { 2721, 28, 37, 30, 1, -32 },
  { 2851, 29, 43, 31, 1, -32 },
  { 3007, 34, 32, 36, 1, -31 },
  { 3143, 23, 32, 25, 1, -31 },
  { 3235, 47, 33, 49, 1, -31 },
  { 3429, 37, 32, 39, 1, -31 },
  { 3577, 31, 33, 33, 1, -32 },
  { 3705, 37, 38, 39, 1, -31 },
  { 3881, 33, 35, 35, 1, -32 },
  { 4026, 39, 33, 41, 1, -32 },
  { 4187, 31, 33, 33, 1, -32 },
  { 4315, 31, 31, 33, 1, -31 },
  { 4436, 29, 34, 31, 1, -31 },
  { 4560, 37, 33, 39, 1, -32 },
  { 4713, 45, 33, 47, 1, -32 },
  { 4899, 30, 33, 32, 1, -32 },
  { 5023, 36, 39, 38, 1, -32 },
  { 5199, 27, 38, 29, 1, -32 },
  { 5328, 6, 35, 8, 1, -33 },
  { 5355, 27, 31, 5, -8, -29 },
  { 5460, 6, 35, 8, 1, -33 },
  { 5487, 16, 12, 18, 1, -31 },
  { 5511, 20, 3, 20, 0, 5 },
  { 5519, 7, 8, 22, 7, -31 },
  { 5526, 18, 24, 20, 1, -23 },
  { 5580, 18, 31, 20, 1, -30 },
  { 5650, 14, 23, 16, 1, -22 },
  { 5691, 18, 32, 20, 1, -31 },
  { 5763, 14, 23, 16, 1, -22 },
  { 5804, 13, 39, 11, 0, -32 },
  { 5868, 19, 32, 20, 1, -23 },
  { 5944, 18, 39, 20, 1, -31 },
  { 6032, 10, 32, 12, 1, -31 },
  { 6072, 12, 39, 11, -2, -31 },
  { 6131, 12, 32, 14, 1, -31 },
  { 6179, 12, 32, 12, 1, -31 },
  { 6227, 29, 24, 31, 1, -23 },
  { 6314, 20, 24, 22, 1, -23 },
  { 6374, 17, 24, 18, 0, -23 },
  { 6425, 19, 35, 20, 0, -26 },
  { 6509, 17, 32, 19, 1, -23 },
  { 6577, 14, 24, 16, 1, -23 },
  { 6619, 16, 28, 18, 1, -27 },
  { 6675, 12, 29, 14, 1, -28 },
  { 6719, 20, 24, 22, 1, -23 },
  { 6779, 20, 26, 20, -1, -25 },
  { 6844, 28, 27, 30, 1, -26 },
  { 6939, 15, 32, 17, 1, -23 },
  { 6999, 19, 34, 21, 1, -26 },
  { 7080, 13, 31, 15, 1, -23 },
  { 7131, 12, 35, 15, 1, -34 },
  { 7184, 3, 36, 7, 2, -34 },
  { 7198, 12, 35, 15, 1, -34 },
  { 7251, 14, 3, 16, 1, -15 },
};

const GFXfont UnifrakturMaguntia_Regular44pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular44pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular44pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR44PT7B_H_
