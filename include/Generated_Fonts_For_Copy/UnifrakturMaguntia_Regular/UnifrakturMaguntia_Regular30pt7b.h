#ifndef _UNIFRAKTURMAGUNTIA_REGULAR30PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x1D, 0xF7, 0x39, 0xCE, 0x21, 0x08, 0x42, 0x10, 0x80, 0x00,
  0x08, 0xEF, 0x90, 0x21, 0x1C, 0xEF, 0xBC, 0xC7, 0x30, 0x88, 0x22, 0x11,
  0x04, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC7, 0xFF, 0xBF, 0xFC, 0x73,
  0x83, 0x98, 0x18, 0xC0, 0xC6, 0x3F, 0xFF, 0xFF, 0xF1, 0x8C, 0x0C, 0xE0,
  0xE7, 0x07, 0x30, 0x31, 0x80, 0x04, 0x01, 0x00, 0x40, 0x78, 0x31, 0x98,
  0x26, 0x0D, 0x83, 0x70, 0xDE, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF4, 0x3F,
  0x87, 0xC0, 0xF0, 0x34, 0x0C, 0x86, 0x1F, 0x01, 0x00, 0x40, 0x10, 0x3C,
  0x00, 0x26, 0x60, 0x04, 0xE7, 0x00, 0xCE, 0x70, 0x18, 0xE7, 0x03, 0x0E,
  0x70, 0x20, 0xE7, 0x04, 0x0E, 0x70, 0x80, 0xE7, 0x10, 0x06, 0x62, 0x00,
  0x3C, 0x63, 0x80, 0x0C, 0xCC, 0x01, 0x8C, 0xE0, 0x11, 0xC6, 0x02, 0x1C,
  0x60, 0x41, 0xC7, 0x08, 0x1C, 0x61, 0x81, 0xC6, 0x30, 0x0C, 0xE6, 0x00,
  0xCC, 0x40, 0x07, 0x80, 0x07, 0x80, 0x19, 0x80, 0x31, 0x80, 0xE3, 0x01,
  0xC6, 0x03, 0x98, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x3E, 0x7E, 0x19, 0xDE,
  0x23, 0x3C, 0x4E, 0x7C, 0x9C, 0x7A, 0x38, 0xFC, 0x70, 0xF0, 0x70, 0xF2,
  0xF1, 0xFC, 0xFC, 0xF0, 0x33, 0xDE, 0x71, 0x88, 0x44, 0x02, 0x18, 0x60,
  0x83, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70,
  0xE1, 0xC1, 0x83, 0x06, 0x06, 0x04, 0x06, 0x80, 0xC0, 0x40, 0xC1, 0x81,
  0x83, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0x61, 0xC3, 0x06, 0x18, 0x40, 0x08, 0x03, 0x03, 0xF3, 0xB7, 0x7B, 0x9F,
  0xE5, 0xE9, 0xEE, 0xED, 0xCF, 0xC0, 0xC0, 0x20, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x01, 0x1F, 0xF3,
  0x88, 0x44, 0x40, 0x07, 0x3F, 0x70, 0x02, 0x7C, 0xFC, 0x01, 0x9E, 0xE2,
  0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80, 0x33, 0x01, 0x86, 0x0E,
  0x1C, 0x38, 0x71, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x3F, 0xE0, 0xFF,
  0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x38, 0x70,
  0xE1, 0xC1, 0x86, 0x03, 0x38, 0x07, 0x80, 0x02, 0x03, 0x03, 0x83, 0xC3,
  0xE3, 0xF2, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xF8, 0x0F, 0xC0, 0xFF, 0x0C, 0x7C,
  0xC1, 0xE4, 0x07, 0xA0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x04, 0x10, 0x23, 0x01, 0x1F, 0xF9, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0xC7, 0xC4, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xE6, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xC3,
  0x86, 0x07, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x5C, 0x06,
  0xE0, 0x27, 0x02, 0x38, 0x11, 0xC1, 0x0E, 0x10, 0x70, 0x83, 0x8F, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x0F, 0xF0,
  0x20, 0x10, 0x7F, 0x81, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x0B, 0xE0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8C, 0x3E, 0x20, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x60, 0x39, 0xC0, 0xE7, 0x03, 0x1C, 0x0C, 0x38,
  0x60, 0x3E, 0x00, 0x07, 0xC0, 0x67, 0x06, 0x1C, 0x30, 0xE3, 0x87, 0x9C,
  0x19, 0xE0, 0x0E, 0x00, 0x73, 0xE3, 0xA3, 0x9E, 0x1C, 0xF0, 0xF7, 0x87,
  0xBC, 0x1D, 0xE0, 0xEF, 0x07, 0x78, 0x31, 0xC3, 0x8E, 0x18, 0x38, 0x80,
  0x78, 0x00, 0x3F, 0xFB, 0xFF, 0x90, 0x04, 0x80, 0x68, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0xC0, 0xC1, 0x0C, 0x0C, 0xE0, 0x27, 0x01, 0x38, 0x19, 0xF0, 0xC7, 0xCC,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x63, 0xE2, 0x07, 0xB0, 0x1D, 0x80, 0xFC,
  0x03, 0x60, 0x1B, 0x01, 0xD8, 0x0C, 0x60, 0xC0, 0xFC, 0x00, 0x07, 0x80,
  0xC6, 0x0C, 0x38, 0x60, 0xE7, 0x07, 0x38, 0x3D, 0xC1, 0xEE, 0x0F, 0x70,
  0x7B, 0x83, 0xDE, 0x3E, 0x73, 0xF1, 0xF7, 0x80, 0x38, 0x01, 0xC6, 0x0E,
  0x70, 0x73, 0xC3, 0x0E, 0x30, 0x71, 0x80, 0xF0, 0x00, 0x23, 0x9E, 0x62,
  0x00, 0x00, 0x00, 0x0C, 0xF7, 0x10, 0x23, 0x9E, 0x62, 0x00, 0x00, 0x00,
  0x08, 0xFF, 0x9C, 0x42, 0x22, 0x00, 0x01, 0x06, 0x0C, 0x18, 0x78, 0xF0,
  0x78, 0x18, 0x0C, 0x06, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x0F, 0x0E, 0x1C, 0x30, 0x60, 0xC0,
  0x1F, 0x8C, 0x3B, 0x03, 0xE0, 0x7E, 0x0F, 0xE1, 0xD8, 0x38, 0x1F, 0x0F,
  0xC7, 0xF0, 0xF0, 0x18, 0x03, 0x08, 0x61, 0x0E, 0x20, 0x78, 0x00, 0x00,
  0x00, 0x18, 0x07, 0x80, 0x70, 0x04, 0x00, 0x01, 0xF8, 0x01, 0x83, 0x81,
  0xC0, 0x30, 0x60, 0x04, 0x30, 0xFD, 0x98, 0x67, 0x66, 0x31, 0x99, 0x9C,
  0xE6, 0x66, 0x39, 0xBB, 0x8C, 0x46, 0xE7, 0x31, 0xBB, 0xD8, 0x67, 0xBC,
  0xD8, 0x00, 0x23, 0x00, 0x18, 0x60, 0x0C, 0x0E, 0x0C, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x0C, 0x7F, 0xE0, 0x71, 0x07, 0xE3, 0xC4, 0x07, 0xCF, 0x88,
  0x07, 0xCF, 0x10, 0x07, 0x9E, 0x20, 0x0F, 0x3C, 0x60, 0x1E, 0x78, 0xF0,
  0x38, 0xF0, 0xF8, 0x71, 0xE0, 0xF0, 0xC3, 0xC0, 0x73, 0x87, 0x80, 0x46,
  0x0F, 0x01, 0x18, 0x1E, 0x00, 0x40, 0x3C, 0x01, 0x80, 0x78, 0x07, 0xC0,
  0xF0, 0x3F, 0xC3, 0xE0, 0x0F, 0xEB, 0xF8, 0x0F, 0xE3, 0xC0, 0x0F, 0x87,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x30, 0x03, 0xFC, 0x3F, 0x03, 0xFF,
  0x93, 0xE1, 0xF3, 0xF8, 0x78, 0x60, 0x3E, 0x1E, 0x10, 0x07, 0x83, 0xCC,
  0x01, 0xE0, 0xFB, 0x00, 0x38, 0x1C, 0xC0, 0x0E, 0x0C, 0x10, 0x03, 0x8F,
  0x86, 0x00, 0xCF, 0xF0, 0xE2, 0x37, 0xFE, 0x07, 0x18, 0x07, 0xC0, 0x0C,
  0x00, 0xF0, 0x06, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x01, 0xF0, 0x01, 0xC1,
  0xFE, 0x00, 0x60, 0x0F, 0xC0, 0x30, 0x01, 0xFC, 0x08, 0x00, 0x3F, 0xCC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x84, 0x01, 0x89, 0xE0,
  0x60, 0xFF, 0x9C, 0x17, 0xE7, 0x0C, 0x10, 0xE3, 0x00, 0x1C, 0xE0, 0x07,
  0x9E, 0x00, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xC7, 0xE0, 0x78, 0x7E, 0x0F,
  0x07, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x60, 0x3C, 0x18, 0x07,
  0xC6, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x30, 0x7F, 0xF8, 0x03, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0x82, 0x7F, 0x1C, 0x08, 0x3E, 0x30, 0x30, 0x3E, 0x40, 0xE0, 0x3E, 0x81,
  0xE0, 0x3D, 0x07, 0xE0, 0x3A, 0x07, 0xE0, 0x34, 0x07, 0xE0, 0x64, 0x07,
  0xC0, 0xC4, 0x07, 0x81, 0x87, 0xC6, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x20,
  0x08, 0x0F, 0x80, 0x10, 0x7F, 0xC0, 0x41, 0xFF, 0xE1, 0x04, 0x1F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x00, 0xC4, 0xF0,
  0x18, 0x3F, 0xE3, 0x82, 0xFC, 0x70, 0xC1, 0x07, 0x18, 0x00, 0x73, 0x80,
  0x0F, 0x3C, 0x00, 0xF3, 0xE3, 0x8F, 0x1F, 0x7E, 0xF1, 0xFB, 0xEF, 0x0F,
  0xCC, 0xF0, 0x7E, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xC0, 0x3C,
  0x18, 0x03, 0xE3, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x06, 0x07, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x97, 0x83, 0xFF, 0x30, 0x0B, 0xF3, 0x00, 0xC6, 0x10, 0x0E, 0x00, 0x80,
  0x70, 0x04, 0x03, 0xC3, 0x20, 0x1F, 0x1D, 0x80, 0xFD, 0xF4, 0x03, 0xFF,
  0x10, 0x4F, 0x90, 0x7C, 0x7E, 0x00, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x70,
  0x3C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x78, 0x1C, 0x01, 0xC0, 0xC0, 0x07, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x18, 0x07, 0x05, 0xE0, 0x30, 0x3F, 0x83, 0x82, 0x3F,
  0x38, 0x60, 0xF9, 0xC7, 0x01, 0x9E, 0x78, 0x10, 0xF3, 0xC3, 0xC7, 0x8F,
  0x3F, 0x3C, 0x7E, 0xFD, 0xE1, 0xF1, 0xFF, 0x0F, 0x87, 0xF8, 0x3E, 0x3F,
  0xC0, 0xF0, 0xEF, 0x03, 0x87, 0x78, 0x18, 0x39, 0xE1, 0x81, 0x8F, 0x90,
  0x1C, 0x3C, 0x00, 0xC0, 0x78, 0x0C, 0x01, 0xFB, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x21,
  0xF8, 0x03, 0x07, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x20, 0x0E, 0x01, 0x80,
  0x78, 0x3E, 0x03, 0xE7, 0xF8, 0x0F, 0x67, 0xE0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xC6,
  0x0C, 0x0E, 0xF8, 0x40, 0x7B, 0xE4, 0x07, 0x0F, 0xC0, 0x38, 0x3C, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xE0, 0x1C, 0x3F, 0x03, 0x01, 0xFE, 0x30, 0x07, 0xC2,
  0x00, 0x18, 0x20, 0x03, 0x02, 0x00, 0x60, 0x30, 0x06, 0x01, 0x00, 0xF0,
  0x18, 0x0F, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0xE3, 0xF0,
  0x0E, 0x5F, 0x80, 0xC0, 0x7C, 0x08, 0x03, 0xF1, 0x00, 0x1F, 0xE0, 0x00,
  0x60, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x30, 0x7E, 0x06, 0x03, 0xFC,
  0x40, 0x1F, 0x84, 0x00, 0x30, 0x40, 0x06, 0x04, 0x00, 0xE0, 0x40, 0x0E,
  0x02, 0x01, 0xE0, 0x30, 0x0F, 0x00, 0xCC, 0xF0, 0x03, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x3C, 0x00, 0xCF,
  0xF0, 0x0C, 0x9F, 0x80, 0x80, 0xFC, 0x10, 0x07, 0xE6, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x08,
  0x03, 0x8F, 0x0C, 0x07, 0x3F, 0xC6, 0x07, 0x33, 0xE6, 0x07, 0x41, 0xE2,
  0x07, 0x41, 0xE2, 0x07, 0xC0, 0xFA, 0x07, 0xC0, 0xF2, 0x07, 0xC0, 0x44,
  0x03, 0xE1, 0x88, 0x01, 0xF7, 0xD0, 0x01, 0xF1, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0x70, 0xF0, 0x18, 0x30, 0xF0, 0x3C, 0x30, 0xF8, 0x7E, 0x20, 0x7C,
  0x9F, 0xC0, 0x7F, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x10, 0x03, 0xF8, 0x07,
  0x07, 0x07, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xE0, 0x18, 0xF0, 0x1C,
  0x7C, 0x0E, 0x3E, 0x07, 0x0F, 0xAF, 0x03, 0xCE, 0x01, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x83,
  0xF8, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x83, 0xC1, 0xE0,
  0x7F, 0xCF, 0xE7, 0xE1, 0xFF, 0xF7, 0xD1, 0xE2, 0x0F, 0xC7, 0xC3, 0xC8,
  0x07, 0x87, 0xC3, 0xD0, 0x0F, 0x87, 0x87, 0xA0, 0x0F, 0x0F, 0x0F, 0xC0,
  0x0E, 0x0E, 0x0E, 0x80, 0x1E, 0x1C, 0x11, 0x88, 0x3C, 0x38, 0x41, 0xFC,
  0x38, 0x71, 0x81, 0xF8, 0x60, 0xE7, 0x00, 0x10, 0xC1, 0xCC, 0x00, 0x01,
  0x83, 0x38, 0x00, 0x02, 0x06, 0x78, 0x00, 0x0C, 0x0C, 0xF0, 0x0C, 0x10,
  0x11, 0xE0, 0x7C, 0x2E, 0x41, 0xE1, 0xFC, 0xBF, 0x83, 0xF8, 0x7E, 0xFE,
  0x03, 0xE0, 0x78, 0x38, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0xF0, 0x1F, 0xF0, 0xFC, 0x1F, 0xFC, 0x8F, 0x18,
  0x3F, 0x83, 0x88, 0x07, 0xC1, 0xE4, 0x01, 0xE0, 0xF2, 0x00, 0xF0, 0x7D,
  0x00, 0x38, 0x1C, 0x80, 0x1E, 0x08, 0x63, 0x0F, 0x0C, 0x1F, 0xC3, 0x8C,
  0x07, 0xE1, 0x86, 0x00, 0x10, 0xC7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x33,
  0xC0, 0x00, 0x31, 0xE0, 0x0C, 0x10, 0x78, 0x1F, 0x08, 0x3E, 0x9F, 0xC8,
  0x0F, 0xE1, 0xF8, 0x07, 0xC0, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xC3, 0xFC,
  0x18, 0x07, 0xE1, 0x80, 0x0F, 0x9C, 0x00, 0x3E, 0xE0, 0x00, 0xF7, 0xC0,
  0x03, 0xBF, 0x80, 0x1C, 0xFF, 0x00, 0x63, 0xF8, 0x03, 0x07, 0xC0, 0x18,
  0x0E, 0x00, 0xC0, 0x20, 0x06, 0x1E, 0x00, 0x23, 0xF0, 0x01, 0x3F, 0xE0,
  0x10, 0x3F, 0x81, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x18, 0x07, 0xFC, 0x1C, 0x03, 0xFF, 0x9F, 0x01, 0x83, 0xFB,
  0xE0, 0x40, 0x7C, 0xFC, 0x30, 0x0F, 0x1F, 0x88, 0x03, 0xC3, 0xF1, 0x00,
  0x70, 0x7E, 0x40, 0x1C, 0x0F, 0x90, 0x07, 0x01, 0xF1, 0x09, 0xC0, 0x3C,
  0x3C, 0x70, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0xC0,
  0x08, 0x00, 0x70, 0x02, 0x00, 0x7C, 0x01, 0x00, 0x3F, 0xC0, 0x80, 0x1F,
  0xFE, 0x40, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x0C, 0x3F, 0xC0, 0xC0, 0x3F, 0x06, 0x00, 0x3E, 0x38, 0x00, 0x7C, 0xE0,
  0x00, 0xF3, 0xE0, 0x01, 0xCF, 0xE0, 0x07, 0x1F, 0xE0, 0x0C, 0x3F, 0x80,
  0x30, 0x3E, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x40, 0x0C, 0x1E, 0x03, 0xA1,
  0xF8, 0x3F, 0x8F, 0xF9, 0xBE, 0x47, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x07,
  0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x1C, 0x03, 0xFF, 0x1F, 0xC1, 0xFF, 0xE8, 0xF8, 0x61, 0xFA, 0x1E, 0x30,
  0x1F, 0x07, 0xC8, 0x03, 0xC0, 0xF2, 0x00, 0x78, 0x3E, 0x80, 0x1E, 0x06,
  0x20, 0x03, 0x83, 0x08, 0x00, 0xE1, 0x01, 0x00, 0x39, 0xC0, 0x20, 0x8E,
  0xF8, 0x07, 0xC3, 0xDF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x30, 0xF0, 0x00,
  0x0C, 0x3E, 0x03, 0x82, 0x07, 0x81, 0xF1, 0x01, 0xE0, 0xFE, 0xC0, 0x7D,
  0x0F, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0x84, 0x0F, 0xFF, 0xC0, 0x81, 0xFC, 0x08, 0x03, 0xC0, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x07, 0x86, 0x00, 0xFF, 0x31, 0x1F, 0xFD,
  0x87, 0xFC, 0x2C, 0x1F, 0x80, 0xF0, 0x70, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0x78, 0x00, 0x13, 0xF0, 0x01, 0x8F, 0xF0, 0xF8, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x18, 0x3F,
  0xC1, 0x80, 0x7F, 0x18, 0x02, 0xFF, 0x40, 0x61, 0xF2, 0x07, 0x06, 0x10,
  0x3C, 0x00, 0x81, 0xF0, 0x02, 0x0F, 0xC0, 0x0F, 0xBF, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x0E, 0x0E, 0x01, 0xF8, 0x70, 0x1F, 0xE2, 0x00, 0x1F,
  0xA0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x18, 0x03, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x21, 0x88, 0x0C, 0x30, 0x43, 0x87, 0x08, 0xF8, 0x79,
  0x07, 0x87, 0x80, 0x78, 0x7C, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0x81,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0x70, 0x78, 0x06, 0x07, 0x80, 0x40, 0x78,
  0x08, 0x07, 0x81, 0x80, 0x78, 0x3C, 0x07, 0x8F, 0xF0, 0xF8, 0x9F, 0xF7,
  0xF0, 0xFE, 0x3C, 0x03, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x0F, 0xF0, 0xF8, 0x0F, 0xFC, 0x9E, 0x0F, 0x7F, 0x8F, 0x8C,
  0x07, 0xC3, 0xC4, 0x03, 0xE1, 0xF2, 0x00, 0xF0, 0x75, 0x00, 0x38, 0x10,
  0x80, 0x1C, 0x10, 0x40, 0x0E, 0x18, 0x10, 0x06, 0x0E, 0x06, 0x63, 0x0F,
  0x80, 0xC3, 0x03, 0xE0, 0x01, 0x01, 0xF8, 0x01, 0x00, 0x7C, 0x07, 0x80,
  0x1E, 0x0F, 0xE0, 0x07, 0x0F, 0xF8, 0x03, 0x08, 0x7F, 0x01, 0x00, 0x1F,
  0xC1, 0x00, 0x03, 0xFD, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x86, 0x3F, 0x80, 0xFF, 0xD2, 0x8F, 0x83, 0xFF,
  0xC2, 0x0F, 0x0E, 0x0F, 0x8C, 0x0F, 0x18, 0x0F, 0x98, 0x1E, 0x20, 0x0F,
  0x70, 0x1E, 0x40, 0x0E, 0xF0, 0x38, 0x80, 0x1D, 0xE0, 0x21, 0x00, 0x3B,
  0xE0, 0xC1, 0x00, 0x63, 0xC3, 0x81, 0x08, 0xC3, 0xC7, 0x81, 0xE1, 0x07,
  0x8F, 0x80, 0x04, 0x07, 0x1F, 0x80, 0x08, 0x0E, 0x1F, 0x01, 0x40, 0x18,
  0x1E, 0x0F, 0xC0, 0x30, 0x1C, 0x3F, 0xC0, 0x70, 0x18, 0x8F, 0xC1, 0xF0,
  0x20, 0x0F, 0xC7, 0xF0, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x39, 0x3F, 0xE3,
  0xF7, 0xFE, 0x7E, 0xC0, 0xF4, 0xCC, 0x07, 0x80, 0x80, 0x78, 0x08, 0x07,
  0x80, 0x80, 0x38, 0x04, 0x07, 0xFC, 0x20, 0xFF, 0x81, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x0B, 0xC0, 0x3C, 0x9F, 0x23, 0xF9, 0xFE, 0x7F, 0x0F, 0xC0, 0xE0, 0x78,
  0x00, 0x00, 0xC0, 0x1F, 0xE3, 0xF0, 0x3F, 0xF2, 0x78, 0x73, 0xFC, 0x3C,
  0xC0, 0x7C, 0x3C, 0x80, 0x3C, 0x3E, 0x80, 0x3C, 0x1E, 0x80, 0x1C, 0x1F,
  0x80, 0x1C, 0x08, 0x80, 0x1C, 0x10, 0x41, 0x18, 0x70, 0x32, 0x18, 0x78,
  0x0C, 0x38, 0x78, 0x00, 0x30, 0x7C, 0x00, 0x20, 0x7C, 0x00, 0x40, 0x3E,
  0x00, 0x80, 0x3E, 0x00, 0xC1, 0x1E, 0x01, 0xF2, 0x1E, 0x07, 0xFC, 0x1E,
  0x00, 0xFC, 0x1E, 0x00, 0x38, 0x1C, 0x04, 0x00, 0x1C, 0x02, 0x00, 0x38,
  0x01, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x38, 0x3E, 0x04, 0x01, 0xE1, 0x80, 0x3C, 0x30, 0x03, 0x82,
  0x00, 0x60, 0x60, 0x1C, 0x07, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0xF8, 0x03, 0xBF, 0x80, 0x61, 0xF8, 0x0C, 0x0F,
  0x83, 0x00, 0xFC, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9F, 0xE0, 0x04, 0x01, 0x80, 0x78, 0x1F, 0x83, 0x38,
  0xC3, 0xB0, 0x14, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xCE, 0xE7, 0x31, 0x06,
  0x00, 0xF0, 0x1F, 0x82, 0x3E, 0x61, 0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCF, 0x1C, 0x79, 0xF7, 0xFE, 0x38, 0xE2, 0x04, 0x02,
  0x08, 0xC0, 0xB8, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x87, 0x1C, 0x77,
  0xC7, 0x9E, 0x70, 0xE7, 0x0F, 0x70, 0x77, 0x07, 0x70, 0x67, 0x06, 0x70,
  0x47, 0x88, 0xFF, 0x01, 0xE0, 0x0E, 0x00, 0x40, 0x0E, 0x0F, 0x89, 0xCC,
  0xFE, 0x27, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xFC,
  0x70, 0x10, 0x60, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x0B, 0xE7, 0x0E, 0x70, 0xF7, 0x07, 0x70, 0x77, 0x07, 0x70,
  0x37, 0x02, 0x70, 0x67, 0xC4, 0xFE, 0x41, 0xF8, 0x06, 0x00, 0x00, 0x0E,
  0x0F, 0x89, 0xCC, 0xEE, 0x3F, 0x1F, 0x99, 0xF0, 0xE0, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0xFC, 0x70, 0x10, 0x18, 0x1F, 0xCF, 0xC4, 0xC2, 0x01, 0x00,
  0xC1, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x0F, 0x01, 0x7C, 0x33, 0xE6, 0x1E, 0xE0, 0x4E, 0x0C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCE, 0x1E, 0xF1, 0xE7, 0x0E, 0x3F, 0xE3, 0x8E, 0x20,
  0x60, 0x06, 0x40, 0x66, 0x0C, 0x70, 0x83, 0xF0, 0x07, 0x89, 0x80, 0xB8,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0x87, 0x38, 0x7F, 0xC7, 0x1E, 0x70,
  0xE7, 0x0E, 0x70, 0xF7, 0x0F, 0x70, 0x77, 0x07, 0x70, 0x67, 0x0E, 0x7E,
  0xCF, 0xCC, 0x38, 0x81, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x0C,
  0x1C, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x38, 0x7E, 0xBC, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3E, 0x1E, 0x0C, 0x00, 0x06, 0x07, 0x83,
  0x80, 0x80, 0x00, 0x40, 0x30, 0x3C, 0x2F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1A,
  0x0D, 0x18, 0x70, 0x00, 0x07, 0x88, 0x99, 0x7B, 0x7F, 0x7E, 0x78, 0x7F,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x7E, 0xBC,
  0x18, 0x08, 0x07, 0x88, 0xB8, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x7E, 0xBC, 0x18, 0x08,
  0x00, 0x04, 0x07, 0x1C, 0x60, 0x73, 0xEF, 0x8F, 0xDF, 0x7C, 0x38, 0xE3,
  0x83, 0x8E, 0x38, 0x38, 0xE3, 0x83, 0x8E, 0x38, 0x38, 0xE3, 0x83, 0x8E,
  0x38, 0x38, 0xE3, 0x83, 0x8E, 0x38, 0x38, 0xE3, 0x87, 0xDF, 0x3E, 0x38,
  0xE1, 0xE1, 0x04, 0x0C, 0x10, 0x40, 0x00, 0x60, 0x83, 0x8E, 0x3E, 0xFD,
  0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0E,
  0x38, 0x71, 0xC7, 0xCF, 0x9C, 0x3C, 0x41, 0xC2, 0x04, 0x01, 0x81, 0xF8,
  0x73, 0xC7, 0x3C, 0x71, 0xE7, 0x0E, 0x70, 0xF7, 0x07, 0x70, 0x77, 0x06,
  0x70, 0x67, 0x8C, 0xFF, 0x81, 0xE0, 0x0C, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0xE0, 0x87, 0x9C, 0x3F, 0xF0, 0xE3, 0xC7, 0x0F, 0x38, 0x78,
  0xC1, 0xC6, 0x0E, 0x30, 0x71, 0x83, 0x3C, 0x1B, 0xF1, 0x9F, 0xE8, 0x1F,
  0x80, 0xD8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x07, 0x80, 0xFC, 0x13, 0xF3, 0x0E, 0x70, 0xE6, 0x0E,
  0x60, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x78, 0xE3, 0xDE, 0x3E, 0xE1, 0x8E,
  0x10, 0xE0, 0x0E, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x61, 0x39, 0xFF,
  0xE7, 0x73, 0x91, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x47, 0xF1,
  0xE0, 0x20, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x00, 0x10, 0xC2, 0x7F, 0xD3,
  0xF6, 0x1C, 0xC1, 0x1C, 0x63, 0xDE, 0x3F, 0xE7, 0x1C, 0x41, 0x98, 0x37,
  0xC4, 0xFF, 0x03, 0xC0, 0x10, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01, 0x81,
  0xC1, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x3F, 0x2F, 0x03, 0x00, 0x80, 0x00, 0x43, 0x03, 0x1C, 0x39, 0xF3,
  0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x38,
  0x71, 0xC3, 0x8E, 0x3E, 0xFC, 0xF9, 0xC1, 0x86, 0x00, 0x00, 0x20, 0x02,
  0x02, 0x30, 0x31, 0xC7, 0xCF, 0x5E, 0x3C, 0x79, 0xE1, 0xC7, 0x0F, 0x1C,
  0x38, 0xE1, 0xC6, 0x0C, 0x30, 0x61, 0x07, 0x0C, 0x30, 0xF9, 0x0B, 0xF0,
  0x07, 0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x78,
  0x60, 0x8F, 0x9E, 0x38, 0xF7, 0xDF, 0x8F, 0x3C, 0x71, 0xC3, 0x8F, 0x38,
  0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x73, 0x87, 0x0C, 0x70,
  0xE1, 0x8E, 0x3E, 0x63, 0xE7, 0xF0, 0x38, 0x3C, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x00, 0x20, 0x0C, 0x67, 0x9E, 0xFF, 0x1D, 0xC7, 0x21, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1D, 0x0F, 0x87, 0xE2, 0x30, 0x88, 0x20,
  0x08, 0x01, 0x0E, 0x3F, 0x83, 0x80, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0x08,
  0xFB, 0xC7, 0xDE, 0x38, 0xE3, 0x8F, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87,
  0x38, 0x73, 0x87, 0x38, 0x77, 0xA6, 0x3C, 0x41, 0x8C, 0x11, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x00, 0x10, 0x3C, 0x7E, 0x0E, 0x0C, 0x0C, 0x10,
  0x23, 0x7C, 0xBE, 0x2E, 0x47, 0x47, 0x87, 0x87, 0x83, 0x83, 0x87, 0x86,
  0x44, 0x38, 0x07, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x30, 0xC0, 0x60, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x07, 0x0C, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x60, 0x80, 0xFF, 0xFF, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 22, 7, 1, -22 },
  { 15, 10, 8, 12, 1, -21 },
  { 25, 13, 17, 15, 1, -19 },
  { 53, 10, 24, 13, 1, -23 },
  { 83, 20, 21, 21, 1, -21 },
  { 136, 15, 19, 17, 1, -19 },
  { 172, 5, 8, 6, 0, -21 },
  { 177, 7, 25, 7, 0, -24 },
  { 199, 7, 25, 7, 0, -24 },
  { 221, 10, 12, 11, 0, -23 },
  { 236, 10, 10, 12, 1, -15 },
  { 249, 5, 9, 6, 0, -5 },
  { 255, 8, 6, 9, 1, -12 },
  { 261, 5, 5, 6, 0, -5 },
  { 265, 14, 23, 16, 1, -22 },
  { 306, 14, 21, 14, 0, -21 },
  { 343, 9, 21, 10, 0, -21 },
  { 367, 13, 20, 13, 0, -20 },
  { 400, 14, 20, 14, 0, -20 },
  { 435, 13, 20, 14, 0, -20 },
  { 468, 14, 22, 14, 0, -22 },
  { 507, 13, 21, 14, 0, -21 },
  { 542, 13, 20, 13, 0, -20 },
  { 575, 13, 21, 14, 0, -21 },
  { 610, 13, 21, 14, 0, -21 },
  { 645, 5, 14, 6, 0, -14 },
  { 654, 5, 18, 5, 0, -14 },
  { 666, 8, 11, 9, 0, -14 },
  { 677, 10, 6, 12, 1, -12 },
  { 685, 8, 11, 9, 0, -14 },
  { 696, 11, 22, 14, 1, -22 },
  { 727, 18, 18, 18, 0, -14 },
  { 768, 23, 22, 24, 1, -21 },
  { 832, 26, 23, 27, 0, -22 },
  { 907, 19, 22, 21, 1, -22 },
  { 960, 23, 23, 24, 1, -22 },
  { 1027, 20, 22, 21, 1, -22 },
  { 1082, 21, 26, 23, 1, -22 },
  { 1151, 21, 23, 23, 1, -22 },
  { 1212, 21, 27, 22, 0, -23 },
  { 1283, 20, 25, 21, 0, -22 },
  { 1346, 20, 29, 21, 1, -22 },
  { 1419, 24, 22, 24, 0, -21 },
  { 1485, 17, 22, 17, 0, -21 },
  { 1532, 31, 23, 33, 1, -21 },
  { 1622, 25, 22, 26, 1, -21 },
  { 1691, 21, 23, 23, 1, -22 },
  { 1752, 26, 26, 27, 0, -21 },
  { 1837, 22, 24, 24, 1, -22 },
  { 1903, 26, 22, 28, 1, -22 },
  { 1975, 21, 22, 23, 1, -22 },
  { 2033, 21, 21, 22, 1, -21 },
  { 2089, 20, 23, 21, 1, -21 },
  { 2147, 25, 23, 27, 1, -22 },
  { 2219, 31, 23, 32, 1, -22 },
  { 2309, 20, 22, 22, 1, -22 },
  { 2364, 24, 27, 26, 1, -22 },
  { 2445, 19, 25, 20, 0, -21 },
  { 2505, 5, 23, 6, 0, -22 },
  { 2520, 19, 21, 3, -6, -20 },
  { 2570, 5, 23, 6, 0, -22 },
  { 2585, 11, 8, 13, 1, -21 },
  { 2596, 14, 2, 14, 0, 3 },
  { 2600, 4, 6, 15, 5, -21 },
  { 2603, 12, 16, 14, 1, -15 },
  { 2627, 12, 22, 13, 1, -21 },
  { 2660, 9, 16, 11, 1, -15 },
  { 2678, 12, 22, 14, 1, -21 },
  { 2711, 9, 16, 11, 1, -15 },
  { 2729, 9, 26, 7, 0, -22 },
  { 2759, 12, 22, 14, 1, -16 },
  { 2792, 12, 26, 13, 1, -21 },
  { 2831, 8, 22, 8, 0, -21 },
  { 2853, 9, 27, 7, -2, -21 },
  { 2884, 8, 22, 10, 1, -21 },
  { 2906, 8, 22, 8, 1, -21 },
  { 2928, 20, 17, 21, 1, -16 },
  { 2971, 13, 16, 15, 1, -15 },
  { 2997, 12, 16, 12, 0, -15 },
  { 3021, 13, 24, 14, 0, -18 },
  { 3060, 12, 22, 13, 0, -16 },
  { 3093, 9, 16, 11, 1, -15 },
  { 3111, 11, 20, 13, 1, -19 },
  { 3139, 9, 20, 9, 0, -19 },
  { 3162, 13, 17, 15, 1, -16 },
  { 3190, 13, 18, 14, 0, -17 },
  { 3220, 19, 19, 21, 1, -18 },
  { 3266, 10, 22, 12, 1, -16 },
  { 3294, 12, 23, 14, 1, -18 },
  { 3329, 8, 21, 10, 1, -15 },
  { 3350, 8, 24, 10, 1, -23 },
  { 3374, 2, 24, 5, 1, -23 },
  { 3380, 8, 24, 10, 1, -23 },
  { 3404, 9, 2, 11, 1, -10 },
};

const GFXfont UnifrakturMaguntia_Regular30pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular30pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular30pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR30PT7B_H_
