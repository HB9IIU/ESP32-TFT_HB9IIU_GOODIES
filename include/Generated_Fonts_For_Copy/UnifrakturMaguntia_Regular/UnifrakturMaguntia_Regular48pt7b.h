#ifndef _UNIFRAKTURMAGUNTIA_REGULAR48PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x04, 0x07, 0x07, 0xC7, 0xF7, 0xFD, 0xFC, 0x7C, 0x3E, 0x1F,
  0x0F, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xE0, 0xF8,
  0xFE, 0x3E, 0x0E, 0x02, 0x00, 0x00, 0x08, 0x04, 0x0C, 0x06, 0x0F, 0x07,
  0x8F, 0xE7, 0xFB, 0xF7, 0xF8, 0xF8, 0x7C, 0x38, 0x1C, 0x1C, 0x0E, 0x0C,
  0x06, 0x06, 0x03, 0x02, 0x01, 0x01, 0x00, 0x81, 0x00, 0x80, 0x03, 0xC3,
  0xC0, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x0E, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC1, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x38, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xE0,
  0x0F, 0xF0, 0x1C, 0x18, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0F, 0x78, 0x0F, 0x7C, 0x0E, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x60, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E,
  0x60, 0x0E, 0x30, 0x1C, 0x1C, 0x78, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0x80, 0x00, 0x02, 0x1F, 0xE0,
  0x00, 0x06, 0x3C, 0xF0, 0x00, 0x0C, 0x38, 0x70, 0x00, 0x18, 0x78, 0x78,
  0x00, 0x38, 0x78, 0x78, 0x00, 0x70, 0x78, 0x7C, 0x00, 0x60, 0xF8, 0x7C,
  0x00, 0xC0, 0xF8, 0x7C, 0x01, 0x80, 0xF8, 0x7C, 0x03, 0x00, 0xF8, 0x7C,
  0x06, 0x00, 0x78, 0x7C, 0x0C, 0x00, 0x78, 0x78, 0x1C, 0x00, 0x78, 0x78,
  0x18, 0x00, 0x38, 0x70, 0x30, 0x00, 0x3C, 0xF0, 0x60, 0x00, 0x1F, 0xE0,
  0xC1, 0xE0, 0x07, 0x81, 0x87, 0xF8, 0x00, 0x03, 0x0F, 0x3C, 0x00, 0x07,
  0x0E, 0x1C, 0x00, 0x0E, 0x1E, 0x1E, 0x00, 0x0C, 0x1E, 0x1E, 0x00, 0x18,
  0x1E, 0x1F, 0x00, 0x30, 0x3E, 0x1F, 0x00, 0x60, 0x3E, 0x1F, 0x00, 0xC0,
  0x3E, 0x1F, 0x01, 0xC0, 0x3E, 0x1F, 0x03, 0x80, 0x1E, 0x1F, 0x03, 0x00,
  0x1E, 0x1E, 0x06, 0x00, 0x1E, 0x1E, 0x0C, 0x00, 0x0E, 0x1C, 0x18, 0x00,
  0x0F, 0x3C, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x01, 0xC6, 0x00, 0x03, 0x87, 0x00, 0x03, 0x83, 0x80, 0x07, 0x83,
  0x80, 0x07, 0x83, 0x80, 0x07, 0x83, 0x80, 0x07, 0xC7, 0x00, 0x07, 0xC7,
  0x00, 0x07, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0xFF, 0x07, 0xF0, 0x3E, 0x1D, 0xF8, 0x1C, 0x39, 0xF8, 0x18, 0x70, 0xFC,
  0x18, 0x70, 0xFC, 0x10, 0xF0, 0x7E, 0x10, 0xF0, 0x7E, 0x30, 0xF0, 0x3F,
  0x20, 0xF8, 0x3F, 0x60, 0xF8, 0x1F, 0xC0, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC1, 0x7E, 0x07, 0xE3, 0x7F, 0x0F, 0xFE, 0x3F, 0xF9, 0xFC, 0x0F, 0xE0,
  0xF8, 0x10, 0x30, 0xF7, 0xF7, 0xE7, 0xC7, 0x86, 0x0C, 0x10, 0x20, 0x81,
  0x00, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x1C, 0x80, 0x1C, 0x01, 0x80, 0x30, 0x0E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x30, 0x1C,
  0x06, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x1B,
  0xE8, 0xF9, 0xDF, 0x79, 0x9E, 0x7D, 0xBE, 0x7F, 0xFE, 0x01, 0x80, 0x7F,
  0xFE, 0x7D, 0xBE, 0x79, 0x9E, 0xF9, 0x9F, 0x1B, 0xD8, 0x07, 0xE0, 0x03,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x08, 0x18, 0x3C, 0x7F, 0x3F, 0x1F, 0x0E, 0x0E, 0x0C,
  0x0C, 0x08, 0x08, 0x10, 0x00, 0x7C, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x20,
  0x00, 0x0F, 0x87, 0xFE, 0x1F, 0xF0, 0xFE, 0x00, 0x10, 0x38, 0x7C, 0xFE,
  0x7C, 0x38, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xE3, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xFC,
  0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFB, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x03,
  0xC0, 0x3C, 0x1E, 0x00, 0xF1, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x47, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x3F, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3C, 0x3F, 0xC7, 0x00, 0xFE, 0x60, 0x07, 0xE4, 0x00, 0x7E, 0xC0, 0x07,
  0xEC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x20, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x06, 0x0F, 0xF0, 0x60, 0x1F, 0x86,
  0x00, 0x7E, 0x40, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x70, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79,
  0xF8, 0x03, 0xCF, 0xC0, 0x1C, 0x3E, 0x01, 0xC1, 0xF0, 0x0C, 0x03, 0xC1,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1B,
  0xE0, 0x01, 0xDF, 0x00, 0x0C, 0xF8, 0x00, 0xC7, 0xC0, 0x06, 0x3E, 0x00,
  0x61, 0xF0, 0x06, 0x0F, 0x80, 0x30, 0x7C, 0x03, 0x03, 0xE0, 0x30, 0x1F,
  0x01, 0x80, 0xF8, 0x18, 0x07, 0xC0, 0x80, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0xF8, 0x7E,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x23, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xE0, 0x7F, 0x8C, 0x01, 0xFC, 0x40, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x9C, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0x7E,
  0x00, 0xF3, 0xF0, 0x07, 0x0F, 0x80, 0x70, 0x3C, 0x03, 0x00, 0xF0, 0x70,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x38, 0xF0, 0x07, 0x07, 0xC0, 0xE0,
  0x7C, 0x0E, 0x07, 0xE1, 0xE0, 0x7E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C,
  0x01, 0xC7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x07,
  0xCF, 0xF0, 0xFC, 0xFF, 0xCF, 0xD8, 0xFC, 0xFF, 0x07, 0xEF, 0xE0, 0x3E,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0,
  0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x38, 0x1E, 0x03, 0x80, 0xF0, 0x70, 0x07,
  0x0E, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFD, 0xC0, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x80,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0xE0, 0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xC7,
  0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0xC0, 0x1E,
  0x7E, 0x01, 0xC7, 0xF8, 0x38, 0x3F, 0xE3, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x1C, 0x7F, 0xC3, 0x81,
  0xFE, 0x70, 0x0F, 0xE7, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xE7,
  0x00, 0x1E, 0x70, 0x01, 0xC3, 0x80, 0x38, 0x0E, 0x07, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x71, 0xC0, 0x0E, 0x0F, 0x01, 0xC0, 0x78, 0x3C, 0x07,
  0x83, 0xC0, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80,
  0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xF7, 0xE0, 0xBF, 0x7E, 0x1B, 0xE3,
  0xFF, 0x3E, 0x1F, 0xE3, 0xE0, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC1, 0x00, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x07,
  0x87, 0xC0, 0x70, 0x7C, 0x0E, 0x03, 0xE0, 0xC0, 0x1E, 0x18, 0x00, 0x7F,
  0x00, 0x10, 0x10, 0x38, 0x7C, 0xFE, 0x3C, 0x18, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x38, 0x7C, 0xFE, 0x7C, 0x38, 0x10,
  0x00, 0x08, 0x04, 0x07, 0x07, 0xC7, 0xF0, 0xF0, 0x30, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x0F, 0x0F, 0xE3,
  0xF0, 0xF8, 0x38, 0x1C, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0x0F, 0x87, 0x00, 0xF3, 0x80,
  0x3E, 0xE0, 0x07, 0xB8, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xDE, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x08, 0x1C, 0x02, 0x07, 0x81, 0x00, 0xF0, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x3C, 0x07, 0xF9, 0xC3,
  0x81, 0xFF, 0x9C, 0x78, 0x3C, 0xF8, 0xC7, 0x07, 0x8F, 0x0C, 0xF0, 0xF0,
  0xF0, 0xCF, 0x1F, 0x0F, 0x0C, 0xE1, 0xE0, 0xF0, 0xCE, 0x3E, 0x1E, 0x1C,
  0xE3, 0xE1, 0xE1, 0xCE, 0x3C, 0x3E, 0x38, 0xE3, 0xC3, 0xC3, 0x8E, 0x3C,
  0x7C, 0x70, 0xE3, 0xCF, 0xCE, 0x0E, 0x3F, 0xFF, 0xC7, 0x71, 0xF1, 0xF0,
  0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x20, 0x1F, 0xFE,
  0x00, 0x06, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x3C, 0xFF, 0xE0, 0x3F, 0x03,
  0x00, 0xFF, 0x87, 0xF8, 0x10, 0x03, 0xFC, 0x7F, 0xC1, 0x80, 0x0F, 0xF0,
  0xFC, 0x08, 0x00, 0x3F, 0x87, 0xE0, 0xC0, 0x00, 0xFC, 0x3F, 0x06, 0x00,
  0x07, 0xF1, 0xF8, 0x30, 0x00, 0x1F, 0x8F, 0xC1, 0x80, 0x00, 0xFC, 0x7E,
  0x0E, 0x00, 0x07, 0xC3, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x81, 0xFE, 0x01,
  0xF0, 0xFC, 0x07, 0xF8, 0x0F, 0x07, 0xE0, 0x3F, 0xE0, 0xF8, 0x3F, 0x00,
  0x7F, 0x07, 0x81, 0xF8, 0x00, 0xF8, 0x38, 0x0F, 0xC0, 0x01, 0xC3, 0x80,
  0x7E, 0x00, 0x0C, 0x18, 0x03, 0xF0, 0x00, 0x41, 0x80, 0x1F, 0x80, 0x00,
  0x18, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x07, 0xF8, 0x02, 0x1F, 0xF8, 0x4F, 0xFC,
  0x00, 0x7F, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x07, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xE3, 0x1F, 0xC0, 0x1F, 0xFF, 0xFD, 0x83,
  0xF8, 0x0F, 0xC1, 0xFF, 0x40, 0xFE, 0x03, 0xC0, 0x1F, 0xF0, 0x1F, 0x81,
  0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x70, 0x00, 0x7F, 0x01, 0xFC, 0x18, 0x00,
  0x0F, 0xC0, 0x3F, 0x06, 0x00, 0x03, 0xF0, 0x0F, 0xF1, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x60, 0x00, 0x1F, 0x00, 0x38, 0x18, 0x00, 0x07, 0xC0, 0x38,
  0x06, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x78, 0x3F, 0xE0, 0x38,
  0x00, 0x1E, 0x3F, 0xFE, 0x07, 0x01, 0x87, 0x3F, 0xFF, 0xC0, 0xF1, 0xC3,
  0xC0, 0x3F, 0xF0, 0x07, 0xC0, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0x80, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xE0,
  0x00, 0x1C, 0x01, 0x8F, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0x80, 0x00, 0x3F, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x02, 0x00,
  0x01, 0xFE, 0x0F, 0x00, 0x0F, 0x02, 0x3F, 0x80, 0x3C, 0x06, 0xFF, 0xF0,
  0xF0, 0x07, 0xFF, 0xC1, 0xE0, 0x18, 0xFF, 0x07, 0xC0, 0x60, 0x38, 0x0F,
  0x03, 0x80, 0x20, 0x3E, 0x0E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7,
  0xF8, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x7E, 0x0F,
  0xF8, 0x00, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x0F,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x3F, 0x80, 0x3C,
  0x00, 0x7F, 0x80, 0xE0, 0x00, 0x7F, 0x81, 0x80, 0x00, 0x7F, 0x8C, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0xFF, 0xF0, 0x0E,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFC,
  0x07, 0xC0, 0x18, 0x3F, 0xE0, 0x7C, 0x03, 0x80, 0x7F, 0x83, 0x80, 0x38,
  0x01, 0xFE, 0x3C, 0x03, 0xC0, 0x07, 0xF1, 0xC0, 0x1E, 0x00, 0x1F, 0xCE,
  0x01, 0xF8, 0x00, 0x7E, 0x60, 0x0F, 0xE0, 0x01, 0xFB, 0x00, 0x7F, 0x80,
  0x07, 0xD8, 0x01, 0xFE, 0x00, 0x3E, 0xC0, 0x0F, 0xF8, 0x00, 0xF2, 0x00,
  0x3F, 0xE0, 0x07, 0x98, 0x00, 0xFF, 0x00, 0x1C, 0x40, 0x03, 0xFC, 0x00,
  0xE3, 0x80, 0x0F, 0xE0, 0x07, 0x06, 0x04, 0x3F, 0x00, 0x38, 0x1F, 0xE0,
  0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0xFE, 0x00,
  0x01, 0x80, 0x1F, 0xFC, 0x00, 0x08, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0C, 0x03, 0x8F, 0xFF, 0xE1, 0xC0, 0x10, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0x00,
  0x00, 0xFF, 0x07, 0xC0, 0x03, 0xC0, 0x8F, 0xE0, 0x07, 0x80, 0xDF, 0xFE,
  0x0F, 0x00, 0x7F, 0xFC, 0x0F, 0x00, 0xC7, 0xF0, 0x1E, 0x01, 0x80, 0xE0,
  0x1E, 0x07, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x81, 0xC0,
  0x7C, 0x3F, 0xC3, 0xF0, 0x7C, 0x1F, 0xE7, 0xFF, 0x7E, 0x1F, 0xFF, 0xFE,
  0x7E, 0x0F, 0xFD, 0xFC, 0x7E, 0x07, 0xFC, 0x78, 0x7E, 0x03, 0xFE, 0x30,
  0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x1F, 0x00,
  0x1F, 0xC0, 0x1E, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x0F, 0xF0, 0x30, 0x00,
  0x07, 0xF8, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x06,
  0x01, 0xFF, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F,
  0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0xFC, 0x38, 0x00, 0x13, 0xFC, 0x1C, 0x00,
  0x0C, 0x7E, 0x06, 0x00, 0x06, 0x07, 0x01, 0x80, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x41,
  0x00, 0x07, 0xF0, 0x3C, 0x60, 0x01, 0xFC, 0x0F, 0x98, 0x00, 0x7F, 0x87,
  0xF6, 0x00, 0x0F, 0xF3, 0xFC, 0xC0, 0x03, 0xFF, 0xFE, 0x18, 0x00, 0x7F,
  0xCF, 0x03, 0x80, 0x8F, 0xF1, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x3C,
  0x00, 0x7F, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x18, 0x00, 0x03, 0x81, 0x07, 0x80, 0x01, 0xE0, 0x13, 0xF8,
  0x00, 0x78, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x67, 0xF8, 0x03, 0xC0, 0x18,
  0x7F, 0x80, 0xF8, 0x0C, 0x07, 0xFC, 0x1E, 0x03, 0x80, 0x7F, 0x87, 0xC1,
  0xE0, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0x70, 0x3F, 0x0F, 0x80, 0x1C, 0x07,
  0xE1, 0xF0, 0x06, 0x00, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x07, 0xF0, 0xFF,
  0x83, 0xF0, 0xFE, 0x3F, 0xF8, 0xFE, 0x0F, 0xE8, 0xFF, 0x9F, 0xC1, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x7F, 0x7F, 0x01, 0xFE, 0x07, 0xE7, 0xE0,
  0x1F, 0xC0, 0xFC, 0xFC, 0x03, 0xFC, 0x0F, 0x9F, 0xC0, 0x3F, 0x81, 0xFB,
  0xF8, 0x03, 0xF0, 0x3F, 0x3F, 0x00, 0x7E, 0x07, 0xC7, 0xF0, 0x07, 0x80,
  0xF8, 0xFE, 0x00, 0xE0, 0x1F, 0x0F, 0xE0, 0x38, 0x03, 0xC0, 0xFC, 0x0E,
  0x00, 0xF8, 0x0F, 0xC3, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x1E, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC7,
  0xF8, 0x00, 0x00, 0xC1, 0xFF, 0x80, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0xC0,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x08, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x3F, 0xFE, 0x00,
  0xFF, 0x71, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x70, 0x1E, 0x00,
  0xFC, 0xFC, 0x07, 0x00, 0x7C, 0xFF, 0x03, 0x00, 0x3E, 0xFF, 0xC1, 0x00,
  0x1F, 0x0F, 0xFB, 0x00, 0x0F, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0xFF, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x04, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x7F, 0xE0, 0x07, 0x80,
  0x3F, 0xF0, 0x0E, 0x00, 0x3F, 0xFE, 0x38, 0x00, 0x3F, 0xF0, 0x70, 0x00,
  0x1F, 0xC0, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F,
  0x80, 0x18, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x3C, 0x04, 0xFE, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x07, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x3E, 0x3F, 0xF0, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0xF3, 0x3F,
  0xF0, 0x01, 0xC0, 0x1F, 0xF0, 0x03, 0x80, 0x1F, 0xF0, 0x0E, 0x00, 0x1F,
  0xF0, 0x30, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x38, 0x00,
  0x7F, 0xFC, 0x38, 0x00, 0x3F, 0xF0, 0x30, 0x00, 0x0F, 0xE0, 0x30, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x18, 0x00,
  0x1F, 0x80, 0x18, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x1F, 0x80, 0x07, 0x00,
  0x9F, 0xC0, 0x01, 0xFF, 0x0F, 0xC0, 0x00, 0x38, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xC0,
  0x00, 0x1C, 0x3F, 0xF0, 0x00, 0x38, 0x7F, 0xF8, 0x00, 0x38, 0xCF, 0xFC,
  0x00, 0x30, 0x03, 0xFE, 0x00, 0x60, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0xFF,
  0x81, 0xC0, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x3C, 0x0F, 0x80, 0xE0, 0x03, 0xC1,
  0xFF, 0x03, 0x80, 0x1E, 0x1F, 0xFC, 0x0C, 0x01, 0xF1, 0xFF, 0xF0, 0x70,
  0x0F, 0x8C, 0x3F, 0xC3, 0x80, 0xFC, 0xC0, 0xFE, 0x0C, 0x07, 0xE4, 0x03,
  0xF8, 0x60, 0x3F, 0x20, 0x0F, 0xC3, 0x81, 0xFD, 0x00, 0x7F, 0x1C, 0x07,
  0xF8, 0x01, 0xFC, 0xC0, 0x3F, 0xC0, 0x0F, 0xC6, 0x01, 0xFE, 0x00, 0x38,
  0x60, 0x07, 0xF8, 0x03, 0x03, 0x00, 0x3F, 0xC0, 0x30, 0x30, 0x00, 0xFF,
  0x07, 0xC6, 0x00, 0x03, 0xFC, 0xFF, 0x20, 0x00, 0x1F, 0xEB, 0xFC, 0x00,
  0x00, 0x7F, 0x87, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0x80, 0xF0, 0x1F, 0x80, 0x3E,
  0x03, 0x80, 0xFE, 0x07, 0xF8, 0x18, 0x07, 0xF0, 0x7F, 0xE0, 0xC0, 0x1F,
  0xC2, 0x7F, 0x8C, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0x3F, 0x00, 0x07, 0x9F, 0x80, 0x03, 0xCF, 0xE0, 0x01, 0xE7, 0xF0,
  0x01, 0xF3, 0xFC, 0x00, 0xF8, 0xFE, 0x00, 0x78, 0x7F, 0x80, 0x7C, 0x1F,
  0xC8, 0xFC, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0C, 0x3F, 0xF8, 0x08, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x00, 0x7F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFF, 0xF3,
  0xFF, 0xCC, 0xFE, 0x01, 0xFF, 0xFF, 0xC7, 0xFB, 0x0F, 0xE0, 0x78, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFC, 0x1C, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC3, 0x00,
  0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x40, 0x01, 0xFE, 0x07, 0xE0, 0x3F, 0x18,
  0x00, 0x1F, 0xC0, 0xFE, 0x07, 0xE2, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFE,
  0x40, 0x00, 0x3F, 0x81, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x01,
  0xF9, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x1C, 0x10, 0x00, 0x07, 0xC0, 0x7C,
  0x02, 0x03, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xC0, 0x7F, 0xF8, 0x1F, 0x01,
  0xF0, 0x30, 0x07, 0xFF, 0x03, 0xE0, 0x3E, 0x0C, 0x00, 0x7F, 0xE0, 0x7C,
  0x07, 0xC3, 0x80, 0x03, 0xC6, 0x0F, 0x80, 0xF0, 0xF0, 0x00, 0x00, 0x81,
  0xE0, 0x1E, 0x1E, 0x00, 0x00, 0x10, 0x3C, 0x03, 0xC7, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x78, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x1F, 0x00, 0x00,
  0x00, 0x1C, 0x01, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x30, 0x7E, 0x00,
  0x00, 0x00, 0x40, 0x06, 0x0F, 0xC0, 0x01, 0xF0, 0x19, 0xC0, 0x81, 0xFC,
  0x00, 0xFF, 0x02, 0x7C, 0x30, 0x1F, 0xC0, 0x3F, 0xF0, 0x9F, 0xEC, 0x03,
  0xFF, 0xCC, 0xFF, 0x37, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xF1, 0x87, 0xF0, 0x38,
  0x1F, 0xFB, 0x03, 0xF0, 0x70, 0x07, 0xFE, 0x03, 0xF8, 0x60, 0x01, 0xFE,
  0x01, 0xF8, 0xC0, 0x01, 0xFE, 0x01, 0xF8, 0xC0, 0x00, 0xFE, 0x01, 0xFC,
  0x80, 0x00, 0x7E, 0x01, 0xFE, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0xF8, 0xC0, 0x00, 0x3F, 0x00, 0x70, 0x40, 0x00, 0x1F, 0x00,
  0x40, 0x60, 0xE0, 0x1F, 0x00, 0xC0, 0x3F, 0xF8, 0x1F, 0x01, 0x80, 0x3F,
  0xF8, 0x1F, 0x03, 0x80, 0x0F, 0xFC, 0x1F, 0x07, 0x00, 0x03, 0x0C, 0x0F,
  0x0F, 0x00, 0x00, 0x08, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x80, 0x00, 0x00,
  0x1C, 0x1F, 0x80, 0x00, 0x00, 0x18, 0x1F, 0x80, 0x00, 0xC0, 0x38, 0x1F,
  0xC0, 0x07, 0xF0, 0x30, 0x1F, 0xC0, 0x0F, 0xF8, 0x60, 0x0F, 0xE1, 0x1F,
  0xF8, 0x60, 0x0F, 0xFF, 0x33, 0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x38,
  0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x03, 0xFE, 0x0E, 0x00, 0x00, 0x7F, 0x87,
  0x80, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00, 0xF9, 0xFF, 0xC0, 0x00,
  0x3E, 0x7F, 0xF8, 0x00, 0x07, 0x8F, 0xFF, 0x80, 0x01, 0xE1, 0xFF, 0xE0,
  0x00, 0x78, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0C, 0x01,
  0x08, 0x00, 0x03, 0x01, 0xF4, 0x00, 0x01, 0x81, 0xFF, 0x00, 0x00, 0x60,
  0xFF, 0xE0, 0x00, 0x30, 0xFF, 0xFE, 0x00, 0x08, 0x01, 0xFF, 0xC0, 0x04,
  0x00, 0x1F, 0xFC, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0x80, 0x03, 0xFF, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x1F, 0xE0, 0x03,
  0xC0, 0x7F, 0xBB, 0xF8, 0x03, 0x80, 0x1F, 0xF1, 0xFE, 0x01, 0x80, 0x07,
  0xF0, 0xFF, 0x00, 0xC0, 0x01, 0xF8, 0x3F, 0xE0, 0x40, 0x00, 0xFE, 0x1F,
  0xF8, 0x20, 0x00, 0x7F, 0x07, 0xFE, 0x10, 0x00, 0x1F, 0x81, 0xFF, 0x88,
  0x00, 0x0F, 0xC0, 0x7F, 0xE6, 0x00, 0x07, 0xE0, 0x1F, 0xF1, 0x00, 0x03,
  0xF0, 0x03, 0xFC, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x30, 0x08, 0xFC, 0x00,
  0x3F, 0x0F, 0x9C, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x03,
  0xE0, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0xC3, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x7F, 0xFF,
  0x00, 0x03, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x1C, 0x00,
  0x03, 0xFE, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x00, 0xFF, 0x07,
  0x80, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x01,
  0xF8, 0x7F, 0x80, 0x00, 0x0F, 0x87, 0xFF, 0x00, 0x00, 0xF8, 0x7F, 0xF8,
  0x00, 0x07, 0x83, 0xFF, 0xE0, 0x00, 0x78, 0x1F, 0xFE, 0x00, 0x07, 0x80,
  0x7F, 0xF0, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x08,
  0x00, 0x83, 0x00, 0xFD, 0x00, 0x3F, 0x60, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFE, 0x19, 0xFC, 0x10, 0x7F, 0xF0, 0x0F,
  0xF6, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF1, 0x0F, 0xF0, 0x0F, 0x87, 0xFF, 0x40, 0xFE, 0x03, 0xC0,
  0x1F, 0xE8, 0x0F, 0xE0, 0x70, 0x01, 0xFF, 0x01, 0xFC, 0x0C, 0x00, 0x1F,
  0xE0, 0x1F, 0xC3, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x60, 0x00, 0x1F, 0x80,
  0x3F, 0xCC, 0x00, 0x01, 0xF0, 0x03, 0xF1, 0x80, 0x00, 0x3E, 0x00, 0x38,
  0x30, 0x00, 0x07, 0xC0, 0x0C, 0x06, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x60,
  0x00, 0x0F, 0x81, 0x80, 0x0C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x0E, 0x03, 0x07, 0x9F, 0xE0, 0x00, 0xFB, 0x80, 0xF5,
  0xFE, 0x00, 0x01, 0x80, 0x1E, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xC1, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x70,
  0x0E, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x20,
  0x03, 0xF8, 0x03, 0xFF, 0x08, 0x00, 0x7F, 0x90, 0x5F, 0xFB, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x18,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xE7, 0xFF, 0xFE, 0x00, 0x60, 0x1F, 0xFF,
  0x00, 0x30, 0x01, 0xFF, 0x80, 0x18, 0x00, 0x1F, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x07, 0xFF, 0x07, 0x00,
  0x03, 0xFF, 0xE3, 0xC1, 0x83, 0xFF, 0xFC, 0xF0, 0x37, 0xFF, 0xE3, 0xBC,
  0x07, 0xFF, 0xC0, 0x2F, 0x00, 0xFF, 0xC0, 0x0B, 0xE0, 0x1F, 0xE0, 0x03,
  0xF8, 0x03, 0xE0, 0x00, 0x5F, 0x00, 0x00, 0x00, 0x17, 0xC0, 0x00, 0x00,
  0x0D, 0xF8, 0x00, 0x00, 0x03, 0x7F, 0x00, 0x00, 0x00, 0x8F, 0xF0, 0x00,
  0x00, 0x61, 0xFE, 0x00, 0x00, 0x70, 0x7F, 0xE0, 0x00, 0x7C, 0x0F, 0xFF,
  0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3C, 0x07, 0xFF,
  0xC0, 0x0C, 0x00, 0x7F, 0xF8, 0x06, 0x00, 0x07, 0xFF, 0x85, 0x80, 0x03,
  0x7F, 0xFE, 0xC0, 0x01, 0x87, 0xFF, 0x30, 0x01, 0xC0, 0xFF, 0x8C, 0x00,
  0xF0, 0x0F, 0xC3, 0x00, 0x3E, 0x00, 0x80, 0xC0, 0x0F, 0xC0, 0x00, 0x10,
  0x03, 0xF8, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x3F, 0xE0, 0x00,
  0x10, 0x07, 0xFC, 0x00, 0x03, 0xDC, 0xFF, 0x80, 0x00, 0x08, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x0F,
  0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x3F, 0xF8,
  0x38, 0x00, 0x1F, 0xFF, 0x1C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80,
  0x03, 0xFF, 0x80, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x06, 0x03, 0x82, 0x00, 0x1C, 0x07, 0x01, 0x00, 0x78, 0x0F, 0x01, 0x01,
  0xF0, 0x1F, 0x01, 0x07, 0xF0, 0x1F, 0x02, 0x0F, 0xF0, 0x3F, 0x04, 0x07,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0x03,
  0xE0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x03,
  0xE0, 0x07, 0xF8, 0x03, 0xE0, 0x03, 0xFC, 0x03, 0xE0, 0x01, 0xFC, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x70, 0x03, 0xE0, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x03,
  0xF0, 0x01, 0x80, 0x03, 0xF0, 0x03, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xF8, 0x1B,
  0xF0, 0xC7, 0xFC, 0x73, 0xF9, 0x01, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xC3,
  0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0x80,
  0x0F, 0xFF, 0xE1, 0x9F, 0xC0, 0x1F, 0xFF, 0xF2, 0x0F, 0xE0, 0x3E, 0x1F,
  0xFA, 0x07, 0xE0, 0x78, 0x03, 0xFE, 0x07, 0xF0, 0x70, 0x01, 0xFC, 0x07,
  0xF0, 0xE0, 0x00, 0xFC, 0x03, 0xFC, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0xC0,
  0x00, 0x7E, 0x01, 0xF0, 0xC0, 0x00, 0x3E, 0x00, 0x40, 0xC0, 0x00, 0x3E,
  0x00, 0xC0, 0xC0, 0x00, 0x3E, 0x01, 0x80, 0x40, 0x00, 0x3E, 0x03, 0x80,
  0x60, 0x00, 0x3C, 0x07, 0xC0, 0x20, 0x00, 0x3C, 0x07, 0xC0, 0x18, 0x0C,
  0x38, 0x07, 0xE0, 0x0F, 0x70, 0x38, 0x07, 0xF0, 0x03, 0xC0, 0x70, 0x07,
  0xF8, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x00, 0x3C,
  0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x06, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x0F,
  0xFC, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xC0,
  0x40, 0x00, 0x00, 0xFF, 0xF1, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x01,
  0xC0, 0x7F, 0x00, 0x01, 0xFF, 0xC1, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xF9,
  0xDC, 0x87, 0xF8, 0x03, 0xFF, 0xFE, 0x83, 0x81, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xC0, 0x7F, 0x83, 0xE0, 0x3F, 0xE0, 0xC0, 0x1F, 0xC1, 0xC0, 0x07,
  0xF0, 0xE0, 0x07, 0xE1, 0xC0, 0x01, 0xF8, 0x70, 0x03, 0xF8, 0xE0, 0x00,
  0xFE, 0x38, 0x00, 0xFC, 0x60, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0xB0, 0x00,
  0x1F, 0x9F, 0x00, 0x1F, 0x18, 0x00, 0x07, 0xCF, 0xC0, 0x06, 0x0C, 0x00,
  0x03, 0xE7, 0xF0, 0x02, 0x02, 0x00, 0x01, 0xF3, 0xF8, 0x07, 0x01, 0x80,
  0x00, 0xF0, 0xFE, 0x07, 0x80, 0x40, 0x00, 0x78, 0x7F, 0x03, 0xE0, 0x30,
  0x04, 0x3C, 0x1F, 0xC3, 0xF8, 0x06, 0x0C, 0x1C, 0x0F, 0xE1, 0xFE, 0x01,
  0xF8, 0x0C, 0x03, 0xF0, 0xFF, 0x80, 0x00, 0x0E, 0x01, 0xF8, 0x3F, 0xE0,
  0x00, 0x06, 0x00, 0x7C, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x3E, 0x03, 0xFC,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x07, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x0F, 0x80, 0xFF, 0xC0, 0x01, 0x80, 0x03,
  0xC1, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xC1, 0x8F, 0xF8, 0x00, 0xFC, 0x00,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x20, 0x00, 0x1F, 0xFB, 0xDF, 0xF8, 0x20, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x7E, 0x43, 0xFF, 0xF0, 0x3F,
  0xE3, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF1, 0xE0, 0x1F, 0x9D,
  0xF0, 0xE0, 0x07, 0xE8, 0x70, 0x60, 0x03, 0xF4, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0x30, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x04, 0x00, 0x0F,
  0x80, 0x03, 0x00, 0x07, 0xC0, 0x00, 0x80, 0x03, 0xFF, 0xE0, 0x60, 0x03,
  0xFF, 0xE0, 0x18, 0x03, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x5F, 0x80, 0x00,
  0x00, 0x6F, 0xC0, 0x00, 0x78, 0x27, 0xF0, 0x00, 0x7E, 0x31, 0xFE, 0x10,
  0x3F, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8,
  0x13, 0xFC, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x1C, 0xFF, 0x01, 0xFF, 0xFF, 0x20,
  0xFE, 0x07, 0xC3, 0xFF, 0x40, 0xFE, 0x1E, 0x00, 0xFF, 0x01, 0xFC, 0x30,
  0x00, 0xFE, 0x01, 0xF8, 0xE0, 0x00, 0xFE, 0x03, 0xF9, 0x80, 0x00, 0xFC,
  0x07, 0xF3, 0x00, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0xEC,
  0x00, 0x03, 0xE0, 0x0F, 0x18, 0x00, 0x07, 0xC0, 0x0C, 0x10, 0x00, 0x0F,
  0x00, 0x70, 0x30, 0x00, 0x1E, 0x01, 0xC0, 0x30, 0x04, 0x3C, 0x07, 0x80,
  0x30, 0x10, 0x78, 0x1F, 0x00, 0x3F, 0xC0, 0xE0, 0x3F, 0x00, 0x06, 0x03,
  0xC0, 0xFE, 0x00, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x01, 0xFC,
  0x00, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x01,
  0x80, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x0C, 0x1F, 0xC0, 0x03,
  0xFE, 0x70, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0x37, 0xFF, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x01, 0xC0, 0x07, 0xC0, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x00,
  0x3E, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0xFF, 0x80, 0x70, 0x00, 0xFE, 0x01, 0x80, 0x01,
  0xF8, 0x0E, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x3E,
  0x01, 0x80, 0x00, 0xF8, 0x06, 0x00, 0x03, 0xE0, 0x08, 0x00, 0x0F, 0x00,
  0x18, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x73, 0xFF,
  0xC0, 0x01, 0xC8, 0xFF, 0x80, 0x06, 0x00, 0xFF, 0x00, 0x30, 0x01, 0xFE,
  0x01, 0x80, 0x03, 0xFE, 0x0C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xF3, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0x1C,
  0x01, 0xC6, 0x00, 0x3B, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE3, 0xE3, 0xC7, 0x87, 0x87,
  0x06, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x01, 0xFC, 0x00, 0x6F, 0xF8, 0x0C, 0x7F, 0xC1, 0xC1, 0xF8, 0x38, 0x0F,
  0x83, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xE0, 0xF8, 0x7F, 0x0F, 0x93, 0xFB, 0xFE, 0x1F, 0xCF, 0xE0,
  0xF8, 0x7C, 0x07, 0x03, 0xC0, 0x60, 0x08, 0x00, 0x70, 0x00, 0x30, 0x03,
  0x1C, 0x00, 0x27, 0x80, 0x02, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x40, 0x7C, 0x38, 0x0F, 0x8F, 0x81,
  0xF7, 0xF8, 0x3F, 0x3F, 0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0x1F, 0x07, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7,
  0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xC3, 0xE0, 0x70, 0x7C, 0x0E, 0x1F,
  0xC1, 0x87, 0xFE, 0x40, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x13,
  0xE0, 0x67, 0xC1, 0x87, 0xC7, 0x0F, 0x9E, 0x0F, 0xBC, 0x18, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x23, 0xFF,
  0x83, 0xFC, 0x01, 0xE0, 0x01, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x11, 0xFC, 0x1F, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0,
  0x0F, 0x1F, 0x00, 0xE1, 0xF0, 0x0E, 0x1F, 0x00, 0xE1, 0xF0, 0x0C, 0x1F,
  0x01, 0xC3, 0xFC, 0x18, 0x7F, 0xE1, 0x00, 0xFF, 0xA0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x13,
  0xE0, 0xE7, 0xC1, 0x87, 0xC7, 0x0F, 0x9E, 0x1F, 0x3C, 0x1F, 0x78, 0x3E,
  0xF0, 0x3B, 0xE1, 0x87, 0xDC, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x23, 0xFF,
  0x83, 0xFC, 0x01, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x3F, 0x90, 0xFF, 0xC3,
  0xFE, 0x1F, 0xF0, 0x41, 0x81, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01,
  0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x67,
  0xFC, 0x0C, 0x3F, 0xE1, 0xC1, 0xFC, 0x38, 0x07, 0x87, 0x80, 0x38, 0x78,
  0x03, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87,
  0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0xFC,
  0x3E, 0x07, 0xC3, 0xF0, 0xFE, 0x1F, 0xF3, 0xE0, 0xFC, 0x3E, 0x0E, 0x03,
  0xE0, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC3, 0x80,
  0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x70, 0x1E, 0x0E, 0x00, 0xF3, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x82, 0x0F, 0x00, 0x23, 0xC0, 0x04,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x80, 0x7C, 0x30, 0x0F, 0x8F, 0x01, 0xF7, 0xF0, 0x3F, 0xFE, 0x07,
  0xC7, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x7E,
  0x47, 0x9F, 0xF0, 0xE1, 0xFE, 0x38, 0x1F, 0x07, 0x00, 0xE1, 0xC0, 0x08,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0x81,
  0xE0, 0x18, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x1F, 0x07, 0xF9,
  0xFF, 0x27, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF2, 0x3F, 0x83,
  0xF0, 0x7C, 0x07, 0x80, 0x20, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x1F,
  0x00, 0xFE, 0x0F, 0xF8, 0x9F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xD0, 0x1E, 0xC1, 0xE2, 0x0E, 0x09,
  0xC0, 0x30, 0x00, 0x00, 0x7E, 0x07, 0x04, 0x38, 0x11, 0xC2, 0x2F, 0x18,
  0xFC, 0xE1, 0xF7, 0x87, 0xFE, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xFE,
  0x7F, 0xFA, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x91, 0xFF, 0x81, 0xFC, 0x01, 0xF0, 0x03,
  0x80, 0x04, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x71, 0x8F, 0x04, 0x70, 0x17,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0xC9, 0xFF, 0x83, 0xF8, 0x07, 0x80, 0x1C, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x1C, 0x07, 0x03, 0x80, 0x3E, 0x0F, 0x87, 0xC0,
  0x3F, 0x3F, 0xCF, 0xE0, 0x7F, 0x6F, 0xDF, 0xFC, 0x9F, 0xC7, 0xE3, 0xF8,
  0x0F, 0x87, 0xE1, 0xF0, 0x0F, 0x83, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0xF0,
  0x0F, 0x83, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0,
  0x0F, 0x83, 0xE0, 0xF0, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0xF9,
  0x3F, 0xCF, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x03, 0xC0, 0x7C,
  0x06, 0x01, 0x80, 0x38, 0x02, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x03, 0xC0, 0xF0, 0x0F, 0x87, 0xE0, 0x7F, 0x3F, 0xE1, 0xFD, 0x3F,
  0xC9, 0xF8, 0x7E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80,
  0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF0,
  0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE4, 0xFF, 0x0F, 0xE1, 0xF8, 0x3F, 0x83,
  0xC0, 0x7C, 0x06, 0x00, 0xF0, 0x10, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x01, 0xF0, 0x03, 0xFF, 0x03, 0xE7, 0xE0, 0x7C, 0xFE, 0x0F, 0x8F,
  0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x03,
  0xC7, 0xC0, 0x71, 0xF8, 0x0C, 0x3F, 0xC3, 0x0F, 0xFC, 0xC0, 0x3F, 0xF0,
  0x01, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x01, 0x81, 0xFC, 0x1C, 0x0F, 0xE3, 0xF0, 0x3F, 0x3F, 0xC0, 0xFE, 0x7E,
  0x03, 0xC1, 0xF8, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x07, 0x80, 0xF8, 0x3E,
  0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C,
  0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x71, 0xFE, 0x07, 0x0F, 0xF8,
  0x38, 0xFF, 0xF1, 0x04, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x73, 0x80, 0x03, 0x88, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x09, 0xFE, 0x03, 0x1F, 0xF0, 0xC0, 0xFC,
  0x38, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x81, 0xE3,
  0xF0, 0x3C, 0x3F, 0x07, 0x87, 0xF1, 0xF8, 0x7F, 0xDF, 0x07, 0xF3, 0xE0,
  0x7C, 0x7C, 0x06, 0x0F, 0x00, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x08, 0x3E, 0x1C, 0x7E,
  0x3C, 0x7F, 0x7E, 0xBF, 0xFE, 0x1F, 0xBE, 0x1F, 0x1C, 0x1F, 0x18, 0x1F,
  0x08, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x10, 0x1F, 0xD8, 0x3F,
  0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x80, 0x40, 0x10, 0x1C,
  0x04, 0x0F, 0x83, 0x0F, 0xFF, 0xC4, 0xFF, 0xE3, 0x0F, 0xF1, 0x80, 0xF8,
  0x60, 0x04, 0x3C, 0x02, 0x0F, 0x81, 0x83, 0xF0, 0xF0, 0x7E, 0x7E, 0x1F,
  0xFF, 0xC3, 0xF3, 0xF8, 0x78, 0x7E, 0x0C, 0x0F, 0x82, 0x01, 0xE1, 0x00,
  0x30, 0xF0, 0x0C, 0x7F, 0x86, 0x3F, 0xFB, 0x03, 0xFF, 0x80, 0x1F, 0xC0,
  0x01, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE4, 0x7F, 0xC1, 0xFC, 0x03, 0xE0, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x60, 0x06, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x7F, 0x0F,
  0xF3, 0x7C, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0,
  0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C,
  0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F,
  0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xCF, 0xE4, 0xFF, 0xEF, 0xE0,
  0xFF, 0x3F, 0x80, 0xF0, 0x7C, 0x01, 0x80, 0xF0, 0x02, 0x00, 0x80, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x0E, 0x00, 0xE0, 0x78, 0x0F,
  0x81, 0xF0, 0x7F, 0x07, 0xE7, 0xFE, 0x1F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0,
  0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x78, 0x0E, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xE0, 0x1F, 0x07, 0x00,
  0x7F, 0x18, 0x03, 0xFE, 0xC0, 0x13, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x04, 0x0F,
  0xC0, 0xF0, 0x1C, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xF7, 0xF8, 0x3F,
  0xA7, 0xF1, 0xF8, 0x3F, 0x87, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x7C, 0x07, 0xC3, 0xE0,
  0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x07,
  0xC0, 0x78, 0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x3E,
  0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x03, 0xE0, 0xFE, 0x18, 0x0F, 0xC3, 0xFF,
  0x60, 0x3F, 0xC1, 0xFF, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x00, 0x40, 0x00, 0x0C, 0x04, 0x07,
  0x03, 0x07, 0xC3, 0x83, 0xF3, 0xE3, 0xFF, 0xFA, 0x7F, 0x7C, 0x1F, 0x3C,
  0x0F, 0x8C, 0x07, 0xC4, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xE7, 0xC0,
  0x41, 0xC0, 0x20, 0x40, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x70, 0x30, 0x7C, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x20, 0x7F, 0x03, 0x03, 0xFC, 0x3C, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xC0,
  0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3F, 0x07, 0x80,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x83,
  0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07,
  0x83, 0xE0, 0x3C, 0x1F, 0x91, 0xE1, 0xFF, 0x0E, 0x07, 0xF0, 0x60, 0x0F,
  0x07, 0x00, 0x30, 0x30, 0x00, 0x83, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xE1, 0x8F,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0x0C,
  0x10, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x27, 0xE1, 0x9F, 0x84,
  0x3E, 0x30, 0xFD, 0x81, 0xF6, 0x07, 0xD8, 0x1F, 0x40, 0x7F, 0x01, 0xFC,
  0x03, 0xB0, 0x1E, 0xC0, 0x79, 0x81, 0xC6, 0x06, 0x08, 0x38, 0x10, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x3C, 0x01, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 36, 11, 1, -35 },
  { 42, 17, 13, 19, 1, -34 },
  { 70, 21, 28, 25, 2, -31 },
  { 144, 16, 39, 20, 2, -37 },
  { 222, 32, 34, 34, 1, -34 },
  { 358, 24, 29, 28, 2, -29 },
  { 445, 7, 13, 10, 1, -34 },
  { 457, 10, 39, 12, 1, -38 },
  { 506, 10, 39, 12, 1, -38 },
  { 555, 16, 19, 17, 0, -36 },
  { 593, 16, 17, 19, 2, -24 },
  { 627, 8, 13, 9, 0, -7 },
  { 640, 14, 9, 14, 1, -19 },
  { 656, 8, 8, 10, 1, -7 },
  { 664, 23, 38, 25, 1, -36 },
  { 774, 21, 34, 23, 1, -34 },
  { 864, 15, 33, 15, 0, -33 },
  { 926, 20, 33, 22, 1, -33 },
  { 1009, 21, 33, 22, 1, -33 },
  { 1096, 21, 33, 22, 0, -33 },
  { 1183, 21, 35, 22, 1, -35 },
  { 1275, 20, 34, 22, 1, -34 },
  { 1360, 19, 33, 21, 1, -33 },
  { 1439, 20, 34, 22, 1, -34 },
  { 1524, 20, 34, 22, 1, -34 },
  { 1609, 8, 24, 10, 1, -23 },
  { 1633, 9, 29, 8, 0, -23 },
  { 1666, 13, 17, 14, 0, -22 },
  { 1694, 17, 10, 19, 1, -19 },
  { 1716, 13, 17, 14, 0, -22 },
  { 1744, 18, 35, 22, 2, -34 },
  { 1823, 28, 29, 29, 1, -22 },
  { 1925, 37, 35, 39, 1, -34 },
  { 2087, 42, 36, 43, 0, -35 },
  { 2276, 31, 36, 33, 1, -35 },
  { 2416, 37, 37, 39, 1, -35 },
  { 2588, 32, 36, 34, 1, -35 },
  { 2732, 34, 42, 36, 1, -36 },
  { 2911, 35, 36, 37, 1, -35 },
  { 3069, 33, 44, 35, 1, -37 },
  { 3251, 31, 42, 33, 1, -35 },
  { 3414, 32, 48, 34, 1, -35 },
  { 3606, 37, 35, 39, 1, -34 },
  { 3768, 25, 35, 27, 1, -34 },
  { 3878, 51, 37, 53, 1, -34 },
  { 4114, 40, 35, 42, 1, -34 },
  { 4289, 34, 35, 36, 1, -34 },
  { 4438, 41, 42, 43, 1, -34 },
  { 4654, 36, 37, 38, 1, -34 },
  { 4821, 43, 36, 45, 1, -35 },
  { 5015, 34, 35, 36, 1, -34 },
  { 5164, 34, 34, 36, 1, -34 },
  { 5309, 32, 37, 34, 1, -34 },
  { 5457, 40, 36, 43, 1, -35 },
  { 5637, 49, 35, 52, 1, -34 },
  { 5852, 33, 36, 35, 1, -35 },
  { 6001, 39, 43, 41, 1, -35 },
  { 6211, 30, 42, 32, 1, -35 },
  { 6369, 7, 37, 9, 1, -35 },
  { 6402, 29, 33, 5, -9, -31 },
  { 6522, 7, 37, 9, 1, -35 },
  { 6555, 18, 13, 20, 1, -34 },
  { 6585, 22, 3, 22, 0, 6 },
  { 6594, 7, 9, 24, 8, -34 },
  { 6602, 20, 26, 22, 1, -25 },
  { 6667, 19, 35, 21, 1, -33 },
  { 6751, 15, 25, 17, 1, -24 },
  { 6798, 20, 34, 22, 1, -33 },
  { 6883, 15, 25, 17, 1, -24 },
  { 6930, 14, 43, 12, 0, -35 },
  { 7006, 20, 35, 22, 1, -25 },
  { 7094, 19, 42, 21, 1, -34 },
  { 7194, 11, 34, 13, 1, -33 },
  { 7241, 13, 43, 12, -2, -34 },
  { 7311, 14, 34, 16, 1, -33 },
  { 7371, 13, 35, 13, 1, -34 },
  { 7428, 32, 26, 34, 1, -25 },
  { 7532, 22, 26, 24, 1, -25 },
  { 7604, 19, 26, 20, 0, -25 },
  { 7666, 21, 39, 22, 0, -29 },
  { 7769, 19, 35, 21, 1, -25 },
  { 7853, 16, 26, 17, 1, -25 },
  { 7905, 18, 31, 20, 1, -30 },
  { 7975, 13, 32, 15, 1, -31 },
  { 8027, 22, 26, 24, 1, -25 },
  { 8099, 22, 28, 22, -1, -27 },
  { 8176, 31, 29, 33, 1, -28 },
  { 8289, 17, 35, 19, 1, -25 },
  { 8364, 21, 37, 22, 1, -29 },
  { 8462, 14, 34, 16, 1, -25 },
  { 8522, 13, 38, 16, 1, -37 },
  { 8584, 3, 39, 8, 2, -37 },
  { 8599, 13, 38, 16, 1, -37 },
  { 8661, 16, 3, 18, 1, -16 },
};

const GFXfont UnifrakturMaguntia_Regular48pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular48pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular48pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR48PT7B_H_
