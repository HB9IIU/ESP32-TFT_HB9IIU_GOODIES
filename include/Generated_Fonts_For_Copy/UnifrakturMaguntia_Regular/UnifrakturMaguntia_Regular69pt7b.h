#ifndef _UNIFRAKTURMAGUNTIA_REGULAR69PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x1E, 0x01, 0xF8, 0x3F, 0xF3, 0xFF,
  0xCF, 0xFC, 0x7F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x3F,
  0x07, 0xFE, 0x3F, 0xF0, 0xFE, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0xF0, 0x1F, 0x01, 0xF8,
  0x7F, 0x83, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C,
  0x03, 0x00, 0x38, 0x07, 0x00, 0x38, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x04, 0x00, 0x20, 0x08, 0x00, 0x40, 0x08, 0x00, 0x40, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0xC0, 0x1C, 0x3F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x30, 0x03, 0xFF, 0x78,
  0x01, 0xFF, 0x7C, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x3E, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0xF8, 0x07,
  0x81, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x3C,
  0x00, 0x00, 0x01, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x1F, 0x07, 0xC0,
  0x00, 0x01, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0x1E, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0x0E, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xE0, 0x3F, 0x83, 0xF8, 0x00, 0x0E, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0x0E, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xE0, 0x03,
  0xF8, 0x1F, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x70, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x70, 0x00, 0x1F, 0x83,
  0xF0, 0x07, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x70, 0x00, 0x07, 0xE0, 0xFC,
  0x07, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x07,
  0x80, 0x00, 0x01, 0xE3, 0xC0, 0x38, 0x00, 0x00, 0x07, 0xFC, 0x03, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x38, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0xF1,
  0xE0, 0x00, 0x00, 0x38, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x3E,
  0x00, 0x00, 0x3C, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xC0, 0x7E, 0x0F, 0xC0,
  0x00, 0x1C, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xF8, 0x00,
  0x1C, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x1C,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x1E, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x0E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x07, 0x00, 0x00, 0x01, 0xE3, 0xE0,
  0x70, 0x00, 0x00, 0x07, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00,
  0xFC, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x0F, 0xE3,
  0xE0, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFE,
  0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF1, 0xFF, 0x00, 0xE0, 0x1F,
  0x1F, 0xF0, 0x0E, 0x03, 0xE0, 0xFF, 0x80, 0xC0, 0x3E, 0x0F, 0xF8, 0x0C,
  0x07, 0xE0, 0x7F, 0xC0, 0xC0, 0x7E, 0x07, 0xFC, 0x18, 0x07, 0xE0, 0x7F,
  0xE1, 0x80, 0xFE, 0x03, 0xFE, 0x18, 0x0F, 0xE0, 0x3F, 0xF3, 0x00, 0xFE,
  0x01, 0xFF, 0x70, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x03, 0x3F, 0xC0, 0x1F, 0xF8, 0xE3, 0xFE, 0x01, 0xFF, 0xFC, 0x1F,
  0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xE1, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x04, 0x00, 0xC0, 0x3C, 0x0F, 0xC3, 0xFC,
  0xFF, 0xCF, 0xF8, 0xFF, 0x07, 0xE0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x20, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x06, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0x1F, 0x98, 0x7F, 0x3E,
  0x7F, 0x7E, 0x38, 0xFC, 0xFC, 0x71, 0xF8, 0xFC, 0x67, 0xE1, 0xFC, 0x9F,
  0xC3, 0xBF, 0xFF, 0x80, 0x07, 0x80, 0x08, 0x3F, 0x82, 0x1F, 0xEB, 0xFC,
  0x7F, 0x93, 0xFC, 0xFE, 0x73, 0xF9, 0xF8, 0xE3, 0xF7, 0xF1, 0xE7, 0xF0,
  0xE7, 0xEE, 0x00, 0x5F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x07, 0x81, 0xF8, 0xFF, 0xDF, 0xF8,
  0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x0E, 0x01, 0xF0, 0x3F, 0x87, 0xFC, 0xFF, 0xE3, 0xF8,
  0x1F, 0x00, 0xE0, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x06, 0x3F, 0xC0, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x78, 0x01, 0xFF, 0x87, 0x80, 0x07, 0xFC,
  0x38, 0x00, 0x3F, 0xF3, 0x80, 0x00, 0xFF, 0x9C, 0x00, 0x07, 0xFC, 0xC0,
  0x00, 0x3F, 0xE6, 0x00, 0x00, 0xFF, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x06, 0x01, 0xF0, 0x00, 0x30, 0x0F, 0x00, 0x01, 0x80, 0xF0, 0x00,
  0x08, 0x0E, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x06, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xE0, 0xFF,
  0xF0, 0x1E, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0xFF, 0x83, 0x00, 0x01, 0xFE,
  0x08, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0xF8, 0x7F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x03,
  0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x77, 0xF0, 0x00, 0x01, 0x9F, 0xC0,
  0x00, 0x0E, 0x7F, 0x00, 0x00, 0x31, 0xFC, 0x00, 0x01, 0x87, 0xF0, 0x00,
  0x0E, 0x1F, 0xC0, 0x00, 0x30, 0x7F, 0x00, 0x01, 0x81, 0xFC, 0x00, 0x0E,
  0x07, 0xF0, 0x00, 0x30, 0x1F, 0xC0, 0x01, 0xC0, 0x7F, 0x00, 0x0E, 0x01,
  0xFC, 0x00, 0x30, 0x07, 0xF0, 0x01, 0xC0, 0x1F, 0xC0, 0x06, 0x00, 0x7F,
  0x00, 0x30, 0x01, 0xFC, 0x01, 0xC0, 0x07, 0xF0, 0x06, 0x00, 0x1F, 0xC0,
  0x38, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x00, 0x07, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x3F, 0xE0, 0x00, 0x37, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0x00,
  0x1F, 0xF0, 0x70, 0x00, 0x3F, 0xE1, 0x80, 0x00, 0x7F, 0x84, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x7E, 0x7F, 0x00,
  0x03, 0xF1, 0xFE, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xF0, 0x3F, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x0F, 0xC0, 0x01, 0xE0, 0x3F, 0x00, 0x1E,
  0x01, 0xFC, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0xFC, 0x01,
  0xFC, 0x07, 0xC0, 0x0F, 0xF0, 0x7E, 0x00, 0x7F, 0x83, 0xF0, 0x03, 0xFC,
  0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x0F, 0xFC, 0x07, 0xF8, 0xFF, 0xF0,
  0x3F, 0xCF, 0xFF, 0xE1, 0xFE, 0x60, 0xFF, 0x0F, 0xF6, 0x03, 0xFC, 0x7F,
  0xB0, 0x0F, 0xF3, 0xFF, 0x00, 0x7F, 0x9F, 0xF8, 0x03, 0xFC, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF,
  0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x0F, 0xC0, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x07, 0x83,
  0xFC, 0x00, 0x3E, 0x0F, 0xFC, 0x00, 0xF0, 0x3F, 0xF8, 0x07, 0xC0, 0x7F,
  0xF8, 0x1E, 0x01, 0xFF, 0xF8, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x3F, 0xFF, 0x00, 0x78, 0x3F, 0xFE,
  0x03, 0xC0, 0x3F, 0xF8, 0x1E, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x7F, 0xC3,
  0xC0, 0x00, 0xFF, 0x9F, 0x00, 0x01, 0xFE, 0x78, 0x00, 0x03, 0xFB, 0xE0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x3F, 0x00, 0x07, 0x80,
  0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0x0F,
  0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x0F, 0xFD, 0xFE, 0x00, 0x7F, 0xEF, 0xF0,
  0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF9, 0xFE, 0x01, 0x7F, 0x87, 0xF8, 0x1B,
  0xFC, 0x3F, 0xE1, 0x9F, 0xE0, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0x87, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0x81, 0xFE, 0x00, 0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0x80, 0x7C, 0x01, 0xFC, 0x03, 0xC0, 0x07, 0xF0, 0x3C, 0x00, 0x1F, 0xC3,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x0E, 0x01, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xC3, 0xF8, 0x1F, 0x00, 0xE0,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x01, 0xF0,
  0x3F, 0x87, 0xFC, 0xFF, 0xE3, 0xF8, 0x1F, 0x00, 0xE0, 0x04, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x01, 0xC0, 0x1F, 0x01, 0xFC, 0x1F, 0xF9, 0xFF, 0x83,
  0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x07, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x1F,
  0xE0, 0x7C, 0x01, 0xFC, 0x3C, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0xE7, 0x80,
  0x01, 0xFD, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xF1, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x04, 0x03, 0xE0, 0x01, 0x00, 0x7C, 0x00, 0xC0, 0x1F, 0x00, 0x30, 0x03,
  0xE0, 0x18, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x70, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x38,
  0x1F, 0x00, 0x1F, 0xBE, 0x3C, 0x3E, 0x00, 0x7F, 0xFE, 0x3C, 0x3E, 0x00,
  0xF9, 0xFC, 0x3C, 0x3C, 0x01, 0xF1, 0xFC, 0x1C, 0x7C, 0x03, 0xE1, 0xFC,
  0x1C, 0x7C, 0x07, 0xC1, 0xFC, 0x1C, 0x78, 0x0F, 0xC1, 0xF8, 0x3C, 0xF8,
  0x1F, 0x81, 0xF8, 0x3C, 0xF8, 0x1F, 0x81, 0xF8, 0x3C, 0xF8, 0x3F, 0x01,
  0xF0, 0x3C, 0xF8, 0x3F, 0x03, 0xF0, 0x3C, 0xF8, 0x7F, 0x03, 0xF0, 0x78,
  0xF8, 0x7E, 0x07, 0xE0, 0x78, 0xF8, 0x7E, 0x07, 0xE0, 0xF0, 0xF8, 0x7E,
  0x0F, 0xE0, 0xF0, 0xF8, 0x7E, 0x1F, 0xE1, 0xE0, 0x78, 0x7E, 0x3F, 0xC3,
  0xE0, 0x78, 0x7E, 0x7F, 0xC7, 0xC0, 0x7C, 0x3F, 0xF7, 0xFF, 0x8F, 0x3C,
  0x3F, 0xE7, 0xFE, 0x0F, 0x3C, 0x1F, 0x83, 0xF8, 0x1E, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0x81, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x70, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0x00,
  0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x38, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x01,
  0x80, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x60, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x18, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0xE0, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x3E, 0x00,
  0x00, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x80,
  0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0x80, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x7F, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x38, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x41, 0xFF, 0xFC, 0x1C, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFB,
  0xC7, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1C, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC3, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x60, 0x1F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0xF6, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x78, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC7,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x70, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xFC, 0x01,
  0xE0, 0x00, 0x01, 0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0x00, 0x08, 0x1F, 0x1F,
  0xFF, 0xFF, 0x80, 0x78, 0x03, 0x81, 0xF1, 0xFF, 0xFF, 0xF8, 0x03, 0xFB,
  0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x18, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x06, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x30, 0xFF, 0xE2, 0x01, 0xF8, 0x01, 0x9F, 0xFF, 0xF0, 0x3F, 0x00,
  0x1B, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x1C,
  0x7F, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x03,
  0xC0, 0x1F, 0xC0, 0x3C, 0x00, 0x08, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xC1, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x10, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0x80, 0xFF, 0xFC, 0x07, 0xF0,
  0x00, 0x70, 0x03, 0xFF, 0xE0, 0x7E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0x8F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xCE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xCE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xEC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xEC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF6, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0x60, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x3F, 0x7C, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF1, 0x80, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x07, 0x9F, 0xFF,
  0xFF, 0x80, 0x70, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0x81, 0xFE,
  0x00, 0x01, 0xF8, 0x06, 0x1F, 0xFC, 0x20, 0x1F, 0x80, 0x19, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0xDF, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x38, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xE0, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0x07, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xFB,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFC, 0xFF,
  0x80, 0x3F, 0xFE, 0x1F, 0xC7, 0xFC, 0x00, 0xFF, 0xF8, 0x7C, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x08, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x27, 0xFF, 0xC0, 0x3E, 0x00,
  0x00, 0x1C, 0x7F, 0xE0, 0x0F, 0x00, 0x00, 0x0C, 0x07, 0xE0, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0x07, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0xC0, 0x00, 0x0F, 0xFE, 0x03,
  0xFC, 0x30, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0x8E, 0x00, 0x00, 0x7F, 0xF0,
  0xFF, 0xF1, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x70, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0xFE, 0x01, 0xC0, 0x00, 0x1F,
  0xFE, 0x0F, 0x00, 0x3C, 0x01, 0xE3, 0xFF, 0xC1, 0xC0, 0x03, 0xFF, 0xF0,
  0x7F, 0xF8, 0x20, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0xE0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x18, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x06, 0x3F, 0xF0, 0x00, 0x07,
  0xC0, 0x01, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x63, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x01, 0xC0, 0x0F, 0xFF, 0x83,
  0xF8, 0x01, 0xE0, 0x03, 0xFF, 0xC1, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xC1,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x7F, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF,
  0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xDF, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE7, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xF3, 0xFF, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xF8, 0x7F, 0xE0, 0x01,
  0xE0, 0x01, 0xFC, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0xFC, 0x07, 0xFC, 0x01,
  0xC0, 0x00, 0xFE, 0x03, 0xFF, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xC1,
  0x80, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xE7, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x81, 0xFF, 0xE8, 0x00, 0x00,
  0x07, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFB, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0xFE, 0x1F,
  0xF8, 0x03, 0x80, 0x00, 0xFE, 0x7F, 0xFC, 0x03, 0x80, 0x01, 0xFC, 0xFF,
  0xFE, 0x07, 0x00, 0x01, 0xFC, 0xCF, 0xFF, 0x8E, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE1, 0x03, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x01, 0x3F, 0xF0,
  0x00, 0x07, 0xE0, 0x78, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFE,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x83,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xC7, 0x0F,
  0xFF, 0xC0, 0x00, 0x3C, 0x20, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xF1, 0x80, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x23, 0xFE, 0x00,
  0x00, 0x7C, 0x07, 0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xC1, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x0E, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0xF0, 0x03, 0xC0, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x3C, 0x00,
  0x1F, 0x83, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xFE, 0x1E, 0x07, 0xFF, 0x03,
  0xC0, 0x03, 0xF8, 0x70, 0x0F, 0xFC, 0x07, 0x00, 0x0F, 0xE1, 0x80, 0x1F,
  0xF8, 0x1E, 0x00, 0x7F, 0xC4, 0x00, 0x3F, 0xE0, 0x78, 0x01, 0xFF, 0x30,
  0x00, 0xFF, 0xC1, 0xE0, 0x07, 0xFC, 0xC0, 0x03, 0xFF, 0x07, 0x80, 0x0F,
  0xFB, 0x00, 0x07, 0xFE, 0x1E, 0x00, 0x3F, 0xEC, 0x00, 0x1F, 0xFE, 0x78,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF1, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0x07, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x07, 0x00, 0x00, 0xFF,
  0xF0, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0x81, 0xC0, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x60,
  0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xE0,
  0x30, 0x00, 0x3F, 0xE0, 0x33, 0xFF, 0xC1, 0x80, 0x00, 0xFF, 0xE2, 0x07,
  0xFF, 0xDC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0x0F,
  0xF8, 0x00, 0x01, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xE3, 0xFF, 0x00, 0x00,
  0x7E, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0x83, 0xFF,
  0x80, 0x01, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xF0, 0x00, 0xFE,
  0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xFC, 0x61, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0x90, 0x7F, 0xFF, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0x83, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF3, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x38, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x18, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x84, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC2, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF1, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xFE, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x30,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x18, 0x00, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x30, 0x03, 0x80, 0x30, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x38, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x38, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x08, 0x0C,
  0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x06, 0x01, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x83, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x60, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0xC7, 0x80, 0x70, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0xC7, 0xF0, 0x30, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0xE7,
  0xFC, 0x18, 0x01, 0xFF, 0xC1, 0x07, 0xFF, 0xE0, 0x67, 0xFF, 0x98, 0x00,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x67, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x82,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE3,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0x81, 0xFF, 0x80,
  0x7F, 0x07, 0xFF, 0xF1, 0x80, 0x7F, 0xC0, 0x7C, 0x00, 0x7F, 0xFD, 0x80,
  0x1F, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x18, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x0C,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x86, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC3, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF1, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x60,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x30, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFC, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x18, 0x01, 0xC0,
  0x7C, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x1C,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xE0, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x7F,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x06, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x7E,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x70, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x70, 0x00, 0x7F, 0xF0, 0xC3, 0xFF, 0xF8,
  0x30, 0x00, 0x3F, 0xFF, 0xC3, 0x9F, 0xFE, 0x70, 0x00, 0x0F, 0xFF, 0xC1,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF3, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x1F, 0xE4, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x33, 0xFF, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xCF,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0xFC,
  0x07, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x06, 0x00,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFE, 0x18, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC3, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xFC, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC6,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x60, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x8E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0xE0, 0x01,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x70, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0x80, 0x00, 0x00, 0xE1, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x81, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xFF, 0x20, 0x00, 0x3F,
  0x8C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x98, 0xFF, 0xFF, 0x06, 0x0F, 0xFE, 0x0C, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xF9, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xF3, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x60, 0x1F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xF2, 0x00, 0xFF, 0xE0, 0x1F,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x78, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x1C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xC6, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x30, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x1C, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x30,
  0x1F, 0xCF, 0xFE, 0x00, 0x00, 0x78, 0x07, 0x00, 0xFE, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0xE0, 0x00, 0x1F, 0xFC, 0x20, 0x7F, 0xFF, 0x8E, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x03, 0xE0, 0x30, 0x03, 0xFF, 0xFF, 0xC1, 0xF0, 0x0C, 0x07,
  0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0x1F, 0xFF, 0xFF, 0xFC, 0x7C, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0x9F, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x4F, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x37, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x1B, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0D, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xCF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x61, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0x70, 0x00, 0x00, 0x3F, 0xFF,
  0xC7, 0xE0, 0x00, 0x01, 0x8F, 0xFF, 0xFE, 0xC0, 0x00, 0x03, 0x07, 0xFF,
  0xF8, 0xC0, 0x00, 0x0E, 0x01, 0xFF, 0xF0, 0xC0, 0x00, 0x1E, 0x00, 0xFF,
  0xE0, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0E, 0x01, 0xBF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x3C, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x41, 0xFF, 0xF0, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xF0, 0x01, 0xF0, 0x30, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x30, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x20, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x40, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x03, 0x03, 0xFF, 0x80,
  0x0F, 0xF0, 0x0C, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x30, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x1C,
  0xFF, 0x80, 0xC1, 0xFF, 0xF0, 0x71, 0xFF, 0x0A, 0x01, 0xFF, 0xFF, 0xC3,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x70,
  0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x98, 0x0F, 0xFC, 0x00, 0xFF, 0x07,
  0xFF, 0xE4, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x38, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFE,
  0x00, 0x1C, 0x00, 0x30, 0x7C, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x30, 0x1F,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0x80, 0x07, 0xFF, 0x00, 0x03,
  0xF8, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xC3, 0xFF,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x40, 0x3F, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF1, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0x0C, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF9, 0x83, 0x98, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xFE, 0x00, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xFF, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0x07, 0xFF, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xFF,
  0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x00,
  0x7F, 0xE0, 0x70, 0x00, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x7F, 0xE0, 0x70,
  0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x1F, 0xF8, 0x60, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x0F, 0xC0, 0x60, 0x00, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0x8F, 0xFC, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0x87, 0xFF, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x1F,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x1F, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0x00, 0x30, 0x3E, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xC1, 0xE0, 0x3E, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x3C,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x80,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xC7, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x38, 0x03, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFE, 0x08, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x70, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0x80, 0x3F, 0xF1, 0xFF,
  0xF8, 0x7E, 0x00, 0x3F, 0xE3, 0x8F, 0xE0, 0xF0, 0x00, 0x3F, 0xE6, 0x0F,
  0x83, 0xC0, 0x00, 0x3F, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xB0, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xEF, 0x9F, 0xFF, 0xFF, 0x00, 0x01,
  0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x5F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x9F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x04, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x18,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x70, 0xFF, 0xF8, 0x70, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x06, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x10, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x1E, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x60, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0xC0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x87,
  0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x1C, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x38, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x60, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFB,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC6, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x20, 0x7E, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0xE0, 0xFC, 0x01, 0xFC, 0x00, 0x3C, 0x07, 0x01, 0xF0, 0x07,
  0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x10,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x60, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x81, 0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xCF, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0,
  0x0E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x8F, 0xFF,
  0xE0, 0x00, 0x01, 0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0xE7, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x3F, 0xFE, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x0C, 0x01, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xDF, 0xFC, 0x00, 0x18, 0xFF, 0xF8,
  0x07, 0x07, 0xFF, 0xC0, 0xF0, 0x3F, 0xF0, 0x1E, 0x00, 0x7F, 0x01, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0x7E, 0x0F,
  0xF0, 0x07, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xE0,
  0xFF, 0x13, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0x80, 0x18,
  0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x04, 0x07, 0x80, 0x00, 0x60, 0xF0, 0x00, 0x03,
  0x1F, 0x00, 0x00, 0x33, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x0F, 0xE0, 0x0C, 0x00, 0xFE,
  0x01, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE3, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFF, 0x00, 0x3E, 0x0F, 0xF0, 0x03, 0xE0, 0xFF, 0x00, 0x3E,
  0x0F, 0xF0, 0x07, 0xC0, 0xFF, 0x00, 0x78, 0x0F, 0xF0, 0x07, 0x80, 0xFF,
  0x00, 0xF0, 0x1F, 0xFC, 0x0C, 0x03, 0xFF, 0xF1, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80,
  0x31, 0xFC, 0x03, 0x8F, 0xF0, 0x38, 0x3F, 0x83, 0xC1, 0xFE, 0x3E, 0x07,
  0xF1, 0xE0, 0x3F, 0x9F, 0x00, 0xF0, 0xF8, 0x06, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x1F, 0xFC, 0x00, 0xE0,
  0xFF, 0xC0, 0xFC, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x3E, 0x0F,
  0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x3C, 0x0F, 0xE0, 0x03, 0xC1, 0xFE, 0x00,
  0x3C, 0x1F, 0xE0, 0x03, 0x81, 0xFF, 0x00, 0x70, 0x3F, 0xFC, 0x07, 0x07,
  0xFF, 0xF0, 0xE0, 0x0F, 0xFF, 0xCC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0x1F, 0xC0, 0x3C, 0x7F, 0x00, 0xE0, 0xFE, 0x07,
  0x83, 0xF8, 0x3E, 0x0F, 0xF0, 0xF0, 0x1F, 0xC7, 0xC0, 0x7F, 0x1F, 0x00,
  0xFE, 0x7C, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3C, 0x3F, 0x03, 0xC0,
  0xFC, 0x78, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x40, 0x7F, 0xE2, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x61, 0xF8, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1B, 0xFF, 0xC0, 0x03, 0x8F, 0xFF, 0xC0, 0x38, 0x1F, 0xFE,
  0x03, 0xC0, 0x7F, 0xE0, 0x3C, 0x00, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0x81, 0xF8, 0x00, 0x3C, 0x0F, 0xC0, 0x03, 0xC0, 0xFE, 0x00,
  0x1E, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0x30,
  0x00, 0xFE, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x1E, 0x03, 0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x04, 0x0F, 0x80, 0x00, 0x61, 0xF0, 0x00, 0x03, 0x3F,
  0x00, 0x00, 0x33, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x01, 0x80, 0x0F, 0xE0, 0x38, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xF0, 0x07, 0xC0, 0xFF, 0x10, 0x7C, 0x1F, 0xF3, 0x0F, 0x83,
  0xFF, 0xE0, 0xF8, 0x1F, 0xFC, 0x0F, 0x00, 0x7F, 0x81, 0xE0, 0x03, 0xF0,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0xCF, 0xF0, 0x8F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF1, 0x07,
  0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0C, 0xFF, 0x00, 0x8F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x80, 0x0F, 0xCC, 0x00, 0xF8, 0x40,
  0x1F, 0x02, 0x03, 0xC0, 0x10, 0x78, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x04, 0x07, 0x80, 0x20, 0xF8,
  0x03, 0x1F, 0x03, 0x13, 0xF0, 0xF1, 0xBF, 0x1F, 0x0F, 0xF3, 0xF0, 0xFF,
  0x3F, 0x0F, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x40, 0xFF, 0x8C, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x04, 0x07, 0x80, 0x60, 0xF8, 0x03, 0x1F, 0x00, 0x13, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x40,
  0xFF, 0xC8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0x9B, 0xFF, 0x6F,
  0xFF, 0x9B, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC4, 0xFF,
  0xF1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xFC, 0x1F, 0xF9, 0xBF, 0xFE, 0x4F, 0xFE, 0x3F, 0xF0, 0x8F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0x27, 0xFF, 0x81, 0xFE, 0xC7,
  0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x07, 0xF8, 0x07,
  0x80, 0x07, 0xE0, 0x06, 0x00, 0x07, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0xFF, 0x80, 0x7F, 0x0F, 0xF8, 0x0F,
  0xE1, 0xFF, 0x81, 0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x3F,
  0xF0, 0xFE, 0x03, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7C,
  0x3F, 0xC0, 0x0F, 0x07, 0xF8, 0x01, 0xE0, 0xFF, 0x80, 0x78, 0x3F, 0xFC,
  0x0E, 0x0F, 0xFF, 0xE3, 0x80, 0x3F, 0xFE, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x40, 0x1F, 0xF0, 0x03, 0x80, 0x7F,
  0xE0, 0x1E, 0x01, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x01,
  0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xFC,
  0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0xFF, 0x80,
  0x1E, 0x0F, 0xFE, 0x00, 0xF8, 0x7F, 0xFC, 0x03, 0xC1, 0xFF, 0xF8, 0x1E,
  0x0F, 0xFF, 0xF8, 0x70, 0x3F, 0xFF, 0xFB, 0x80, 0x83, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x07, 0xC2, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x06, 0x7F, 0xF0, 0x01,
  0x87, 0xFF, 0xC0, 0x70, 0x7F, 0xFC, 0x1C, 0x07, 0xFE, 0x07, 0x80, 0x3F,
  0x81, 0xF0, 0x07, 0xF0, 0x7C, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0xC3, 0xF0,
  0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0xC0,
  0x0F, 0xC7, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xF0, 0x07, 0xE1,
  0xFE, 0x00, 0xFC, 0x3F, 0xE0, 0x1F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0xC1,
  0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0xF9, 0xF8, 0x0F, 0xFC, 0x3F, 0x00,
  0xFF, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0x08, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x3E, 0x01, 0xC0, 0xFE, 0x07, 0x81, 0xFE, 0x1F, 0x87,
  0xFC, 0x3F, 0x0F, 0xFC, 0xFF, 0x3F, 0xFB, 0xFE, 0x47, 0xFD, 0xFE, 0x0F,
  0xF3, 0xF8, 0x1F, 0xC3, 0xE0, 0x3F, 0x87, 0x80, 0x7F, 0x07, 0x00, 0xFE,
  0x04, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x86, 0x00, 0xFF, 0xD8, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0F, 0x80, 0x30, 0x07, 0xF0, 0x0C, 0x07, 0xFF, 0x0F, 0x03,
  0xFF, 0xFF, 0xC1, 0x8F, 0xFF, 0xE0, 0xC1, 0xFF, 0xF0, 0x60, 0x1F, 0xF8,
  0x38, 0x01, 0xFC, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x01, 0xF0, 0x01,
  0x80, 0x7E, 0x00, 0xE0, 0x1F, 0xC0, 0x7C, 0x07, 0xF8, 0x3F, 0x81, 0xFF,
  0x1F, 0xF0, 0x3F, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0,
  0x3F, 0x83, 0xFE, 0x07, 0xC0, 0x7F, 0x80, 0xE0, 0x0F, 0xE0, 0x30, 0x01,
  0xF8, 0x18, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x07, 0xE0, 0x03, 0x83, 0xFF,
  0x00, 0xC1, 0xFF, 0xF0, 0x60, 0x7F, 0xFF, 0x30, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x04, 0x1F,
  0xF9, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0x7C,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xF0, 0x1F, 0xFC, 0x8F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0xCF, 0xFF, 0x37, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF0, 0x0F,
  0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x10,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x0E, 0x00,
  0x1F, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xFF, 0x03,
  0xC0, 0x03, 0xFF, 0x07, 0x00, 0x07, 0xFF, 0x9C, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x47, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x0F, 0xF0,
  0x01, 0xC0, 0x01, 0x80, 0xFF, 0xC0, 0x3F, 0x00, 0x3C, 0x0F, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFE, 0x03, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xF3, 0x7F, 0xFC, 0xFF, 0x80, 0xFF, 0x61, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0x78, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x0E, 0x00, 0x7F, 0x81,
  0xFF, 0xC1, 0xC0, 0x0F, 0xF8, 0x3F, 0xFF, 0x38, 0x01, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x08, 0x01, 0xE0, 0x0E, 0x00,
  0xFC, 0x07, 0x00, 0xFF, 0x07, 0xC0, 0xFF, 0x87, 0xE0, 0x7F, 0xE7, 0xF8,
  0x7F, 0xF7, 0xFC, 0x27, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x1F,
  0x00, 0x7F, 0x0F, 0x80, 0x3F, 0x83, 0x80, 0x1F, 0xC1, 0x80, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC2, 0x00, 0x1F, 0xF1, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0E, 0x0F, 0x80, 0x06, 0x03, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0xC0,
  0x0F, 0x80, 0x38, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x1F, 0xF0, 0x07, 0x80,
  0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F,
  0x01, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x7F, 0x8C, 0x3E, 0x03, 0xFF, 0x60, 0xF8, 0x1F, 0xFF, 0x03,
  0xC0, 0x1F, 0xF8, 0x1E, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0E, 0x7F, 0xC2, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x01, 0x03, 0x00, 0xC1, 0xF0, 0x60, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x06, 0x7F,
  0xC1, 0x87, 0xF8, 0x30, 0x7F, 0x8C, 0x0F, 0xF3, 0x80, 0xFE, 0x60, 0x1F,
  0xDC, 0x03, 0xFB, 0x80, 0x7F, 0x60, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xF7, 0x00, 0x3E,
  0xE0, 0x07, 0x9C, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x07, 0x03, 0x00, 0xE0,
  0x30, 0x38, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 13, 51, 16, 2, -50 },
  { 84, 24, 19, 28, 2, -49 },
  { 141, 31, 39, 36, 2, -44 },
  { 293, 24, 56, 29, 2, -53 },
  { 461, 45, 48, 49, 2, -49 },
  { 731, 36, 44, 40, 2, -43 },
  { 929, 11, 19, 14, 1, -49 },
  { 956, 15, 56, 17, 1, -54 },
  { 1061, 15, 56, 17, 1, -54 },
  { 1166, 23, 27, 24, 0, -52 },
  { 1244, 22, 24, 27, 3, -35 },
  { 1310, 11, 19, 13, 0, -11 },
  { 1337, 19, 13, 21, 2, -27 },
  { 1368, 12, 12, 14, 1, -11 },
  { 1386, 33, 55, 36, 2, -52 },
  { 1613, 30, 49, 33, 1, -48 },
  { 1797, 20, 47, 22, 1, -47 },
  { 1915, 29, 47, 31, 1, -47 },
  { 2086, 30, 47, 32, 1, -47 },
  { 2263, 30, 47, 32, 1, -47 },
  { 2440, 30, 49, 32, 1, -49 },
  { 2624, 29, 50, 31, 1, -49 },
  { 2806, 28, 47, 30, 1, -47 },
  { 2971, 30, 49, 32, 1, -49 },
  { 3155, 29, 49, 31, 1, -49 },
  { 3333, 12, 34, 14, 1, -33 },
  { 3384, 13, 41, 12, 0, -33 },
  { 3451, 19, 25, 20, 0, -32 },
  { 3511, 23, 15, 27, 2, -28 },
  { 3555, 19, 25, 20, 0, -32 },
  { 3615, 26, 50, 31, 2, -49 },
  { 3778, 40, 41, 42, 1, -32 },
  { 3983, 53, 50, 56, 2, -49 },
  { 4315, 60, 51, 62, 0, -50 },
  { 4698, 44, 51, 47, 2, -50 },
  { 4979, 52, 53, 56, 2, -50 },
  { 5324, 45, 51, 48, 2, -50 },
  { 5611, 50, 59, 52, 1, -51 },
  { 5980, 49, 52, 53, 2, -50 },
  { 6299, 48, 62, 51, 1, -53 },
  { 6671, 45, 59, 47, 1, -51 },
  { 7003, 46, 68, 49, 1, -51 },
  { 7394, 54, 51, 56, 1, -49 },
  { 7739, 37, 50, 39, 1, -49 },
  { 7971, 73, 52, 76, 2, -48 },
  { 8446, 57, 50, 61, 2, -49 },
  { 8803, 49, 51, 52, 1, -49 },
  { 9116, 59, 61, 62, 1, -49 },
  { 9566, 53, 55, 55, 1, -50 },
  { 9931, 61, 51, 64, 2, -50 },
  { 10320, 49, 51, 52, 2, -50 },
  { 10633, 48, 50, 52, 2, -49 },
  { 10933, 47, 52, 49, 1, -48 },
  { 11239, 58, 51, 61, 2, -50 },
  { 11609, 72, 51, 74, 1, -50 },
  { 12068, 47, 51, 50, 1, -50 },
  { 12368, 55, 62, 59, 2, -51 },
  { 12795, 43, 60, 46, 1, -51 },
  { 13118, 10, 54, 13, 1, -51 },
  { 13186, 42, 48, 7, -13, -45 },
  { 13438, 10, 54, 13, 1, -51 },
  { 13506, 26, 19, 29, 1, -49 },
  { 13568, 33, 5, 31, -1, 8 },
  { 13589, 10, 12, 35, 11, -48 },
  { 13604, 28, 37, 32, 2, -35 },
  { 13734, 28, 50, 31, 1, -48 },
  { 13909, 21, 36, 24, 2, -35 },
  { 14004, 28, 49, 31, 2, -48 },
  { 14176, 22, 36, 25, 2, -35 },
  { 14275, 21, 61, 17, -1, -50 },
  { 14436, 29, 51, 32, 2, -36 },
  { 14621, 28, 60, 31, 1, -48 },
  { 14831, 16, 49, 19, 1, -48 },
  { 14929, 20, 62, 17, -4, -49 },
  { 15084, 20, 50, 22, 1, -48 },
  { 15209, 20, 50, 19, 1, -48 },
  { 15334, 45, 37, 49, 2, -36 },
  { 15543, 31, 37, 35, 2, -35 },
  { 15687, 27, 36, 29, 0, -35 },
  { 15809, 30, 55, 31, 0, -41 },
  { 16016, 27, 50, 30, 1, -36 },
  { 16185, 23, 37, 25, 1, -36 },
  { 16292, 26, 44, 29, 1, -43 },
  { 16435, 19, 46, 21, 1, -44 },
  { 16545, 31, 37, 35, 2, -36 },
  { 16689, 31, 40, 31, -1, -39 },
  { 16844, 44, 43, 48, 2, -41 },
  { 17081, 25, 50, 27, 1, -36 },
  { 17238, 30, 53, 32, 1, -41 },
  { 17437, 19, 48, 23, 2, -35 },
  { 17551, 19, 55, 23, 1, -54 },
  { 17682, 4, 57, 11, 3, -54 },
  { 17711, 19, 55, 23, 1, -54 },
  { 17842, 22, 5, 25, 2, -23 },
};

const GFXfont UnifrakturMaguntia_Regular69pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular69pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular69pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR69PT7B_H_
