#ifndef _UNIFRAKTURMAGUNTIA_REGULAR15PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0x5D, 0xA4, 0x90, 0x09, 0x80, 0x49, 0xFA, 0x92, 0x14, 0x69, 0xF9,
  0x22, 0xDF, 0xCA, 0x14, 0x43, 0x25, 0x2D, 0xF0, 0xD3, 0x9C, 0x98, 0x80,
  0x70, 0x54, 0x2D, 0x8B, 0x64, 0x52, 0x1D, 0x60, 0xB4, 0x4D, 0x23, 0x48,
  0xD4, 0x18, 0x18, 0x34, 0x34, 0x38, 0x33, 0x5A, 0x5A, 0xCE, 0x6C, 0x7F,
  0x5D, 0x20, 0x24, 0x44, 0xCC, 0xCC, 0xC4, 0x46, 0x84, 0x22, 0x23, 0x32,
  0x22, 0x2C, 0x27, 0xFE, 0x40, 0x42, 0x3E, 0x84, 0x20, 0x76, 0x78, 0x3C,
  0x5C, 0x03, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x38, 0xD9, 0x96, 0x3C, 0x78, 0xF1, 0xE3, 0x44, 0xD8, 0xE0, 0x23,
  0x28, 0x42, 0x10, 0x84, 0x37, 0xC0, 0x39, 0x38, 0xC3, 0x0C, 0x21, 0x19,
  0x7F, 0xF0, 0x39, 0x98, 0x10, 0x61, 0xC4, 0xC1, 0xE3, 0x44, 0x70, 0x08,
  0x30, 0xA2, 0x44, 0x91, 0x3F, 0x84, 0x18, 0x78, 0x7C, 0xE1, 0x03, 0xC7,
  0xC8, 0xC1, 0xE3, 0x44, 0x70, 0x38, 0xD9, 0x12, 0x0F, 0x9C, 0xB1, 0x63,
  0x44, 0xD8, 0xE0, 0x7E, 0x10, 0x82, 0x08, 0x61, 0x0C, 0x31, 0x80, 0x10,
  0xD9, 0x12, 0x27, 0x8B, 0x91, 0x43, 0x87, 0x89, 0xE0, 0x38, 0x9B, 0x36,
  0x6C, 0x4B, 0x8D, 0x02, 0x4C, 0x90, 0xE0, 0x5C, 0x00, 0xB8, 0x5C, 0x00,
  0xB2, 0x80, 0x12, 0x4E, 0x31, 0xFC, 0x0F, 0xC0, 0x84, 0x37, 0xC8, 0x39,
  0x3C, 0x53, 0x39, 0x86, 0x8E, 0x00, 0x43, 0x80, 0x1E, 0x30, 0x93, 0xD2,
  0xDB, 0x55, 0x69, 0xDA, 0xC2, 0x3E, 0x00, 0x18, 0x27, 0xE6, 0x86, 0xC8,
  0x64, 0xC2, 0x47, 0x64, 0x14, 0x40, 0x84, 0x18, 0x43, 0xDF, 0x0E, 0x60,
  0x3C, 0xE3, 0xFB, 0x21, 0x8D, 0x04, 0x78, 0x22, 0x25, 0x78, 0xD0, 0x61,
  0x03, 0x1C, 0x19, 0x70, 0x81, 0xF8, 0x19, 0x09, 0xF6, 0xC1, 0x60, 0x4C,
  0x13, 0x86, 0x71, 0x8C, 0x72, 0x0F, 0x11, 0xF8, 0x1F, 0x03, 0xFC, 0x44,
  0xE8, 0x86, 0x8C, 0x38, 0xE3, 0x46, 0x13, 0x22, 0x1C, 0x23, 0xE4, 0x47,
  0x80, 0x00, 0x19, 0x09, 0xF4, 0xC1, 0x60, 0x4D, 0xD3, 0xB6, 0x71, 0x8C,
  0x72, 0x0F, 0x11, 0xF8, 0x1E, 0x07, 0xF1, 0x0F, 0xC2, 0x48, 0x65, 0x0F,
  0xD0, 0xF1, 0xCC, 0x31, 0x86, 0x10, 0xC6, 0x08, 0x80, 0xE0, 0x1C, 0x84,
  0x71, 0x93, 0xA4, 0x44, 0xDD, 0x9D, 0xF9, 0x9B, 0x13, 0x62, 0x66, 0x88,
  0x7E, 0x00, 0x00, 0x00, 0xC0, 0x7C, 0x11, 0x02, 0x10, 0x67, 0x0F, 0x70,
  0xE6, 0x0C, 0x68, 0x8F, 0xA1, 0x18, 0x60, 0x08, 0x0E, 0x00, 0x3E, 0x11,
  0xD4, 0x19, 0x04, 0x43, 0x09, 0xC1, 0x98, 0x06, 0x00, 0xDC, 0x3B, 0x88,
  0x7C, 0x3E, 0x11, 0xD4, 0x19, 0x04, 0x43, 0x09, 0xC1, 0x98, 0x06, 0x00,
  0xC0, 0x30, 0x05, 0xC2, 0xB8, 0x87, 0xC0, 0x03, 0x80, 0xC4, 0x13, 0xA3,
  0xD9, 0x38, 0xD1, 0x8A, 0x1D, 0xC0, 0xEC, 0x04, 0xC6, 0x4C, 0xB8, 0x70,
  0x0C, 0x33, 0x61, 0x61, 0x71, 0x3E, 0x30, 0x20, 0x30, 0xF9, 0x1E, 0x10,
  0x80, 0x7D, 0xFE, 0x8E, 0x66, 0x87, 0x27, 0x83, 0x32, 0x73, 0x34, 0x2B,
  0x24, 0x02, 0x2C, 0x02, 0x2C, 0x75, 0xC7, 0x1F, 0x86, 0x00, 0x00, 0x10,
  0x43, 0xE7, 0x21, 0xCD, 0x0E, 0x68, 0x31, 0xB9, 0x90, 0x2D, 0x00, 0x48,
  0x02, 0x63, 0xA3, 0xC6, 0x0C, 0x04, 0x01, 0xE0, 0xCF, 0x20, 0x64, 0x07,
  0xE0, 0xCE, 0x08, 0x42, 0x70, 0x57, 0x10, 0x7C, 0x00, 0x10, 0x43, 0xE6,
  0x23, 0xF9, 0x0C, 0xE8, 0x63, 0xAB, 0x0C, 0xB8, 0x20, 0x41, 0x06, 0x10,
  0x7D, 0x04, 0xF0, 0x04, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x33,
  0xC4, 0x0C, 0xC0, 0x67, 0x06, 0x38, 0x20, 0x84, 0x71, 0xCB, 0xAF, 0x1F,
  0x60, 0x00, 0x10, 0x41, 0xFB, 0xC4, 0x73, 0x20, 0xCE, 0x83, 0x12, 0x05,
  0x87, 0x9E, 0x00, 0x5C, 0x02, 0x30, 0xF0, 0xC5, 0xC1, 0xC0, 0x04, 0x03,
  0xFC, 0x86, 0x20, 0x04, 0x19, 0xBF, 0xB3, 0x8A, 0x01, 0x70, 0x27, 0xF8,
  0x7E, 0x00, 0x3E, 0x08, 0xF2, 0x07, 0xC6, 0x08, 0xC0, 0xFC, 0x00, 0xC1,
  0x98, 0x7C, 0x03, 0x88, 0x1E, 0x00, 0x38, 0xDA, 0x66, 0x18, 0xC6, 0x39,
  0x84, 0x62, 0x18, 0x86, 0xFB, 0x87, 0x30, 0x00, 0x18, 0xC3, 0xFB, 0x21,
  0x8D, 0x04, 0x48, 0x22, 0x25, 0x30, 0xD0, 0xC1, 0x07, 0x3C, 0x10, 0x79,
  0x00, 0xF0, 0x19, 0x18, 0x7E, 0xEC, 0x46, 0x8E, 0x82, 0xC6, 0x82, 0xC4,
  0x4A, 0x6C, 0x34, 0x6E, 0x04, 0x27, 0x3C, 0x22, 0x0E, 0x72, 0x07, 0xBC,
  0x38, 0x9F, 0x78, 0x6A, 0x18, 0x87, 0x9F, 0xE0, 0x60, 0x18, 0x0B, 0x0E,
  0xFF, 0x18, 0x38, 0xC3, 0xFB, 0x21, 0x8D, 0x04, 0x68, 0x22, 0x25, 0x30,
  0xC9, 0x80, 0x8E, 0x08, 0x30, 0x79, 0x85, 0x8C, 0x40, 0x41, 0xFC, 0x00,
  0x1F, 0x08, 0x64, 0x18, 0x86, 0x32, 0x03, 0xE0, 0x18, 0x03, 0x00, 0xDC,
  0x2B, 0x88, 0x7C, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x00, 0xD5, 0x55, 0x57, 0x10, 0xC4,
  0xA1, 0xFE, 0xC8, 0x80, 0x10, 0x71, 0x32, 0x6C, 0xD9, 0x9B, 0xBE, 0xB1,
  0x86, 0x9E, 0x6D, 0x96, 0x59, 0x78, 0xC0, 0x13, 0x97, 0x8C, 0x21, 0x87,
  0xC1, 0xC1, 0xE0, 0xE6, 0x4C, 0xD9, 0x32, 0x74, 0x30, 0x13, 0x97, 0xAE,
  0x21, 0x87, 0x07, 0x84, 0xF6, 0x66, 0x44, 0x44, 0x44, 0x10, 0x71, 0x32,
  0x2C, 0xC9, 0x93, 0x3A, 0x04, 0x89, 0xE0, 0x02, 0xE6, 0x1A, 0x79, 0xB6,
  0x59, 0x65, 0x97, 0x84, 0x21, 0x00, 0x64, 0x46, 0xE6, 0x66, 0x72, 0x32,
  0x02, 0x73, 0x33, 0x33, 0x33, 0x3C, 0xBB, 0xD8, 0xEE, 0x31, 0x8C, 0x71,
  0x00, 0xBB, 0x18, 0xC6, 0x31, 0x8C, 0x71, 0x00, 0x49, 0x1F, 0xFE, 0x49,
  0x92, 0x64, 0x99, 0x26, 0xCC, 0x9B, 0x48, 0xDB, 0xDB, 0x26, 0x4C, 0x99,
  0x93, 0x13, 0xE5, 0x93, 0x4D, 0x2E, 0x8C, 0x81, 0x93, 0xE3, 0x66, 0x4C,
  0x99, 0x7C, 0x70, 0x41, 0x02, 0x00, 0x10, 0xE4, 0xD2, 0xCB, 0x26, 0x9E,
  0x08, 0x20, 0x80, 0x53, 0xFA, 0xC6, 0x31, 0xC4, 0x18, 0x97, 0xE2, 0xD9,
  0xB4, 0x7E, 0x10, 0x12, 0x27, 0xE6, 0x66, 0x72, 0x44, 0xDB, 0x9B, 0x26,
  0x4C, 0x9B, 0x9B, 0x02, 0x2D, 0xFB, 0x64, 0x94, 0x5A, 0x30, 0x40, 0x10,
  0x2E, 0xD8, 0xDB, 0x24, 0xC9, 0x12, 0x49, 0xBC, 0x33, 0x00, 0x49, 0xA3,
  0xC8, 0x20, 0x83, 0x9C, 0x82, 0x47, 0x80, 0xC1, 0x91, 0xF3, 0x26, 0x6C,
  0xD9, 0xBA, 0x24, 0x10, 0x43, 0x00, 0x23, 0x8C, 0x47, 0xDB, 0x73, 0x9C,
  0x98, 0x12, 0x62, 0x22, 0xC2, 0x26, 0x23, 0xFF, 0xF8, 0x86, 0x22, 0x62,
  0x12, 0x62, 0x2C, 0xF8,
};

const GFXglyph UnifrakturMaguntia_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 6, 4, 6, 0, -11 },
  { 9, 7, 8, 8, 0, -9 },
  { 16, 5, 12, 6, 1, -11 },
  { 24, 10, 11, 11, 0, -11 },
  { 38, 8, 10, 9, 0, -10 },
  { 48, 3, 4, 3, 0, -11 },
  { 50, 4, 12, 4, 0, -12 },
  { 56, 4, 12, 4, 0, -12 },
  { 62, 5, 4, 5, 0, -10 },
  { 65, 5, 6, 6, 1, -8 },
  { 69, 2, 4, 3, 0, -2 },
  { 70, 5, 3, 4, 0, -6 },
  { 72, 3, 2, 3, 0, -2 },
  { 73, 8, 12, 8, 0, -11 },
  { 85, 7, 11, 7, 0, -11 },
  { 95, 5, 10, 5, 0, -10 },
  { 102, 6, 10, 7, 0, -10 },
  { 110, 7, 10, 7, 0, -10 },
  { 119, 7, 10, 7, 0, -10 },
  { 128, 7, 10, 7, 0, -10 },
  { 137, 7, 11, 7, 0, -11 },
  { 147, 6, 10, 6, 0, -10 },
  { 155, 7, 11, 7, 0, -11 },
  { 165, 7, 11, 7, 0, -11 },
  { 175, 3, 7, 3, 0, -7 },
  { 178, 3, 9, 3, 0, -7 },
  { 182, 4, 6, 4, 0, -7 },
  { 185, 6, 3, 6, 0, -6 },
  { 188, 4, 6, 4, 0, -7 },
  { 191, 6, 11, 7, 0, -11 },
  { 200, 9, 9, 9, 0, -7 },
  { 211, 12, 11, 12, 0, -11 },
  { 228, 13, 11, 13, 0, -11 },
  { 246, 10, 11, 10, 0, -11 },
  { 260, 12, 12, 12, 0, -11 },
  { 278, 10, 11, 11, 0, -11 },
  { 292, 11, 13, 11, 0, -11 },
  { 310, 11, 11, 12, 0, -11 },
  { 326, 11, 14, 11, 0, -12 },
  { 346, 10, 12, 10, 0, -11 },
  { 361, 10, 14, 11, 0, -11 },
  { 379, 12, 11, 12, 0, -11 },
  { 396, 8, 11, 9, 0, -11 },
  { 407, 16, 12, 17, 0, -11 },
  { 431, 13, 11, 13, 0, -11 },
  { 449, 11, 11, 11, 0, -11 },
  { 465, 13, 14, 13, 0, -11 },
  { 488, 12, 12, 12, 0, -11 },
  { 506, 14, 11, 14, 0, -11 },
  { 526, 11, 11, 11, 0, -11 },
  { 542, 11, 11, 11, 0, -11 },
  { 558, 10, 11, 11, 0, -10 },
  { 572, 13, 11, 13, 0, -11 },
  { 590, 16, 11, 16, 0, -11 },
  { 612, 10, 11, 11, 0, -11 },
  { 626, 13, 13, 13, 0, -11 },
  { 648, 10, 12, 10, 0, -11 },
  { 663, 2, 12, 3, 0, -11 },
  { 666, 9, 11, 2, -3, -10 },
  { 679, 2, 12, 3, 0, -11 },
  { 682, 6, 4, 6, 0, -11 },
  { 685, 7, 1, 7, 0, 2 },
  { 686, 3, 3, 8, 2, -11 },
  { 688, 7, 8, 7, 0, -8 },
  { 695, 6, 10, 7, 0, -10 },
  { 703, 5, 8, 5, 0, -8 },
  { 708, 7, 10, 7, 0, -10 },
  { 717, 5, 8, 5, 0, -8 },
  { 722, 4, 14, 4, 0, -12 },
  { 729, 7, 11, 7, 0, -8 },
  { 739, 6, 14, 7, 0, -11 },
  { 750, 4, 10, 4, 0, -10 },
  { 755, 4, 14, 4, -1, -11 },
  { 762, 5, 10, 5, 0, -10 },
  { 769, 5, 10, 4, 0, -10 },
  { 776, 10, 8, 11, 0, -8 },
  { 786, 7, 8, 8, 0, -8 },
  { 793, 6, 8, 6, 0, -8 },
  { 799, 7, 12, 7, 0, -9 },
  { 810, 6, 11, 6, 0, -8 },
  { 819, 5, 8, 5, 0, -8 },
  { 824, 6, 9, 6, 0, -9 },
  { 831, 4, 10, 5, 0, -10 },
  { 836, 7, 8, 8, 0, -8 },
  { 843, 6, 9, 7, 0, -9 },
  { 850, 10, 9, 10, 0, -9 },
  { 862, 6, 11, 6, 0, -8 },
  { 871, 7, 12, 7, 0, -9 },
  { 882, 5, 11, 5, 0, -8 },
  { 889, 4, 12, 5, 0, -12 },
  { 895, 1, 13, 2, 1, -12 },
  { 897, 4, 12, 5, 0, -12 },
  { 903, 5, 1, 6, 0, -5 },
};

const GFXfont UnifrakturMaguntia_Regular15pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular15pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular15pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR15PT7B_H_
