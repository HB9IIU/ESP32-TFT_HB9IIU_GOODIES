#ifndef _UNIFRAKTURMAGUNTIA_REGULAR52PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x78, 0x7F, 0x9F, 0xF7, 0xF8, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x30, 0x1E, 0x0F, 0xC7, 0xF8, 0x78, 0x0C, 0x03,
  0x00, 0x00, 0x08, 0x02, 0x03, 0x01, 0x81, 0xC0, 0xF1, 0xFC, 0x7E, 0x7F,
  0xBF, 0xCF, 0xC3, 0xF0, 0xF0, 0x7C, 0x3C, 0x0F, 0x06, 0x03, 0x81, 0x80,
  0xE0, 0x40, 0x30, 0x30, 0x0C, 0x08, 0x02, 0x04, 0x01, 0x00, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x1E, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x87, 0x81, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x78, 0x38, 0x3C, 0x06, 0x0E, 0x01, 0xC7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0x79, 0xF8, 0x0C, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x98, 0x07, 0xEF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEE, 0x00, 0x79, 0x80, 0x1E, 0x70, 0x07,
  0x0C, 0x03, 0xC1, 0xC1, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x81, 0xFE, 0x00, 0x00, 0x18, 0x79, 0xE0, 0x00, 0x06, 0x1E, 0x3C,
  0x00, 0x01, 0x83, 0xC3, 0xC0, 0x00, 0x60, 0xF8, 0x78, 0x00, 0x1C, 0x1F,
  0x0F, 0x80, 0x07, 0x03, 0xE1, 0xF0, 0x01, 0xC0, 0xF8, 0x3E, 0x00, 0x30,
  0x1F, 0x07, 0xC0, 0x0C, 0x03, 0xE0, 0xF8, 0x03, 0x00, 0x7C, 0x1F, 0x00,
  0xC0, 0x07, 0xC3, 0xE0, 0x38, 0x00, 0xF8, 0x7C, 0x0E, 0x00, 0x1F, 0x0F,
  0x03, 0x80, 0x01, 0xE1, 0xE0, 0x60, 0x00, 0x3C, 0x78, 0x18, 0x00, 0x03,
  0xCF, 0x06, 0x00, 0x00, 0x3F, 0xC1, 0x81, 0xF0, 0x03, 0xE0, 0x70, 0xFF,
  0x00, 0x00, 0x1C, 0x3C, 0xF0, 0x00, 0x07, 0x07, 0x8F, 0x00, 0x01, 0xC1,
  0xE1, 0xF0, 0x00, 0x30, 0x3C, 0x3E, 0x00, 0x0C, 0x0F, 0x87, 0xC0, 0x03,
  0x01, 0xF0, 0xF8, 0x00, 0xC0, 0x3E, 0x0F, 0x80, 0x38, 0x07, 0xC1, 0xF0,
  0x0E, 0x00, 0xF8, 0x3E, 0x03, 0x80, 0x1F, 0x0F, 0x80, 0x60, 0x03, 0xE1,
  0xF0, 0x18, 0x00, 0x3C, 0x3E, 0x06, 0x00, 0x07, 0x87, 0xC1, 0x80, 0x00,
  0x78, 0xF0, 0x70, 0x00, 0x0F, 0x1C, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xF0, 0x70, 0x00, 0x7C,
  0x1C, 0x00, 0x1F, 0x07, 0x00, 0x07, 0xE3, 0xC0, 0x01, 0xF8, 0xE0, 0x00,
  0x7E, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x1F, 0x83, 0xFC, 0x1F, 0xE0, 0x3C, 0x0F, 0xFC, 0x06, 0x07, 0x3F,
  0x01, 0x83, 0x8F, 0xE0, 0x61, 0xE3, 0xF8, 0x10, 0xF8, 0x7F, 0x0C, 0x3E,
  0x1F, 0xC3, 0x0F, 0x83, 0xF8, 0x83, 0xE0, 0xFE, 0x60, 0xF8, 0x1F, 0xF0,
  0x3E, 0x07, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0xC1, 0x7E, 0x07,
  0xF8, 0xDF, 0xC0, 0xFF, 0xE3, 0xF8, 0x7F, 0xF8, 0x7F, 0xF3, 0xFC, 0x07,
  0xF0, 0x3C, 0x00, 0x08, 0x18, 0x3C, 0x7E, 0xFF, 0x3F, 0x1F, 0x0E, 0x0E,
  0x0C, 0x0C, 0x08, 0x08, 0x10, 0x00, 0xE0, 0x30, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0xFE, 0x01,
  0xBE, 0xC7, 0xCE, 0x7D, 0xE3, 0x3E, 0xF9, 0xBE, 0x7E, 0xBF, 0x31, 0xF0,
  0x90, 0x78, 0x4F, 0xD7, 0xE7, 0xC9, 0xF3, 0xE6, 0x7F, 0xE7, 0x3E, 0x33,
  0xD8, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x08, 0x06, 0x07, 0x07, 0xE7, 0xF9, 0xF8, 0x7C, 0x1E, 0x06, 0x03,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFC, 0x00,
  0x10, 0x18, 0x3C, 0x7E, 0xFF, 0x3C, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80,
  0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x07, 0x80, 0x1F, 0x1E, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x40, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x82,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE3, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xC1, 0xFF, 0x1C, 0x03, 0xF9, 0xC0, 0x0F, 0xEC, 0x00, 0x7F, 0x40, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x40, 0xE0, 0x02,
  0x0E, 0x00, 0x10, 0x60, 0x00, 0x86, 0x00, 0x04, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0x01, 0xC1, 0xFE, 0x0C, 0x01, 0xFC, 0x60, 0x03, 0xF1, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x80, 0x03, 0xF7, 0x80, 0x07, 0xFF,
  0x00, 0x1E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xCF, 0xC0, 0x0F, 0x1F, 0x00,
  0x78, 0x3E, 0x01, 0xC0, 0x7C, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x37, 0xE0, 0x00, 0x9F, 0x80, 0x06,
  0x7E, 0x00, 0x31, 0xF8, 0x00, 0x87, 0xE0, 0x06, 0x1F, 0x80, 0x30, 0x7E,
  0x00, 0x81, 0xF8, 0x06, 0x07, 0xE0, 0x10, 0x1F, 0x80, 0xC0, 0x7E, 0x06,
  0x01, 0xF8, 0x10, 0x07, 0xE0, 0xC0, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x10,
  0x00, 0x20, 0x7C, 0x07, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x19, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x1F,
  0xE3, 0x80, 0x3F, 0x8C, 0x00, 0x7F, 0x20, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF2, 0x00,
  0x07, 0xDE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xEF, 0xC0, 0x0F,
  0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0x01, 0xF0, 0x70, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x1F, 0x00, 0x38, 0x3E, 0x01, 0xC0,
  0xFC, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xE1, 0xE0, 0x1F, 0x87, 0x80, 0x7E,
  0x3E, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0xFE, 0x07, 0xE7, 0xFC, 0x1F, 0xB9, 0xF8, 0xFE, 0x83,
  0xF3, 0xFE, 0x0F, 0xEF, 0xF0, 0x1F, 0xBF, 0xC0, 0x7E, 0xFE, 0x01, 0xFB,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8,
  0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xF0, 0xF8, 0x03,
  0xC3, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x1C, 0x0E, 0x00,
  0x38, 0x70, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x38, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x18, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x1C, 0x07, 0x80, 0x38,
  0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xF0, 0x01, 0xC7, 0xE0, 0x07, 0x1F, 0xC0, 0x3C, 0x3F, 0xC0,
  0xE0, 0xFF, 0x87, 0x01, 0xFF, 0xB8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x1C, 0x3F, 0xF0, 0xE0,
  0x3F, 0xE7, 0x80, 0x7F, 0x9C, 0x00, 0x7E, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x70, 0xE0, 0x03, 0x81, 0xC0,
  0x1C, 0x03, 0xC0, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x3C,
  0x00, 0x60, 0x78, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x83,
  0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F,
  0xBF, 0x00, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xE0, 0x7F, 0x9F,
  0xC1, 0x7E, 0x3F, 0x9D, 0xF8, 0x7F, 0xE7, 0xE0, 0xFF, 0x1F, 0x81, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x3C, 0x1F, 0x80, 0xF0, 0x7E,
  0x03, 0x80, 0xF8, 0x1C, 0x01, 0xF0, 0x70, 0x03, 0xC3, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x18, 0x38, 0x7E, 0xFF, 0x7E, 0x3C, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x18, 0x3C, 0x7E, 0xFF, 0x3C,
  0x18, 0x18, 0x00, 0x00, 0x06, 0x07, 0x07, 0xE7, 0xF9, 0xF8, 0x78, 0x18,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03,
  0x03, 0x83, 0xF3, 0xFC, 0xFC, 0x3E, 0x0F, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xC3, 0xE1, 0xE0, 0x1E, 0x38, 0x03, 0xEE, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7C, 0xE0,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x40, 0xF0, 0x08, 0x0E, 0x02, 0x00, 0xF0,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xC0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0xFF, 0x9C,
  0x3C, 0x0F, 0xFE, 0x71, 0xE0, 0x79, 0xF8, 0xE7, 0x83, 0xC7, 0xC3, 0x9C,
  0x1F, 0x1F, 0x0E, 0xF0, 0xF8, 0x7C, 0x3B, 0xC3, 0xE1, 0xE0, 0xEF, 0x1F,
  0x07, 0x87, 0x38, 0x7C, 0x3E, 0x1C, 0xE1, 0xE0, 0xF0, 0x73, 0x8F, 0x87,
  0xC3, 0x8E, 0x3E, 0x1F, 0x0E, 0x3C, 0xF8, 0xFC, 0x70, 0xF1, 0xE7, 0xF7,
  0x81, 0xC7, 0xFF, 0xFC, 0x77, 0x0F, 0x8F, 0xC1, 0xCE, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x01, 0xFF, 0xE0, 0x00,
  0x1C, 0x07, 0xFF, 0xF8, 0x00, 0x78, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x1C,
  0x0F, 0xFC, 0x07, 0xF0, 0x30, 0x03, 0xFE, 0x1F, 0xE0, 0x20, 0x01, 0xFF,
  0x3F, 0xE0, 0x60, 0x00, 0xFF, 0x0F, 0xE0, 0x40, 0x00, 0x7F, 0x07, 0xE0,
  0xC0, 0x00, 0x7F, 0x07, 0xE0, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0xC0, 0x00,
  0x3F, 0x87, 0xE0, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x07, 0xE0, 0x7F,
  0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0xF0, 0x3C,
  0x07, 0xE0, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0x00, 0xF0, 0x78, 0x07, 0xE0,
  0x00, 0x70, 0xF0, 0x07, 0xE0, 0x00, 0x60, 0xE0, 0x07, 0xE0, 0x00, 0x41,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0xF0,
  0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x17, 0xF1, 0x00, 0x1F, 0xFC, 0x67, 0xFF,
  0x00, 0x0F, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFC, 0x00, 0x01,
  0xFF, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0xE2, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xA0, 0x3F, 0x80, 0xFC,
  0x07, 0xFF, 0x01, 0xFC, 0x07, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x78, 0x00,
  0x3F, 0xC0, 0x3F, 0x83, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x1C, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xE6, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x30, 0x00, 0x07, 0xE0, 0x03, 0x81, 0x80, 0x00, 0x3F, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x70, 0x00, 0x07, 0x81, 0xFF,
  0x01, 0xC0, 0x00, 0x3C, 0x3F, 0xFC, 0x0E, 0x00, 0x43, 0xC7, 0xFF, 0xF0,
  0x3C, 0x06, 0x1E, 0x7F, 0xFF, 0xC0, 0x7F, 0xC0, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x1F, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x78, 0x00, 0x1E, 0x04, 0x3F, 0x80, 0x0F, 0x00, 0x9F, 0xFF, 0x07, 0x80,
  0x2F, 0xFF, 0x83, 0xE0, 0x0F, 0xFF, 0xC0, 0xF0, 0x06, 0x0F, 0xC0, 0x7C,
  0x07, 0x00, 0xE0, 0x1F, 0x03, 0x80, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x01, 0xF8, 0x3F, 0xE0,
  0x00, 0x7E, 0x0F, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0x07, 0xF0, 0x3F,
  0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0x80, 0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x03, 0xFE, 0x07, 0x00,
  0x00, 0x7F, 0xC3, 0x80, 0x00, 0x1F, 0xF9, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x60, 0x0F, 0xFF, 0xC1, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0x80, 0x21, 0xFF, 0xE0, 0x3E, 0x00, 0x60, 0x7F, 0xE0,
  0x7C, 0x01, 0xC0, 0x1F, 0xF0, 0x78, 0x03, 0x80, 0x07, 0xF8, 0x70, 0x03,
  0x80, 0x03, 0xF8, 0xE0, 0x07, 0xC0, 0x01, 0xFC, 0xE0, 0x0F, 0xE0, 0x00,
  0xFC, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0xC0, 0x0F, 0xF8, 0x00, 0x7E, 0xC0,
  0x0F, 0xFC, 0x00, 0x3E, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x40, 0x03, 0xFE,
  0x00, 0x1E, 0x60, 0x03, 0xFF, 0x00, 0x1E, 0x60, 0x00, 0xFF, 0x00, 0x0F,
  0x30, 0x00, 0x7F, 0x80, 0x0F, 0x18, 0x00, 0x3F, 0x80, 0x0E, 0x0E, 0x04,
  0x1F, 0x80, 0x0E, 0x03, 0xFC, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0x20, 0x00, 0x18, 0x00, 0x7F, 0xE0,
  0x00, 0x18, 0x01, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0xFF, 0xFC, 0x00, 0x60,
  0x07, 0xFF, 0xFF, 0x00, 0xC0, 0x1C, 0x1F, 0xFF, 0xFF, 0x80, 0x10, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0x0F, 0xE0,
  0x01, 0xE0, 0x13, 0xFF, 0xE0, 0x78, 0x03, 0xFF, 0xF8, 0x1F, 0x00, 0x7F,
  0xFE, 0x03, 0xC0, 0x18, 0x3F, 0x00, 0xF8, 0x0E, 0x00, 0xC0, 0x1F, 0x03,
  0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0xE0,
  0x1F, 0x87, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xCF, 0xFA, 0x7E, 0x0F, 0xFD,
  0xFF, 0xCF, 0xC0, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xFC, 0xFC, 0x3F, 0x00,
  0xFF, 0xC7, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x01, 0xFF,
  0x0E, 0x00, 0x00, 0x3F, 0xF3, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x30, 0x03, 0xFF, 0xF0, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xC7, 0xC0,
  0x00, 0xFF, 0xFC, 0x3C, 0x00, 0x05, 0xFF, 0x83, 0xC0, 0x00, 0x63, 0xF8,
  0x1C, 0x00, 0x06, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x10, 0x06, 0x00, 0x07,
  0x80, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x0C,
  0x00, 0x1F, 0xC0, 0x10, 0x60, 0x00, 0xFF, 0x01, 0xC3, 0x00, 0x07, 0xF8,
  0x1F, 0x98, 0x00, 0x1F, 0xE1, 0xFE, 0x60, 0x00, 0xFF, 0x9F, 0xF3, 0x00,
  0x03, 0xFF, 0xFF, 0x0C, 0x00, 0x1F, 0xFD, 0xF0, 0x38, 0x04, 0x7F, 0xC7,
  0x00, 0xF9, 0xF1, 0xFF, 0x18, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00,
  0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x30, 0x00,
  0x01, 0xE0, 0xC1, 0xE0, 0x00, 0x0E, 0x01, 0x8F, 0xC0, 0x00, 0xF0, 0x02,
  0xFF, 0x80, 0x07, 0xC0, 0x0C, 0xFF, 0x00, 0x1E, 0x00, 0x63, 0xFE, 0x00,
  0xF8, 0x03, 0x07, 0xFE, 0x07, 0xC0, 0x38, 0x0F, 0xFC, 0x1F, 0x01, 0xC0,
  0x0F, 0xE0, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x30, 0x0F,
  0x83, 0xF0, 0x01, 0x80, 0x7E, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xF8, 0x1F, 0x83, 0xFC, 0x7F, 0xF0, 0x7E,
  0x07, 0xFB, 0xFF, 0xE1, 0xF8, 0x1F, 0xE0, 0x7F, 0xC7, 0xE0, 0x3F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x7F, 0x01, 0xFF, 0x03, 0xF9, 0xFC,
  0x03, 0xFC, 0x07, 0xE7, 0xF0, 0x07, 0xF8, 0x1F, 0x9F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x7F, 0x80, 0x3F, 0x80, 0xF8, 0xFE, 0x00, 0x7E, 0x03, 0xE3, 0xF8,
  0x01, 0xF0, 0x0F, 0x87, 0xF0, 0x07, 0x80, 0x3E, 0x1F, 0xC0, 0x1C, 0x01,
  0xF0, 0x3F, 0x80, 0xE0, 0x07, 0xC0, 0xFF, 0x06, 0x00, 0x1E, 0x01, 0xFE,
  0x30, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1C, 0xFF, 0x80, 0x00, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x3F, 0xE0,
  0x00, 0x0C, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x02, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xE7,
  0xBF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x60, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0xF0, 0x03,
  0xE3, 0xFC, 0x0E, 0x00, 0x3E, 0x7F, 0xE0, 0xC0, 0x07, 0xEF, 0xFF, 0x08,
  0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x7F, 0xE0, 0x00, 0xF8, 0x03,
  0xFC, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7E, 0x0F, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0xC0, 0x38, 0x00, 0x3F,
  0xFE, 0x1C, 0x00, 0x0F, 0xFE, 0x1C, 0x00, 0x03, 0xFC, 0x0E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x18, 0x00,
  0x07, 0xC0, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x03, 0xF8, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0x38, 0x04, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x87, 0xFC, 0x00, 0x07, 0xC7, 0xFF, 0x80, 0x01, 0xE7, 0xFF, 0xE0, 0x00,
  0xE4, 0x1F, 0xF8, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x60, 0x01, 0xFF, 0x80,
  0x60, 0x00, 0x7F, 0xE0, 0x60, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0x03, 0xFF, 0x80,
  0x07, 0x80, 0x1F, 0xFC, 0x00, 0xE0, 0x01, 0xFF, 0xF8, 0x38, 0x00, 0x1F,
  0xFE, 0x07, 0x00, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x07, 0xE0,
  0x03, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x03,
  0xF8, 0x00, 0x38, 0x04, 0x7F, 0x00, 0x03, 0xE7, 0xCF, 0xE0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x08, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x07, 0x07, 0xFF, 0x00,
  0x00, 0xE1, 0xFF, 0xF0, 0x00, 0x38, 0x63, 0xFF, 0x00, 0x07, 0x00, 0x3F,
  0xF0, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x0C, 0x00,
  0x03, 0xFF, 0xC7, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0x0F, 0xE0, 0x38, 0x00, 0x78, 0x3F, 0xF8, 0x1C, 0x00, 0xF8,
  0x7F, 0xFC, 0x0C, 0x00, 0xF8, 0xFF, 0xFE, 0x0E, 0x01, 0xF8, 0xC1, 0xFE,
  0x0E, 0x01, 0xF9, 0x80, 0xFF, 0x06, 0x01, 0xF9, 0x00, 0x7F, 0x07, 0x01,
  0xF9, 0x00, 0x3F, 0x87, 0x01, 0xFD, 0x00, 0x3F, 0x87, 0x01, 0xFD, 0x00,
  0x3F, 0xE7, 0x01, 0xFF, 0x00, 0x1F, 0xC6, 0x00, 0xFF, 0x00, 0x0F, 0x0E,
  0x00, 0xFF, 0x80, 0x06, 0x0C, 0x00, 0x7F, 0x80, 0x18, 0x18, 0x00, 0x7F,
  0xC0, 0x78, 0x30, 0x00, 0x3F, 0xE1, 0xFC, 0x60, 0x00, 0x1F, 0xE7, 0xFE,
  0x80, 0x00, 0x1F, 0xF5, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x3F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC0, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF9, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x3C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3,
  0xF8, 0x00, 0x3E, 0x3F, 0x80, 0x03, 0xE3, 0xF8, 0x00, 0x3E, 0x3F, 0xC0,
  0x03, 0xE3, 0xFE, 0x00, 0x3E, 0x1F, 0xE0, 0x03, 0xC1, 0xFF, 0x00, 0x7C,
  0x0F, 0xF0, 0x0F, 0x80, 0xFF, 0x3F, 0xF0, 0x07, 0xF8, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x2F, 0xFF, 0xF0, 0x06, 0x03, 0xFF, 0xC0, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7E, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0x90, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFE, 0x07, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFC, 0x1C, 0x00,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x30, 0x00, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0x40, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xF1, 0x80, 0x00, 0xFF, 0x01, 0xFC,
  0x07, 0xE3, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE6, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x98, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x10, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x30,
  0x30, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0xC0, 0x71, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0x00, 0x7F, 0xF8, 0x0F, 0x80, 0x7C, 0x0C, 0x00, 0x7F, 0xF8, 0x1F,
  0x00, 0xF8, 0x38, 0x00, 0x7F, 0xF0, 0x3E, 0x01, 0xF0, 0xF0, 0x00, 0x38,
  0x60, 0x7C, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xC0, 0xF0, 0x07, 0x87, 0xC0,
  0x00, 0x01, 0x01, 0xE0, 0x0F, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x1E,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x7E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC1, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x01, 0x83, 0xF8, 0x00, 0x1F, 0x00, 0xC0, 0x06, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0x3E, 0x0C, 0x07, 0xF0, 0x03, 0xFF, 0x04, 0xFE, 0x30,
  0x0F, 0xF1, 0x8F, 0xFF, 0x1B, 0xFF, 0xC0, 0x0F, 0xFE, 0x31, 0xFF, 0xEF,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x43, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x71,
  0xFE, 0x03, 0xFF, 0xFF, 0xC4, 0x0F, 0xE0, 0x38, 0x07, 0xFE, 0xC0, 0x7E,
  0x07, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0x04,
  0x00, 0x07, 0xF8, 0x03, 0xF0, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x8C, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xEC, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x40, 0x00, 0x0F, 0xC0, 0x0E, 0x04, 0x00, 0x00, 0xFC,
  0x00, 0xC0, 0x60, 0x00, 0x07, 0xC0, 0x18, 0x07, 0xFF, 0xC0, 0x7C, 0x03,
  0x00, 0x3F, 0xFC, 0x07, 0xC0, 0x70, 0x01, 0xFF, 0xE0, 0x7C, 0x0E, 0x00,
  0x0F, 0xFE, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x60, 0x7C, 0x1E, 0x00, 0x00,
  0x06, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x7F, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x18, 0x03, 0xFC,
  0x00, 0xFF, 0xC1, 0x80, 0x1F, 0xE7, 0x1F, 0xFE, 0x30, 0x01, 0xFF, 0xE1,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0x81, 0xFF, 0xF8, 0x00,
  0x60, 0x01, 0xFF, 0xE0, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0xE0, 0x00, 0x07,
  0xFC, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0x3F, 0xC7, 0xC0,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0xF0, 0x00, 0x01, 0xF3, 0xFF, 0xE0,
  0x00, 0x0F, 0x8F, 0xFF, 0x80, 0x00, 0x3C, 0x3F, 0xFE, 0x00, 0x01, 0xE0,
  0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x01, 0xFE, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x38, 0x07, 0xD0, 0x00, 0x01,
  0x80, 0xFF, 0x00, 0x00, 0x0C, 0x1F, 0xFE, 0x00, 0x00, 0xC1, 0xFF, 0xF8,
  0x00, 0x0C, 0x19, 0xFF, 0xF0, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x0C, 0x00,
  0x07, 0xFF, 0xC1, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x3F, 0xC0, 0x03, 0xE1, 0xFF, 0x8F, 0xFC, 0x00, 0x70, 0x07, 0xFF, 0x9F,
  0xE0, 0x0E, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0xC0, 0x01, 0xFE, 0x1F, 0xF8,
  0x0C, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0xC0, 0x00, 0xFE, 0x07, 0xFE, 0x0C,
  0x00, 0x07, 0xF0, 0x7F, 0xF0, 0xC0, 0x00, 0x7F, 0x03, 0xFF, 0x8C, 0x00,
  0x07, 0xF0, 0x0F, 0xFC, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xC4, 0x00, 0x03,
  0xF0, 0x03, 0xFE, 0x60, 0x00, 0x3F, 0x00, 0x1F, 0xE3, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x18, 0x06, 0x3F, 0x00, 0x07, 0xF0, 0xFF, 0x83, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFE, 0x0C,
  0x00, 0x01, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x1F, 0xFF, 0x80, 0x01, 0x80,
  0x07, 0xFF, 0x80, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x38, 0x00, 0x01, 0xFF,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xC0,
  0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0xFF,
  0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0x00,
  0x07, 0x80, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x00,
  0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x03, 0x80,
  0x3F, 0x40, 0x03, 0xE6, 0x00, 0xFF, 0x00, 0x1F, 0xEC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0xC7, 0xFF, 0xC4, 0x1F, 0xE3,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0xE6, 0x07, 0xF0,
  0x0F, 0x81, 0xFF, 0xD0, 0x1F, 0xE0, 0x78, 0x01, 0xFF, 0xC0, 0x3F, 0x81,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x06, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x38,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF3, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x8C, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x30, 0x00,
  0x01, 0xF8, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x00,
  0x1F, 0x80, 0xC0, 0x06, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x0C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x38, 0x00, 0x03, 0xE7, 0xF8, 0x00, 0x38, 0x0C, 0x0F,
  0xBF, 0xE0, 0x00, 0x7F, 0xC0, 0x3C, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x60, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0x00, 0x1F, 0xE0,
  0x07, 0xFE, 0x0C, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x60, 0x00, 0xFF, 0xB0,
  0x8F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x08, 0x00, 0x3F, 0xFF, 0xE0, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0x3F,
  0xFC, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x01, 0xE0, 0x00,
  0x0F, 0xFC, 0x0E, 0x00, 0x01, 0xFF, 0xF0, 0x70, 0x20, 0x3F, 0xFF, 0xC3,
  0x80, 0x87, 0xFF, 0xFF, 0x3C, 0x07, 0xFF, 0xFC, 0x0D, 0xF0, 0x1F, 0xFF,
  0x00, 0x2F, 0x80, 0x7F, 0xF0, 0x01, 0x7C, 0x01, 0xFE, 0x00, 0x0D, 0xF0,
  0x07, 0xC0, 0x00, 0x6F, 0x80, 0x00, 0x00, 0x03, 0x7E, 0x00, 0x00, 0x00,
  0x1B, 0xF8, 0x00, 0x00, 0x00, 0xCF, 0xE0, 0x00, 0x00, 0x0C, 0x7F, 0x80,
  0x00, 0x00, 0x61, 0xFF, 0x00, 0x00, 0x06, 0x0F, 0xFC, 0x00, 0x00, 0xF0,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x2E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0x00,
  0x1C, 0x00, 0x7F, 0xFC, 0x01, 0xC0, 0x00, 0xFF, 0xF8, 0x4C, 0x00, 0x01,
  0xFF, 0xF7, 0x40, 0x00, 0x63, 0xFF, 0xE6, 0x00, 0x06, 0x0F, 0xFE, 0x30,
  0x00, 0xF0, 0x1F, 0xE1, 0x80, 0x07, 0x80, 0x3E, 0x0C, 0x00, 0x7C, 0x00,
  0x00, 0x60, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x00,
  0xFF, 0x80, 0x00, 0x30, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x1F, 0xF8, 0x00,
  0x03, 0xCE, 0x7F, 0xE0, 0x00, 0x01, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3C, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x3C,
  0x00, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x38, 0x00, 0x00, 0x3F,
  0xF3, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x3F, 0xF8, 0x01, 0xC0, 0x00, 0x7F,
  0xF8, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x38, 0x30,
  0x00, 0x70, 0x1E, 0x02, 0x00, 0x3C, 0x03, 0xC0, 0x40, 0x1F, 0x00, 0xF0,
  0x08, 0x0F, 0xE0, 0x3E, 0x01, 0x07, 0xF8, 0x07, 0xC0, 0x40, 0xFF, 0x00,
  0xFC, 0x10, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x1F,
  0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x0F,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x7F, 0xF0, 0x05, 0xF8, 0x1F, 0xFF, 0x83, 0x3F, 0x04, 0x1F, 0xFD, 0xC7,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0xC3, 0xF8, 0x03,
  0xFF, 0xFF, 0xC8, 0x1F, 0xC0, 0x3E, 0x03, 0xFF, 0x81, 0xFE, 0x07, 0x80,
  0x1F, 0xF0, 0x0F, 0xE0, 0x70, 0x00, 0xFF, 0x00, 0xFF, 0x0E, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xCC, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0xC0, 0x00, 0x1F, 0x80, 0x18, 0x0C, 0x00, 0x01, 0xF8, 0x01,
  0x80, 0xC0, 0x00, 0x0F, 0x80, 0x30, 0x04, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0xF0, 0x02, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x30,
  0x02, 0x0F, 0x01, 0xFC, 0x01, 0xC0, 0xC1, 0xE0, 0x1F, 0xE0, 0x07, 0xF8,
  0x1C, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0xFF, 0x80, 0x00, 0x78, 0x03, 0xBF, 0xFC, 0x00, 0x03, 0x80, 0x20,
  0xFF, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x0F,
  0xC6, 0x7F, 0xE0, 0x03, 0xFF, 0xFE, 0x61, 0xA0, 0x7F, 0x80, 0x1F, 0xFF,
  0xFF, 0x03, 0x80, 0xFF, 0x00, 0xFE, 0x3F, 0xF8, 0x0C, 0x01, 0xFE, 0x07,
  0xC0, 0x1F, 0xF0, 0x70, 0x07, 0xF8, 0x1E, 0x00, 0x3F, 0xC1, 0xC0, 0x0F,
  0xE0, 0xE0, 0x00, 0x7F, 0x0F, 0x00, 0x3F, 0xC3, 0x80, 0x00, 0xFE, 0x3C,
  0x00, 0x7F, 0x8C, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0xFF, 0x30, 0x00, 0x07,
  0xE7, 0xE0, 0x03, 0xF0, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0x03, 0x00,
  0x00, 0x3E, 0x7F, 0x00, 0x18, 0x04, 0x00, 0x00, 0xF9, 0xFE, 0x00, 0xE0,
  0x18, 0x00, 0x03, 0xE3, 0xF8, 0x07, 0x80, 0x20, 0x00, 0x0F, 0x0F, 0xF0,
  0x3E, 0x00, 0xC0, 0x08, 0x3C, 0x1F, 0xC0, 0xFC, 0x01, 0x80, 0x60, 0xE0,
  0x7F, 0x83, 0xF8, 0x01, 0xFF, 0x07, 0x80, 0xFE, 0x0F, 0xF0, 0x01, 0xF0,
  0x1C, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x60, 0x07, 0xE0, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x3E, 0x03,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x03,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x3F, 0xF0,
  0x00, 0x38, 0x00, 0x3E, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x70, 0x1F,
  0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xC0, 0xC1, 0xFF, 0x80, 0x1F, 0xE0, 0x06,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x10, 0x00, 0x07, 0xFE, 0x0F, 0xFF,
  0x80, 0xC0, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0x86, 0x00, 0x00, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x00, 0x1F, 0xFE, 0x01,
  0xF8, 0x87, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF,
  0xE1, 0xFF, 0x8F, 0xC3, 0xFE, 0x7F, 0xE3, 0xC0, 0x1F, 0xCC, 0x7C, 0x70,
  0x01, 0xF9, 0x06, 0x0C, 0x00, 0x1F, 0xA0, 0x01, 0x80, 0x03, 0xF8, 0x00,
  0x30, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0xFC,
  0x00, 0x18, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x03, 0xFF, 0xF0, 0x30, 0x00,
  0xFF, 0xFE, 0x03, 0x00, 0x1F, 0xFF, 0x80, 0x38, 0x67, 0xFF, 0xF0, 0x01,
  0xF1, 0xFF, 0xFC, 0x00, 0x00, 0x47, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0B, 0xF8, 0x00, 0x00, 0x01, 0x7F, 0x00, 0x00,
  0xE0, 0x27, 0xF0, 0x00, 0x3F, 0x08, 0xFF, 0x00, 0x0F, 0xF3, 0x1F, 0xFD,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0x02, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0xC3, 0xFC, 0x0F, 0xFF, 0xFF, 0xA0, 0x7F, 0x03, 0xC0,
  0x3F, 0xF8, 0x0F, 0xE1, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x70, 0x00, 0x7F,
  0x00, 0xFE, 0x38, 0x00, 0x1F, 0xE0, 0x3F, 0xCC, 0x00, 0x03, 0xF8, 0x07,
  0xF3, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xF0,
  0x00, 0x07, 0xE0, 0x07, 0x8C, 0x00, 0x00, 0xF8, 0x00, 0xC1, 0x00, 0x00,
  0x3E, 0x00, 0xE0, 0x60, 0x00, 0x0F, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xC0,
  0x3C, 0x01, 0x00, 0x20, 0xF0, 0x1F, 0x00, 0x30, 0x30, 0x78, 0x0F, 0xC0,
  0x07, 0xF8, 0x1E, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x30,
  0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x03, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xF0,
  0x0F, 0xE0, 0x02, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x04,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x00,
  0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0x80, 0x07, 0xF8, 0x07, 0x00, 0x01,
  0xFC, 0x07, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00,
  0xFC, 0x06, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00,
  0xF8, 0x03, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x1F, 0x1F, 0xE0, 0x00, 0x0E, 0x3F, 0xF0, 0x00,
  0x1E, 0x7F, 0xF8, 0x00, 0x1C, 0xCF, 0xFC, 0x00, 0x1C, 0x03, 0xFE, 0x00,
  0x18, 0x01, 0xFF, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x60, 0x00, 0x7F, 0xE1,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0xFF, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0x1F,
  0x03, 0xC1, 0xE0, 0xF0, 0x0E, 0x3C, 0x00, 0xE6, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x70, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x0E, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xFE, 0x00, 0x0D, 0xFE, 0x00, 0x63, 0xFF, 0x03, 0x87, 0xF8, 0x1C, 0x07,
  0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xFC, 0x1F,
  0x03, 0xF8, 0xFE, 0xC7, 0xFD, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x0F, 0xC0,
  0x78, 0x1E, 0x00, 0x80, 0x18, 0x00, 0x18, 0x00, 0x07, 0x20, 0x20, 0xE0,
  0x00, 0x8F, 0x00, 0x06, 0xF8, 0x00, 0x17, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x40, 0x3E, 0x06,
  0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0xE0, 0x7D, 0xFF, 0x83, 0xF0, 0xFC, 0x1F,
  0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xC1, 0xF0, 0x1E, 0x0F, 0xC0, 0xE0,
  0xFF, 0x84, 0x0F, 0xFE, 0x40, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xF8, 0x06, 0xFC, 0x0C, 0x7C, 0x1C, 0x7E, 0x1C, 0x3E, 0x38, 0x3F, 0x78,
  0x1C, 0x78, 0x10, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x03,
  0xE0, 0x00, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x08, 0xFF, 0x00, 0xC1, 0xFC, 0x1F,
  0x03, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0x78,
  0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x07, 0xC0, 0x1C, 0x1F, 0x00, 0x70, 0x7F,
  0x01, 0x87, 0xFE, 0x0C, 0x0F, 0xFE, 0x20, 0x07, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00,
  0xFC, 0x01, 0xBF, 0x01, 0x8F, 0x81, 0xC7, 0xE1, 0xE1, 0xF0, 0xE0, 0xF8,
  0xF0, 0x7E, 0x78, 0x1F, 0x3C, 0x0F, 0xDE, 0x07, 0x0F, 0x0E, 0x0F, 0xB8,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x0F, 0xC4, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0x1F, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x0D, 0xFF, 0x00, 0x63, 0xFF, 0x03, 0x83, 0xFC, 0x1C, 0x07, 0xE0, 0xF0,
  0x07, 0x87, 0xC0, 0x0C, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC3, 0xE0, 0x0F,
  0x0F, 0xC0, 0x3C, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x87,
  0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x07, 0xE1, 0xFC, 0x0F, 0xF9, 0xF0, 0x3F, 0x07, 0xE0, 0xF0, 0x1F,
  0x81, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x06,
  0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF8, 0x07, 0x03, 0xE0, 0x38, 0x07, 0xC1,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x30, 0xF0, 0x00, 0x8F, 0x00, 0x02, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x10, 0x07, 0xC1, 0x80,
  0x3E, 0x1E, 0x01, 0xF1, 0xF8, 0x0F, 0xBF, 0xE0, 0x7E, 0x3F, 0x03, 0xE0,
  0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x3E, 0x03, 0xF1,
  0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0x87, 0xF2, 0x3C, 0x7F, 0xE1, 0xC1, 0xFE, 0x0E,
  0x03, 0xE0, 0xE0, 0x0E, 0x06, 0x00, 0x30, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x01, 0xE0,
  0x3F, 0x07, 0xF8, 0x7F, 0xC9, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF9, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x38,
  0x01, 0x80, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFF, 0x0D, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0x90, 0x0F, 0x10, 0x3C,
  0x30, 0xE0, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xC3, 0x07,
  0x02, 0x1C, 0x02, 0x78, 0xE7, 0xF3, 0xC7, 0xEF, 0x8F, 0xDF, 0x1F, 0xFE,
  0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE2, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F,
  0x00, 0x0E, 0x00, 0x08, 0x00, 0x00, 0x3C, 0x01, 0xC2, 0x0F, 0x02, 0x3C,
  0x02, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE2, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0x08, 0x00, 0x08, 0x01, 0x00, 0x40, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0xFC, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xF1, 0xFC, 0x07, 0xF9, 0xFF, 0x7F,
  0xF0, 0xBF, 0xC7, 0xF9, 0xFF, 0x23, 0xF0, 0xFC, 0x1F, 0x80, 0x7C, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F,
  0x87, 0xF0, 0x7C, 0x8F, 0xF9, 0xFF, 0x0F, 0xD0, 0xFE, 0x1F, 0xC1, 0xFE,
  0x0F, 0x81, 0xF0, 0x1F, 0x80, 0xE0, 0x1C, 0x03, 0xE0, 0x0C, 0x03, 0x80,
  0x3C, 0x01, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x1E, 0x07, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x9F, 0xF0, 0x7F, 0xB7, 0xFC,
  0x9F, 0xE3, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xC1, 0xF0,
  0x3F, 0xE1, 0xF9, 0x1F, 0xC1, 0xFE, 0x0F, 0x80, 0xFE, 0x07, 0x00, 0x7C,
  0x07, 0x00, 0x38, 0x02, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF8, 0x3E, 0x1F, 0xC3,
  0xE1, 0xFC, 0x3E, 0x0F, 0xE3, 0xE0, 0x7E, 0x3E, 0x03, 0xF3, 0xE0, 0x3F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1C, 0x7F, 0x01, 0x8F, 0xFC,
  0x30, 0x7F, 0xF6, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x1F, 0xC0, 0xE0,
  0x3F, 0xC3, 0xE0, 0x3F, 0x9F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x0F, 0xC0,
  0x7C, 0x1F, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x1F, 0xC0,
  0x38, 0x7F, 0xC0, 0x61, 0xFF, 0xE1, 0x83, 0xFF, 0xF2, 0x04, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xE6, 0x00, 0x03, 0xC4, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0x27, 0xF8, 0x06, 0x3F, 0xF1, 0xC1, 0xFE, 0x1C, 0x0F,
  0xC3, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0xFC,
  0x07, 0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xC7, 0xF0, 0x7C, 0x3F, 0x8F, 0xC3,
  0xFF, 0x7C, 0x1F, 0xC7, 0xC0, 0xF8, 0x7C, 0x07, 0x07, 0xC0, 0x20, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0E, 0x02, 0x0F, 0x83, 0x87, 0xE3, 0xC7, 0xFB, 0xF3,
  0xFF, 0xFA, 0x7F, 0x7E, 0x1F, 0x1E, 0x0F, 0x8E, 0x07, 0xC2, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x20,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x00, 0x7C, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x08, 0x02, 0x01, 0xC0, 0x20, 0x3F, 0x02, 0x07, 0xFE, 0xE0,
  0x9F, 0xFE, 0x10, 0xFF, 0xC3, 0x03, 0xF8, 0x60, 0x0F, 0x07, 0x00, 0x60,
  0xF0, 0x0C, 0x0F, 0x81, 0xE0, 0xFC, 0x3F, 0x07, 0xF7, 0xF8, 0x7F, 0xFF,
  0x83, 0xF9, 0xFC, 0x1F, 0x0F, 0xC0, 0xE0, 0x7E, 0x0C, 0x03, 0xE0, 0x80,
  0x1C, 0x1C, 0x01, 0x83, 0xF0, 0x18, 0x7F, 0xC3, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x03, 0xE0, 0x1F, 0x80, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE2, 0x1F, 0xEC, 0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x1C, 0x00, 0xE0, 0x3E, 0x00, 0xE0, 0x3F, 0x01, 0xF0,
  0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x8F, 0x81, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF9, 0x1F, 0xE7, 0xFF, 0x3F, 0xFD, 0xFE,
  0x07, 0xF0, 0xFC, 0x01, 0xE0, 0x7C, 0x00, 0xC0, 0x38, 0x00, 0x40, 0x10,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x0E, 0x07,
  0xC0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x8F, 0xFC, 0x3F, 0xB1, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xC0,
  0x3E, 0x03, 0x80, 0x7C, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x18, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1C, 0x03, 0xF0, 0x70, 0x07, 0xF8, 0xC0,
  0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x60, 0x06, 0x07, 0xF0, 0x3C, 0x03, 0x81, 0xFE, 0x1F, 0x83,
  0xF0, 0x7F, 0x8F, 0xF1, 0xFE, 0x0F, 0xE7, 0xFF, 0xBF, 0x81, 0xFE, 0x1F,
  0x87, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xE0,
  0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x80, 0x78,
  0x3E, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x03,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x3F, 0x03, 0xE0, 0x38, 0x0F, 0xC1, 0xFC,
  0x1C, 0x03, 0xF0, 0xFF, 0xC6, 0x01, 0xFE, 0x3F, 0xFB, 0x00, 0x7F, 0x81,
  0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x01, 0x03, 0xC0, 0xC0,
  0xF8, 0x78, 0x7F, 0x3E, 0x3F, 0xDF, 0xC9, 0xFF, 0xF0, 0x7E, 0x7C, 0x1F,
  0x9E, 0x07, 0xE3, 0x01, 0xF8, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE2, 0x01, 0xFC, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1C, 0x7C, 0x06, 0x0E, 0x01, 0x01, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x06, 0x0E, 0x07, 0xC0,
  0xE3, 0xF0, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0x03, 0xF8,
  0x06, 0x07, 0xF0, 0x78, 0x1F, 0xE3, 0xF0, 0x3F, 0xBF, 0xE0, 0x7F, 0x1F,
  0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE1, 0xFD, 0x8F, 0x0F,
  0xFC, 0x38, 0x0F, 0xE0, 0xE0, 0x1F, 0x07, 0x00, 0x38, 0x18, 0x00, 0x40,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x10, 0x7E,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x21,
  0xC1, 0x87, 0xEC, 0x1F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x17, 0xE0, 0x47,
  0xE1, 0x8F, 0xC2, 0x0F, 0xCC, 0x1F, 0x90, 0x1F, 0x60, 0x3E, 0xC0, 0x7D,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xB8, 0x0F, 0x30, 0x1E, 0x60,
  0x38, 0xC0, 0x60, 0xC1, 0x80, 0xEE, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 39, 12, 1, -38 },
  { 50, 18, 14, 21, 1, -37 },
  { 82, 23, 29, 27, 2, -33 },
  { 166, 18, 42, 22, 2, -40 },
  { 261, 35, 37, 37, 1, -37 },
  { 423, 26, 33, 30, 2, -32 },
  { 531, 8, 14, 10, 1, -37 },
  { 545, 11, 42, 13, 1, -41 },
  { 603, 11, 43, 13, 1, -41 },
  { 663, 17, 20, 18, 0, -39 },
  { 706, 17, 18, 21, 2, -26 },
  { 745, 9, 14, 10, 0, -8 },
  { 761, 15, 10, 15, 1, -20 },
  { 780, 8, 9, 10, 1, -8 },
  { 789, 25, 41, 27, 1, -39 },
  { 918, 23, 37, 25, 1, -37 },
  { 1025, 15, 36, 17, 1, -36 },
  { 1093, 21, 35, 23, 1, -35 },
  { 1185, 22, 35, 24, 1, -35 },
  { 1282, 22, 35, 24, 1, -35 },
  { 1379, 22, 36, 24, 1, -36 },
  { 1478, 22, 36, 24, 1, -36 },
  { 1577, 21, 35, 22, 1, -35 },
  { 1669, 22, 37, 24, 1, -37 },
  { 1771, 22, 37, 24, 1, -37 },
  { 1873, 8, 26, 10, 1, -25 },
  { 1899, 9, 31, 9, 0, -25 },
  { 1934, 14, 19, 15, 0, -24 },
  { 1968, 18, 11, 20, 1, -21 },
  { 1993, 14, 19, 15, 0, -24 },
  { 2027, 19, 38, 24, 2, -37 },
  { 2118, 30, 31, 32, 1, -24 },
  { 2235, 40, 38, 42, 1, -37 },
  { 2425, 45, 39, 46, 0, -38 },
  { 2645, 34, 39, 36, 1, -38 },
  { 2811, 40, 40, 42, 1, -38 },
  { 3011, 35, 39, 37, 1, -38 },
  { 3182, 37, 45, 39, 1, -38 },
  { 3391, 38, 38, 40, 1, -37 },
  { 3572, 36, 47, 38, 1, -40 },
  { 3784, 33, 45, 36, 1, -38 },
  { 3970, 35, 51, 37, 1, -38 },
  { 4194, 40, 38, 42, 1, -37 },
  { 4384, 28, 38, 30, 1, -37 },
  { 4517, 55, 39, 58, 1, -36 },
  { 4786, 44, 38, 46, 1, -37 },
  { 4995, 37, 38, 39, 1, -37 },
  { 5171, 44, 46, 46, 1, -37 },
  { 5424, 39, 41, 41, 1, -37 },
  { 5624, 46, 39, 48, 1, -38 },
  { 5849, 37, 38, 39, 1, -37 },
  { 6025, 37, 37, 39, 1, -37 },
  { 6197, 35, 39, 37, 1, -36 },
  { 6368, 44, 39, 46, 1, -38 },
  { 6583, 54, 38, 56, 1, -37 },
  { 6840, 35, 39, 37, 1, -38 },
  { 7011, 42, 46, 45, 1, -38 },
  { 7253, 32, 45, 35, 1, -38 },
  { 7433, 7, 40, 10, 1, -38 },
  { 7468, 32, 36, 6, -10, -34 },
  { 7612, 7, 40, 10, 1, -38 },
  { 7647, 19, 15, 22, 1, -37 },
  { 7683, 24, 4, 24, 0, 6 },
  { 7695, 8, 9, 26, 8, -36 },
  { 7704, 22, 28, 24, 1, -27 },
  { 7781, 21, 38, 23, 1, -36 },
  { 7881, 16, 27, 18, 1, -26 },
  { 7935, 22, 37, 24, 1, -36 },
  { 8037, 17, 27, 19, 1, -26 },
  { 8095, 15, 46, 13, 0, -37 },
  { 8182, 22, 38, 24, 1, -27 },
  { 8287, 21, 45, 23, 1, -36 },
  { 8406, 12, 37, 14, 1, -36 },
  { 8462, 15, 47, 13, -3, -37 },
  { 8551, 15, 37, 17, 1, -36 },
  { 8621, 15, 37, 14, 1, -36 },
  { 8691, 35, 28, 37, 1, -27 },
  { 8814, 24, 28, 26, 1, -27 },
  { 8898, 20, 28, 22, 0, -27 },
  { 8968, 23, 41, 23, 0, -31 },
  { 9086, 20, 38, 22, 1, -27 },
  { 9181, 17, 28, 19, 1, -27 },
  { 9241, 20, 33, 22, 1, -32 },
  { 9324, 14, 34, 16, 1, -33 },
  { 9384, 24, 28, 26, 1, -27 },
  { 9468, 23, 30, 23, -1, -29 },
  { 9555, 34, 32, 36, 1, -31 },
  { 9691, 18, 38, 20, 1, -27 },
  { 9777, 22, 40, 24, 1, -31 },
  { 9887, 15, 37, 17, 1, -27 },
  { 9957, 14, 41, 17, 1, -40 },
  { 10029, 4, 43, 8, 2, -41 },
  { 10051, 14, 41, 17, 1, -40 },
  { 10123, 17, 4, 19, 1, -18 },
};

const GFXfont UnifrakturMaguntia_Regular52pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular52pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular52pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR52PT7B_H_
