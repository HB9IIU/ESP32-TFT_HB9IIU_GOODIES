#ifndef _UNIFRAKTURMAGUNTIA_REGULAR60PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0x60, 0x0F, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x0F, 0x01, 0xF8, 0x3F, 0xC7,
  0xFE, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x04,
  0x03, 0x80, 0x70, 0x3E, 0x07, 0xC3, 0xF8, 0x7F, 0x3F, 0xE7, 0xFC, 0x7F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0x80, 0xF8, 0x3C, 0x03, 0x80, 0xE0, 0x1C,
  0x06, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x60, 0x10, 0x02, 0x01, 0x80,
  0x10, 0x08, 0x01, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x07, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x0F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x83, 0x80, 0xF0,
  0x0E, 0x07, 0x00, 0x78, 0x78, 0x01, 0xC3, 0xC0, 0x0F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xF8, 0x07, 0x9F, 0xE0,
  0x10, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x38, 0x07, 0xFB, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x00, 0x0F,
  0x38, 0x00, 0x70, 0xE0, 0x07, 0x83, 0x80, 0x78, 0x0E, 0x07, 0x80, 0x3F,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x18, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0xF3,
  0xC0, 0x00, 0x01, 0xC3, 0xC3, 0xC0, 0x00, 0x03, 0x0F, 0x87, 0xC0, 0x00,
  0x0C, 0x1F, 0x0F, 0x80, 0x00, 0x38, 0x7E, 0x1F, 0x80, 0x00, 0xE0, 0xFC,
  0x1F, 0x00, 0x03, 0x81, 0xF8, 0x3E, 0x00, 0x0E, 0x03, 0xE0, 0x7C, 0x00,
  0x38, 0x07, 0xC0, 0xF8, 0x00, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0x00, 0x3E, 0x07, 0xC0, 0x1C, 0x00, 0x7E, 0x0F, 0x80,
  0x70, 0x00, 0xFC, 0x3F, 0x01, 0xC0, 0x00, 0xF8, 0x7C, 0x07, 0x00, 0x01,
  0xF0, 0xF8, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x30, 0x00, 0x01, 0xE7, 0x80,
  0xC0, 0x00, 0x01, 0xFE, 0x03, 0x81, 0xF0, 0x01, 0xF8, 0x0E, 0x0F, 0xF8,
  0x00, 0x00, 0x38, 0x3C, 0x78, 0x00, 0x00, 0xE0, 0xF8, 0x78, 0x00, 0x03,
  0x81, 0xE0, 0xF8, 0x00, 0x0E, 0x07, 0xC1, 0xF0, 0x00, 0x18, 0x0F, 0x83,
  0xF0, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0x01, 0xC0, 0x7E, 0x0F, 0xC0, 0x07,
  0x00, 0xFC, 0x1F, 0x80, 0x1C, 0x01, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0xF0,
  0x7E, 0x01, 0xC0, 0x07, 0xE0, 0xFC, 0x03, 0x00, 0x0F, 0xC1, 0xF8, 0x0E,
  0x00, 0x0F, 0x83, 0xF0, 0x38, 0x00, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x1E,
  0x0F, 0x83, 0x80, 0x00, 0x3E, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x38,
  0x00, 0x00, 0x3F, 0xE0, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1F, 0x03, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x0F, 0xE1, 0xC0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x1F, 0x9E, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x03, 0xC0, 0x73,
  0xF8, 0x07, 0x01, 0xE7, 0xF8, 0x0E, 0x07, 0x87, 0xF0, 0x18, 0x1F, 0x0F,
  0xF0, 0x30, 0x3E, 0x0F, 0xE0, 0x60, 0x7C, 0x1F, 0xE0, 0x81, 0xF8, 0x1F,
  0xC3, 0x03, 0xF0, 0x3F, 0xC6, 0x07, 0xE0, 0x3F, 0x98, 0x0F, 0xC0, 0x7F,
  0xB0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x00, 0xFE, 0x06, 0xFF, 0x01, 0xFF, 0x18, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0x00, 0x03, 0x01, 0xC0, 0xF8, 0x7F, 0xBF, 0xF3, 0xF8, 0x3E, 0x0F,
  0x81, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x00, 0x00,
  0x78, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x10, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xFC, 0x00, 0xDF, 0xB8, 0xFC, 0xF3, 0xF7, 0xC6, 0x3E, 0x7E,
  0x67, 0xE7, 0xF6, 0xFE, 0x3F, 0xFF, 0xC2, 0x1F, 0x84, 0x40, 0xF0, 0x47,
  0xFF, 0xFE, 0x7F, 0x6F, 0xE7, 0xE6, 0x7E, 0x7C, 0x63, 0xEF, 0xCF, 0x3F,
  0x0C, 0xFB, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x04, 0x03, 0x01, 0xE0,
  0xFC, 0x7F, 0xCF, 0xF1, 0xFC, 0x3E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFC, 0x00, 0x08, 0x03, 0x01, 0xE0, 0xFC, 0xFF, 0x9F, 0xC3,
  0xE0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF1, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x9F,
  0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E,
  0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0C,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xF8, 0x3F, 0xF0, 0xF0, 0x07, 0xFC, 0x70, 0x01, 0xFE, 0x70,
  0x00, 0xFF, 0x30, 0x00, 0x3F, 0x98, 0x00, 0x1F, 0xC8, 0x00, 0x0F, 0xEC,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x08, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x03, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x41,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x38, 0x1F, 0xF8, 0x18, 0x01, 0xFE, 0x0C,
  0x00, 0x3F, 0xC2, 0x00, 0x0F, 0xF1, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xCE, 0x00, 0x07, 0xF7, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xC7, 0xE0, 0x01,
  0xF1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3C, 0x0F, 0xC0, 0x1E, 0x01, 0xF8,
  0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x37, 0xE0, 0x00, 0x1D, 0xF8, 0x00, 0x0E, 0x7E, 0x00, 0x03, 0x1F, 0x80,
  0x01, 0xC7, 0xE0, 0x00, 0x61, 0xF8, 0x00, 0x30, 0x7E, 0x00, 0x1C, 0x1F,
  0x80, 0x06, 0x07, 0xE0, 0x03, 0x01, 0xF8, 0x01, 0xC0, 0x7E, 0x00, 0x60,
  0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x06, 0x00, 0x7E, 0x03,
  0x80, 0x1F, 0x80, 0xC0, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x04, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x8F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0x01, 0xFF, 0x07, 0x00, 0x1F, 0xE3, 0x80,
  0x03, 0xF8, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF3, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xBF, 0x80,
  0x03, 0xEF, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x78,
  0x7E, 0x00, 0x78, 0x1F, 0x80, 0x3C, 0x07, 0xE0, 0x3C, 0x03, 0xF0, 0x3E,
  0x01, 0xFC, 0x1F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0x87, 0xE0, 0x01, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0x88, 0xFC,
  0x1F, 0xC8, 0x3F, 0x0F, 0xE8, 0x0F, 0xC7, 0xFC, 0x07, 0xF7, 0xFC, 0x03,
  0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x07, 0xC3, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x70, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x1F, 0x80, 0x03, 0xC7, 0xE0, 0x00, 0xF1, 0xFC, 0x00, 0x38, 0x3F, 0x80,
  0x1E, 0x0F, 0xF8, 0x07, 0x03, 0xFF, 0x83, 0x80, 0x7F, 0xF1, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xC7, 0xFF, 0x00, 0x60, 0x7F, 0xE0, 0x70, 0x07,
  0xFC, 0x1C, 0x00, 0xFF, 0x0E, 0x00, 0x1F, 0xE7, 0x80, 0x03, 0xF9, 0xE0,
  0x00, 0x7E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xF9, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x3E,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x01,
  0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xEF,
  0xE0, 0x1F, 0xF7, 0xF0, 0x0F, 0xFB, 0xF8, 0x07, 0xFC, 0xFE, 0x07, 0xFE,
  0x7F, 0x06, 0xFF, 0x1F, 0xE6, 0x7F, 0x07, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x30, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x80, 0x3E, 0x1F, 0xC0,
  0x1F, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0x80, 0x7E,
  0x03, 0x80, 0x3F, 0x03, 0xC0, 0x0F, 0xC3, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x02, 0x01, 0xC0, 0x78, 0x7F, 0x3F, 0xE7, 0xF0,
  0x78, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0x01, 0xE0, 0xFC, 0xFF, 0x9F, 0xC3,
  0xE0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x38, 0x07, 0x83, 0xF8,
  0xFF, 0x8F, 0xE0, 0x78, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x18, 0x07,
  0x81, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x7C, 0x1F, 0xC1, 0xE0, 0x0F,
  0xC7, 0x80, 0x0F, 0x8E, 0x00, 0x1F, 0xBC, 0x00, 0x3F, 0x78, 0x00, 0x3E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x20, 0x1E, 0x00, 0x40, 0x3C, 0x01, 0x80, 0x7C, 0x06, 0x00, 0x7C, 0x18,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x07,
  0xC0, 0x1F, 0x7C, 0x70, 0xF0, 0x0F, 0xFF, 0x8E, 0x3E, 0x03, 0xE7, 0xE1,
  0xC7, 0x80, 0xF8, 0xFC, 0x38, 0xF0, 0x3E, 0x1F, 0x87, 0x3E, 0x0F, 0x83,
  0xE0, 0xE7, 0x81, 0xF0, 0x7C, 0x1C, 0xF0, 0x7C, 0x0F, 0x87, 0x9E, 0x0F,
  0x83, 0xE0, 0xF3, 0xC3, 0xE0, 0x7C, 0x1C, 0x78, 0x7C, 0x1F, 0x87, 0x8F,
  0x0F, 0x83, 0xE0, 0xF1, 0xE3, 0xF0, 0xFC, 0x3C, 0x3C, 0x7E, 0x3F, 0x8F,
  0x03, 0x87, 0xCF, 0xF3, 0xE0, 0x78, 0xFF, 0xFF, 0xF9, 0xEF, 0x0F, 0xE7,
  0xFC, 0x38, 0xE0, 0xF0, 0x7E, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFC, 0x01, 0xC0, 0x7F, 0xF8, 0x0F, 0xF0, 0x06, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x18, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x30, 0x00, 0x3F,
  0xF0, 0x7F, 0x80, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x01, 0x80, 0x00, 0x3F,
  0xC1, 0xFE, 0x03, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x0E, 0x00, 0x00, 0x7F,
  0x07, 0xF8, 0x1C, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x38, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x78, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x78, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xC1,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xE0, 0x1F,
  0xE0, 0x00, 0xFE, 0x07, 0x80, 0x3F, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x7F,
  0x80, 0x00, 0x38, 0x3C, 0x00, 0xFF, 0x00, 0x00, 0x60, 0xF0, 0x01, 0xFE,
  0x00, 0x01, 0x81, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x40, 0xFF, 0xF0, 0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0x8F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x60, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE4,
  0x03, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0x1F,
  0xFC, 0x01, 0xFE, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x78, 0x00,
  0x07, 0xFC, 0x01, 0xFE, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x70,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFC,
  0x70, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x87, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xE0, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0x01, 0xC0, 0x06,
  0x0F, 0x1F, 0xFF, 0xF8, 0x0F, 0x00, 0xC1, 0xF3, 0xFF, 0xFF, 0xC0, 0x7E,
  0x78, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x01, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x07, 0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1C, 0x00, 0x01, 0xF8, 0xE0, 0xFE,
  0x00, 0x07, 0xC0, 0x63, 0xFF, 0x00, 0x1F, 0x00, 0x4F, 0xFF, 0xE0, 0x7C,
  0x00, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x06, 0x07,
  0xF0, 0x0F, 0xC0, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xE0, 0x01, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x3E, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F,
  0x83, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xF8,
  0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x0E, 0x00,
  0x00, 0x1F, 0xF8, 0x38, 0x00, 0x00, 0x3F, 0xF8, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x1F, 0xFE, 0x03,
  0xF0, 0x01, 0x80, 0x3F, 0xF8, 0x0F, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x78,
  0x00, 0x70, 0x00, 0x7F, 0xE1, 0xE0, 0x03, 0xC0, 0x00, 0x7F, 0x87, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x3C, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0xE0, 0x03,
  0xFC, 0x00, 0x07, 0xFB, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xEE, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x98, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x60, 0x01, 0xFF,
  0xC0, 0x00, 0xFD, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xF6, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xCC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x30, 0x00, 0x1F, 0xF8,
  0x00, 0x7C, 0x60, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xC1, 0xE0, 0x60, 0xFC, 0x00, 0x0E, 0x01, 0xFF, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0xC3,
  0xFF, 0xFF, 0x03, 0x80, 0x0C, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x38,
  0x00, 0x03, 0xF1, 0xC1, 0xFC, 0x00, 0x0F, 0x80, 0xC7, 0xFE, 0x20, 0x3E,
  0x00, 0x9F, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xFF,
  0xFC, 0x07, 0xC0, 0x0C, 0x0F, 0xE0, 0x1F, 0x00, 0x70, 0x07, 0x80, 0x3E,
  0x01, 0xC0, 0x02, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x03, 0x00, 0xFE, 0x0F, 0xF8,
  0x1F, 0x81, 0xFC, 0x1F, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F,
  0xFC, 0xFF, 0x3F, 0xC0, 0x3F, 0xF8, 0x7C, 0x7F, 0x80, 0x3F, 0xF8, 0x20,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0x80,
  0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x00, 0x7F,
  0xF1, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0x00, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7F,
  0xFF, 0xFE, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0xF0, 0x00, 0x06, 0x3F, 0xE0, 0x1C, 0x00, 0x01, 0x81, 0xF8, 0x07,
  0x80, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0xC0, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x01, 0xC1, 0x80, 0x00, 0xFF, 0x80,
  0x3C, 0x30, 0x00, 0x0F, 0xF8, 0x0F, 0xC7, 0x00, 0x01, 0xFF, 0x83, 0xFC,
  0x60, 0x00, 0x1F, 0xF8, 0xFF, 0xCC, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x07, 0xFF, 0x9F, 0x81, 0xC0, 0x00,
  0x7F, 0xF0, 0xE0, 0x1E, 0x01, 0x87, 0xFE, 0x18, 0x00, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x10, 0x7E, 0x00, 0x00, 0xF8,
  0x01, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x37, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xC7, 0xFE, 0x00, 0x7C, 0x00, 0x60, 0x7F,
  0xF0, 0x1F, 0x80, 0x18, 0x07, 0xFF, 0x03, 0xE0, 0x0E, 0x00, 0x7F, 0xF0,
  0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xF0,
  0x3E, 0x00, 0x03, 0x80, 0xFE, 0x0F, 0xC0, 0x01, 0xC0, 0x1F, 0x81, 0xFC,
  0x00, 0x70, 0x07, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0xFE, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0x83, 0xF8, 0x1F, 0xF1, 0xFF, 0xF8,
  0x7F, 0x01, 0xFF, 0x7F, 0xFF, 0x8F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF1, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xDF, 0xE0, 0x07, 0xFC,
  0x03, 0xFB, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x7F, 0xC0, 0x07, 0xF8, 0x0F,
  0xE7, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0x9F,
  0xF0, 0x01, 0xF8, 0x03, 0xF1, 0xFE, 0x00, 0x1E, 0x00, 0x7E, 0x3F, 0xE0,
  0x07, 0x80, 0x1F, 0x83, 0xFC, 0x00, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x38,
  0x00, 0x7C, 0x07, 0xFC, 0x0E, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x00, 0x03,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x7F,
  0xE0, 0x00, 0x00, 0x0C, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xE1, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x87, 0xF0,
  0x07, 0x80, 0x0F, 0xE3, 0xFE, 0x01, 0xC0, 0x03, 0xF1, 0xFF, 0xC0, 0x60,
  0x00, 0xFC, 0xFF, 0xF8, 0x30, 0x00, 0x3F, 0x23, 0xFF, 0x98, 0x00, 0x0F,
  0x80, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x1F,
  0xFF, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0xFF, 0xD8,
  0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x78, 0x00, 0x07, 0xFF, 0x80, 0xE0, 0x00,
  0x03, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xE0,
  0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xF8, 0x1C, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x00,
  0x3F, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x00,
  0x00, 0x7E, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x00, 0xF8,
  0x7F, 0xFE, 0x00, 0x01, 0xE1, 0xFF, 0xFE, 0x00, 0x03, 0xC6, 0x0F, 0xFE,
  0x00, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xF8, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xFF,
  0xE0, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00,
  0x18, 0x00, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x00,
  0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x1C, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x3F, 0xFF, 0x00, 0x00, 0x78, 0x7F,
  0xFF, 0x80, 0x00, 0x70, 0xE3, 0xFF, 0xC0, 0x00, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0x80,
  0x00, 0x3F, 0xFE, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x38, 0x00,
  0x1F, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0xF8, 0x3F, 0xFF, 0x01, 0xC0, 0x07,
  0xE0, 0xFF, 0xFE, 0x07, 0x80, 0x1F, 0x87, 0x9F, 0xFC, 0x0E, 0x00, 0x7E,
  0x38, 0x1F, 0xF0, 0x38, 0x03, 0xF8, 0xC0, 0x3F, 0xE0, 0xF0, 0x0F, 0xE2,
  0x00, 0x7F, 0x83, 0xC0, 0x3F, 0x88, 0x01, 0xFF, 0x07, 0x00, 0xFF, 0x20,
  0x03, 0xFC, 0x1C, 0x03, 0xFC, 0x80, 0x0F, 0xF8, 0x70, 0x0F, 0xFE, 0x00,
  0x1F, 0xF9, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x8E, 0x00, 0x7F, 0xE0, 0x00,
  0xFC, 0x38, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0xC0, 0x03, 0xFF, 0x00, 0x0C,
  0x06, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x30, 0x00, 0x1F, 0xF8, 0x0F, 0xC1,
  0x80, 0x00, 0x3F, 0xF0, 0xFF, 0x8C, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xA7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0E,
  0x00, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x07, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1C, 0x00, 0xFF, 0x83, 0xFF, 0xE0,
  0x60, 0x01, 0xFE, 0x08, 0xFF, 0xC3, 0x00, 0x07, 0xFE, 0xC1, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0,
  0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0xE0,
  0x00, 0x3F, 0x3F, 0xE0, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x3E, 0x1F, 0xF0,
  0x00, 0x3E, 0x1F, 0xF8, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x7C, 0x0F, 0xFC,
  0x00, 0xFC, 0x07, 0xFC, 0x81, 0xF8, 0x07, 0xFC, 0x7F, 0xF0, 0x03, 0xFE,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x02, 0x03, 0xFF, 0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xD8, 0x3F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xD8, 0x1F, 0xE0, 0x1E, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xE0, 0x38, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x30, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x60, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x60, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x40, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x40, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x40, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFE, 0x40, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x40, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xC0, 0x60, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0x80, 0x70, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0x00, 0x38, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x00, 0x3F, 0xFF,
  0x00, 0xFC, 0x01, 0xF8, 0x0E, 0x00, 0x1F, 0xFF, 0x80, 0xFC, 0x01, 0xF8,
  0x1E, 0x00, 0x0F, 0xFF, 0x80, 0x7C, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xFF,
  0x80, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x7C, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0x80, 0x78, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE1, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC1,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC1, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0x80, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0x86, 0x01, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0x9F, 0x83, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x03, 0x3F, 0xC2, 0x00, 0x7F, 0xC3, 0x0F, 0xFF, 0x86, 0x7F, 0xF6, 0x00,
  0x7F, 0xFE, 0x19, 0xFF, 0xCC, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x10, 0x7F,
  0xFD, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF9, 0xBF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF2, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x0E, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE3, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xF9, 0x80,
  0x7F, 0x81, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x08, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xC2, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x80, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0x20, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE8, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xE2, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x70, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x1F, 0x80, 0x1C, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x3F,
  0xFF, 0x01, 0xF8, 0x07, 0x00, 0x0F, 0xFF, 0xC0, 0x7E, 0x03, 0xC0, 0x00,
  0xFF, 0xF0, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xCC, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x03, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x40, 0x3C, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x01,
  0xFE, 0x00, 0x00, 0x60, 0x03, 0x80, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x70, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x18,
  0x00, 0xFF, 0xC6, 0x1F, 0xFF, 0x0C, 0x00, 0x1F, 0xFF, 0x8C, 0x7F, 0xEF,
  0x00, 0x03, 0xFF, 0x82, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xE1, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x70, 0x00, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x00,
  0x03, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x07, 0xF1,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x87, 0xFF, 0xF8,
  0x00, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x3E, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x07, 0x08,
  0x00, 0x00, 0x38, 0x03, 0xFA, 0x00, 0x00, 0x06, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xE0, 0x00, 0x0C,
  0x04, 0x7F, 0xFE, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x30, 0x00, 0x01, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x1F, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0x00,
  0x7F, 0xE7, 0x7F, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1C, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x03,
  0x00, 0x00, 0x7F, 0x83, 0xFF, 0xC0, 0x60, 0x00, 0x0F, 0xF0, 0x3F, 0xFC,
  0x0C, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC1, 0x80, 0x00, 0x1F, 0xC0, 0x3F,
  0xFC, 0x30, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC6, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFC, 0x40, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x8C, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x1C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xF1, 0xC0, 0x18, 0x7E, 0x00, 0x01, 0xFE, 0x0F, 0x9E,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0C, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x40, 0x00, 0xE1, 0xC0, 0x03, 0xFA, 0x00, 0x0F,
  0xE6, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x02, 0xC7, 0xFF, 0xE0, 0x83, 0xFE,
  0x18, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x0E, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x20, 0x3F, 0xE0, 0x07, 0xE0,
  0xFF, 0xF9, 0x80, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xF4, 0x01, 0xFF, 0x00,
  0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x60, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x81, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x8E, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80,
  0x70, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x03, 0x80,
  0x18, 0x1F, 0x9F, 0xF8, 0x00, 0x07, 0x81, 0xC0, 0x3E, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x03, 0xFC, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xF8,
  0x00, 0x07, 0xE0, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x30, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x81, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x0C,
  0x00, 0x07, 0xFE, 0x20, 0x4F, 0xFE, 0x70, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x38, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x07,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x3C, 0x04, 0x07, 0xFF, 0xFF, 0x87, 0x80, 0xC3, 0xFF, 0xFF,
  0xF8, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0x1E, 0x00, 0xFF, 0xFF, 0x00, 0x33,
  0xE0, 0x0F, 0xFF, 0x80, 0x06, 0x7C, 0x00, 0xFF, 0xE0, 0x00, 0x4F, 0x80,
  0x0F, 0xF0, 0x00, 0x09, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xBF, 0x00, 0x00,
  0x00, 0x00, 0x37, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x8F, 0xF0, 0x00, 0x00, 0x00, 0x31, 0xFF, 0x00, 0x00, 0x00, 0x06,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0x83, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x3F,
  0xFC, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x70, 0x00, 0x03, 0xFF, 0xF8, 0x4C, 0x00, 0x00, 0x9F, 0xFF, 0xF9, 0x80,
  0x00, 0x70, 0xFF, 0xFC, 0x30, 0x00, 0x1C, 0x0F, 0xFF, 0x0C, 0x00, 0x07,
  0x80, 0x7F, 0xC1, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x30, 0x00, 0x7E, 0x00,
  0x00, 0x02, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x0C,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x3C, 0x00, 0x01, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x67, 0xFF, 0xC3,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x20,
  0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x0F, 0xFF, 0xC3, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0E,
  0x01, 0xF0, 0x60, 0x00, 0x38, 0x03, 0xE0, 0x30, 0x00, 0xF0, 0x07, 0xC0,
  0x10, 0x03, 0xF0, 0x07, 0xC0, 0x10, 0x0F, 0xE0, 0x0F, 0xC0, 0x30, 0x3F,
  0xE0, 0x0F, 0xC0, 0x60, 0x7F, 0xE0, 0x1F, 0xC0, 0x60, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xE0,
  0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x70,
  0x00, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0x80,
  0xCF, 0xE0, 0xC1, 0xFF, 0xE3, 0x8F, 0xF3, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x67, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x18, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xF6, 0x03, 0xFC,
  0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x3C, 0x00, 0x7F, 0xF0, 0x07,
  0xF8, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x30, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x8E, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xE1, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x38, 0x00, 0x00,
  0xFE, 0x00, 0x18, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0x01, 0xF8, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x01, 0x80,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x30, 0x01, 0x83, 0xC0, 0x1F, 0xC0,
  0x03, 0x80, 0x60, 0x78, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x1E, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x03, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0xE7, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x10, 0x3F, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x1E, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC7, 0x78, 0xC3, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xB8, 0x76, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x70, 0x0F,
  0xFC, 0x03, 0xFE, 0x3F, 0xFE, 0x01, 0x80, 0x1F, 0xF0, 0x0F, 0xC0, 0x1F,
  0xF8, 0x0E, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0xFF,
  0x81, 0xE0, 0x00, 0x7F, 0xC1, 0xE0, 0x01, 0xFE, 0x07, 0x00, 0x00, 0xFF,
  0x0F, 0x80, 0x07, 0xFC, 0x38, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x0F, 0xF8,
  0xE0, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0xF3, 0x80, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x7F, 0x06, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xF0, 0x18,
  0x00, 0x00, 0x7E, 0x7F, 0x80, 0x01, 0x80, 0x60, 0x00, 0x01, 0xF8, 0xFF,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x1F, 0x0F, 0xF8, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x7C, 0x1F, 0xF0,
  0x1F, 0x80, 0x18, 0x00, 0x41, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x30, 0x02,
  0x07, 0x80, 0xFF, 0x83, 0xFC, 0x00, 0x70, 0x70, 0x1E, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0xF0, 0x07, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x81, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x01, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x01, 0x81,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x60, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xF9,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x40,
  0x7F, 0xFE, 0x00, 0xFF, 0x70, 0x7F, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0x87, 0xFE, 0x3F,
  0xFC, 0x3E, 0x00, 0xFF, 0x19, 0xFC, 0x3C, 0x00, 0x3F, 0xC8, 0x3C, 0x1E,
  0x00, 0x0F, 0xEC, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x38, 0x73, 0xFF, 0xFF,
  0x00, 0x07, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0B,
  0xFC, 0x00, 0x00, 0x00, 0x0D, 0xFE, 0x00, 0x00, 0x3C, 0x04, 0x7F, 0x80,
  0x00, 0x3F, 0x86, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0x0F, 0xFE, 0x30, 0x1F,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x04, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x60, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x60, 0x3F, 0xC0, 0x7E, 0x01, 0xFF, 0xF0, 0x1F, 0xF0,
  0x3C, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x1C, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0x8E, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE7, 0x00, 0x00, 0x1F, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xFD, 0xC0, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x70, 0x30, 0x00, 0x00, 0xFC, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x06, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x03, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xC0, 0x06, 0x0F, 0x00,
  0x7E, 0x00, 0x38, 0x06, 0x07, 0x80, 0x7F, 0x00, 0x07, 0xFC, 0x07, 0xC0,
  0x3F, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x20, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x70, 0x1F, 0xF0, 0x00, 0x1F,
  0xFE, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x80, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x0F,
  0xF8, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0xE0,
  0x00, 0x03, 0xF8, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0xFC,
  0x01, 0x80, 0x00, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x00,
  0x01, 0xF8, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x03,
  0xE3, 0xFF, 0x80, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x00, 0xF3, 0xFF, 0xF8,
  0x00, 0x07, 0x31, 0xFF, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x03, 0x80,
  0x0F, 0xFC, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0x00, 0xFF, 0xE0,
  0x30, 0x00, 0x03, 0xFF, 0xE7, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xC7, 0xC0, 0x3E, 0x0F, 0x81,
  0xE0, 0x1F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x39, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x3F, 0x1F, 0x87,
  0xC1, 0xF0, 0x78, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x06, 0xFF, 0xE0, 0x06, 0x3F, 0xFC, 0x07, 0x07, 0xFC,
  0x07, 0x00, 0xFC, 0x07, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xC0, 0x1F,
  0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xE0, 0xFE, 0x47, 0xFD, 0xFF, 0xE3, 0xFF, 0xBF, 0xE0,
  0xFF, 0x8F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0x01, 0xF0, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x30, 0x78,
  0x00, 0x0C, 0x78, 0x00, 0x02, 0x7C, 0x00, 0x01, 0xBE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0xFC, 0x0E, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xE0, 0xFF,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E,
  0x00, 0xF0, 0x3F, 0x00, 0x78, 0x1F, 0x80, 0x78, 0x0F, 0xC0, 0x38, 0x0F,
  0xF0, 0x18, 0x07, 0xFC, 0x18, 0x0F, 0xFF, 0x98, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x07, 0xFC, 0x01, 0x9F, 0x80, 0x61, 0xF8, 0x1C, 0x3F, 0x07, 0x83, 0xF1,
  0xE0, 0x7E, 0x3C, 0x0F, 0xA7, 0x80, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x04, 0x3F, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x31, 0xFF, 0x00, 0xF0, 0x3F, 0xC1, 0xF8, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01,
  0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x78, 0x3F, 0x00, 0x3C, 0x1F, 0x80,
  0x1E, 0x0F, 0xC0, 0x0E, 0x07, 0xE0, 0x07, 0x07, 0xF8, 0x07, 0x07, 0xFF,
  0x03, 0x03, 0xFF, 0xE3, 0x80, 0x3F, 0xFD, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x33, 0xF0,
  0x1C, 0x7F, 0x03, 0x87, 0xE0, 0xF0, 0xFE, 0x3C, 0x0F, 0xC7, 0x81, 0xF8,
  0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0E, 0x1F, 0x0E, 0x03,
  0xEF, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x08, 0x0F, 0xFD, 0x81,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0x87, 0xC0, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x19, 0xFF, 0xC0,
  0x0C, 0x3F, 0xFC, 0x07, 0x07, 0xFE, 0x03, 0x80, 0x7F, 0x01, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x38, 0x1F, 0x00, 0x1E, 0x07, 0xC0,
  0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xDD, 0xFC, 0x0F, 0xFC, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x78, 0x03, 0xF0, 0x08, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1C, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x0F,
  0x80, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x20, 0x3E, 0x00, 0x08, 0x3C, 0x00,
  0x06, 0x3E, 0x00, 0x01, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x08, 0x00, 0xFC, 0x0C, 0x00, 0x7E, 0x0E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0xBF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xE1, 0xFE, 0x03, 0xF0, 0x7F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xFC,
  0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF8, 0x07, 0xC1, 0xFC, 0x43, 0xC1, 0xFF, 0xC3, 0xE1, 0xFF,
  0xC1, 0xE0, 0x1F, 0xC0, 0xE0, 0x07, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F,
  0xF1, 0x7F, 0x88, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE4,
  0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x04, 0x00, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x06, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xE8, 0x01, 0xE6, 0x01, 0xF1, 0x80, 0xF0, 0x40,
  0xE0, 0x33, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x1E,
  0x18, 0x1C, 0x06, 0x1E, 0x01, 0x1F, 0x0C, 0x5F, 0x1E, 0x3F, 0x9F, 0x1F,
  0xCF, 0x87, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xFF, 0x7F, 0xFF, 0xC7, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x41, 0xFF,
  0x31, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x1C, 0x18, 0x3C, 0x06, 0x3E,
  0x01, 0x1E, 0x00, 0x5F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x41, 0xFF, 0x71, 0xFF, 0xE0, 0x7F,
  0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x00, 0x38, 0x03, 0xC0, 0x38, 0x00, 0xFC, 0x0F, 0xC0, 0xF8,
  0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFF, 0xCF, 0xFE, 0x1F, 0xFB,
  0x7F, 0xB7, 0xFF, 0x27, 0xF8, 0x7F, 0xC7, 0xFC, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0xC3, 0xFE, 0x0F, 0xE4, 0xFF, 0xCF, 0xFC, 0x1F, 0xF0, 0xFF, 0x07,
  0xF0, 0x3F, 0xE0, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0xF0, 0x0F, 0x00, 0x3E,
  0x00, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0x80, 0x08, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x1F, 0x00, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xF8, 0x7F, 0xF9, 0xFF, 0xC4, 0xFF,
  0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x01, 0xFF, 0x03, 0xF1, 0x1F, 0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xFE,
  0x07, 0xC0, 0x1F, 0xC0, 0x3C, 0x01, 0xF8, 0x03, 0x80, 0x07, 0x80, 0x10,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xC0, 0x0F, 0xDF, 0xC0, 0x3F, 0x1F, 0xE0, 0x3F, 0x0F, 0xF0, 0x3F,
  0x0F, 0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0x03, 0xFC, 0x3F, 0x01, 0xFC, 0x3F,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x78, 0x3F,
  0xC0, 0x70, 0xFF, 0xE0, 0xE0, 0x7F, 0xF9, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xC1, 0xF8, 0x1F, 0xF0, 0xFE, 0x03, 0xFC,
  0xFF, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xF0, 0x1F, 0xC0,
  0x7E, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x07,
  0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81,
  0xF8, 0x03, 0xC0, 0x7E, 0x00, 0xF0, 0xFF, 0x80, 0x78, 0x7F, 0xF0, 0x1E,
  0x1F, 0xFE, 0x07, 0x0F, 0xFF, 0xE3, 0x03, 0x3F, 0xFE, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03,
  0xC2, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x4F, 0xFC, 0x03, 0x8F,
  0xFF, 0x0E, 0x07, 0xFC, 0x3C, 0x07, 0xF0, 0xF0, 0x07, 0xE1, 0xE0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F,
  0x81, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0xD7, 0xE0, 0xFF, 0xCF, 0xC0, 0xFF,
  0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xE0, 0x7E, 0x00, 0x80, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0xE0, 0x18, 0x1F,
  0x03, 0x83, 0xF8, 0x7C, 0x3F, 0xC7, 0xC7, 0xFC, 0xFE, 0x5F, 0xFF, 0xE8,
  0xFF, 0x7F, 0x0F, 0xE3, 0xE0, 0x7C, 0x3C, 0x07, 0xC1, 0x80, 0x7C, 0x10,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE1, 0x00, 0xFF, 0xA0, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x08, 0x01, 0x00, 0x38,
  0x03, 0x00, 0xFC, 0x06, 0x07, 0xFC, 0x18, 0x1F, 0xFF, 0xF0, 0x67, 0xFF,
  0xE1, 0x83, 0xFF, 0x86, 0x01, 0xFC, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x40,
  0x78, 0x01, 0x00, 0xF8, 0x07, 0x01, 0xF8, 0x1F, 0x03, 0xF8, 0x7F, 0x07,
  0xF9, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xC1, 0xFC, 0x0F,
  0x01, 0xFC, 0x0C, 0x01, 0xF8, 0x10, 0x01, 0xE0, 0x60, 0x03, 0xC1, 0xE0,
  0x03, 0x07, 0xF8, 0x0C, 0x1F, 0xFC, 0x10, 0x7F, 0xFE, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC1, 0x0F, 0xF2, 0x3F, 0xFC,
  0x1F, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x60, 0x08, 0x00,
  0x08, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0x00, 0x1C, 0x01, 0xF8, 0x03, 0xE0,
  0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x0F, 0xF8, 0x5F, 0xC0, 0xFF, 0xC8, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0x0F, 0xFB, 0x3F, 0xFF, 0x3F, 0xE0, 0x7F, 0xE3, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x70, 0x07, 0x80, 0x02,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x03, 0x80, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x80,
  0xFF, 0x03, 0xF8, 0x3F, 0xF0, 0x7F, 0x9F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0,
  0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xC0, 0x0F, 0x80, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x7C, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xFC, 0x0E,
  0x00, 0x7F, 0xE3, 0x80, 0x0F, 0xFE, 0x60, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0x00, 0x04, 0x0F, 0xF0, 0x0F, 0x00, 0x70, 0x3F, 0xE0,
  0x7E, 0x03, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xF9, 0xFF,
  0x83, 0xFC, 0xDF, 0xF8, 0xFF, 0x07, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0xFC, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x7E, 0x00, 0xF0,
  0x3F, 0x01, 0xF8, 0x03, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x03, 0xF0, 0x1F,
  0xC0, 0x70, 0x0F, 0xE0, 0xFF, 0xC3, 0x80, 0x7F, 0x87, 0xFF, 0xD8, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x02, 0x01, 0xE0, 0x38, 0x1F, 0xC1, 0xC0, 0xFE, 0x1F, 0x0F, 0xF9,
  0xF8, 0x7F, 0xDF, 0xE4, 0x7F, 0xBF, 0x03, 0xF9, 0xF8, 0x1F, 0x87, 0x80,
  0xFC, 0x38, 0x07, 0xE0, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x40, 0x1F, 0xE4, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xC3, 0xE0, 0x0C, 0x07, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x0F, 0x03, 0x00, 0xFC, 0x0F, 0x0F, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x08,
  0x07, 0xF0, 0x06, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xC3, 0xF8, 0x0F, 0xF1,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x01,
  0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFE, 0x21, 0xE0, 0x7F, 0xF0,
  0x78, 0x3F, 0xF8, 0x1C, 0x01, 0xFC, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x00, 0x40, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x02, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x20, 0x30, 0x18, 0x3E, 0x18, 0x1F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xBF,
  0xC0, 0x47, 0xF8, 0x30, 0xFE, 0x18, 0x3F, 0x86, 0x07, 0xE3, 0x01, 0xF8,
  0xC0, 0x3E, 0x70, 0x0F, 0xDC, 0x03, 0xF6, 0x00, 0xF9, 0x80, 0x3E, 0x60,
  0x0F, 0x98, 0x03, 0xE6, 0x00, 0xF1, 0x80, 0x3C, 0x70, 0x0E, 0x0C, 0x03,
  0x83, 0x01, 0xC0, 0x60, 0x60, 0x0C, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 12, 44, 14, 1, -43 },
  { 67, 21, 17, 24, 1, -43 },
  { 112, 27, 34, 31, 2, -38 },
  { 227, 21, 49, 25, 2, -46 },
  { 356, 39, 42, 43, 2, -43 },
  { 561, 31, 38, 34, 2, -37 },
  { 709, 10, 17, 12, 1, -43 },
  { 731, 13, 49, 15, 1, -47 },
  { 811, 13, 49, 15, 1, -47 },
  { 891, 20, 24, 21, 0, -45 },
  { 951, 20, 21, 24, 2, -30 },
  { 1004, 10, 16, 11, 0, -9 },
  { 1024, 16, 12, 18, 2, -24 },
  { 1048, 10, 10, 12, 1, -9 },
  { 1061, 28, 48, 31, 2, -45 },
  { 1229, 26, 43, 28, 1, -42 },
  { 1369, 18, 41, 19, 1, -41 },
  { 1462, 25, 41, 27, 1, -41 },
  { 1591, 26, 41, 28, 1, -41 },
  { 1725, 26, 41, 27, 1, -41 },
  { 1859, 26, 42, 28, 1, -42 },
  { 1996, 25, 42, 27, 1, -42 },
  { 2128, 24, 41, 26, 1, -41 },
  { 2251, 26, 42, 28, 1, -42 },
  { 2388, 25, 43, 27, 1, -43 },
  { 2523, 10, 30, 12, 1, -29 },
  { 2561, 11, 36, 10, 0, -29 },
  { 2611, 17, 22, 17, 0, -28 },
  { 2658, 21, 12, 23, 1, -24 },
  { 2690, 17, 22, 17, 0, -28 },
  { 2737, 23, 44, 27, 2, -43 },
  { 2864, 35, 36, 36, 1, -28 },
  { 3022, 47, 44, 49, 1, -43 },
  { 3281, 52, 45, 54, 0, -44 },
  { 3574, 39, 45, 41, 1, -44 },
  { 3794, 46, 46, 49, 1, -44 },
  { 4059, 39, 45, 42, 2, -44 },
  { 4279, 43, 51, 45, 1, -44 },
  { 4554, 43, 45, 46, 2, -43 },
  { 4796, 42, 54, 44, 1, -46 },
  { 5080, 39, 52, 41, 1, -44 },
  { 5334, 40, 59, 43, 1, -44 },
  { 5629, 46, 44, 49, 1, -43 },
  { 5882, 32, 43, 34, 1, -42 },
  { 6054, 64, 45, 66, 1, -42 },
  { 6414, 50, 43, 53, 2, -42 },
  { 6683, 43, 44, 45, 1, -43 },
  { 6920, 51, 52, 54, 1, -42 },
  { 7252, 46, 47, 48, 1, -43 },
  { 7523, 54, 44, 56, 1, -43 },
  { 7820, 43, 44, 46, 1, -43 },
  { 8057, 43, 44, 45, 1, -43 },
  { 8294, 40, 46, 43, 1, -42 },
  { 8524, 51, 45, 53, 1, -44 },
  { 8811, 62, 44, 65, 1, -43 },
  { 9152, 41, 45, 43, 1, -44 },
  { 9383, 49, 53, 51, 1, -44 },
  { 9708, 37, 52, 40, 1, -44 },
  { 9949, 8, 47, 11, 1, -44 },
  { 9996, 36, 42, 6, -11, -39 },
  { 10185, 8, 47, 11, 1, -44 },
  { 10232, 22, 16, 25, 1, -42 },
  { 10276, 29, 4, 27, -1, 7 },
  { 10291, 9, 11, 30, 10, -42 },
  { 10304, 25, 33, 28, 1, -31 },
  { 10408, 25, 43, 27, 1, -41 },
  { 10543, 19, 31, 21, 1, -30 },
  { 10617, 25, 43, 27, 1, -42 },
  { 10752, 19, 32, 22, 1, -31 },
  { 10828, 19, 54, 15, -1, -44 },
  { 10957, 26, 44, 28, 1, -31 },
  { 11100, 25, 52, 27, 1, -42 },
  { 11263, 14, 43, 16, 1, -42 },
  { 11339, 17, 54, 15, -3, -43 },
  { 11454, 17, 43, 19, 1, -42 },
  { 11546, 17, 43, 16, 1, -42 },
  { 11638, 39, 32, 43, 2, -31 },
  { 11794, 28, 32, 30, 1, -31 },
  { 11906, 24, 32, 25, 0, -31 },
  { 12002, 26, 48, 27, 0, -36 },
  { 12158, 23, 43, 26, 1, -31 },
  { 12282, 20, 32, 22, 1, -31 },
  { 12362, 23, 38, 25, 1, -37 },
  { 12472, 16, 39, 19, 1, -38 },
  { 12550, 28, 32, 30, 1, -31 },
  { 12662, 27, 35, 27, -1, -34 },
  { 12781, 38, 37, 41, 2, -35 },
  { 12957, 21, 44, 24, 1, -32 },
  { 13073, 26, 46, 28, 1, -36 },
  { 13223, 18, 42, 20, 1, -31 },
  { 13318, 16, 48, 20, 1, -47 },
  { 13414, 3, 50, 10, 3, -47 },
  { 13433, 16, 48, 20, 1, -47 },
  { 13529, 20, 4, 22, 1, -20 },
};

const GFXfont UnifrakturMaguntia_Regular60pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular60pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular60pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR60PT7B_H_
