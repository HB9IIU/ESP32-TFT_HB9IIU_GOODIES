#ifndef _UNIFRAKTURMAGUNTIA_REGULAR45PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x08, 0x1C, 0x3E, 0x7F, 0xFF, 0x7E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x18, 0x3C, 0x7E, 0x3F, 0x1C, 0x08, 0x00, 0x10,
  0x08, 0x18, 0x18, 0x3C, 0x3C, 0x7E, 0x7F, 0xBE, 0x3F, 0x1E, 0x1E, 0x0E,
  0x0E, 0x0C, 0x0E, 0x0C, 0x0C, 0x08, 0x0C, 0x18, 0x08, 0x10, 0x10, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x38,
  0x01, 0xE1, 0xC0, 0x0E, 0x1E, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80,
  0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x78, 0x01,
  0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0x0C, 0x38, 0x0C, 0x70,
  0x1C, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xFF, 0x81, 0xDF, 0x81, 0x9F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xDC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7B, 0x00,
  0xE6, 0x01, 0xC7, 0x0F, 0x07, 0xFC, 0x01, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x63,
  0x8E, 0x00, 0x03, 0x1E, 0x3C, 0x00, 0x18, 0x78, 0xF0, 0x00, 0xE1, 0xE3,
  0xC0, 0x03, 0x0F, 0x8F, 0x80, 0x18, 0x3E, 0x3E, 0x00, 0xC0, 0xF8, 0xF8,
  0x06, 0x03, 0xE3, 0xE0, 0x30, 0x0F, 0x8F, 0x81, 0x80, 0x1E, 0x3C, 0x0E,
  0x00, 0x78, 0xF0, 0x30, 0x01, 0xE3, 0xC1, 0x80, 0x03, 0x8E, 0x0C, 0x00,
  0x07, 0xF0, 0x61, 0xF0, 0x0F, 0x83, 0x0F, 0xE0, 0x00, 0x18, 0x71, 0xC0,
  0x00, 0xC3, 0xC7, 0x80, 0x07, 0x0F, 0x1E, 0x00, 0x18, 0x3C, 0x78, 0x00,
  0xC1, 0xF1, 0xF0, 0x06, 0x07, 0xC7, 0xC0, 0x30, 0x1F, 0x1F, 0x01, 0x80,
  0x7C, 0x7C, 0x0C, 0x01, 0xF1, 0xF0, 0x70, 0x03, 0xC7, 0x81, 0x80, 0x0F,
  0x1E, 0x0C, 0x00, 0x3C, 0x78, 0x60, 0x00, 0x71, 0xC3, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC3,
  0x00, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x07, 0xC3, 0x80, 0x07, 0xC7,
  0x00, 0x07, 0xC7, 0x00, 0x07, 0xCE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x0F, 0xF0, 0x38, 0x1D, 0xF8,
  0x18, 0x38, 0xF8, 0x10, 0x38, 0xFC, 0x10, 0x78, 0x7C, 0x30, 0x78, 0x7E,
  0x20, 0x78, 0x3E, 0x20, 0xF8, 0x3F, 0x60, 0xF8, 0x1F, 0xC0, 0x7C, 0x1F,
  0x80, 0x7C, 0x0F, 0xC2, 0x7E, 0x07, 0xE3, 0x3F, 0x0F, 0xFE, 0x1F, 0xFB,
  0xFC, 0x07, 0xE0, 0xF0, 0x10, 0x61, 0xE7, 0xF7, 0xE7, 0xC7, 0x06, 0x08,
  0x30, 0x41, 0x80, 0x03, 0x81, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0E,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0C, 0x06, 0x03, 0x03, 0x80, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0xBF, 0x8F, 0x39, 0xEF, 0x27, 0x9F, 0x5F, 0x3F, 0xFE,
  0x03, 0x80, 0xFF, 0xF9, 0xF5, 0xF3, 0xC9, 0xEF, 0xBB, 0xE2, 0x7A, 0x01,
  0xF8, 0x01, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x10,
  0x30, 0xF3, 0xFF, 0xE3, 0xC3, 0x86, 0x0C, 0x10, 0x20, 0x80, 0x00, 0x38,
  0xFF, 0x87, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x71, 0xFF, 0x0F, 0xF8, 0xFE,
  0x00, 0x10, 0x61, 0xE7, 0xF7, 0xC7, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0x80, 0x3C, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x7C,
  0x0F, 0x0F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xC7, 0x80,
  0xF8, 0xF8, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x3C, 0x01, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0,
  0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC3, 0xFF, 0xC0, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xE0, 0xFE, 0x70, 0x1F, 0x98, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x10,
  0x70, 0x04, 0x30, 0x01, 0x08, 0x00, 0x47, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xE0,
  0xFE, 0x10, 0x0F, 0xC4, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0E, 0x3C, 0x03,
  0x87, 0xC0, 0x60, 0x78, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x09, 0xE0, 0x01, 0x9E, 0x00, 0x11, 0xE0, 0x02, 0x1E, 0x00,
  0x61, 0xE0, 0x04, 0x1E, 0x00, 0xC1, 0xE0, 0x18, 0x1E, 0x01, 0x01, 0xE0,
  0x30, 0x1E, 0x06, 0x01, 0xE0, 0x40, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xE0, 0x18, 0x01, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x23, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xCF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xE0, 0xFE, 0x30, 0x07, 0xEC, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x01, 0xDF, 0x00, 0x7B, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0xC0, 0x60, 0x7C,
  0x18, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x63, 0xC0, 0x18, 0x3C, 0x07,
  0x07, 0xC1, 0xE0, 0xFC, 0x38, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x1C, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x1C, 0x0F, 0xCF, 0xE1, 0xFB,
  0xFE, 0x3F, 0x47, 0xE7, 0xF8, 0x7E, 0xFE, 0x07, 0xDF, 0xC0, 0xFB, 0xF0,
  0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xDF, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xE0, 0x01, 0xB0, 0x00, 0xC8, 0x00, 0x32,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0xF3, 0x80, 0x70, 0x1C, 0x1C,
  0x01, 0xC3, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x73, 0xC0, 0x0E, 0x78,
  0x01, 0x8F, 0x80, 0x71, 0xFC, 0x0E, 0x3F, 0xC3, 0x83, 0xFE, 0xC0, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0x1F, 0xF0, 0xE0,
  0xFF, 0x38, 0x07, 0xEF, 0x00, 0x7D, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x01, 0xE7, 0x00,
  0x38, 0x70, 0x0E, 0x07, 0x03, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xC7,
  0x80, 0x30, 0x78, 0x0E, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1F, 0x1E, 0x03,
  0xE3, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0x7C, 0x17,
  0xCF, 0xC6, 0xF8, 0xFF, 0x9F, 0x0F, 0xE3, 0xE0, 0x78, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xF0, 0x3C,
  0x3E, 0x07, 0x07, 0xC0, 0xC0, 0x78, 0x38, 0x07, 0x8E, 0x00, 0x3F, 0x00,
  0x10, 0x71, 0xF7, 0xF7, 0x86, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x18, 0x79, 0xFD, 0xF1, 0xC1, 0x00, 0x00, 0x08, 0x1C, 0x3E, 0x7F,
  0x3C, 0x18, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x18,
  0x3C, 0x7E, 0xFE, 0x1E, 0x0E, 0x0C, 0x0C, 0x08, 0x08, 0x10, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0x07,
  0x83, 0x00, 0xF1, 0xC0, 0x3E, 0x60, 0x07, 0xBC, 0x01, 0xEF, 0xC0, 0x79,
  0xF0, 0x1E, 0x7C, 0x0F, 0x84, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x20, 0x70, 0x08, 0x0E, 0x04, 0x01, 0xC3, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x70,
  0x1E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0xFF, 0x31, 0xE0, 0xFF,
  0xCC, 0x70, 0x79, 0xE3, 0xBC, 0x3C, 0x78, 0xEE, 0x1E, 0x1E, 0x3B, 0x87,
  0x87, 0x0E, 0xE3, 0xC3, 0xC3, 0x38, 0xF0, 0xF0, 0xCE, 0x7C, 0x38, 0x73,
  0x9E, 0x1E, 0x38, 0xE7, 0x8F, 0x8E, 0x39, 0xE7, 0xE7, 0x0E, 0x3F, 0xFF,
  0x9D, 0xC7, 0x8F, 0x86, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0x00, 0x60,
  0x3F, 0xFF, 0x00, 0x38, 0x0E, 0x3F, 0xF0, 0x3F, 0x03, 0x00, 0xFF, 0x1F,
  0xE0, 0xC0, 0x0F, 0xE3, 0xF8, 0x10, 0x00, 0xFE, 0x3F, 0x06, 0x00, 0x1F,
  0xC3, 0xE0, 0xC0, 0x01, 0xF8, 0x7C, 0x18, 0x00, 0x3F, 0x0F, 0x83, 0x00,
  0x03, 0xE1, 0xF0, 0x70, 0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0xFE, 0x01, 0xE0, 0xF8, 0x1F, 0xE0, 0x3C, 0x1F, 0x01, 0xFE, 0x0F, 0x83,
  0xE0, 0x0F, 0xC1, 0xE0, 0x7C, 0x00, 0x78, 0x38, 0x0F, 0x80, 0x03, 0x0E,
  0x01, 0xF0, 0x00, 0x41, 0x80, 0x3E, 0x00, 0x18, 0x60, 0x07, 0xC0, 0x00,
  0x18, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x0F, 0xFE, 0x03,
  0xF8, 0x03, 0x7F, 0xE1, 0xBF, 0x30, 0x03, 0xFF, 0xE7, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x18, 0xFE, 0x01,
  0xFF, 0xFF, 0x20, 0xFC, 0x07, 0xC0, 0xFF, 0x40, 0xFC, 0x0E, 0x00, 0xFF,
  0x01, 0xF8, 0x38, 0x00, 0xFE, 0x03, 0xF0, 0x60, 0x00, 0xFC, 0x03, 0xF0,
  0xC0, 0x00, 0xF8, 0x07, 0xF1, 0x80, 0x01, 0xF0, 0x0F, 0xF3, 0x00, 0x03,
  0xE0, 0x0F, 0x86, 0x00, 0x03, 0xC0, 0x18, 0x0C, 0x00, 0x07, 0x80, 0xE0,
  0x18, 0x00, 0x0F, 0x07, 0xF8, 0x18, 0x00, 0x1E, 0x3F, 0xF8, 0x38, 0x04,
  0x39, 0xFF, 0xF8, 0x1E, 0x30, 0xE0, 0x1F, 0xF8, 0x07, 0x01, 0x80, 0x0F,
  0xF0, 0x00, 0x06, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x07,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0x00, 0x00, 0x7F, 0xE0, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0xE0, 0xC7,
  0xE0, 0x0E, 0x02, 0x7F, 0xF0, 0xF0, 0x0F, 0xFF, 0x0F, 0x00, 0xC7, 0xE0,
  0x78, 0x1C, 0x06, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xFE, 0x00, 0x07, 0xC7, 0xF8,
  0x00, 0x3E, 0x1F, 0xE0, 0x01, 0xF0, 0xFF, 0x80, 0x0F, 0x83, 0xFE, 0x00,
  0x7C, 0x0F, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xFC,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x00,
  0xF8, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x38, 0x00, 0xFF, 0x03, 0x00,
  0x03, 0xFC, 0x30, 0x00, 0x0F, 0xF2, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x01,
  0xFF, 0xC0, 0x1C, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0xC1,
  0xF0, 0x0E, 0x0F, 0xF8, 0x78, 0x06, 0x00, 0xFE, 0x1C, 0x03, 0x80, 0x1F,
  0xCE, 0x01, 0xE0, 0x03, 0xF3, 0x00, 0x7C, 0x00, 0x7E, 0xC0, 0x3F, 0x80,
  0x0F, 0xB0, 0x0F, 0xF0, 0x01, 0xEC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x0F, 0x40, 0x0F, 0xF0, 0x03, 0xD0, 0x01, 0xFE, 0x00, 0x76, 0x00,
  0x3F, 0x80, 0x1C, 0xC0, 0x07, 0xE0, 0x07, 0x1C, 0x10, 0xF8, 0x01, 0xC0,
  0xF8, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0x40, 0x00, 0xC0, 0x1F, 0xF0, 0x00,
  0x20, 0x0F, 0xFF, 0x00, 0x18, 0x07, 0xFF, 0xE0, 0x0C, 0x07, 0x3F, 0xFF,
  0x06, 0x01, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x38, 0x11, 0xFC, 0x01, 0xC0,
  0x4F, 0xFE, 0x0F, 0x00, 0xFF, 0xF0, 0x78, 0x06, 0x3F, 0x01, 0xE0, 0x60,
  0x18, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0xC0, 0x80, 0x7C, 0x7F, 0x87, 0xC1,
  0xF0, 0xFF, 0x3F, 0xB7, 0xC3, 0xFF, 0xFF, 0x9F, 0x07, 0xFF, 0xFC, 0x7C,
  0x0F, 0xF9, 0xF1, 0xF0, 0x1F, 0xF1, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x80,
  0x7F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0xC0, 0x38, 0x00, 0x7F, 0x81, 0x80,
  0x00, 0xFF, 0x0C, 0x00, 0x01, 0xFE, 0x40, 0x00, 0x03, 0xFE, 0x00, 0x08,
  0x0F, 0xFE, 0x00, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFE, 0x3C,
  0x00, 0x3F, 0xFC, 0x78, 0x00, 0x4F, 0xF0, 0x70, 0x00, 0xC3, 0xE0, 0x60,
  0x01, 0xC0, 0x80, 0xE0, 0x03, 0xC0, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0xC0,
  0x03, 0xF0, 0x18, 0xC0, 0x03, 0xF8, 0x3C, 0x40, 0x03, 0xF8, 0x7E, 0x40,
  0x03, 0xFC, 0xFF, 0x60, 0x01, 0xFE, 0xFE, 0x30, 0x00, 0xFF, 0xBC, 0x18,
  0x00, 0xFF, 0x1C, 0x0C, 0x04, 0x7F, 0x90, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x03,
  0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0x80, 0x00,
  0xF0, 0x43, 0xC0, 0x00, 0xE0, 0x13, 0xF0, 0x00, 0xF0, 0x0F, 0xFC, 0x00,
  0xF0, 0x04, 0x7F, 0x00, 0xF0, 0x0C, 0x1F, 0xE0, 0x78, 0x0C, 0x07, 0xF8,
  0x7C, 0x1C, 0x01, 0xF8, 0x3C, 0x1E, 0x00, 0x78, 0x3E, 0x1F, 0x00, 0x30,
  0x1F, 0x0F, 0x80, 0x30, 0x0F, 0x87, 0xE0, 0x7C, 0x07, 0xC3, 0xF0, 0x7F,
  0x87, 0xE1, 0xFC, 0xFF, 0xE3, 0xF0, 0x7F, 0x5F, 0xF1, 0xF8, 0x1F, 0xC1,
  0xFC, 0xFC, 0x0F, 0xF0, 0x7E, 0x7E, 0x03, 0xF8, 0x1F, 0xBF, 0x80, 0xFE,
  0x0F, 0xCF, 0xC0, 0x3F, 0x03, 0xE7, 0xE0, 0x1F, 0x81, 0xF3, 0xF0, 0x07,
  0xC0, 0xF9, 0xFC, 0x03, 0xE0, 0x7C, 0x7E, 0x00, 0xE0, 0x3E, 0x3F, 0x80,
  0xE0, 0x1E, 0x0F, 0xC0, 0xE0, 0x0F, 0x03, 0xF0, 0x60, 0x0F, 0x00, 0xFC,
  0x40, 0x07, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x03,
  0xF8, 0x07, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x18, 0xFF, 0x40, 0x00, 0x60, 0xFF, 0x80, 0x01, 0x80, 0xFC, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x30, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x3F, 0xF0, 0x07, 0xF0, 0xFF, 0xF0, 0x07, 0xF7, 0x1F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x40, 0x3C, 0x01,
  0xF3, 0xE0, 0x38, 0x03, 0xCF, 0xE0, 0x60, 0x0F, 0xBF, 0xE0, 0x80, 0x1F,
  0x4F, 0xF2, 0x00, 0x3C, 0x0F, 0xF8, 0x00, 0x70, 0x0F, 0xE0, 0x01, 0xE0,
  0x0F, 0x80, 0x03, 0x80, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF0, 0x7F, 0xE0, 0x0E, 0x00, 0xFF,
  0x88, 0xE0, 0x03, 0xFF, 0x87, 0x00, 0x07, 0xF8, 0x30, 0x00, 0x0F, 0x81,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF8, 0x03, 0x00, 0x0F,
  0xC0, 0x0C, 0x00, 0x7E, 0x00, 0x38, 0x09, 0xF8, 0x00, 0xFF, 0x8F, 0xE0,
  0x00, 0x60, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1F,
  0x0F, 0xE0, 0x00, 0x79, 0xFF, 0xC0, 0x03, 0x9F, 0xFF, 0x00, 0x1C, 0x07,
  0xFC, 0x01, 0xC0, 0x1F, 0xF0, 0x0C, 0x00, 0x7F, 0xC0, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0x07, 0xFE, 0x00, 0x70, 0x07, 0xFC, 0x43, 0x80, 0x0F, 0xFE, 0x0C,
  0x00, 0x1F, 0xF0, 0x30, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x07, 0x80, 0x30, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0xF8, 0x03, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3F,
  0x00, 0x18, 0x04, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x18, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x07, 0x0F, 0xF8, 0x00, 0x18,
  0x7F, 0xF0, 0x00, 0xE3, 0x3F, 0xE0, 0x03, 0x00, 0x3F, 0xC0, 0x18, 0x00,
  0x7F, 0x80, 0x40, 0x00, 0xFF, 0x86, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x06, 0x00,
  0x07, 0x80, 0x00, 0x60, 0x01, 0xE0, 0xFC, 0x06, 0x00, 0x38, 0x3F, 0xE0,
  0xE0, 0x0F, 0x1F, 0xFE, 0x0C, 0x03, 0xE3, 0x9F, 0xE1, 0xC0, 0x7C, 0xC0,
  0xFC, 0x38, 0x0F, 0x90, 0x1F, 0xC3, 0x01, 0xF2, 0x01, 0xF8, 0x60, 0x3F,
  0x40, 0x3F, 0x8C, 0x07, 0xE8, 0x03, 0xF9, 0x80, 0xFF, 0x00, 0x7E, 0x70,
  0x0F, 0xE0, 0x03, 0x0C, 0x01, 0xFE, 0x00, 0xC1, 0x00, 0x1F, 0xC0, 0x70,
  0x40, 0x03, 0xFC, 0x3F, 0x30, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x07, 0x81, 0xF8, 0x03, 0xC0, 0xF0, 0x3F, 0x00,
  0xFC, 0x0C, 0x03, 0xF0, 0x3F, 0xC1, 0x80, 0x7E, 0x0B, 0xFC, 0x60, 0x0F,
  0xF4, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xF0, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF3,
  0xE0, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3F, 0x00,
  0x1E, 0x3F, 0x00, 0x1E, 0x3F, 0x80, 0x1E, 0x3F, 0xC0, 0x1E, 0x1F, 0xC0,
  0x3C, 0x1F, 0xC8, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xDF, 0xFC, 0x02, 0x03, 0xFF, 0x9C, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xDF, 0xFE, 0x47, 0xE0, 0x3F, 0xFF,
  0xF8, 0xFE, 0x83, 0xF0, 0x38, 0x1F, 0xF0, 0x7F, 0x83, 0xF0, 0x60, 0x0F,
  0xF0, 0x3F, 0x01, 0xF8, 0x40, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0xC0, 0x01,
  0xF8, 0x1F, 0x81, 0xF8, 0x80, 0x01, 0xFC, 0x0F, 0x81, 0xFC, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0xFE, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x70, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x60, 0x60, 0x00,
  0x3C, 0x07, 0xC0, 0xC0, 0x7F, 0xF0, 0x3C, 0x07, 0xC1, 0x80, 0x3F, 0xF0,
  0x3C, 0x07, 0x83, 0x80, 0x1F, 0xF8, 0x3C, 0x07, 0x87, 0x00, 0x07, 0x18,
  0x3C, 0x07, 0x87, 0x00, 0x00, 0x18, 0x3C, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x38, 0x07, 0x1F, 0x00, 0x00, 0x00,
  0x30, 0x07, 0x1F, 0x80, 0x00, 0x00, 0x30, 0x06, 0x1F, 0x80, 0x00, 0x00,
  0x60, 0x06, 0x1F, 0x80, 0x03, 0xC0, 0x60, 0x04, 0x0F, 0xC0, 0x0F, 0xE0,
  0x4F, 0x0C, 0x0F, 0xC0, 0x1F, 0xF0, 0x9F, 0xC8, 0x0F, 0xF3, 0x37, 0xF9,
  0xBF, 0xF0, 0x07, 0xFE, 0x23, 0xFF, 0x7F, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x4F, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x87, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xF0,
  0x07, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xE6, 0x0F, 0xC1, 0xC0, 0x7F,
  0xD0, 0x3F, 0x06, 0x00, 0x7F, 0x80, 0x7C, 0x10, 0x00, 0xFE, 0x01, 0xF8,
  0xC0, 0x01, 0xF8, 0x07, 0xE2, 0x00, 0x07, 0xF0, 0x1F, 0x88, 0x00, 0x0F,
  0xC0, 0x3F, 0xA0, 0x00, 0x1F, 0x00, 0xFC, 0xC0, 0x00, 0x7C, 0x01, 0xC1,
  0x00, 0x01, 0xF0, 0x04, 0x06, 0x04, 0x03, 0xC0, 0x30, 0x1F, 0xFC, 0x0F,
  0x01, 0x80, 0x3F, 0xF0, 0x3C, 0x0C, 0x00, 0x7F, 0xE0, 0xF0, 0x70, 0x00,
  0x21, 0x83, 0xC1, 0xC0, 0x00, 0x06, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0x87, 0xE0, 0x00,
  0x00, 0x0C, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x0F, 0x01, 0x80,
  0xFC, 0x00, 0xFE, 0x04, 0x03, 0xF8, 0x07, 0xFC, 0x30, 0x0F, 0xFF, 0x37,
  0xF9, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xC3, 0xFF, 0xE0, 0x06,
  0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x07, 0xF8, 0x78,
  0x00, 0x03, 0xFC, 0x78, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3E, 0x7F, 0xC0, 0x00, 0x3E, 0x7F,
  0xF0, 0x00, 0x1E, 0x3F, 0xFC, 0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x0E, 0x07,
  0xFE, 0x00, 0x0E, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x07, 0x90, 0x00, 0x0C, 0x1F,
  0xC0, 0x00, 0x18, 0x3F, 0xF0, 0x00, 0x10, 0x7F, 0xF8, 0x00, 0x30, 0x8F,
  0xFE, 0x00, 0x60, 0x03, 0xFF, 0x80, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x07,
  0x80, 0x0F, 0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0xC7, 0xF8, 0x01, 0xC0,
  0x7F, 0xF7, 0xF0, 0x0E, 0x00, 0xFF, 0x1F, 0xE0, 0x30, 0x01, 0xFC, 0x3F,
  0xC0, 0x80, 0x03, 0xF0, 0xFF, 0x82, 0x00, 0x0F, 0xC1, 0xFF, 0x08, 0x00,
  0x1F, 0x03, 0xFE, 0x20, 0x00, 0x7C, 0x07, 0xFC, 0x80, 0x01, 0xF0, 0x0F,
  0xFB, 0x00, 0x07, 0xC0, 0x1F, 0xE6, 0x00, 0x1F, 0x00, 0x1F, 0x8C, 0x04,
  0x7C, 0x00, 0x3F, 0x1E, 0x39, 0xF0, 0x00, 0x7C, 0x0F, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x3F,
  0xE0, 0x00, 0x80, 0x01, 0xFF, 0xE0, 0x04, 0x00, 0x0F, 0xFF, 0xE0, 0x20,
  0x00, 0x73, 0xFF, 0xF7, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1D, 0xFE, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x60,
  0x07, 0xFF, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x38, 0x00, 0x07, 0xF8, 0x1E,
  0x00, 0x00, 0xFE, 0x07, 0x80, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x03,
  0xE1, 0xFF, 0xC0, 0x00, 0x78, 0x3F, 0xFC, 0x00, 0x1E, 0x07, 0xFF, 0x00,
  0x07, 0x80, 0x7F, 0xE0, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x1E,
  0x40, 0x0E, 0x20, 0x1F, 0xC0, 0x0F, 0xD8, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0x06, 0x3F, 0xF9, 0x0F, 0xE2, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE7, 0xE0, 0x00, 0x7F, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF,
  0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xF2, 0x0F, 0xE0, 0x3C, 0x1F, 0xF2, 0x07,
  0xE0, 0x70, 0x07, 0xFC, 0x07, 0xF0, 0x60, 0x01, 0xFC, 0x07, 0xF0, 0xE0,
  0x00, 0xFC, 0x03, 0xF0, 0xC0, 0x00, 0x7C, 0x03, 0xFC, 0xC0, 0x00, 0x7C,
  0x01, 0xFC, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0xC0, 0x00, 0x3E, 0x00, 0xC0,
  0xC0, 0x00, 0x3E, 0x01, 0x80, 0x40, 0x00, 0x1E, 0x06, 0x00, 0x60, 0x00,
  0x1E, 0x1C, 0x00, 0x30, 0x00, 0x1E, 0x3E, 0x00, 0x18, 0x0C, 0x1E, 0xFF,
  0x00, 0x0F, 0xF0, 0x1E, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0x1F, 0x80, 0x00,
  0x00, 0x1C, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x00, 0x00, 0x1C,
  0x0F, 0xC0, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0xE0,
  0x01, 0xE0, 0x30, 0x0F, 0xE0, 0x07, 0xF0, 0x20, 0x07, 0xE0, 0x0F, 0xF8,
  0x40, 0x07, 0xF0, 0x1F, 0xFC, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x06, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xC7, 0xFF, 0xF8,
  0x03, 0x00, 0xFF, 0xF0, 0x06, 0x00, 0x1F, 0xE0, 0x0C, 0x00, 0x07, 0x80,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x1F, 0xE0, 0x70, 0x00, 0x7F, 0xF8,
  0xF0, 0xC1, 0xFF, 0xFC, 0xF0, 0x6F, 0xFF, 0xDC, 0xF0, 0x3F, 0xFE, 0x06,
  0xF0, 0x1F, 0xF8, 0x02, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x01,
  0x78, 0x00, 0x00, 0x03, 0x7C, 0x00, 0x00, 0x03, 0x7E, 0x00, 0x00, 0x02,
  0x3F, 0x00, 0x00, 0x06, 0x3F, 0xC0, 0x00, 0x0E, 0x1F, 0xE0, 0x00, 0x3C,
  0x1F, 0xFC, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3C, 0x0F, 0xFF, 0x00, 0x30, 0x03, 0xFF, 0xC0,
  0x60, 0x00, 0xFF, 0xE3, 0x40, 0x00, 0x3F, 0xFE, 0xC0, 0x01, 0x8F, 0xFC,
  0xC0, 0x06, 0x07, 0xF0, 0x80, 0x0E, 0x01, 0xE0, 0xC0, 0x1F, 0x00, 0x00,
  0xC0, 0x1F, 0x00, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x60, 0x1F, 0xE0, 0x00,
  0x30, 0x1F, 0xF0, 0x00, 0x0E, 0x6F, 0xF8, 0x00, 0x01, 0x87, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0xF0, 0x38, 0x00,
  0x7F, 0xF8, 0x60, 0x00, 0x87, 0xFC, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x08, 0x00, 0x7F, 0xE0, 0x30,
  0x00, 0x1F, 0xFD, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x18, 0x1C, 0x10, 0x01, 0xC0, 0xF0, 0x20, 0x1E, 0x07,
  0x80, 0x81, 0xF0, 0x1E, 0x06, 0x1F, 0xC0, 0xF8, 0x30, 0x7F, 0x03, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00,
  0x3F, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xC0, 0x3F, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x30, 0x03, 0xF0, 0x01, 0x80, 0x0F, 0xC0, 0x0C, 0x00, 0x3F, 0x00, 0x70,
  0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC1, 0xFF, 0x80,
  0xFF, 0x0C, 0xFF, 0x86, 0x7C, 0x00, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x87,
  0xF8, 0x03, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xE0, 0x07, 0xFF,
  0xF1, 0x9F, 0xC0, 0x3F, 0xFF, 0xE4, 0x3F, 0x80, 0xF0, 0x7F, 0xE0, 0x7E,
  0x07, 0x00, 0x7F, 0x81, 0xFC, 0x38, 0x00, 0xFE, 0x03, 0xF0, 0xC0, 0x01,
  0xF8, 0x0F, 0xF3, 0x00, 0x03, 0xE0, 0x1F, 0x0C, 0x00, 0x0F, 0x80, 0x38,
  0x30, 0x00, 0x1E, 0x00, 0xC0, 0xC0, 0x00, 0x78, 0x06, 0x03, 0x00, 0x01,
  0xE0, 0x38, 0x04, 0x00, 0x07, 0x80, 0xE0, 0x18, 0x00, 0x1E, 0x07, 0xC0,
  0x30, 0x08, 0x70, 0x1F, 0x80, 0x3B, 0xC1, 0x80, 0x7F, 0x00, 0x38, 0x0E,
  0x01, 0xFE, 0x00, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x01, 0x80, 0x0F, 0xF0,
  0x00, 0x04, 0x00, 0x1F, 0xE0, 0x01, 0xA0, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xC0,
  0x7F, 0xFE, 0x00, 0x0E, 0x01, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x0F, 0xFC,
  0x00, 0x80, 0x00, 0x1F, 0xF8, 0x04, 0x00, 0x00, 0x3F, 0xFC, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x1E, 0x1F,
  0xF8, 0x00, 0xFF, 0xFC, 0xCC, 0x87, 0xF0, 0x07, 0xFF, 0xFE, 0x1C, 0x0F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x30, 0x1F, 0xC1, 0xE0, 0x1F, 0xC1, 0x80, 0x3F,
  0x07, 0x00, 0x3F, 0x86, 0x00, 0xFE, 0x38, 0x00, 0x7E, 0x38, 0x01, 0xF8,
  0xC0, 0x00, 0xF8, 0xF0, 0x07, 0xF3, 0x00, 0x03, 0xE7, 0xC0, 0x0F, 0xEC,
  0x00, 0x07, 0x9F, 0x80, 0x1C, 0x30, 0x00, 0x1E, 0x7E, 0x00, 0x60, 0xC0,
  0x00, 0x79, 0xFC, 0x03, 0x01, 0x00, 0x01, 0xE3, 0xF8, 0x1C, 0x06, 0x00,
  0x07, 0x8F, 0xE0, 0xF8, 0x0C, 0x02, 0x1C, 0x1F, 0xC3, 0xF0, 0x1C, 0x30,
  0x70, 0x7F, 0x0F, 0xE0, 0x1F, 0x03, 0x80, 0xFC, 0x3F, 0xC0, 0x00, 0x0C,
  0x01, 0xF0, 0xFF, 0x80, 0x00, 0x20, 0x07, 0xC1, 0xFF, 0x00, 0x01, 0x80,
  0x1F, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x3C, 0x07, 0xF0, 0x03, 0xE0, 0x00,
  0xE0, 0x07, 0xC0, 0x7F, 0x80, 0x03, 0x00, 0x1F, 0x03, 0xFF, 0x00, 0x0E,
  0x00, 0x38, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0xE0, 0x83, 0xFC, 0x03, 0xFC,
  0x03, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x08, 0x00, 0x0F, 0xF8, 0xFF, 0xF0,
  0x40, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x06, 0x00, 0xFF, 0xE0, 0x3E, 0x47,
  0xFF, 0xC1, 0xFF, 0x3F, 0xFF, 0x87, 0xF8, 0xFD, 0xFF, 0x3F, 0xE7, 0x80,
  0xFC, 0xCF, 0x1C, 0x01, 0xF2, 0x18, 0xE0, 0x03, 0xF0, 0x03, 0x00, 0x0F,
  0xC0, 0x0C, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x7C, 0x00, 0x40, 0x01, 0xE0,
  0x01, 0x80, 0x07, 0xC0, 0x02, 0x00, 0x3F, 0xFE, 0x06, 0x01, 0xFF, 0xF0,
  0x0F, 0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0B,
  0xF0, 0x00, 0x30, 0x4F, 0xC0, 0x03, 0xE1, 0x3F, 0xC0, 0x0F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x0B, 0xFC, 0x07, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFC,
  0x67, 0xF0, 0x3F, 0xFF, 0xEC, 0x3F, 0x87, 0xC1, 0xFF, 0x81, 0xF8, 0x70,
  0x07, 0xF8, 0x1F, 0xCE, 0x00, 0x3F, 0x80, 0xFC, 0xC0, 0x01, 0xF8, 0x0F,
  0xCC, 0x00, 0x0F, 0x80, 0xFE, 0xC0, 0x00, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0x80, 0x3E, 0xC0, 0x00, 0x78, 0x01, 0x8C, 0x00, 0x07, 0x80, 0x70, 0x40,
  0x00, 0x78, 0x0E, 0x02, 0x00, 0x07, 0x81, 0xE0, 0x30, 0x18, 0x70, 0x3E,
  0x00, 0xFE, 0x07, 0x03, 0xF0, 0x01, 0x80, 0xE0, 0x3F, 0x00, 0x00, 0x0E,
  0x03, 0xF8, 0x00, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0x18, 0x03, 0xFC, 0x00,
  0x01, 0x80, 0x1F, 0xC0, 0x00, 0x30, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x0F,
  0xE0, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x0F, 0x01, 0x07, 0xE0, 0x01, 0xFC,
  0x20, 0x7E, 0x00, 0x3F, 0xFE, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x7E, 0x00,
  0x87, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x08, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xC0,
  0x7F, 0x80, 0x70, 0x01, 0xF8, 0x0E, 0x00, 0x0F, 0xC0, 0xC0, 0x00, 0x7C,
  0x0C, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x07, 0x80, 0xC0,
  0x00, 0x78, 0x06, 0x00, 0x0F, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x1F, 0x80,
  0x00, 0xE7, 0xFC, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0xC8, 0xFF, 0x00, 0x1C,
  0x07, 0xF8, 0x01, 0x80, 0x3F, 0xC0, 0x30, 0x01, 0xFF, 0x04, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xC0,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x78, 0xE0, 0x78, 0x38, 0x38, 0x0E, 0x30, 0x03, 0xB0, 0x00, 0xD0,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x71, 0xF3,
  0xE3, 0xC3, 0xC3, 0x83, 0x03, 0x02, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x18, 0xFF, 0x06, 0x0F, 0xC1, 0xC0,
  0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xFC, 0x1F, 0x0F, 0x83,
  0xE1, 0xF8, 0x7C, 0x9F, 0x9F, 0xE3, 0xFD, 0xFC, 0x3F, 0x1F, 0x03, 0x81,
  0xC0, 0x20, 0x08, 0x00, 0xE0, 0x00, 0xE0, 0x08, 0x70, 0x01, 0x38, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x04, 0x0F,
  0x83, 0x01, 0xE1, 0xE0, 0x79, 0xF8, 0x1F, 0xBF, 0x07, 0x87, 0xE1, 0xE0,
  0xF8, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x78, 0x0E, 0x3E, 0x07, 0x0F,
  0xC1, 0x87, 0xFC, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x07, 0x80, 0x7F, 0x02, 0x7C, 0x18, 0xF8,
  0xE3, 0xE7, 0x87, 0xDC, 0x18, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xE1, 0x1F, 0xF8, 0x3F, 0x80, 0x78, 0x00, 0xC0, 0x38, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x13, 0xF8, 0x3C, 0x1F, 0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x1E,
  0x03, 0xC3, 0xC0, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C,
  0x03, 0x87, 0x80, 0x70, 0xF0, 0x0C, 0x3E, 0x01, 0x87, 0xF0, 0x61, 0xFF,
  0x08, 0x0F, 0xFB, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x07, 0x80, 0x7F, 0x06, 0x7C, 0x18, 0xF8, 0xE3, 0xE7,
  0x87, 0x9C, 0x1F, 0x70, 0x7F, 0xC0, 0xEF, 0x0C, 0x3F, 0xC0, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xE1,
  0x1F, 0xF8, 0x3F, 0x80, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x43, 0xFE,
  0x3F, 0xF1, 0xFF, 0x08, 0xF0, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x0F,
  0x00, 0x7F, 0xCF, 0xFE, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00,
  0x4F, 0xF0, 0x18, 0xFF, 0x86, 0x0F, 0xE1, 0xC0, 0x78, 0x78, 0x07, 0x0F,
  0x00, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC3, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x3E, 0x1F,
  0x07, 0xC1, 0xFF, 0x7C, 0x3F, 0x0F, 0x83, 0x81, 0xF0, 0x40, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x1C, 0x03, 0x87, 0x80, 0x70, 0x78,
  0x18, 0x07, 0x86, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x08, 0x38, 0x03, 0x3C, 0x00, 0x4E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x82, 0x03, 0xE1, 0x80, 0x79, 0xF0,
  0x1E, 0xFE, 0x07, 0xCF, 0xC1, 0xE1, 0xF0, 0x78, 0x3E, 0x1E, 0x0F, 0x87,
  0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0,
  0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E,
  0x3F, 0xC7, 0x1F, 0xE1, 0x81, 0xF0, 0xE0, 0x38, 0x30, 0x04, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x0E, 0x03, 0xE1, 0xFC, 0xFF, 0xAF, 0x83, 0xE0, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE4, 0x7F, 0x1F, 0x83, 0xE0, 0x70, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0xE0,
  0x7C, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x60, 0x0F, 0x00,
  0xFC, 0x1F, 0xE2, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0x20, 0xE1, 0x1C, 0x0F, 0x00, 0x00, 0xFC, 0x1C, 0x11, 0xC0,
  0x9E, 0x32, 0xE3, 0x9F, 0x3C, 0xFB, 0xE3, 0xFE, 0x1F, 0x80, 0xF8, 0x0F,
  0xFC, 0xFF, 0xEF, 0xFF, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC8, 0xFF, 0x81, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x20, 0x00,
  0xFC, 0x1C, 0x31, 0xC0, 0x9E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xC8, 0xFF, 0x81, 0xFC, 0x03, 0xC0,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x18, 0x03, 0xC1,
  0xF0, 0xF0, 0x0F, 0x8F, 0xC7, 0xE0, 0x7F, 0x7F, 0xBF, 0xF2, 0xFE, 0x3F,
  0x1F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0xF8, 0x1F, 0x07, 0x83,
  0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0xC1, 0xE0, 0xF8,
  0x1F, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0x78, 0x3E, 0x07,
  0xC1, 0xE0, 0xF8, 0x1F, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0,
  0x78, 0x3E, 0x07, 0xE3, 0xF0, 0xF9, 0x3F, 0x9F, 0xE3, 0xF8, 0x7C, 0x3F,
  0x07, 0xE0, 0xE0, 0x78, 0x1F, 0x01, 0x80, 0xC0, 0x38, 0x04, 0x02, 0x00,
  0x20, 0x10, 0x08, 0x01, 0xC0, 0x60, 0x0F, 0x87, 0x80, 0xFC, 0x7F, 0x07,
  0xFD, 0xFE, 0x4F, 0xC7, 0xE0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0xC1, 0xF4, 0x7F, 0x0F, 0xE1, 0xF0, 0x7F, 0x07, 0x01, 0xF0, 0x18,
  0x07, 0x00, 0x80, 0x18, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0xF3,
  0xF0, 0x7C, 0x7E, 0x0F, 0x1F, 0xC3, 0xC3, 0xF0, 0xF0, 0x7E, 0x3C, 0x0F,
  0x8F, 0x03, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1C, 0x7C, 0x07, 0x1F, 0xC1, 0x8F, 0xF8, 0xC0, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x78, 0x02, 0x0F, 0xE0,
  0xE0, 0x7E, 0x1E, 0x07, 0xF3, 0xF0, 0x3F, 0xFF, 0x81, 0xF0, 0xFC, 0x0F,
  0x07, 0xC0, 0xF0, 0x7E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1C,
  0x3F, 0x01, 0xC7, 0xF8, 0x38, 0xFF, 0xE3, 0x0F, 0xFF, 0x60, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x5F, 0xE0, 0x47, 0xFC, 0xE0, 0xFC, 0x70, 0x3C, 0x70, 0x1E, 0x38,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x79,
  0xF0, 0x3C, 0xF8, 0x1E, 0x3E, 0x0F, 0x1F, 0x87, 0x87, 0xEF, 0xC3, 0xF9,
  0xE0, 0xF8, 0xF0, 0x38, 0x78, 0x10, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x10, 0x10, 0xF0, 0x67, 0xE3, 0x9F, 0x9F, 0xFF, 0xFE, 0x7C, 0xF1, 0xF3,
  0x87, 0xC6, 0x1F, 0x10, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFB, 0x0F, 0xF8, 0x5F,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0x40, 0x00, 0x60, 0x00, 0xCE, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x08, 0x04, 0x0F, 0x06, 0x1F, 0xE7, 0x1F,
  0xFF, 0x10, 0xFF, 0x18, 0x1F, 0x0C, 0x01, 0x0E, 0x01, 0x07, 0x81, 0x83,
  0xE1, 0xE0, 0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0x1F, 0x87, 0x07, 0xC3, 0x01,
  0xE1, 0x00, 0x71, 0xC0, 0x31, 0xF8, 0x11, 0xFF, 0x90, 0x3F, 0xF0, 0x07,
  0xF0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF,
  0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x33, 0xFE, 0x5F,
  0xC0, 0x78, 0x03, 0x00, 0x10, 0x10, 0x03, 0x01, 0xE0, 0x18, 0x0F, 0x81,
  0xE0, 0xFC, 0x1F, 0x8F, 0xF1, 0xFE, 0x4F, 0x83, 0xE0, 0x7C, 0x1E, 0x03,
  0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F,
  0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F,
  0x07, 0x80, 0xF8, 0x3C, 0x07, 0xE3, 0xF4, 0x7F, 0xAF, 0xE0, 0xFE, 0x7E,
  0x03, 0xE1, 0xF0, 0x06, 0x07, 0x00, 0x20, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x02, 0x03, 0x00, 0x30, 0x78, 0x0F, 0x07, 0xC1, 0xF8, 0x7E,
  0x7F, 0xC7, 0xF8, 0x7C, 0x3F, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0,
  0xF8, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x03, 0x80, 0xF0, 0x38, 0x0F,
  0x03, 0x80, 0xF0, 0x30, 0x0E, 0x03, 0x01, 0xE0, 0x30, 0x1C, 0x07, 0x81,
  0x80, 0x7E, 0x30, 0x0F, 0xF2, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x0F, 0xC0, 0x60, 0x18, 0x3F, 0x07,
  0xC3, 0xE1, 0xFC, 0xFE, 0x3F, 0x07, 0xED, 0xFE, 0xFC, 0x1F, 0x87, 0xC3,
  0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0,
  0xF0, 0x7C, 0x0F, 0x87, 0x83, 0xE0, 0x3C, 0x3C, 0x1F, 0x01, 0xE1, 0xE0,
  0xF8, 0x0F, 0x0F, 0x07, 0xC0, 0x70, 0x78, 0x3E, 0x03, 0x83, 0xC1, 0xF0,
  0x38, 0x1E, 0x0F, 0x81, 0xC1, 0xF0, 0x7E, 0x0C, 0x0F, 0xC7, 0xFC, 0x80,
  0xFF, 0x1F, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x30,
  0x01, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x1F, 0x1C,
  0x1F, 0x1E, 0x3F, 0xBE, 0x4F, 0xFF, 0x0F, 0x9E, 0x0F, 0x8C, 0x07, 0x88,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x88, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x41, 0x80, 0xC0, 0x80, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x10, 0x30, 0x3C, 0x1C, 0xFC, 0x0F, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x41,
  0xFC, 0x1C, 0x1F, 0x8F, 0x83, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC8, 0xF1, 0xFF, 0x1C, 0x3F, 0xC3, 0x01,
  0xF0, 0xE0, 0x1C, 0x18, 0x01, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x38, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x21, 0xF0, 0x0F, 0x00,
  0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x71, 0xE4, 0x3F, 0xC2, 0xFF,
  0x01, 0xFC, 0x0F, 0xF0, 0xCF, 0x8C, 0x7E, 0x41, 0xF6, 0x0F, 0xB0, 0x7D,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0x80, 0xC4, 0x06, 0x30,
  0x60, 0x82, 0x03, 0xE0, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x0F, 0x00, 0xF0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 34, 10, 1, -33 },
  { 35, 16, 12, 18, 1, -32 },
  { 59, 21, 26, 23, 1, -29 },
  { 128, 15, 36, 19, 2, -34 },
  { 196, 30, 32, 32, 1, -32 },
  { 316, 24, 28, 26, 1, -28 },
  { 400, 7, 12, 9, 1, -32 },
  { 411, 10, 36, 11, 1, -35 },
  { 456, 10, 36, 11, 1, -35 },
  { 501, 15, 17, 16, 0, -33 },
  { 533, 15, 16, 18, 2, -23 },
  { 563, 7, 12, 8, 0, -7 },
  { 574, 13, 9, 13, 1, -18 },
  { 589, 7, 8, 9, 1, -7 },
  { 596, 22, 36, 23, 1, -34 },
  { 695, 19, 32, 21, 1, -32 },
  { 771, 14, 31, 14, 0, -31 },
  { 826, 18, 30, 20, 1, -30 },
  { 894, 19, 31, 21, 1, -31 },
  { 968, 20, 31, 21, 0, -31 },
  { 1046, 19, 31, 21, 1, -31 },
  { 1120, 19, 32, 20, 1, -32 },
  { 1196, 18, 30, 19, 1, -30 },
  { 1264, 19, 32, 21, 1, -32 },
  { 1340, 19, 32, 20, 1, -32 },
  { 1416, 7, 22, 9, 1, -21 },
  { 1436, 8, 26, 8, 0, -21 },
  { 1462, 12, 17, 13, 0, -21 },
  { 1488, 16, 9, 17, 1, -18 },
  { 1506, 12, 17, 13, 0, -21 },
  { 1532, 18, 33, 21, 1, -32 },
  { 1607, 26, 27, 27, 1, -21 },
  { 1695, 35, 33, 37, 1, -32 },
  { 1840, 39, 34, 40, 0, -33 },
  { 2006, 29, 34, 31, 1, -33 },
  { 2130, 34, 35, 36, 1, -33 },
  { 2279, 30, 34, 32, 1, -33 },
  { 2407, 32, 39, 34, 1, -33 },
  { 2563, 33, 33, 35, 1, -32 },
  { 2700, 31, 41, 33, 1, -35 },
  { 2859, 29, 38, 31, 1, -33 },
  { 2997, 30, 44, 32, 1, -33 },
  { 3162, 35, 33, 37, 1, -32 },
  { 3307, 24, 33, 26, 1, -32 },
  { 3406, 48, 34, 50, 1, -32 },
  { 3610, 38, 33, 40, 1, -32 },
  { 3767, 32, 33, 34, 1, -32 },
  { 3899, 38, 40, 40, 1, -32 },
  { 4089, 34, 35, 36, 1, -32 },
  { 4238, 40, 34, 42, 1, -33 },
  { 4408, 32, 33, 34, 1, -32 },
  { 4540, 32, 32, 34, 1, -32 },
  { 4668, 30, 34, 32, 1, -31 },
  { 4796, 38, 34, 40, 1, -33 },
  { 4958, 46, 33, 49, 1, -32 },
  { 5148, 30, 34, 32, 1, -33 },
  { 5276, 36, 40, 39, 1, -33 },
  { 5456, 28, 38, 30, 1, -33 },
  { 5589, 6, 35, 8, 1, -33 },
  { 5616, 27, 31, 5, -8, -29 },
  { 5721, 6, 35, 8, 1, -33 },
  { 5748, 17, 12, 19, 1, -32 },
  { 5774, 21, 3, 21, 0, 5 },
  { 5782, 7, 9, 23, 7, -32 },
  { 5790, 19, 24, 21, 1, -23 },
  { 5847, 18, 32, 20, 1, -31 },
  { 5919, 14, 24, 16, 1, -23 },
  { 5961, 19, 32, 20, 1, -31 },
  { 6037, 14, 24, 16, 1, -23 },
  { 6079, 13, 41, 11, 0, -33 },
  { 6146, 19, 33, 21, 1, -23 },
  { 6225, 18, 40, 20, 1, -32 },
  { 6315, 10, 32, 12, 1, -31 },
  { 6355, 12, 40, 11, -2, -32 },
  { 6415, 13, 32, 15, 1, -31 },
  { 6467, 13, 32, 12, 1, -31 },
  { 6519, 30, 25, 32, 1, -24 },
  { 6613, 21, 24, 23, 1, -23 },
  { 6676, 18, 24, 19, 0, -23 },
  { 6730, 20, 36, 20, 0, -27 },
  { 6820, 17, 32, 19, 1, -23 },
  { 6888, 14, 24, 16, 1, -23 },
  { 6930, 17, 29, 19, 1, -28 },
  { 6992, 12, 30, 14, 1, -29 },
  { 7037, 21, 24, 23, 1, -23 },
  { 7100, 20, 27, 20, -1, -26 },
  { 7168, 29, 27, 31, 1, -26 },
  { 7266, 16, 33, 18, 1, -24 },
  { 7332, 19, 35, 21, 1, -27 },
  { 7416, 13, 32, 15, 1, -24 },
  { 7468, 12, 36, 15, 1, -35 },
  { 7522, 3, 37, 7, 2, -35 },
  { 7536, 12, 36, 15, 1, -35 },
  { 7590, 14, 3, 16, 1, -15 },
};

const GFXfont UnifrakturMaguntia_Regular45pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular45pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular45pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR45PT7B_H_
