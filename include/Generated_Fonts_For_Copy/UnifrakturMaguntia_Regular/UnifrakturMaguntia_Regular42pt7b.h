#ifndef _UNIFRAKTURMAGUNTIA_REGULAR42PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x18, 0x3C, 0xFE, 0x7F, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x38, 0x7C, 0x7E, 0x38, 0x10, 0x00, 0x10, 0x10, 0x20, 0x60,
  0xE1, 0xE7, 0xF7, 0xF3, 0xE3, 0xC3, 0x83, 0x87, 0x07, 0x06, 0x0C, 0x08,
  0x18, 0x20, 0x20, 0x40, 0x41, 0x01, 0x00, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07,
  0x8E, 0x00, 0xE1, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0x0E, 0x1C, 0x0C, 0x30, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0xC0, 0xE7, 0xC1, 0xCF, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE6, 0x07, 0xEE, 0x07, 0xFC, 0x07, 0xB8,
  0x0F, 0x70, 0x0E, 0xC0, 0x38, 0xC0, 0x71, 0xC1, 0xC0, 0xEF, 0x00, 0xFC,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x21,
  0xF8, 0x00, 0x06, 0x39, 0xC0, 0x00, 0xC7, 0x8E, 0x00, 0x18, 0x70, 0xE0,
  0x01, 0x8F, 0x0F, 0x00, 0x30, 0xF0, 0xF0, 0x06, 0x0F, 0x0F, 0x00, 0xC0,
  0xF0, 0xF0, 0x18, 0x0F, 0x0F, 0x03, 0x00, 0xF0, 0xF0, 0x60, 0x07, 0x0E,
  0x06, 0x00, 0x78, 0xE0, 0xC0, 0x03, 0x9C, 0x18, 0x00, 0x1F, 0x83, 0x0F,
  0x00, 0xF0, 0x63, 0xF8, 0x00, 0x0C, 0x39, 0xC0, 0x01, 0x87, 0x1E, 0x00,
  0x30, 0xF1, 0xE0, 0x03, 0x0F, 0x0E, 0x00, 0x60, 0xF0, 0xF0, 0x0C, 0x0F,
  0x0F, 0x01, 0x80, 0xF0, 0xF0, 0x30, 0x0F, 0x0F, 0x06, 0x00, 0xF0, 0xE0,
  0xC0, 0x0F, 0x1E, 0x0C, 0x00, 0x71, 0xE1, 0x80, 0x03, 0x9C, 0x30, 0x00,
  0x3F, 0x82, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x30, 0x00, 0x38,
  0x60, 0x01, 0xE1, 0x80, 0x07, 0x87, 0x00, 0x1E, 0x18, 0x00, 0x78, 0xE0,
  0x01, 0xE3, 0x00, 0x07, 0xD8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0,
  0xF8, 0x7F, 0x0F, 0xF0, 0x70, 0x67, 0xC1, 0x83, 0x9F, 0x86, 0x1E, 0x3E,
  0x18, 0x70, 0xFC, 0x41, 0xC1, 0xF1, 0x0F, 0x87, 0xE8, 0x3E, 0x0F, 0xE0,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0xCF, 0xC7, 0xFE, 0x1F,
  0xFF, 0xF0, 0x3F, 0x87, 0x80, 0x20, 0xC7, 0xBF, 0x7C, 0xF1, 0xC6, 0x18,
  0x42, 0x08, 0x03, 0x83, 0x03, 0x03, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x70,
  0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x70, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x78, 0x07, 0xF8, 0xF3, 0x3D, 0xED, 0xE7, 0x97, 0x93, 0xF6, 0x47, 0x89,
  0xF7, 0xE7, 0xB7, 0xBC, 0xCF, 0x17, 0xA0, 0x3F, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xFF,
  0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x10, 0x71, 0xF7, 0xF1, 0xE3, 0x83, 0x04, 0x08, 0x20, 0x40, 0x00,
  0x21, 0xFF, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x04, 0x7F, 0xC7, 0xF8, 0xFC,
  0x00, 0x30, 0x63, 0xF7, 0xE3, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x00,
  0xE3, 0xC0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0,
  0x3E, 0x7C, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x81, 0xE1, 0xE0, 0x38, 0xF0, 0x07, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x0F,
  0xC0, 0xFE, 0x09, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x3F,
  0xC7, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x0F, 0xE6,
  0x03, 0xF2, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x08,
  0x70, 0x04, 0x30, 0x02, 0x30, 0x01, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0x07, 0xF1, 0x80, 0xFC,
  0x40, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xD8, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0x3E,
  0x01, 0x87, 0x80, 0xE0, 0xF0, 0x60, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0x78, 0x00,
  0x2F, 0x00, 0x09, 0xE0, 0x02, 0x3C, 0x00, 0x47, 0x80, 0x10, 0xF0, 0x04,
  0x1E, 0x00, 0x83, 0xC0, 0x20, 0x78, 0x08, 0x0F, 0x01, 0x01, 0xE0, 0x40,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x02, 0x0F, 0x03, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x7F, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0x83, 0xF9, 0x80, 0x3E, 0x40, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF6, 0x00, 0x3F, 0xC0, 0x1E,
  0xF8, 0x07, 0xBE, 0x01, 0xCF, 0x80, 0x61, 0xE0, 0x30, 0x3C, 0x18, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x03, 0x0E, 0x03, 0x87, 0x83, 0x81, 0xE1, 0xC0,
  0xF1, 0xE0, 0x7C, 0xF0, 0x3C, 0xF0, 0x0C, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x1F, 0x8F, 0x9F, 0xE7, 0xD9, 0xFB, 0xE8, 0x7D, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x3D, 0xF0, 0x1E, 0xF8, 0x1E, 0x7C, 0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x83,
  0x81, 0x80, 0xE1, 0x80, 0x1F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xEC, 0x00, 0x26, 0x00, 0x32, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xC0, 0xE0, 0xE0, 0x18, 0x70, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x31,
  0xC0, 0x0C, 0x78, 0x07, 0x1F, 0x01, 0xC7, 0xF0, 0xE0, 0xFF, 0x70, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x18, 0xFF, 0x0C, 0x0F,
  0xE7, 0x01, 0xFB, 0x80, 0x3E, 0xE0, 0x07, 0xB8, 0x00, 0xFE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xE7, 0x00, 0x70, 0xC0, 0x38, 0x1C,
  0x1C, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x06, 0x1C, 0x07, 0x07, 0x07, 0x03,
  0xC3, 0x81, 0xE3, 0xC0, 0xF9, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7E,
  0xF8, 0x7F, 0x7E, 0x6F, 0x9F, 0xE7, 0xC7, 0xE3, 0xE0, 0x41, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x80, 0x3C, 0xF0, 0x3C, 0xF8, 0x1E, 0x3C, 0x0E, 0x1E,
  0x07, 0x07, 0x83, 0x01, 0xC3, 0x00, 0x7E, 0x00, 0x20, 0x61, 0xE7, 0xE7,
  0x86, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0xFD, 0xF8,
  0xC1, 0x80, 0x00, 0x10, 0x18, 0x3C, 0x7E, 0x3C, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x38, 0x7C, 0xFE, 0x1E, 0x1C, 0x0C,
  0x08, 0x08, 0x10, 0x10, 0x00, 0x20, 0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x7C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x07, 0xF0, 0x1C, 0x3C,
  0x70, 0x1E, 0x60, 0x0F, 0x60, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x0F,
  0x38, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x04, 0x1C, 0x04, 0x1C, 0x08,
  0x0E, 0x18, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x0C, 0x38, 0x1F, 0xCE, 0x70, 0x7F, 0xCE, 0x70, 0xF3,
  0xC6, 0xE1, 0xE3, 0xC6, 0xE1, 0xC3, 0x86, 0xE3, 0xC3, 0x8E, 0xE3, 0x87,
  0x8E, 0xE7, 0x87, 0x0C, 0xE7, 0x8F, 0x1C, 0xE7, 0x9F, 0x38, 0xE7, 0xBF,
  0x78, 0xE7, 0xFF, 0xF3, 0x63, 0xC7, 0xC7, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x02, 0x07, 0xFF, 0x00, 0x0C,
  0x0F, 0xFF, 0x80, 0x38, 0x38, 0x7F, 0xC1, 0xF8, 0x20, 0x1F, 0xC7, 0xF0,
  0x40, 0x0F, 0xE3, 0xF0, 0x40, 0x07, 0xE1, 0xF0, 0xC0, 0x03, 0xE1, 0xF0,
  0xC0, 0x03, 0xF1, 0xF0, 0xC0, 0x03, 0xF1, 0xF0, 0xC0, 0x01, 0xF1, 0xF0,
  0xE0, 0x01, 0xE1, 0xF0, 0xFE, 0x01, 0xE1, 0xF0, 0x7F, 0x01, 0xE1, 0xF0,
  0x3F, 0x83, 0xC1, 0xF0, 0x1F, 0xC3, 0xC1, 0xF0, 0x07, 0xC3, 0x81, 0xF0,
  0x01, 0x87, 0x01, 0xF0, 0x01, 0x8E, 0x01, 0xF0, 0x01, 0x0C, 0x01, 0xF0,
  0x00, 0x18, 0x01, 0xF0, 0x00, 0x20, 0x01, 0xF0, 0x00, 0x70, 0x01, 0xF0,
  0x01, 0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x07, 0xF9,
  0x00, 0x7F, 0xCD, 0xFF, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0xFC,
  0x00, 0x0F, 0xC0, 0x70, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFC,
  0x67, 0xF0, 0x1F, 0xFF, 0xE8, 0x3F, 0x03, 0xC0, 0xFF, 0x81, 0xF8, 0x78,
  0x03, 0xF8, 0x1F, 0x87, 0x00, 0x1F, 0x81, 0xF8, 0x60, 0x01, 0xF8, 0x0F,
  0xC6, 0x00, 0x0F, 0x80, 0xFE, 0x40, 0x00, 0xF8, 0x07, 0xC6, 0x00, 0x0F,
  0x80, 0x30, 0x60, 0x00, 0x78, 0x0C, 0x06, 0x00, 0x07, 0x83, 0xF0, 0x70,
  0x00, 0x70, 0xFF, 0x83, 0x80, 0x8F, 0x7F, 0xFC, 0x1E, 0x30, 0xE0, 0x7F,
  0xE0, 0x38, 0x0C, 0x00, 0x7F, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x00,
  0xE0, 0x21, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0x7F,
  0xC0, 0x38, 0x00, 0x03, 0xFF, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x83, 0x80, 0x1E, 0x18, 0xFC, 0x07, 0x81, 0x7F, 0xF0, 0xE0, 0x1F,
  0xFC, 0x3C, 0x04, 0x3E, 0x0F, 0x03, 0x01, 0x81, 0xE0, 0xC0, 0x00, 0x7C,
  0x38, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xF0, 0x07, 0xE0,
  0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xE0,
  0x1C, 0x00, 0xFC, 0x07, 0x00, 0x1F, 0xC1, 0x80, 0x01, 0xFE, 0x60, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x70, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0xE0, 0x3E, 0x02, 0x1F, 0xF0,
  0x78, 0x06, 0x07, 0xF8, 0x70, 0x0C, 0x03, 0xF8, 0xE0, 0x1C, 0x00, 0xFC,
  0xC0, 0x3C, 0x00, 0x7C, 0xC0, 0x3E, 0x00, 0x3E, 0xC0, 0x3F, 0x00, 0x3E,
  0xC0, 0x3F, 0x80, 0x1E, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F,
  0x40, 0x0F, 0xE0, 0x0F, 0x60, 0x07, 0xF0, 0x07, 0x30, 0x03, 0xF0, 0x07,
  0x1C, 0x21, 0xF0, 0x06, 0x03, 0xC0, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x0C,
  0x03, 0xFF, 0x00, 0x08, 0x07, 0xFF, 0x80, 0x10, 0x1F, 0xFF, 0xF0, 0x60,
  0x30, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xC1, 0xC0, 0x07, 0x86, 0x3F, 0x00, 0xF0, 0x2F, 0xFE, 0x0E, 0x01,
  0xFF, 0xC1, 0xE0, 0x21, 0xF0, 0x3C, 0x0C, 0x02, 0x03, 0xC1, 0x80, 0x00,
  0x7C, 0x38, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87,
  0xE0, 0xE0, 0x78, 0x7F, 0x1F, 0xAF, 0xC3, 0xFB, 0xFF, 0xFC, 0x3F, 0xFF,
  0xEF, 0xC1, 0xFE, 0x7C, 0xFC, 0x0F, 0xF1, 0x87, 0xC0, 0x7F, 0x80, 0x7C,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x3F, 0x80, 0x70, 0x01, 0xF8, 0x0E, 0x00, 0x1F, 0xC1, 0x80, 0x00,
  0xFF, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0E, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xEC, 0xF8, 0x0F, 0xFF, 0xE3, 0x80,
  0x0F, 0xFE, 0x1C, 0x00, 0x67, 0xF0, 0x60, 0x03, 0x87, 0x03, 0x80, 0x0E,
  0x08, 0x0C, 0x00, 0x78, 0x00, 0x30, 0x01, 0xF0, 0x10, 0xC0, 0x07, 0xE0,
  0x63, 0x00, 0x1F, 0xC3, 0xE4, 0x00, 0x7F, 0x1F, 0xD8, 0x00, 0xFE, 0xFE,
  0x60, 0x03, 0xFF, 0xF0, 0xC0, 0x07, 0xF1, 0xC1, 0x80, 0x8F, 0xE2, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78,
  0x01, 0xF8, 0x00, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x38, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x07, 0x0C, 0x3C, 0x00, 0x78,
  0x0B, 0xF0, 0x03, 0xC0, 0x37, 0xF0, 0x0E, 0x01, 0x8F, 0xE0, 0x78, 0x0C,
  0x3F, 0xC3, 0xC0, 0xE0, 0x3F, 0x8F, 0x07, 0x00, 0x7C, 0x7C, 0x3C, 0x00,
  0xC1, 0xF1, 0xF0, 0x06, 0x07, 0xC7, 0xC0, 0x70, 0x1F, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x3F, 0xE3, 0xF0, 0xFD, 0xFF, 0xCF, 0xC1, 0xF8, 0x3F, 0xBF,
  0x07, 0xF0, 0x7E, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x1F, 0x81, 0xF7, 0xC0,
  0x3F, 0x07, 0xDF, 0x80, 0xFC, 0x1F, 0x7E, 0x01, 0xF0, 0x7D, 0xF8, 0x07,
  0x81, 0xF3, 0xF0, 0x1C, 0x07, 0x87, 0xC0, 0x60, 0x1E, 0x1F, 0x83, 0x00,
  0x70, 0x3F, 0x10, 0x03, 0xC0, 0x7E, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0xFC, 0x03, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x06,
  0x3F, 0xE0, 0x00, 0x30, 0x3F, 0x80, 0x01, 0x80, 0xFC, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x07, 0xC0, 0x07,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0xFC, 0x3F, 0xF8,
  0x03, 0xF9, 0x9F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1E,
  0x01, 0xF0, 0xE0, 0x78, 0x07, 0x87, 0xC0, 0xC0, 0x1E, 0x7F, 0x83, 0x00,
  0x79, 0x7F, 0x18, 0x03, 0xC0, 0xFF, 0xC0, 0x0F, 0x01, 0xFC, 0x00, 0x38,
  0x03, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x01, 0xE0, 0xFF, 0x80, 0x38, 0x07, 0xFC, 0x8E,
  0x00, 0x7F, 0xE1, 0x80, 0x03, 0xF8, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x80, 0x60,
  0x01, 0xF0, 0x06, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x02, 0xFC,
  0x00, 0x7F, 0x8F, 0xC0, 0x01, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x01, 0xE7, 0xFE, 0x00, 0x39, 0xFF, 0xE0, 0x07, 0x21, 0xFE, 0x00, 0xC0,
  0x1F, 0xE0, 0x30, 0x01, 0xFE, 0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1E, 0x0F, 0xF8, 0x03, 0x80,
  0x3F, 0xE4, 0x30, 0x01, 0xFF, 0x83, 0x00, 0x07, 0xF0, 0x60, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x20,
  0x00, 0x78, 0x03, 0x00, 0x07, 0x80, 0x10, 0x00, 0xFC, 0x01, 0x80, 0x0F,
  0xC0, 0x0E, 0x02, 0x7C, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x40, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x1F, 0x80, 0x01,
  0xC3, 0xFC, 0x00, 0x18, 0x7F, 0xF0, 0x01, 0x88, 0xFF, 0x00, 0x30, 0x07,
  0xFC, 0x02, 0x00, 0x1F, 0xE0, 0x40, 0x00, 0xFF, 0xB8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x78, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0x18, 0x01, 0xE0, 0xFC, 0x0C, 0x01, 0xC3, 0xFE, 0x0E, 0x03, 0xC7, 0xFF,
  0x06, 0x03, 0xC6, 0x3F, 0x86, 0x07, 0xCC, 0x0F, 0xC7, 0x07, 0xC8, 0x0F,
  0xC3, 0x07, 0xE8, 0x07, 0xC3, 0x03, 0xE8, 0x07, 0xF3, 0x03, 0xF8, 0x03,
  0xE6, 0x03, 0xF8, 0x01, 0xC6, 0x01, 0xFC, 0x03, 0x04, 0x01, 0xFC, 0x0E,
  0x08, 0x00, 0xFE, 0x3F, 0x30, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x07,
  0xE0, 0x0C, 0x0F, 0x07, 0xE0, 0x3E, 0x07, 0x03, 0xF0, 0x7F, 0x06, 0x03,
  0xF0, 0xFF, 0x84, 0x01, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x78, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x07, 0x9F, 0x00, 0x78, 0x1E, 0x03, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0xF8,
  0x00, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x7E, 0x00, 0x3D, 0xF8, 0x00,
  0xF3, 0xF0, 0x03, 0xCF, 0xE0, 0x1E, 0x3F, 0x80, 0x78, 0x7E, 0x03, 0xC0,
  0xFD, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x30, 0x7F, 0xE1, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF,
  0xBF, 0xFB, 0x3F, 0x03, 0xFF, 0xFE, 0x3F, 0xA1, 0xF8, 0x70, 0x3F, 0xC1,
  0xFC, 0x0F, 0x86, 0x00, 0xFE, 0x0F, 0xC0, 0xFC, 0xC0, 0x07, 0xE0, 0x7E,
  0x0F, 0xC8, 0x00, 0x3F, 0x03, 0xE0, 0x7C, 0x80, 0x01, 0xF0, 0x3E, 0x07,
  0xE8, 0x00, 0x1F, 0x83, 0xE0, 0x7F, 0x80, 0x00, 0xF8, 0x1E, 0x03, 0xCC,
  0x00, 0x0F, 0x81, 0xF0, 0x10, 0x40, 0x00, 0xF8, 0x1E, 0x02, 0x07, 0xFE,
  0x07, 0x81, 0xE0, 0x40, 0x3F, 0xE0, 0x78, 0x1E, 0x0C, 0x01, 0xFF, 0x07,
  0x81, 0xE1, 0xC0, 0x06, 0x30, 0x70, 0x1E, 0x38, 0x00, 0x01, 0x07, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x78, 0x00, 0x00, 0x06, 0x01, 0xC7,
  0xC0, 0x00, 0x00, 0x60, 0x1C, 0x7C, 0x00, 0x00, 0x0C, 0x01, 0x87, 0xC0,
  0x01, 0x00, 0xC0, 0x10, 0x7E, 0x00, 0x7C, 0x09, 0xC1, 0x07, 0xE0, 0x1F,
  0xE1, 0x3E, 0x20, 0x3F, 0x13, 0xFF, 0x37, 0xFE, 0x03, 0xFF, 0x23, 0xFE,
  0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xDB, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x0F,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFC, 0x83, 0xE0,
  0xE0, 0x3F, 0xA0, 0x7E, 0x10, 0x03, 0xFC, 0x07, 0xC6, 0x00, 0x3F, 0x80,
  0xF8, 0x80, 0x03, 0xF0, 0x1F, 0x90, 0x00, 0x3E, 0x03, 0xFA, 0x00, 0x07,
  0xE0, 0x3F, 0xC0, 0x00, 0x7C, 0x03, 0x8C, 0x00, 0x0F, 0x80, 0x40, 0x80,
  0x01, 0xF0, 0x10, 0x1F, 0xF8, 0x1E, 0x06, 0x01, 0xFF, 0x83, 0xC1, 0x80,
  0x1F, 0xF0, 0x78, 0x70, 0x00, 0x06, 0x0E, 0x0E, 0x00, 0x00, 0x41, 0xC3,
  0xC0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x00,
  0xC3, 0xF0, 0x00, 0x00, 0x38, 0x7E, 0x00, 0x1C, 0x06, 0x07, 0xC0, 0x0F,
  0xC0, 0x80, 0xFC, 0x03, 0xFC, 0x30, 0x1F, 0xCC, 0xFF, 0xCC, 0x01, 0xFF,
  0x21, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x0C, 0x0F, 0xFE, 0x00, 0xC0, 0x07, 0xFC, 0x06, 0x00, 0x07, 0xF8,
  0x38, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0xF9, 0xFE, 0x00, 0x01, 0xE7, 0xFE,
  0x00, 0x07, 0x8F, 0xFE, 0x00, 0x1E, 0x1F, 0xF8, 0x00, 0x38, 0x1F, 0xF0,
  0x00, 0xE0, 0x1F, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x80, 0x00, 0xC0, 0xF8, 0x00, 0x02, 0x0F, 0xF0, 0x00, 0x18,
  0x7F, 0xF0, 0x00, 0x42, 0x7F, 0xE0, 0x02, 0x00, 0x7F, 0xE0, 0x30, 0x00,
  0x7F, 0xF3, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x00,
  0x1F, 0xFE, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x7E, 0x00, 0x7C, 0x7F, 0x8F,
  0xE0, 0x0E, 0x01, 0xFF, 0x3F, 0x00, 0xC0, 0x0F, 0xC3, 0xF8, 0x0C, 0x00,
  0xFC, 0x3F, 0xC0, 0x80, 0x07, 0xE1, 0xFE, 0x08, 0x00, 0x7E, 0x0F, 0xF0,
  0x80, 0x03, 0xE0, 0x7F, 0x88, 0x00, 0x3E, 0x03, 0xFC, 0xC0, 0x03, 0xE0,
  0x1F, 0xC4, 0x00, 0x3E, 0x00, 0xFE, 0x20, 0x23, 0xE0, 0x07, 0xE1, 0xC7,
  0x3E, 0x00, 0x3E, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x00,
  0xFE, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x01, 0x00, 0x03, 0xFF, 0xC0, 0x20,
  0x00, 0x7F, 0xFF, 0x8E, 0x00, 0x08, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1C, 0xFE, 0x00, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0x03,
  0xFF, 0x80, 0x0C, 0x00, 0x7F, 0xC0, 0x18, 0x00, 0x1F, 0xE0, 0x38, 0x00,
  0x0F, 0xE0, 0x78, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0xFE, 0x00, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x78, 0x7F, 0xE0,
  0x00, 0x78, 0x3F, 0xF8, 0x00, 0x78, 0x1F, 0xF8, 0x00, 0x38, 0x07, 0xFC,
  0x00, 0x38, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x78, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x0F, 0x80, 0x0F, 0x20, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0, 0x9F, 0xF8, 0x8F, 0xE2, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xF9, 0xF8, 0x00, 0x3F,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x03,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0x8D, 0xFE, 0x03, 0xFF, 0xFC, 0xC3,
  0xF0, 0x3C, 0x0F, 0xF4, 0x0F, 0xC1, 0x80, 0x1F, 0xE0, 0x7E, 0x1C, 0x00,
  0x7F, 0x03, 0xF8, 0xC0, 0x01, 0xF8, 0x0F, 0xC6, 0x00, 0x07, 0xC0, 0x3F,
  0xB0, 0x00, 0x3E, 0x00, 0xF1, 0x80, 0x00, 0xF0, 0x06, 0x0C, 0x00, 0x07,
  0x80, 0x60, 0x60, 0x00, 0x3C, 0x0C, 0x01, 0x80, 0x01, 0xE0, 0xC0, 0x0C,
  0x00, 0x0F, 0x1F, 0x00, 0x38, 0x08, 0x3B, 0xFC, 0x00, 0x7F, 0x81, 0xC7,
  0xE0, 0x00, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x01, 0x80, 0xFC,
  0x00, 0x30, 0x0C, 0x07, 0xE0, 0x07, 0xE0, 0xC0, 0x1F, 0x80, 0x7F, 0x84,
  0x00, 0xFC, 0x07, 0xFE, 0x60, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0x81, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0x87, 0xFF, 0xE0, 0x18, 0x03, 0xFF,
  0x00, 0xC0, 0x03, 0xF0, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xE0, 0x60,
  0x00, 0xFF, 0xC3, 0x82, 0x0F, 0xFF, 0x8E, 0x0C, 0xFF, 0xFF, 0x38, 0x1F,
  0xFE, 0x06, 0xF0, 0x3F, 0xE0, 0x0B, 0xC0, 0x7F, 0x00, 0x2F, 0x80, 0xE0,
  0x00, 0xBE, 0x00, 0x00, 0x03, 0x7C, 0x00, 0x00, 0x09, 0xF8, 0x00, 0x00,
  0x23, 0xF0, 0x00, 0x01, 0x8F, 0xF0, 0x00, 0x1C, 0x1F, 0xF0, 0x01, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0E, 0x07, 0xFF, 0x00, 0x70, 0x03,
  0xFF, 0x01, 0x80, 0x07, 0xFE, 0x2C, 0x00, 0x27, 0xFF, 0x20, 0x01, 0x87,
  0xF8, 0x80, 0x0C, 0x0F, 0xC2, 0x00, 0x70, 0x04, 0x08, 0x03, 0xE0, 0x00,
  0x30, 0x0F, 0xC0, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x80, 0x7F, 0x00, 0x01,
  0x85, 0xFE, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0xC0,
  0xF0, 0x00, 0xFF, 0x83, 0x80, 0x07, 0xFF, 0x18, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x80, 0x0F, 0xF8, 0x06,
  0x00, 0x0F, 0xFC, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x60, 0x70, 0x80, 0x1C, 0x0E, 0x04, 0x07, 0x81, 0xE0,
  0x41, 0xF0, 0x3E, 0x08, 0x7F, 0x03, 0xE0, 0x83, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x01, 0xFC, 0x01, 0xF0, 0x1F,
  0xE0, 0x1F, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0x01,
  0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x1C, 0x01, 0xF0, 0x01, 0x80, 0x1F, 0x00, 0x30, 0x01, 0xF0, 0x06, 0x00,
  0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xFC, 0x03, 0xF0,
  0x7F, 0xE0, 0xDF, 0x08, 0x7F, 0xF9, 0xFF, 0x03, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFC, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xC4, 0xFE, 0x03, 0xFF, 0xFD,
  0x0F, 0xC0, 0xF0, 0x3F, 0xE0, 0xFC, 0x1C, 0x03, 0xFC, 0x1F, 0x87, 0x00,
  0x3F, 0x81, 0xF8, 0xC0, 0x03, 0xF0, 0x3F, 0x98, 0x00, 0x3E, 0x03, 0xC2,
  0x00, 0x07, 0xC0, 0x10, 0x40, 0x00, 0x78, 0x04, 0x0C, 0x00, 0x0F, 0x01,
  0x80, 0x80, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x38, 0x1F, 0x01, 0x80, 0x87,
  0x03, 0xE0, 0x1C, 0xE1, 0xC0, 0x7E, 0x00, 0x70, 0x30, 0x0F, 0xE0, 0x00,
  0x06, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01, 0xF0, 0x1F, 0xF8, 0x00,
  0x1E, 0x07, 0xFF, 0x80, 0x03, 0x81, 0x8F, 0xFC, 0x00, 0x60, 0x00, 0x7F,
  0xC0, 0x08, 0x00, 0x07, 0xFC, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x00, 0xFF, 0xC3, 0xC3, 0xFF, 0x00, 0x7F,
  0xFE, 0x6C, 0x87, 0xF0, 0x1F, 0xFF, 0xF0, 0x60, 0x7E, 0x07, 0xE3, 0xFE,
  0x0C, 0x07, 0xE0, 0xE0, 0x1F, 0xC3, 0x00, 0xFC, 0x38, 0x01, 0xF8, 0x60,
  0x0F, 0xC6, 0x00, 0x1F, 0x9E, 0x01, 0xF8, 0xC0, 0x01, 0xF3, 0xC0, 0x1F,
  0xD8, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0x00, 0x03, 0xCF, 0x80, 0x10, 0x60,
  0x00, 0x79, 0xF8, 0x06, 0x04, 0x00, 0x0F, 0x3F, 0x01, 0xC0, 0xC0, 0x01,
  0xC7, 0xF0, 0x78, 0x08, 0x04, 0x38, 0x7E, 0x1F, 0x80, 0xC3, 0x06, 0x07,
  0xE3, 0xF8, 0x07, 0xC1, 0xC0, 0xFC, 0x3F, 0x80, 0x00, 0x30, 0x0F, 0x87,
  0xF8, 0x00, 0x0C, 0x01, 0xF0, 0x7F, 0x80, 0x01, 0x00, 0x1E, 0x07, 0xF0,
  0x00, 0x40, 0x03, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x70, 0x07, 0xC0, 0xFF,
  0x00, 0x0C, 0x00, 0x70, 0x3F, 0xF0, 0x01, 0xE0, 0x0E, 0x18, 0xFF, 0x00,
  0x7E, 0x01, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x30, 0x00, 0x7F, 0x8F, 0xFE,
  0x04, 0x00, 0x0F, 0xFF, 0x1F, 0xF3, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x60, 0x0F, 0xFC, 0x0F, 0x91, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0x1F, 0xE7, 0xE3, 0xF1, 0xFE, 0x70, 0x1F, 0xB3, 0xCE,
  0x00, 0xFA, 0x00, 0xC0, 0x07, 0xE0, 0x0C, 0x00, 0x7C, 0x00, 0xC0, 0x03,
  0xC0, 0x04, 0x00, 0x3C, 0x00, 0x40, 0x03, 0xC0, 0x06, 0x00, 0x7F, 0xF8,
  0x30, 0x0F, 0xFF, 0x01, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x09, 0xF0, 0x00, 0xF0, 0x9F, 0x80, 0x1F, 0xD9, 0xFF, 0x61, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC2, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xFE, 0x23, 0xF0, 0x3F, 0xFF, 0xD0, 0x7E,
  0x1E, 0x07, 0xFC, 0x1F, 0x86, 0x00, 0xFF, 0x03, 0xE3, 0x00, 0x1F, 0xC0,
  0xFC, 0xC0, 0x03, 0xF0, 0x3F, 0x30, 0x00, 0x7C, 0x07, 0xE8, 0x00, 0x1F,
  0x01, 0xFE, 0x00, 0x03, 0xC0, 0x38, 0xC0, 0x00, 0xF0, 0x0C, 0x10, 0x00,
  0x38, 0x0E, 0x06, 0x00, 0x0E, 0x07, 0x80, 0xC0, 0x43, 0x83, 0xE0, 0x1F,
  0xE1, 0xC0, 0xF8, 0x00, 0x40, 0x70, 0x3F, 0x00, 0x00, 0x18, 0x0F, 0xC0,
  0x00, 0x0E, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x1F,
  0xC0, 0x00, 0x40, 0x03, 0xF0, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0xC1, 0x07, 0xE0, 0x07, 0xFF, 0x81, 0xF8, 0x03, 0xFF,
  0xC0, 0x7E, 0x01, 0x1F, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x3C, 0x01, 0xF0, 0x04, 0x00, 0x00, 0x78, 0x00, 0x80, 0x00, 0x3C, 0x00,
  0x10, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0x80,
  0xFE, 0x03, 0x80, 0x0F, 0xC0, 0xC0, 0x01, 0xF0, 0x30, 0x00, 0x7C, 0x0C,
  0x00, 0x1F, 0x03, 0x00, 0x03, 0xC0, 0xC0, 0x01, 0xE0, 0x30, 0x00, 0x78,
  0x04, 0x00, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x38, 0xFE, 0x00, 0x0E, 0xFF, 0xC0, 0x03, 0xA7, 0xF8, 0x00, 0xC0, 0x7F,
  0x00, 0x60, 0x0F, 0xE0, 0x30, 0x01, 0xFE, 0x18, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xCE, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFC, 0x01, 0x00, 0x02, 0x00, 0x0E,
  0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xBC, 0x1E, 0x3C, 0x38, 0x1C,
  0xE0, 0x1B, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE3, 0xCF, 0x1E, 0x38, 0x20, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x02, 0x3F, 0xC1, 0x87, 0xE0,
  0xE0, 0xF8, 0x70, 0x3C, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xE3, 0xF8, 0xFF, 0x7C, 0x1F, 0x1F, 0x03, 0x83, 0x80, 0xC0, 0x20,
  0x00, 0xE0, 0x41, 0x80, 0x23, 0x80, 0x0B, 0xC0, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x08, 0x1F, 0x0C, 0x0F, 0x9F, 0x07,
  0xFF, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C, 0x1F, 0x3E, 0x07,
  0x9F, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xE3, 0xE0, 0x71, 0xF0, 0x38, 0xF8,
  0x38, 0x7C, 0x18, 0x3F, 0x08, 0x3F, 0xE8, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x3F, 0x02, 0x78, 0x33, 0xE3, 0x0F,
  0x38, 0x7D, 0xC1, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFE, 0x3F,
  0x80, 0x78, 0x01, 0x00, 0x38, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x2F, 0xE0, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x0F, 0x3E, 0x07, 0x9F, 0x01, 0xCF, 0x80, 0xE7, 0xC0, 0x73, 0xE0,
  0x39, 0xF0, 0x18, 0xF8, 0x0C, 0x7C, 0x0C, 0x7F, 0x86, 0x1F, 0xF6, 0x01,
  0xFE, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x3F, 0x02,
  0x78, 0x33, 0xE3, 0x0F, 0x38, 0x79, 0xC3, 0xEE, 0x0F, 0xF0, 0x67, 0x9C,
  0x3F, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xFE, 0x1F, 0x80, 0x78, 0x01, 0x00, 0x00, 0x00, 0xF9, 0x1F,
  0xF1, 0xFE, 0x13, 0xE1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0xC0, 0x3F,
  0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x05, 0xFC, 0x03, 0x3F, 0xC1, 0x83, 0xF0, 0xE0, 0x78, 0x70,
  0x06, 0x1C, 0x03, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x1E, 0x3E, 0x0F,
  0x8F, 0x83, 0xE1, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF0,
  0xFD, 0xBC, 0x1F, 0x8F, 0x07, 0x03, 0xC0, 0x80, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x08, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x30, 0x3C, 0x18, 0x07, 0xB8,
  0x00, 0x10, 0x00, 0x01, 0xF0, 0x43, 0x80, 0x23, 0x80, 0x0B, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x10, 0x1E, 0x3C,
  0x0F, 0xBF, 0x07, 0xEF, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x1E, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x0E, 0x1F, 0x67, 0x1F, 0xE3,
  0x03, 0xC3, 0x80, 0xE1, 0x80, 0x21, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x38, 0x0F, 0x07, 0xE3, 0xFC, 0xBE,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xE1, 0xF8, 0x7C, 0x0F, 0x00, 0x80, 0x03, 0x80,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00,
  0xF0, 0x0F, 0x81, 0xFC, 0x3F, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x74, 0x0E, 0x20, 0xC1, 0x38, 0x0C, 0x00, 0x00, 0xF8, 0x30, 0x86, 0x04,
  0xE3, 0x3E, 0x73, 0xEF, 0x3F, 0xF3, 0xF8, 0x3E, 0x03, 0xE0, 0x3F, 0xFF,
  0xFF, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x43, 0xFE, 0x7F, 0x80,
  0xF0, 0x07, 0x00, 0x20, 0x01, 0xF8, 0x30, 0x8E, 0x04, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x23, 0xFC, 0x7F, 0x80, 0xF0, 0x07, 0x00,
  0x20, 0x20, 0x10, 0x08, 0x03, 0x81, 0xC1, 0xC0, 0x3C, 0x3E, 0x3E, 0x07,
  0xE7, 0xF7, 0xF8, 0xFF, 0x9F, 0x9F, 0xC9, 0xF1, 0xF0, 0xF8, 0x1E, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78,
  0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07,
  0x81, 0xF1, 0xF0, 0x78, 0x3F, 0xBF, 0x87, 0xF3, 0xF1, 0xF8, 0x7E, 0x0E,
  0x0F, 0x03, 0xC0, 0xC0, 0x60, 0x1C, 0x04, 0x04, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x03, 0x00, 0xF0, 0xF0, 0x3F, 0x3F, 0x07, 0xEF, 0xFD, 0x3E, 0x3F,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0xE1, 0xE0, 0xFC, 0x3E, 0x9F, 0xC7, 0xE1, 0xE0, 0x7C,
  0x18, 0x07, 0x01, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x01, 0xF0, 0x3E,
  0xF8, 0x7C, 0xFC, 0x7C, 0x7C, 0x7C, 0x7E, 0x7C, 0x3E, 0x7C, 0x1F, 0x3C,
  0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0E, 0x7C, 0x0C, 0xFF, 0x18, 0x7F, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x03,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xFC, 0x0C, 0x1F, 0x87, 0x07, 0xE7, 0xE0, 0xFF, 0xFC, 0x1E, 0x1F, 0x87,
  0x83, 0xE1, 0xE0, 0xFC, 0x78, 0x1F, 0x0E, 0x07, 0xC3, 0x80, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xE1, 0xF0, 0x39, 0xFC, 0x1C,
  0xFF, 0x86, 0x3F, 0xFB, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0E, 0xE0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0xF0, 0x05, 0xF8, 0x18, 0xFF, 0x38, 0x7E, 0x70, 0x3C, 0x70, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF8, 0x3C, 0xF8, 0x3C, 0x7C, 0x3C, 0x7E, 0x7C, 0x3F, 0xBC, 0x1F, 0x3C,
  0x0C, 0x1C, 0x08, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x01, 0xC1, 0x0F,
  0x1C, 0xFD, 0xFF, 0xEF, 0xCF, 0xBC, 0x79, 0xC3, 0xC6, 0x1E, 0x20, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF9, 0x0F, 0xF0, 0xBF, 0x00, 0x78, 0x01, 0x80, 0x08, 0x00, 0x01, 0xE0,
  0x02, 0x18, 0x00, 0x04, 0x00, 0x02, 0x02, 0x02, 0x03, 0x02, 0x07, 0xC2,
  0x1F, 0xFE, 0x23, 0xFE, 0x60, 0xF8, 0x60, 0x10, 0xE0, 0x20, 0xF0, 0x60,
  0xF8, 0xF0, 0x7D, 0xF8, 0x7F, 0xFC, 0x3C, 0x7E, 0x18, 0x1E, 0x10, 0x1E,
  0x30, 0x0C, 0x7C, 0x08, 0xFF, 0x18, 0x7F, 0xF0, 0x1F, 0xE0, 0x03, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x81, 0xF0, 0x7F, 0xFF, 0xFC, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x89,
  0xFE, 0x7F, 0x81, 0xE0, 0x1C, 0x01, 0x00, 0x00, 0x04, 0x07, 0x00, 0xC0,
  0xF0, 0x3C, 0x3F, 0x0F, 0xCF, 0xE1, 0xFD, 0x3C, 0x1F, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xE3, 0xE4, 0xFE, 0xFF, 0xAF, 0xE7, 0xE0, 0x78, 0x7C, 0x06, 0x07, 0x00,
  0x80, 0x40, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x81, 0x80, 0x70, 0xF0,
  0x3C, 0x3E, 0x3F, 0x8F, 0xF3, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0x8F, 0x83,
  0xF1, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x03, 0xC1, 0xC0, 0xF0, 0x60, 0x38,
  0x18, 0x0E, 0x06, 0x03, 0x83, 0x01, 0xC0, 0xC0, 0x60, 0x7C, 0x30, 0x1F,
  0xC8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x80, 0xC0, 0x21, 0xF8, 0x3C, 0x1C, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3,
  0xFB, 0xFC, 0x1F, 0x8F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3E, 0x0F,
  0x0F, 0x07, 0xC1, 0xF1, 0xE0, 0xF8, 0x1E, 0x3C, 0x1F, 0x03, 0xC7, 0x83,
  0xE0, 0x78, 0xF0, 0x7C, 0x0F, 0x1E, 0x0F, 0x81, 0xC3, 0xC1, 0xF0, 0x38,
  0x78, 0x3E, 0x0E, 0x0F, 0x87, 0xC1, 0x81, 0xF1, 0xFE, 0x20, 0x7F, 0x1F,
  0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x70, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x80, 0x04, 0x00, 0x08, 0x10, 0x38, 0x30, 0x78, 0xE1, 0xFB, 0xE5, 0xFF,
  0xE1, 0xF7, 0x83, 0xC6, 0x07, 0x8C, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xA0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x08, 0x70, 0x20, 0x40, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0xC1, 0x83, 0xC1, 0xFF, 0x80, 0x7C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x80, 0x20, 0xFC,
  0x18, 0x3F, 0x8F, 0x07, 0xEF, 0xE0, 0xFC, 0xFC, 0x1E, 0x1F, 0x07, 0x83,
  0xE1, 0xE0, 0xF8, 0x78, 0x1E, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x0F, 0xD1, 0xC7, 0xF8, 0x60, 0x3C, 0x38, 0x06, 0x0C, 0x00, 0x86,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x01, 0xF8, 0x3F, 0xC4, 0x7C, 0x03,
  0xC0, 0x38, 0x03, 0x00, 0x60, 0x08, 0x31, 0xC4, 0x7F, 0x8F, 0xF8, 0x0F,
  0xC0, 0xBE, 0x13, 0xE2, 0x1F, 0x61, 0xF4, 0x0F, 0x40, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xEC, 0x0E, 0x40, 0xC6, 0x18, 0x31, 0x01, 0xE0, 0x00,
  0x20, 0x38, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0xF0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x3C, 0x0E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE,
};

const GFXglyph UnifrakturMaguntia_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 31, 10, 1, -30 },
  { 32, 15, 12, 17, 1, -30 },
  { 55, 19, 24, 22, 1, -27 },
  { 112, 15, 34, 18, 1, -32 },
  { 176, 28, 30, 30, 1, -30 },
  { 281, 22, 26, 24, 1, -26 },
  { 353, 6, 12, 8, 1, -30 },
  { 362, 9, 34, 10, 1, -33 },
  { 401, 9, 34, 10, 1, -33 },
  { 440, 14, 16, 15, 0, -31 },
  { 468, 13, 15, 17, 2, -21 },
  { 493, 7, 11, 8, 0, -6 },
  { 503, 12, 9, 13, 1, -17 },
  { 517, 7, 7, 8, 1, -6 },
  { 524, 20, 33, 22, 1, -31 },
  { 607, 18, 30, 20, 1, -30 },
  { 675, 13, 29, 13, 0, -29 },
  { 723, 17, 28, 19, 1, -28 },
  { 783, 18, 29, 20, 1, -29 },
  { 849, 19, 29, 19, 0, -29 },
  { 918, 18, 30, 20, 1, -30 },
  { 986, 17, 30, 19, 1, -30 },
  { 1050, 17, 29, 18, 1, -29 },
  { 1112, 18, 30, 20, 1, -30 },
  { 1180, 17, 30, 19, 1, -30 },
  { 1244, 7, 21, 8, 1, -20 },
  { 1263, 8, 25, 7, 0, -20 },
  { 1288, 12, 16, 12, 0, -20 },
  { 1312, 14, 9, 16, 1, -17 },
  { 1328, 12, 16, 12, 0, -20 },
  { 1352, 16, 31, 19, 1, -30 },
  { 1414, 24, 26, 26, 1, -20 },
  { 1492, 32, 31, 34, 1, -30 },
  { 1616, 36, 32, 38, 0, -31 },
  { 1760, 27, 32, 29, 1, -31 },
  { 1868, 32, 33, 34, 1, -31 },
  { 2000, 28, 32, 30, 1, -31 },
  { 2112, 30, 36, 32, 1, -31 },
  { 2247, 30, 31, 32, 1, -30 },
  { 2364, 30, 39, 31, 0, -33 },
  { 2511, 27, 36, 29, 1, -31 },
  { 2633, 28, 41, 30, 1, -31 },
  { 2777, 32, 31, 34, 1, -30 },
  { 2901, 22, 31, 24, 1, -30 },
  { 2987, 44, 31, 46, 1, -29 },
  { 3158, 35, 31, 37, 1, -30 },
  { 3294, 30, 31, 32, 1, -30 },
  { 3411, 36, 37, 37, 1, -30 },
  { 3578, 32, 33, 33, 1, -30 },
  { 3710, 37, 31, 39, 1, -30 },
  { 3854, 30, 30, 32, 1, -30 },
  { 3967, 30, 30, 31, 1, -30 },
  { 4080, 28, 32, 30, 1, -29 },
  { 4192, 35, 32, 37, 1, -31 },
  { 4332, 43, 31, 45, 1, -30 },
  { 4499, 28, 32, 30, 1, -31 },
  { 4611, 34, 38, 36, 1, -31 },
  { 4773, 26, 36, 28, 1, -31 },
  { 4890, 6, 33, 8, 1, -31 },
  { 4915, 26, 29, 4, -8, -27 },
  { 5010, 6, 33, 8, 1, -31 },
  { 5035, 15, 12, 18, 1, -30 },
  { 5058, 19, 3, 19, 0, 5 },
  { 5066, 6, 7, 21, 7, -29 },
  { 5072, 18, 23, 19, 1, -22 },
  { 5124, 17, 30, 19, 1, -29 },
  { 5188, 13, 22, 15, 1, -21 },
  { 5224, 17, 30, 19, 1, -29 },
  { 5288, 13, 22, 15, 1, -21 },
  { 5324, 12, 38, 10, 0, -31 },
  { 5381, 18, 31, 20, 1, -22 },
  { 5451, 17, 36, 19, 1, -29 },
  { 5528, 10, 30, 11, 1, -29 },
  { 5566, 12, 38, 10, -2, -30 },
  { 5623, 12, 30, 14, 1, -29 },
  { 5668, 12, 30, 11, 1, -29 },
  { 5713, 28, 23, 30, 1, -22 },
  { 5794, 19, 23, 21, 1, -22 },
  { 5849, 16, 23, 17, 0, -22 },
  { 5895, 18, 33, 19, 0, -25 },
  { 5970, 16, 31, 18, 1, -22 },
  { 6032, 13, 23, 15, 1, -22 },
  { 6070, 16, 27, 18, 1, -26 },
  { 6124, 11, 28, 13, 1, -27 },
  { 6163, 19, 23, 21, 1, -22 },
  { 6218, 18, 25, 19, 0, -24 },
  { 6275, 27, 26, 29, 1, -25 },
  { 6363, 15, 31, 17, 1, -22 },
  { 6422, 18, 32, 20, 1, -25 },
  { 6494, 12, 30, 14, 1, -22 },
  { 6539, 11, 34, 14, 1, -33 },
  { 6586, 3, 35, 7, 2, -33 },
  { 6600, 11, 34, 14, 1, -33 },
  { 6647, 13, 3, 15, 1, -14 },
};

const GFXfont UnifrakturMaguntia_Regular42pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular42pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular42pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR42PT7B_H_
