#ifndef _UNIFRAKTURMAGUNTIA_REGULAR24PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0x4E, 0xFE, 0x66, 0x64, 0x44, 0x40, 0x04, 0x6F, 0x40, 0x44, 0xE6,
  0x6F, 0x63, 0x22, 0x44, 0x19, 0x83, 0x30, 0x66, 0x7F, 0xFF, 0xFE, 0x26,
  0x0C, 0xC1, 0x98, 0xFF, 0xDF, 0xF8, 0xCC, 0x19, 0x02, 0x20, 0xCC, 0x00,
  0x10, 0x10, 0x3C, 0x62, 0x43, 0xC3, 0xE3, 0xF0, 0x7C, 0x3E, 0x1F, 0xC7,
  0xC3, 0xC3, 0xC3, 0x46, 0x38, 0x10, 0x10, 0x78, 0x03, 0x98, 0x0B, 0x30,
  0x36, 0x60, 0x4C, 0xC1, 0x19, 0x84, 0x33, 0x10, 0x66, 0x40, 0x79, 0x1C,
  0x06, 0x4C, 0x19, 0x98, 0x23, 0x30, 0x86, 0x62, 0x0C, 0xC8, 0x19, 0xA0,
  0x13, 0x80, 0x3C, 0x0E, 0x01, 0x90, 0x39, 0x03, 0x90, 0x3B, 0x01, 0xC0,
  0x1C, 0xF3, 0xC6, 0x4E, 0x4C, 0xE4, 0xC7, 0x4C, 0x78, 0xE3, 0x9E, 0x3E,
  0x3C, 0xE0, 0x27, 0x73, 0x22, 0x08, 0x42, 0x08, 0x61, 0x86, 0x38, 0xE3,
  0x8E, 0x38, 0x61, 0x86, 0x18, 0x20, 0x81, 0x02, 0x40, 0x81, 0x04, 0x18,
  0x61, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x86, 0x10, 0x42, 0x10, 0x10,
  0x3C, 0xDB, 0x76, 0x1A, 0xF7, 0xFF, 0x5C, 0x38, 0x10, 0x10, 0x10, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x46, 0xF3, 0x22, 0x40, 0x7D, 0x0F, 0xBE, 0x46,
  0xF2, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x00, 0x0E, 0x03, 0x30, 0xC6, 0x38, 0xE7, 0x1C, 0xE1,
  0xDC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xE3, 0x8C,
  0x60, 0x8C, 0x0F, 0x00, 0x08, 0x30, 0xE3, 0xC9, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x0F, 0x3F, 0x1F, 0x0F, 0xE6, 0x3D, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x21, 0x10, 0x4F, 0xF7,
  0xFF, 0xFF, 0x1F, 0x04, 0x79, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x01, 0xC0,
  0xFE, 0x01, 0xC0, 0x1C, 0x03, 0xB0, 0x7E, 0x0C, 0xC1, 0x9C, 0x60, 0xF8,
  0x03, 0x00, 0xE0, 0x2C, 0x05, 0x81, 0x30, 0x46, 0x08, 0xC2, 0x18, 0x83,
  0x1F, 0xFF, 0xFF, 0x81, 0x80, 0x30, 0x0E, 0x01, 0xE0, 0x7E, 0x3F, 0x87,
  0xE0, 0xF0, 0x10, 0x02, 0x00, 0x7E, 0x0F, 0xE1, 0xFE, 0x61, 0xC8, 0x1C,
  0x03, 0x80, 0x76, 0x0F, 0xC1, 0x98, 0x33, 0x8C, 0x1E, 0x00, 0x0F, 0x03,
  0x30, 0xC7, 0x18, 0xE7, 0x0C, 0xE0, 0x1C, 0xC3, 0xEC, 0x71, 0xCE, 0x19,
  0xC3, 0x38, 0x67, 0x0C, 0xE1, 0x8C, 0x61, 0x8C, 0x0E, 0x00, 0x7F, 0xDF,
  0xF4, 0x0A, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x0F, 0x06, 0x11, 0x83, 0x30, 0x66,
  0x0C, 0xF1, 0x0F, 0x41, 0xF8, 0x1F, 0x84, 0x79, 0x07, 0x20, 0x7C, 0x0F,
  0x81, 0x98, 0x33, 0x0C, 0x1F, 0x00, 0x1E, 0x06, 0x70, 0x86, 0x30, 0xE6,
  0x1D, 0xC3, 0xB8, 0x73, 0x0E, 0x71, 0xC6, 0x78, 0x77, 0x00, 0xE6, 0x1C,
  0xE3, 0x1C, 0x61, 0x98, 0x1E, 0x00, 0x27, 0xA0, 0x00, 0x04, 0x6F, 0x20,
  0x27, 0xA0, 0x00, 0x04, 0x6F, 0x32, 0x24, 0x06, 0x18, 0x63, 0x8E, 0x0E,
  0x06, 0x04, 0x06, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE3, 0x0C, 0x30, 0xC0, 0x3E, 0x21, 0xA0, 0xF8, 0x7E, 0x3A, 0x38,
  0x7C, 0x70, 0x60, 0x31, 0x1C, 0x83, 0x80, 0x00, 0x40, 0x30, 0x3C, 0x08,
  0x00, 0x07, 0xE0, 0x70, 0xC3, 0x01, 0x98, 0xFA, 0x66, 0xED, 0x3B, 0xBC,
  0xCC, 0xF3, 0x32, 0xDD, 0xC9, 0x77, 0x46, 0xEE, 0x4C, 0x03, 0x18, 0x30,
  0x1F, 0x80, 0x1F, 0x00, 0x9F, 0xE0, 0xC8, 0x3C, 0xF2, 0x07, 0x9C, 0x80,
  0xE7, 0x20, 0x39, 0xCC, 0x0E, 0x73, 0xC3, 0x1C, 0x78, 0xC7, 0x06, 0x61,
  0xC1, 0x10, 0x70, 0x08, 0x1C, 0x04, 0x07, 0x07, 0xC1, 0xC3, 0xF9, 0xF4,
  0x1F, 0xDE, 0x03, 0xC3, 0x00, 0x00, 0x00, 0x1F, 0x87, 0x81, 0xFF, 0x4E,
  0x1C, 0x7C, 0x78, 0x81, 0xE1, 0xCC, 0x07, 0x0E, 0x40, 0x38, 0x3B, 0x01,
  0xC2, 0x08, 0x0E, 0x7C, 0x22, 0x6F, 0xF0, 0xE2, 0x03, 0xC0, 0x20, 0x0E,
  0x02, 0x00, 0x70, 0x78, 0x03, 0x87, 0xF0, 0x18, 0x07, 0xC0, 0x80, 0x1F,
  0x88, 0x00, 0x7F, 0x80, 0x1F, 0x38, 0x62, 0xFD, 0x84, 0x63, 0x10, 0x0E,
  0x60, 0x1C, 0xE0, 0x3B, 0xE0, 0x73, 0xE0, 0xE3, 0xE1, 0xC3, 0xC3, 0xC3,
  0xC7, 0x83, 0x07, 0x84, 0x07, 0x90, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xE1, 0xF8, 0xE1, 0x1F, 0x20,
  0x81, 0xE8, 0x70, 0x3A, 0x1E, 0x06, 0x87, 0xC1, 0xE0, 0xF8, 0x38, 0x1E,
  0x0D, 0x93, 0x83, 0x18, 0x40, 0x80, 0x20, 0x20, 0xF0, 0x10, 0xFF, 0x04,
  0x47, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x38, 0x62, 0xFD, 0x86,
  0x63, 0x10, 0x0E, 0x60, 0x1C, 0xE0, 0x39, 0xEF, 0xF3, 0xFF, 0xE3, 0xED,
  0xC3, 0xE3, 0xC3, 0xC7, 0x83, 0x07, 0x84, 0x07, 0x90, 0x0F, 0xC0, 0x0F,
  0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xE4, 0xC0, 0xFE,
  0x60, 0x2E, 0x10, 0x11, 0x04, 0x0C, 0x01, 0x03, 0x84, 0x40, 0xF3, 0x90,
  0x3F, 0xF2, 0x07, 0x90, 0x7C, 0xF0, 0x00, 0x1C, 0x07, 0x07, 0x80, 0xC0,
  0xE0, 0x38, 0x38, 0x1C, 0x0C, 0x07, 0x03, 0x00, 0xC1, 0x80, 0x38, 0xC0,
  0x03, 0xE0, 0x00, 0x0F, 0x18, 0x18, 0x5E, 0x0C, 0x37, 0x8C, 0x21, 0xEE,
  0x70, 0x67, 0x38, 0x43, 0x9C, 0x79, 0xCF, 0x7E, 0xE3, 0xC7, 0x70, 0xE3,
  0xF8, 0x78, 0xFE, 0x1C, 0x77, 0x0C, 0x33, 0xC4, 0x18, 0xE4, 0x18, 0x38,
  0x08, 0x07, 0x98, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x5E, 0x00, 0x47, 0x80, 0x41, 0x00, 0x60, 0x00, 0x38, 0x38, 0x1C,
  0x3E, 0x0F, 0x7F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x38, 0x1E, 0x1C,
  0x07, 0x0E, 0x61, 0x87, 0x78, 0x83, 0x5F, 0x81, 0x87, 0x81, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x07, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x30, 0xF8, 0x20,
  0x7E, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x30, 0x20, 0x38, 0x30, 0x38, 0x0D,
  0xBC, 0x02, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x3C,
  0x06, 0x7E, 0x06, 0x8F, 0x04, 0x07, 0xC8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0xF8, 0x0C, 0x3E, 0x04, 0x0F, 0xC6, 0x00, 0xC2, 0x00, 0xC1, 0x00, 0xE0,
  0x40, 0x70, 0x20, 0x38, 0x0C, 0x5E, 0x01, 0xC7, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x8F,
  0x00, 0x8F, 0xC0, 0xC8, 0xF0, 0x40, 0x3E, 0x40, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x60, 0x20, 0x18, 0x02, 0x07, 0x3E, 0x20, 0xCD, 0xE4, 0x1A, 0x1C,
  0xC3, 0xC3, 0xD8, 0x78, 0x3F, 0x0F, 0x02, 0x40, 0xF1, 0x90, 0x1E, 0xFC,
  0x01, 0xE7, 0x00, 0x1C, 0x70, 0x61, 0x8E, 0x1E, 0x21, 0xE5, 0xF8, 0x1F,
  0x1E, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0, 0xC1, 0x8C, 0x0E, 0x60, 0x37,
  0x01, 0xBC, 0x0C, 0xF0, 0xE7, 0x86, 0x1D, 0xC0, 0xE0, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x1F, 0x01, 0xFC, 0x21, 0xFE, 0x07, 0xE0, 0x1E, 0x1C, 0x38,
  0x1F, 0xDF, 0xBE, 0x1F, 0xF3, 0xE3, 0x90, 0x78, 0xF1, 0xC8, 0x1E, 0x38,
  0xF4, 0x07, 0x0C, 0x3E, 0x01, 0x87, 0x19, 0x00, 0xE3, 0x88, 0xFC, 0x61,
  0x88, 0x1E, 0x30, 0xCC, 0x01, 0x18, 0x66, 0x00, 0x0C, 0x37, 0x00, 0x04,
  0x13, 0x80, 0xC2, 0x08, 0xE1, 0xF2, 0xE8, 0x7B, 0x3E, 0xF8, 0x1E, 0x0E,
  0x9C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x07, 0xF9, 0xF8, 0xFF,
  0xD3, 0xC8, 0x3E, 0x1C, 0x81, 0xE1, 0xC8, 0x0E, 0x1E, 0x80, 0x60, 0xC8,
  0x07, 0x18, 0xFC, 0x61, 0x03, 0xC6, 0x30, 0x04, 0x67, 0x00, 0x06, 0x70,
  0x00, 0x47, 0x01, 0x84, 0x70, 0x7C, 0x83, 0xE9, 0xF0, 0x3C, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x06, 0x0F, 0x84,
  0x01, 0xE6, 0x00, 0x7B, 0x80, 0x1D, 0xF0, 0x06, 0xFE, 0x03, 0x1F, 0x01,
  0x83, 0x80, 0xC0, 0x40, 0x63, 0x40, 0x23, 0xE0, 0x13, 0xF8, 0x10, 0x3F,
  0x30, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x01, 0x01, 0xFC, 0x18, 0x18,
  0xF3, 0xC0, 0x83, 0xEF, 0x08, 0x0E, 0x7C, 0x40, 0x71, 0xF2, 0x03, 0x87,
  0xC8, 0x0C, 0x0E, 0x22, 0x60, 0x38, 0xE3, 0x01, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x20, 0x06, 0x01, 0x00, 0xF8, 0x10, 0x0F, 0xE1, 0x00, 0x8F, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0C, 0x1F, 0x02,
  0x00, 0xF0, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xE0, 0x0C, 0x7F, 0x01, 0x83,
  0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xC1, 0xA0, 0xD0, 0x7C, 0x3E, 0x3F,
  0xDB, 0xD8, 0x7F, 0x7E, 0x03, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0x01, 0xFC, 0x7C, 0x1F, 0xF4, 0x71, 0x83, 0xC3, 0xC8, 0x0E,
  0x1E, 0x40, 0x30, 0x7A, 0x01, 0xC1, 0x10, 0x0E, 0x30, 0x80, 0x33, 0x03,
  0x11, 0xFC, 0x07, 0x0C, 0xE0, 0x00, 0x47, 0x80, 0x06, 0x3C, 0x0C, 0x20,
  0xE0, 0xF2, 0x07, 0x8B, 0xF0, 0x3F, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xF8, 0x86, 0x7F, 0x84, 0x07, 0x84, 0x00, 0x02, 0x00, 0x03, 0x00, 0xF1,
  0x11, 0xFC, 0xC7, 0xF1, 0x61, 0xE0, 0xB0, 0x40, 0x5C, 0x00, 0x2F, 0x00,
  0x13, 0xE0, 0x18, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x10, 0x7E, 0x10, 0x0F, 0xA8, 0x33, 0xE4, 0x18, 0x62, 0x1E,
  0x01, 0x07, 0x80, 0x4B, 0xE0, 0x18, 0xF0, 0x00, 0x3C, 0x0F, 0x0C, 0x0F,
  0xCC, 0x00, 0xF0, 0x00, 0x3E, 0x08, 0x0F, 0xC8, 0x01, 0xF8, 0x00, 0x06,
  0x01, 0x0C, 0x83, 0x0C, 0x47, 0x86, 0x27, 0x83, 0x81, 0xC1, 0xE0, 0xE0,
  0xF8, 0x70, 0x3C, 0x38, 0x0E, 0x1C, 0x03, 0x0E, 0x01, 0x07, 0x01, 0x03,
  0x81, 0x81, 0xC1, 0xE0, 0xE1, 0xF8, 0xF9, 0x1F, 0x9E, 0x07, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xF0, 0x7F, 0xB7, 0x8C, 0x3E, 0x38,
  0x81, 0xE3, 0xC8, 0x0E, 0x1E, 0x80, 0xE1, 0x08, 0x06, 0x10, 0x80, 0x63,
  0x04, 0x6C, 0x38, 0x38, 0x83, 0xC0, 0x10, 0x1E, 0x06, 0x00, 0xE0, 0xF8,
  0x0E, 0x3F, 0xC0, 0x40, 0x3E, 0x08, 0x01, 0xF9, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x8C, 0x78, 0x1F, 0xE9, 0xDE, 0x1C, 0xF8, 0x87, 0x88,
  0x1E, 0x41, 0xC4, 0x07, 0x60, 0xF4, 0x03, 0xB8, 0x31, 0x00, 0xDC, 0x10,
  0x80, 0x6F, 0x18, 0x23, 0x23, 0x8E, 0x0E, 0x30, 0xE7, 0x80, 0x10, 0x71,
  0xE0, 0x10, 0x30, 0x70, 0xF0, 0x18, 0x18, 0xFE, 0x0E, 0x08, 0x8F, 0x8F,
  0x84, 0x03, 0xFB, 0xE4, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x87,
  0x4F, 0xE3, 0xCE, 0x7B, 0xE4, 0x0D, 0x02, 0x07, 0x01, 0x03, 0x80, 0x80,
  0xC0, 0x20, 0xFE, 0x06, 0xFE, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x25, 0xC0, 0x7A, 0xFA, 0x3E, 0x3E, 0x27, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xE3, 0xE1, 0xFE, 0x9E, 0x61, 0xF1, 0xC8, 0x1E, 0x3D, 0x01,
  0xC3, 0xA0, 0x38, 0x7C, 0x03, 0x0C, 0x80, 0x63, 0x0C, 0xD8, 0xE0, 0x63,
  0x1E, 0x00, 0x43, 0xC0, 0x10, 0x3C, 0x04, 0x07, 0x80, 0xC4, 0x70, 0x3F,
  0x8E, 0x1B, 0xE1, 0xC0, 0x38, 0x38, 0x40, 0x06, 0x04, 0x01, 0x80, 0x60,
  0x60, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x60, 0xF0, 0x80, 0xE1,
  0x00, 0xC2, 0x01, 0x86, 0x06, 0x06, 0x08, 0x00, 0x78, 0x07, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xBE, 0x03, 0xBE, 0x04,
  0x1E, 0x10, 0x1F, 0x40, 0x1F, 0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xF0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x08, 0x06,
  0x07, 0x86, 0x66, 0x16, 0x04, 0xFF, 0xFF, 0xFC, 0xD9, 0x92, 0x08, 0x07,
  0x02, 0xF1, 0x1C, 0xC3, 0x31, 0xCC, 0x73, 0x1C, 0xE7, 0x39, 0xC7, 0xBC,
  0xCC, 0x41, 0x00, 0x04, 0x5C, 0x38, 0x0C, 0x06, 0x03, 0x11, 0x9C, 0xFE,
  0x63, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0B, 0xC8, 0x78, 0x18, 0x08, 0x00,
  0x1C, 0x79, 0x3E, 0x6C, 0x18, 0x30, 0x60, 0xE1, 0xC1, 0xF9, 0xC2, 0x00,
  0x40, 0x40, 0x20, 0x1E, 0x0F, 0xC3, 0xF0, 0x3C, 0x6F, 0x63, 0xB0, 0xD8,
  0x6C, 0x36, 0x1B, 0x0F, 0xE4, 0x7C, 0x18, 0x00, 0x1C, 0x79, 0x36, 0x7C,
  0x7B, 0x38, 0x60, 0xE1, 0xC1, 0xF9, 0xC2, 0x00, 0x00, 0x7C, 0xF2, 0x04,
  0x0C, 0x3F, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40,
  0x81, 0x02, 0x04, 0x00, 0x08, 0x07, 0x82, 0xF9, 0x0C, 0xC1, 0x30, 0xCC,
  0x33, 0x0C, 0xE3, 0x38, 0xE7, 0x79, 0xEE, 0x41, 0x80, 0x6C, 0x11, 0x88,
  0x3C, 0x00, 0x07, 0x26, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0xC3, 0x78, 0xEE,
  0x31, 0xCC, 0x73, 0x1C, 0xC3, 0x30, 0xCC, 0x33, 0x09, 0xF6, 0x11, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x00, 0x10, 0xE3, 0x08, 0x00, 0x87, 0xAE, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0x18, 0x00, 0x18, 0x38, 0x60, 0x01, 0x06,
  0x0F, 0x6C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61,
  0xAE, 0x00, 0x07, 0x11, 0x69, 0xB3, 0xE7, 0x1F, 0xD8, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0E, 0xBE, 0x18, 0x00, 0x07, 0x31, 0x61, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0xBE, 0x18, 0x00, 0x00, 0x00,
  0xC6, 0x63, 0xFF, 0xF7, 0x9C, 0xF7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7B, 0xDE, 0x72, 0x10, 0xC0, 0x42,
  0x1C, 0xE3, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E,
  0x73, 0xC7, 0x10, 0xE0, 0x00, 0x06, 0x3F, 0x19, 0xCC, 0x76, 0x3B, 0x0D,
  0x86, 0xC3, 0x61, 0x7D, 0x0F, 0x03, 0x00, 0x00, 0x40, 0x30, 0x0F, 0x11,
  0xDE, 0x3B, 0x8C, 0x73, 0x0C, 0xC3, 0x30, 0xCC, 0x37, 0x0B, 0xF4, 0xBE,
  0x0F, 0x03, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x04, 0x03, 0x81, 0x7C,
  0x8E, 0x63, 0x98, 0xEE, 0x3B, 0x8E, 0x63, 0x9C, 0xE3, 0xF8, 0x46, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x32, 0x77, 0xBB, 0x3A, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3A, 0x7C, 0x08, 0x00, 0x06, 0x02, 0x60, 0x08, 0x32,
  0x3F, 0x91, 0xC4, 0x21, 0x88, 0x77, 0x0E, 0xE2, 0x18, 0x86, 0x79, 0x0F,
  0x80, 0xC0, 0x04, 0x10, 0x61, 0xC7, 0xF6, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xAF, 0x86, 0x00, 0x61, 0x1C, 0x73, 0xCF, 0x39, 0xC7, 0x38, 0xE7,
  0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0x7B, 0xF7, 0x08, 0xC0, 0x00, 0x40, 0x10,
  0x4C, 0x33, 0x9E, 0xFB, 0xDC, 0x73, 0x1C, 0xC3, 0x10, 0xC4, 0x33, 0x08,
  0xE4, 0x7E, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x8C, 0x27, 0xBD, 0xE7,
  0xBD, 0xCE, 0x31, 0xDC, 0x63, 0xB8, 0xC3, 0x71, 0x86, 0xE3, 0x09, 0xC6,
  0x33, 0x9E, 0x47, 0x9F, 0x04, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x8E,
  0xEB, 0xF1, 0x90, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xC7, 0x84, 0xC4,
  0x02, 0x00, 0x84, 0x37, 0x06, 0x00, 0x60, 0x08, 0x01, 0xC4, 0x3F, 0xC3,
  0x9C, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x1C, 0x67, 0xC8,
  0x33, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x21, 0xEF, 0x86, 0x10, 0x86,
  0xFE, 0x3D, 0x78, 0xE3, 0x8E, 0x38, 0xE2, 0xF0, 0x02, 0x18, 0x61, 0xC3,
  0x87, 0x06, 0x0C, 0x10, 0xC2, 0x80, 0x81, 0x83, 0x0E, 0x1C, 0x38, 0x30,
  0x30, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x40, 0xC1, 0x87,
  0x0E, 0x0C, 0x18, 0x18, 0x38, 0xC3, 0x87, 0x0E, 0x0C, 0x18, 0x20, 0x86,
  0x00, 0xFF, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 8, 6, 10, 1, -17 },
  { 16, 11, 14, 12, 1, -15 },
  { 36, 8, 19, 10, 1, -18 },
  { 55, 15, 17, 17, 1, -17 },
  { 87, 12, 15, 14, 1, -15 },
  { 110, 4, 6, 5, 0, -17 },
  { 113, 6, 20, 6, 0, -19 },
  { 128, 6, 20, 6, 0, -19 },
  { 143, 8, 9, 8, 0, -18 },
  { 152, 8, 8, 10, 1, -12 },
  { 160, 4, 7, 4, 0, -4 },
  { 164, 6, 4, 7, 1, -9 },
  { 167, 4, 4, 5, 0, -4 },
  { 169, 11, 19, 13, 1, -18 },
  { 196, 11, 17, 11, 0, -17 },
  { 220, 7, 16, 8, 0, -16 },
  { 234, 10, 16, 11, 0, -16 },
  { 254, 11, 16, 11, 0, -16 },
  { 276, 11, 16, 11, 0, -16 },
  { 298, 11, 17, 11, 0, -17 },
  { 322, 11, 17, 11, 0, -17 },
  { 346, 10, 16, 10, 0, -16 },
  { 366, 11, 17, 11, 0, -17 },
  { 390, 11, 17, 11, 0, -17 },
  { 414, 4, 11, 5, 0, -11 },
  { 420, 4, 14, 4, 0, -11 },
  { 427, 7, 9, 7, 0, -11 },
  { 435, 8, 6, 9, 1, -10 },
  { 441, 7, 9, 7, 0, -11 },
  { 449, 9, 17, 11, 1, -17 },
  { 469, 14, 14, 15, 0, -11 },
  { 494, 18, 18, 20, 1, -17 },
  { 535, 21, 17, 21, 0, -17 },
  { 580, 15, 17, 16, 1, -17 },
  { 612, 18, 19, 19, 1, -18 },
  { 655, 15, 17, 17, 1, -17 },
  { 687, 18, 21, 18, 0, -18 },
  { 735, 17, 18, 18, 1, -17 },
  { 774, 17, 22, 18, 0, -19 },
  { 821, 16, 20, 16, 0, -17 },
  { 861, 17, 23, 17, 0, -17 },
  { 910, 19, 18, 19, 0, -17 },
  { 953, 13, 17, 14, 0, -17 },
  { 981, 25, 18, 27, 1, -17 },
  { 1038, 20, 18, 21, 1, -17 },
  { 1083, 17, 18, 18, 1, -17 },
  { 1122, 21, 21, 21, 0, -17 },
  { 1178, 19, 19, 19, 0, -17 },
  { 1224, 21, 17, 22, 1, -17 },
  { 1269, 17, 17, 18, 1, -17 },
  { 1306, 17, 17, 18, 1, -17 },
  { 1343, 17, 18, 17, 0, -17 },
  { 1382, 20, 19, 21, 1, -18 },
  { 1430, 25, 17, 26, 0, -17 },
  { 1484, 17, 18, 17, 0, -18 },
  { 1523, 19, 22, 21, 1, -18 },
  { 1576, 15, 20, 16, 0, -17 },
  { 1614, 4, 19, 4, 0, -18 },
  { 1624, 15, 17, 3, -5, -16 },
  { 1656, 4, 19, 4, 0, -18 },
  { 1666, 9, 6, 10, 0, -17 },
  { 1673, 11, 2, 11, 0, 3 },
  { 1676, 3, 5, 12, 4, -17 },
  { 1678, 10, 13, 11, 1, -12 },
  { 1695, 9, 18, 11, 1, -17 },
  { 1716, 7, 13, 9, 1, -12 },
  { 1728, 9, 17, 11, 1, -17 },
  { 1748, 7, 13, 9, 1, -12 },
  { 1760, 7, 22, 6, 0, -18 },
  { 1780, 10, 17, 11, 1, -12 },
  { 1802, 10, 21, 11, 0, -17 },
  { 1829, 6, 18, 7, 0, -17 },
  { 1843, 7, 21, 6, -1, -17 },
  { 1862, 7, 18, 8, 0, -17 },
  { 1878, 7, 18, 7, 0, -17 },
  { 1894, 15, 13, 17, 1, -13 },
  { 1919, 11, 13, 12, 1, -12 },
  { 1937, 9, 13, 10, 0, -12 },
  { 1952, 10, 19, 11, 0, -14 },
  { 1976, 10, 17, 10, 0, -12 },
  { 1998, 8, 13, 9, 0, -12 },
  { 2011, 10, 15, 10, 0, -15 },
  { 2030, 7, 16, 7, 0, -15 },
  { 2044, 11, 13, 12, 1, -12 },
  { 2062, 10, 14, 11, 0, -14 },
  { 2080, 15, 15, 17, 1, -14 },
  { 2109, 9, 18, 9, 0, -13 },
  { 2130, 11, 18, 11, 0, -14 },
  { 2155, 6, 17, 8, 1, -13 },
  { 2168, 7, 20, 8, 0, -19 },
  { 2186, 2, 20, 4, 1, -19 },
  { 2191, 7, 20, 8, 0, -19 },
  { 2209, 7, 2, 9, 1, -8 },
};

const GFXfont UnifrakturMaguntia_Regular24pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular24pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular24pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR24PT7B_H_
