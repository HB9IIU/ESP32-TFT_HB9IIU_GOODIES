#ifndef _UNIFRAKTURMAGUNTIA_REGULAR54PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x03, 0x01, 0xE0, 0xFC, 0x7F, 0x9F, 0xF7, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x0C, 0x07, 0x83, 0xF9, 0xFE, 0x1F, 0x03,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x60, 0x70, 0x0C, 0x1F, 0x03,
  0xC7, 0xF1, 0xFE, 0xFF, 0x3F, 0xC7, 0xE1, 0xF8, 0x78, 0x1F, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x40, 0x10, 0x10, 0x06,
  0x06, 0x00, 0x80, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xE0,
  0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x78, 0x38, 0x1C, 0x07, 0x0E, 0x00, 0xE7, 0x80,
  0x39, 0xE0, 0x0F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x3D, 0xF8, 0x0E,
  0x7F, 0x01, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xD8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0x70, 0x03, 0x9C, 0x01, 0xE3, 0x80, 0x70, 0x70, 0x78, 0x07, 0xFC, 0x00,
  0x7C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0x00, 0x00, 0x06, 0x1E, 0x78,
  0x00, 0x00, 0xC3, 0xC3, 0xC0, 0x00, 0x18, 0x3C, 0x3C, 0x00, 0x03, 0x87,
  0xC3, 0xE0, 0x00, 0x70, 0x7C, 0x3E, 0x00, 0x0E, 0x07, 0xC3, 0xE0, 0x01,
  0xC0, 0x7C, 0x3F, 0x00, 0x18, 0x0F, 0xC3, 0xF0, 0x03, 0x00, 0xFC, 0x3F,
  0x00, 0x60, 0x07, 0xC3, 0xF0, 0x0C, 0x00, 0x7C, 0x3E, 0x01, 0xC0, 0x07,
  0xC3, 0xE0, 0x38, 0x00, 0x7C, 0x3E, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0xE0,
  0x00, 0x3C, 0x3C, 0x0C, 0x00, 0x01, 0xE7, 0x81, 0x80, 0x00, 0x0F, 0xF0,
  0x30, 0x3E, 0x00, 0x3C, 0x07, 0x0F, 0xF8, 0x00, 0x00, 0xE1, 0xE3, 0xC0,
  0x00, 0x1C, 0x3E, 0x3C, 0x00, 0x03, 0x83, 0xC3, 0xE0, 0x00, 0x30, 0x7C,
  0x1E, 0x00, 0x06, 0x07, 0xC1, 0xF0, 0x00, 0xC0, 0x7C, 0x1F, 0x00, 0x18,
  0x07, 0xC1, 0xF0, 0x03, 0x80, 0x7C, 0x1F, 0x00, 0x70, 0x07, 0xC1, 0xF0,
  0x0E, 0x00, 0x7C, 0x1F, 0x01, 0xC0, 0x07, 0xC1, 0xF0, 0x18, 0x00, 0x7C,
  0x1E, 0x03, 0x00, 0x03, 0xC3, 0xE0, 0x60, 0x00, 0x3E, 0x3C, 0x0E, 0x00,
  0x01, 0xE3, 0xC1, 0xC0, 0x00, 0x0F, 0xF8, 0x18, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7E, 0x1E, 0x00, 0x07, 0xE1, 0xE0, 0x00,
  0x3E, 0x3C, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0x70, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFC,
  0x0F, 0xFC, 0x07, 0x81, 0xEF, 0xE0, 0x30, 0x3C, 0xFE, 0x03, 0x03, 0x87,
  0xF0, 0x20, 0x78, 0x7F, 0x06, 0x0F, 0x87, 0xF8, 0x60, 0xF8, 0x3F, 0x84,
  0x0F, 0x83, 0xFC, 0xC0, 0xF8, 0x1F, 0xCC, 0x0F, 0x81, 0xFF, 0x80, 0xFC,
  0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x27, 0xE0, 0x3F,
  0xC7, 0x7F, 0x03, 0xFF, 0xC3, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x7F, 0x80,
  0x7F, 0x81, 0xE0, 0x00, 0x08, 0x1C, 0x3E, 0x7F, 0xFF, 0x3F, 0x1F, 0x0F,
  0x0E, 0x0E, 0x0C, 0x0C, 0x08, 0x10, 0x00, 0x20, 0x0E, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x70, 0x08, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x1D, 0xFE, 0x3E, 0x79, 0xF7, 0xCC, 0xF9, 0xF3, 0x3E,
  0x7E, 0xDF, 0x98, 0xFC, 0x64, 0x1E, 0x09, 0xFF, 0xFE, 0x7E, 0xDF, 0x9F,
  0x33, 0xEF, 0x8E, 0x7C, 0x67, 0xD0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x08, 0x06,
  0x07, 0x8F, 0xE7, 0xF8, 0xFC, 0x3C, 0x1E, 0x07, 0x03, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x00, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFC, 0x00, 0x08, 0x0C,
  0x0F, 0x0F, 0xEF, 0xF1, 0xF0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC7, 0xC0, 0x07,
  0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x07,
  0x83, 0xE0, 0x03, 0xC7, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0xC7, 0xE0, 0x87, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3E, 0x0F, 0xF8, 0xE0, 0x1F, 0xE7, 0x00, 0x3F, 0x98, 0x00, 0x7F, 0x60,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x40, 0x70, 0x01, 0x03, 0x80, 0x04, 0x1C, 0x00, 0x10,
  0xE0, 0x00, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0xE0, 0xFF, 0x83, 0x80, 0x7F, 0x84, 0x00, 0x7F,
  0x10, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFB, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x1F,
  0x7E, 0x00, 0x3C, 0x7C, 0x00, 0x70, 0xFC, 0x01, 0xC0, 0xF8, 0x07, 0x00,
  0xF8, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x37, 0xC0, 0x00, 0xCF, 0x80, 0x03, 0x1F, 0x00, 0x06,
  0x3E, 0x00, 0x18, 0x7C, 0x00, 0x30, 0xF8, 0x00, 0xC1, 0xF0, 0x03, 0x03,
  0xE0, 0x06, 0x07, 0xC0, 0x18, 0x0F, 0x80, 0x60, 0x1F, 0x00, 0xC0, 0x3E,
  0x03, 0x00, 0x7C, 0x04, 0x00, 0xF8, 0x18, 0x01, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1C, 0x00, 0x30, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0x7E,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x8F, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x1F, 0xF1,
  0xC0, 0x0F, 0xE3, 0x00, 0x0F, 0xE4, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF3, 0x00, 0x03, 0xEF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0x78, 0xFC, 0x00, 0xE1, 0xF8, 0x03, 0x81, 0xF0, 0x0E,
  0x01, 0xF0, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x87,
  0xC0, 0x0E, 0x0F, 0xC0, 0x38, 0x0F, 0x80, 0x70, 0x1F, 0x81, 0xE0, 0x3F,
  0x07, 0xC0, 0x7F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x60,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xE0, 0x1F,
  0x8F, 0xF0, 0x3F, 0x3F, 0xF0, 0x7E, 0xFF, 0xF1, 0xFD, 0x87, 0xF3, 0xFE,
  0x07, 0xE7, 0xFC, 0x0F, 0xEF, 0xF0, 0x0F, 0xDF, 0xE0, 0x1F, 0xBF, 0xC0,
  0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E,
  0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xC0, 0x3C, 0x07, 0x00,
  0x3C, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xC0,
  0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x87, 0x00, 0x3C, 0x03, 0x80,
  0xF0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x1F, 0x00, 0x0E, 0x3E,
  0x00, 0x1C, 0x7C, 0x00, 0x38, 0xF8, 0x00, 0x71, 0xF8, 0x00, 0xE3, 0xF8,
  0x03, 0xC3, 0xFC, 0x07, 0x07, 0xFE, 0x1C, 0x07, 0xFE, 0x70, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xE3, 0xFF, 0x83, 0x81, 0xFF, 0x0E, 0x01, 0xFF, 0x3C, 0x00, 0xFE,
  0x70, 0x00, 0xFD, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x70,
  0x00, 0x3C, 0xF0, 0x00, 0xF0, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x70,
  0x38, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3E, 0x0F, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF9, 0xF8, 0x0F, 0xF3,
  0xF8, 0x17, 0xE7, 0xF0, 0x6F, 0xC7, 0xFF, 0x9F, 0x87, 0xFE, 0x3F, 0x07,
  0xF8, 0xFE, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00,
  0xF0, 0x7E, 0x01, 0xC0, 0xFC, 0x07, 0x80, 0xF8, 0x0E, 0x00, 0xF8, 0x18,
  0x00, 0xF8, 0x60, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x07, 0xCF,
  0xF3, 0xF8, 0xF0, 0x30, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x03, 0x03, 0xC3, 0xFB, 0xFC, 0x7C, 0x1C, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x7C, 0x7F, 0x8F, 0xE1, 0xE0, 0x30,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x30, 0x1E, 0x1F, 0xC7, 0xF8, 0x7E, 0x0F, 0x03, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xE0, 0xF8, 0x38, 0x07,
  0xC7, 0x00, 0x3E, 0xE0, 0x03, 0xEE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x08,
  0x1E, 0x00, 0x81, 0xE0, 0x18, 0x0F, 0x01, 0x00, 0x78, 0x60, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x1C, 0x3C, 0x03, 0xEF, 0x1C, 0xF0, 0x0F, 0xFE, 0x39, 0xE0, 0x7C,
  0xF8, 0x73, 0xC1, 0xF1, 0xF0, 0xEF, 0x07, 0xC3, 0xE1, 0xDE, 0x0F, 0x07,
  0x83, 0xBC, 0x3E, 0x0F, 0x0E, 0x78, 0xF8, 0x3E, 0x1C, 0xF1, 0xF0, 0x78,
  0x39, 0xE3, 0xE1, 0xF0, 0xE3, 0xC7, 0x83, 0xE3, 0xC7, 0x8F, 0x0F, 0xC7,
  0x0F, 0x1F, 0x3F, 0x3C, 0x0E, 0x3F, 0xDF, 0xF1, 0xDC, 0x3E, 0x1F, 0x83,
  0xBC, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x7F, 0xFF,
  0xC0, 0x07, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x18, 0x07, 0xFE, 0x07,
  0xF8, 0x0C, 0x00, 0x7F, 0xC7, 0xFE, 0x02, 0x00, 0x0F, 0xF8, 0x7F, 0x81,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x60, 0x00, 0x7F, 0x83, 0xF8, 0x30, 0x00,
  0x0F, 0xE0, 0xFC, 0x0C, 0x00, 0x03, 0xFC, 0x3F, 0x03, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x3C, 0x00, 0x07, 0xE0, 0xFC,
  0x07, 0x80, 0x01, 0xF8, 0x3F, 0x01, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x7F,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0xFC, 0x01, 0xFF, 0x01,
  0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x3C, 0x03,
  0xF0, 0x00, 0x1C, 0x1E, 0x00, 0xFC, 0x00, 0x07, 0x07, 0x00, 0x3F, 0x00,
  0x01, 0x83, 0x80, 0x0F, 0xC0, 0x00, 0x41, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFC, 0x1B, 0xFC, 0xC0, 0x03, 0xFF, 0x9C, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x02, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0xE7, 0xFC, 0x00,
  0xFF, 0xFF, 0xF3, 0x07, 0xF8, 0x03, 0xFC, 0xFF, 0xF4, 0x07, 0xF8, 0x0F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x78,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC1, 0xC0,
  0x00, 0x3F, 0x80, 0x3F, 0x83, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xC6, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x18, 0x00,
  0x01, 0xF8, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x7F, 0x80, 0x70, 0x00, 0x0F, 0x83, 0xFF, 0xC0, 0xE0, 0x06,
  0x1F, 0x1F, 0xFF, 0xC0, 0xF0, 0x0C, 0x3C, 0xFF, 0xFF, 0xC0, 0xFC, 0xE0,
  0x70, 0x03, 0xFF, 0x80, 0x3F, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x67, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x60, 0x00,
  0x1F, 0xB8, 0x1F, 0x00, 0x07, 0x80, 0x87, 0xF8, 0x01, 0xE0, 0x19, 0xFF,
  0xF0, 0x7C, 0x01, 0xFF, 0xFC, 0x0F, 0x00, 0x3F, 0xFF, 0x03, 0xE0, 0x1C,
  0x0F, 0x80, 0xF8, 0x06, 0x00, 0x60, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xFF, 0x00,
  0x78, 0x00, 0x1F, 0xF0, 0x0E, 0x00, 0x03, 0xFE, 0x03, 0x80, 0x00, 0x3F,
  0xF0, 0xC0, 0x00, 0x03, 0xFF, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xFF, 0x87, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0x00, 0x20, 0xFF, 0xE0, 0x3E, 0x00, 0x70, 0x1F, 0xF8,
  0x3E, 0x00, 0x70, 0x07, 0xFE, 0x1E, 0x00, 0x70, 0x00, 0xFF, 0x0E, 0x00,
  0x78, 0x00, 0x3F, 0xCF, 0x00, 0x7E, 0x00, 0x0F, 0xE7, 0x00, 0x3F, 0x00,
  0x03, 0xFB, 0x80, 0x1F, 0xC0, 0x00, 0xFD, 0xC0, 0x0F, 0xF0, 0x00, 0x7E,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xD8, 0x00,
  0xFF, 0xC0, 0x03, 0xEC, 0x00, 0x3F, 0xF0, 0x00, 0xF6, 0x00, 0x0F, 0xF8,
  0x00, 0x79, 0x80, 0x03, 0xFE, 0x00, 0x3C, 0x60, 0x00, 0xFF, 0x00, 0x1E,
  0x1C, 0x00, 0x3F, 0x80, 0x07, 0x07, 0xDE, 0x0F, 0x80, 0x03, 0x80, 0x7C,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x01, 0xFF,
  0xFC, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xE0,
  0x18, 0x01, 0x81, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x60, 0x00, 0x0F, 0xDE, 0x0F, 0x80, 0x01, 0xE0, 0x21, 0xFE, 0x20, 0x3C,
  0x01, 0x3F, 0xFE, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x78, 0x01, 0xFF, 0xF0,
  0x0F, 0x80, 0x70, 0x3E, 0x01, 0xF0, 0x0E, 0x00, 0xC0, 0x1F, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x78, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFE, 0x03, 0x80,
  0x7E, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0xFF, 0x8F, 0xFB, 0x7E, 0x07, 0xFC,
  0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0x9F, 0xC7, 0xF0,
  0x1F, 0xF8, 0xF8, 0x7F, 0x00, 0xFF, 0xC3, 0x07, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x70, 0x00,
  0x0F, 0xF8, 0x0E, 0x00, 0x00, 0x7F, 0xE1, 0x80, 0x00, 0x03, 0xFF, 0x20,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x07,
  0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x03, 0xFF, 0xF8,
  0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x70, 0x00, 0x0C, 0x7F, 0x01, 0xC0, 0x00,
  0x30, 0x7C, 0x03, 0x80, 0x00, 0xE0, 0x20, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x60, 0xC0, 0x00, 0xFE, 0x01,
  0xE1, 0x80, 0x01, 0xFE, 0x07, 0xE1, 0x80, 0x03, 0xFE, 0x1F, 0xE3, 0x00,
  0x03, 0xFE, 0x3F, 0xE3, 0x00, 0x07, 0xFE, 0xFF, 0x87, 0x00, 0x07, 0xFF,
  0xFE, 0x03, 0x80, 0xCF, 0xFC, 0x78, 0x03, 0xFF, 0x8F, 0xFC, 0x60, 0x00,
  0x60, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x08, 0x00, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x60,
  0xF8, 0x00, 0x0F, 0x80, 0x67, 0xF8, 0x00, 0x3E, 0x00, 0x5F, 0xF8, 0x00,
  0xF8, 0x00, 0xCF, 0xF8, 0x01, 0xE0, 0x03, 0x0F, 0xF8, 0x07, 0xC0, 0x18,
  0x0F, 0xF8, 0x1F, 0x80, 0x60, 0x0F, 0xF8, 0x3E, 0x03, 0xC0, 0x0F, 0xF0,
  0xFC, 0x0F, 0x00, 0x0F, 0x81, 0xF8, 0x3E, 0x00, 0x0E, 0x03, 0xF0, 0x7C,
  0x00, 0x30, 0x0F, 0xE1, 0xFC, 0x01, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xC0,
  0x3F, 0x07, 0xF8, 0x3F, 0xF0, 0x7E, 0x07, 0xF0, 0xFF, 0xF0, 0xFC, 0x0F,
  0xF3, 0xFF, 0xE1, 0xFC, 0x0F, 0xF0, 0x3F, 0xE3, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE7, 0xF0, 0x1F, 0xF0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xBF, 0x80, 0x3F, 0xC0, 0x7F, 0x7F, 0x80, 0x3F, 0xC0,
  0x7E, 0xFF, 0x00, 0x3F, 0x80, 0xFC, 0xFE, 0x00, 0x7F, 0x01, 0xF9, 0xFE,
  0x00, 0x7C, 0x03, 0xF3, 0xFC, 0x00, 0xF8, 0x07, 0xC3, 0xF8, 0x01, 0xE0,
  0x0F, 0x87, 0xF8, 0x07, 0x80, 0x1F, 0x07, 0xF8, 0x0C, 0x00, 0x7C, 0x07,
  0xF0, 0x30, 0x00, 0xF0, 0x07, 0xF0, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x00,
  0x07, 0x80, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x00,
  0x03, 0xFC, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x7F,
  0xC0, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0x80, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0x03, 0xFF,
  0xE0, 0x01, 0xFE, 0x3F, 0xFF, 0xC0, 0x07, 0xFD, 0xC1, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x3C, 0x03, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0x00, 0x1F,
  0x8F, 0xF0, 0x1C, 0x00, 0x7C, 0xFF, 0xE0, 0x60, 0x01, 0xF2, 0x7F, 0xC3,
  0x00, 0x0F, 0x80, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0xC0, 0x00, 0xF0,
  0x03, 0xFC, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0xC0, 0x03, 0xC0, 0x0F,
  0xFE, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x1C, 0x00, 0x0F, 0xFF, 0x03, 0x80,
  0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x78,
  0x00, 0x7F, 0x80, 0x03, 0xC0, 0x4F, 0xF0, 0x00, 0x3F, 0xF4, 0xFF, 0x00,
  0x00, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xFC, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x00,
  0x78, 0xFF, 0xFC, 0x00, 0x0E, 0x31, 0xFF, 0xC0, 0x01, 0xC0, 0x0F, 0xFC,
  0x00, 0x70, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x0F, 0xFE, 0x03, 0x00, 0x00,
  0xFF, 0xF3, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0xF8,
  0x01, 0xE0, 0x01, 0xFF, 0xFC, 0x1C, 0x00, 0x0F, 0xFF, 0x03, 0x80, 0x00,
  0x3F, 0xE0, 0x38, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x01, 0x80, 0x00,
  0x3F, 0x00, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0x00, 0x03, 0xF8, 0x00, 0x1C, 0x06, 0x3F, 0x80, 0x00, 0xFF, 0xC3, 0xFC,
  0x00, 0x01, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x00,
  0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x03, 0x83, 0xFF, 0xC0, 0x00, 0x38, 0x7F,
  0xFE, 0x00, 0x07, 0x08, 0x3F, 0xF0, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x0E,
  0x00, 0x0F, 0xFE, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x60, 0x07, 0x00,
  0x03, 0xC0, 0xFF, 0x00, 0xE0, 0x01, 0xF0, 0x7F, 0xF0, 0x1C, 0x00, 0x78,
  0x3F, 0xFE, 0x07, 0x00, 0x3E, 0x1F, 0xFF, 0xC1, 0xC0, 0x0F, 0x8E, 0x0F,
  0xF8, 0x38, 0x07, 0xE3, 0x01, 0xFE, 0x0E, 0x01, 0xF8, 0x80, 0x3F, 0xC3,
  0x80, 0x7F, 0x20, 0x07, 0xF0, 0xE0, 0x1F, 0xC8, 0x01, 0xFC, 0x38, 0x07,
  0xFA, 0x00, 0x7F, 0xCE, 0x00, 0xFF, 0x80, 0x0F, 0xF3, 0x80, 0x3F, 0xE0,
  0x01, 0xF0, 0xC0, 0x0F, 0xF8, 0x00, 0x30, 0x30, 0x01, 0xFF, 0x00, 0x18,
  0x18, 0x00, 0x7F, 0xE0, 0x1C, 0x0C, 0x00, 0x0F, 0xF8, 0x1F, 0x86, 0x00,
  0x01, 0xFF, 0x1F, 0xF2, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0,
  0x00, 0xC0, 0x3E, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xC0, 0x1F, 0xC0, 0x7F, 0xE0, 0x60, 0x07, 0xF8, 0x3F, 0xFC, 0x30,
  0x01, 0xFF, 0x00, 0xFF, 0xD8, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x3F, 0x80,
  0x01, 0xF1, 0xFC, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x7C, 0x7F, 0x80, 0x03,
  0xE3, 0xFC, 0x00, 0x1F, 0x1F, 0xF0, 0x00, 0xF8, 0x7F, 0xC0, 0x07, 0xC3,
  0xFE, 0x00, 0x7C, 0x0F, 0xF0, 0x07, 0xC0, 0x7F, 0xCF, 0xFC, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x30, 0x1F, 0xFF, 0x03, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xFF,
  0x98, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xC0, 0xE0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0xE0, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xF8,
  0x60, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x20, 0x00, 0x3F, 0xE0, 0x3F,
  0x80, 0xFE, 0x30, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x98, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xCC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xFB, 0x00, 0x00, 0x3F, 0x80, 0x7E,
  0x01, 0xE0, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x60, 0x60, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x60, 0x38, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x60, 0x0F,
  0xFF, 0x80, 0xF8, 0x07, 0xC0, 0x60, 0x03, 0xFF, 0xC0, 0x7C, 0x03, 0xE0,
  0x70, 0x00, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0x78, 0x00, 0x3F, 0xB0, 0x1F,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0x08, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x04, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x03, 0x87, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0xFE,
  0x00, 0x07, 0xE0, 0x19, 0xC0, 0x40, 0x7F, 0x00, 0x0F, 0xF8, 0x19, 0xF0,
  0x60, 0x3F, 0xC0, 0x0F, 0xFE, 0x19, 0xFE, 0x20, 0x0F, 0xF9, 0x8F, 0xFF,
  0x09, 0xFF, 0xE0, 0x03, 0xFF, 0x8C, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFD, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x87, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xC3, 0x07, 0xF0,
  0x1F, 0x8F, 0xFF, 0x30, 0x1F, 0xC0, 0xE0, 0x0F, 0xFD, 0x00, 0xFE, 0x0E,
  0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x60, 0x00, 0x7F, 0xC0, 0x1F, 0xC2, 0x00,
  0x01, 0xFE, 0x00, 0xFE, 0x30, 0x00, 0x0F, 0xF0, 0x07, 0xF1, 0x80, 0x00,
  0x3F, 0x80, 0x3F, 0xCC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x07, 0xF1, 0x00, 0x00, 0x1F, 0x80, 0x1E, 0x08, 0x00, 0x00, 0xFC,
  0x00, 0xE0, 0x60, 0x00, 0x07, 0xE0, 0x0E, 0x03, 0xC7, 0xE0, 0x1F, 0x00,
  0xE0, 0x0F, 0xFF, 0x80, 0xF8, 0x0E, 0x00, 0x3F, 0xFC, 0x07, 0xC0, 0x70,
  0x00, 0xFF, 0xE0, 0x3E, 0x07, 0x00, 0x01, 0xE3, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x08, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x78, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x3F, 0xC0, 0x00, 0x30, 0x03, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x18,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0x80, 0x3F, 0xC0, 0x0F, 0xFE, 0x18, 0x00,
  0xFF, 0xB8, 0xFF, 0xF9, 0xC0, 0x07, 0xFF, 0x84, 0x3F, 0xFC, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x0F,
  0xFF, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0x80, 0x38, 0x00, 0x07, 0xFF, 0x01,
  0xC0, 0x00, 0x07, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x00,
  0x0F, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xF9, 0xFF, 0xC0, 0x00,
  0x03, 0xE7, 0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0xFF, 0xC0, 0x00, 0x1F, 0x1F,
  0xFF, 0x80, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0xC6, 0x00, 0x00, 0x70, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0xFF,
  0x80, 0x00, 0x06, 0x0F, 0xFF, 0x80, 0x00, 0x30, 0x7F, 0xFF, 0x00, 0x01,
  0x82, 0x1F, 0xFF, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x60, 0x00, 0x3F,
  0xFF, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x1F, 0xE0, 0x00, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0x07, 0x00, 0x3F, 0xFC,
  0xFF, 0x00, 0x38, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xC0, 0x00, 0xFF, 0x0F,
  0xFC, 0x03, 0x00, 0x01, 0xFC, 0x1F, 0xF8, 0x0C, 0x00, 0x07, 0xF0, 0x3F,
  0xF0, 0x30, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0xC0, 0x00, 0x3F, 0x80, 0xFF,
  0xC3, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x8C, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x10, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x60, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE1, 0x80, 0x23, 0xF8, 0x00, 0x3F, 0xC3,
  0xC7, 0x87, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x1C, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x1F,
  0xF8, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0x7C, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x81,
  0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xFF,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x1C, 0x40, 0x01, 0xC7, 0x00, 0x3F, 0x80,
  0x03, 0xF3, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0x7F, 0xC1, 0xC3, 0xFF, 0xE2, 0x0F, 0xF1, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x03,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x18, 0x7F, 0x80, 0x1F, 0xFF,
  0xFF, 0x30, 0x3F, 0xC0, 0x3E, 0x03, 0xFF, 0xA0, 0x1F, 0xE0, 0x78, 0x00,
  0xFF, 0xE0, 0x1F, 0xE0, 0x70, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x60, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x60, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0xE0, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0xC0, 0x00,
  0x07, 0xE0, 0x01, 0xE0, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0xF0, 0x07, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x60, 0x00,
  0x03, 0xF0, 0x38, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x38, 0x00,
  0x01, 0xF1, 0xFC, 0x00, 0x1C, 0x01, 0x81, 0xF7, 0xFE, 0x00, 0x07, 0x86,
  0x01, 0xF7, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x00, 0x70,
  0x03, 0x80, 0x3F, 0xC0, 0x00, 0xFC, 0x03, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x06, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x04, 0x00, 0x1F, 0xE0, 0x0F, 0xFF,
  0x8C, 0x00, 0x1F, 0xFB, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xC7, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0xF0, 0x40, 0x3F,
  0xFF, 0xC1, 0xE0, 0x41, 0xFF, 0xFF, 0xC3, 0xC0, 0x7F, 0xFF, 0xE1, 0xCF,
  0x80, 0xFF, 0xFE, 0x00, 0x9F, 0x00, 0xFF, 0xF0, 0x01, 0xBE, 0x00, 0xFF,
  0xC0, 0x01, 0x3E, 0x00, 0xFE, 0x00, 0x02, 0x7C, 0x00, 0x60, 0x00, 0x04,
  0xFC, 0x00, 0x00, 0x00, 0x09, 0xFC, 0x00, 0x00, 0x00, 0x13, 0xFC, 0x00,
  0x00, 0x00, 0x63, 0xFC, 0x00, 0x00, 0x00, 0xC7, 0xFC, 0x00, 0x00, 0x03,
  0x07, 0xFE, 0x00, 0x00, 0x1E, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x03, 0xFF, 0xF8,
  0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x01, 0xFF, 0xF0, 0x18, 0x00,
  0x01, 0xFF, 0xF3, 0x60, 0x00, 0x33, 0xFF, 0xF9, 0x00, 0x03, 0x83, 0xFF,
  0xCC, 0x00, 0x1C, 0x03, 0xFC, 0x30, 0x00, 0xF0, 0x07, 0xE0, 0xC0, 0x07,
  0xE0, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x7F, 0x80, 0x00,
  0x18, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x0F,
  0xFC, 0x00, 0x00, 0xC0, 0x9F, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x78, 0x00, 0x0F, 0xFF, 0x81,
  0xC0, 0x00, 0x7F, 0xFF, 0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x20, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0E, 0x01, 0xC0, 0x80, 0x03, 0x80, 0x78, 0x0C, 0x00,
  0xF8, 0x07, 0x80, 0x40, 0x3F, 0x00, 0xF8, 0x04, 0x0F, 0xF0, 0x1F, 0x80,
  0xC1, 0xFE, 0x01, 0xF8, 0x18, 0x2F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x06, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x37, 0xE0, 0x67, 0xFE, 0x06, 0x7F, 0x08,
  0x1F, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x0C, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x61, 0xFE, 0x00, 0xFF, 0xFF, 0xF9, 0x03, 0xFC, 0x03, 0xC0,
  0x1F, 0xFC, 0x07, 0xF0, 0x1E, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x70, 0x00,
  0x7F, 0x80, 0x7F, 0x83, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x8E, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x30, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0xC0, 0x00, 0x0F,
  0xC0, 0x06, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xFC,
  0x01, 0xC0, 0x18, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0x00, 0x10, 0xF8, 0x07,
  0xE0, 0x07, 0x01, 0x83, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x0E, 0x00, 0xFF,
  0x80, 0x07, 0xC0, 0x38, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x74, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0xC7,
  0xFF, 0xC0, 0x00, 0x70, 0x02, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xFF, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x3C, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x7E, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0xEE, 0x31, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x83, 0x40, 0x7F,
  0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFF, 0x01,
  0x80, 0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0x83, 0x80, 0x1F, 0xE0, 0x78, 0x00,
  0x7F, 0x83, 0x80, 0x0F, 0xE0, 0x70, 0x00, 0x3F, 0x87, 0x80, 0x0F, 0xF0,
  0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x07, 0xF8, 0xE0, 0x00, 0x1F, 0xCF, 0xC0,
  0x07, 0xFC, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0xC0, 0x00, 0x0F,
  0xCF, 0xE0, 0x01, 0xC0, 0x40, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0x80, 0x60,
  0x00, 0x07, 0xCF, 0xF0, 0x03, 0x80, 0x60, 0x00, 0x07, 0xC7, 0xF8, 0x07,
  0x80, 0x20, 0x00, 0x07, 0x87, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x07, 0x83,
  0xFC, 0x0F, 0xC0, 0x18, 0x03, 0x0F, 0x03, 0xFC, 0x1F, 0xE0, 0x0E, 0x0E,
  0x0F, 0x01, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x0E, 0x01, 0xFE, 0x1F, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x7E,
  0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x7C, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0xFE, 0x00,
  0x0E, 0xC0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x3E, 0x03, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x1C, 0x07, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x1C, 0x08, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x18, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x10,
  0x00, 0x03, 0xFF, 0x07, 0xFF, 0xE0, 0x20, 0x00, 0x01, 0xFF, 0xFC, 0x7F,
  0xF8, 0x40, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xE6, 0x1F, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xF0, 0xF8, 0x1F,
  0xF3, 0xFF, 0x8F, 0x00, 0x3F, 0x98, 0xF8, 0x70, 0x00, 0xFC, 0x81, 0x03,
  0x80, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0xFE,
  0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0x04, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0x80, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0x02, 0x7F, 0xFF, 0x80, 0x07, 0xF3,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x2F, 0xE0,
  0x00, 0x00, 0x03, 0x7F, 0x00, 0x00, 0x78, 0x13, 0xFC, 0x00, 0x07, 0xF1,
  0x8F, 0xF8, 0x20, 0x7F, 0xDC, 0x7F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x19, 0xFF, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x73, 0xFE, 0x01, 0xFF, 0xFF, 0xE4, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x03, 0xC0, 0x1F, 0xF8, 0x07, 0xF0, 0x78, 0x00, 0xFF, 0x80, 0x7F,
  0x87, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x8E,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xFE, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x8C, 0x00, 0x00,
  0xFC, 0x00, 0x60, 0x60, 0x00, 0x07, 0x80, 0x0C, 0x06, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x30, 0x00, 0x07, 0x80, 0x78, 0x03, 0x00, 0x10, 0xF8, 0x0F,
  0xC0, 0x1C, 0x06, 0x0F, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0xF0, 0x1F, 0xC0,
  0x00, 0xE0, 0x0F, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x1C, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x18, 0x1F,
  0xE0, 0x00, 0x7F, 0xC3, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x23, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xFF,
  0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x00,
  0xFE, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x07, 0xE0, 0x18, 0x00,
  0x01, 0xF8, 0x06, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x30,
  0x00, 0x07, 0x80, 0x06, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x03, 0xE0,
  0xFE, 0x00, 0x00, 0x78, 0xFF, 0xE0, 0x00, 0x1C, 0x7F, 0xFC, 0x00, 0x0F,
  0x33, 0xFF, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0xE0, 0x07, 0xFC, 0x00,
  0x70, 0x00, 0xFF, 0xC0, 0x38, 0x00, 0x1F, 0xF8, 0x18, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xF9, 0xF0, 0x1F, 0x07, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC7,
  0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF8, 0xF8, 0xFC,
  0x7C, 0x3C, 0x1E, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xCF, 0xFC, 0x03, 0x0F, 0xFC, 0x0C, 0x07, 0xE0, 0x38, 0x07, 0xC0, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x9F, 0xE3, 0xFE, 0x1F, 0xFB, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x07, 0xC0,
  0x3C, 0x0F, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x0C, 0x3C, 0x00, 0x11, 0xE0, 0x00, 0x2F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x08, 0x07, 0xE0, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x7F, 0x81,
  0xFB, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF8, 0x07,
  0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xE1, 0xF8, 0x07, 0x87,
  0xE0, 0x1C, 0x1F, 0x80, 0xF0, 0x7E, 0x03, 0x81, 0xFC, 0x0C, 0x0F, 0xF8,
  0x60, 0x7F, 0xFB, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xFE, 0x00, 0xDF, 0x00, 0xCF, 0xC0, 0xC3, 0xE0, 0xE1, 0xF8, 0xF0, 0x7C,
  0x78, 0x3F, 0x78, 0x08, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x27, 0xF8, 0x01, 0x87, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F,
  0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x1E, 0x1F, 0x80, 0x3C, 0x3F, 0x00, 0x78,
  0x7E, 0x00, 0xF0, 0xFC, 0x01, 0xE1, 0xF8, 0x03, 0x83, 0xF0, 0x07, 0x07,
  0xE0, 0x0C, 0x0F, 0xF0, 0x38, 0x7F, 0xF0, 0x60, 0x3F, 0xF9, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xFE, 0x00, 0xDF, 0x01, 0xCF, 0xC0, 0xC3,
  0xE0, 0xE1, 0xF8, 0xF0, 0xFC, 0x78, 0x3E, 0x78, 0x1F, 0xBC, 0x07, 0xDE,
  0x03, 0xCF, 0x03, 0x07, 0x8E, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFB, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x08, 0x78, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x1C, 0x00, 0x1F, 0x00, 0x3F, 0xFC, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x2F, 0xF8, 0x00, 0x8F, 0xFE, 0x07, 0x07,
  0xFC, 0x1E, 0x07, 0xF0, 0x38, 0x03, 0xE0, 0xF0, 0x03, 0x83, 0xE0, 0x07,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC7, 0xF8, 0x1F, 0xF3, 0xF0, 0x3F, 0x83, 0xE0, 0x38, 0x07, 0xC0, 0x60,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x18, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0x81, 0xF0, 0x0E, 0x01, 0xF0, 0x38,
  0x01, 0xF1, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFC,
  0x08, 0x1E, 0x00, 0x10, 0xF0, 0x00, 0x47, 0x80, 0x00, 0xBE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x10, 0x07, 0xE0, 0xC0, 0x1F, 0x87, 0x80, 0x7E, 0x7E, 0x01, 0xFB, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F,
  0x80, 0xF0, 0xFE, 0x63, 0xC7, 0xFE, 0x1E, 0x07, 0xF8, 0x70, 0x0F, 0x81,
  0xC0, 0x0E, 0x0E, 0x00, 0x10, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x38,
  0x01, 0xE0, 0x1F, 0x81, 0xFF, 0x0F, 0xFC, 0x9F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x90, 0x7E,
  0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x70, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xFC, 0x0B, 0xF8, 0x13, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE8, 0x03,
  0xC4, 0x03, 0x82, 0x07, 0x02, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x78, 0x03, 0x86, 0x0E, 0x06, 0x3C, 0x24, 0xF0, 0xC7, 0xE7, 0x8F, 0xCF,
  0x1F, 0xBE, 0x3F, 0xFC, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC4, 0x7F,
  0xF0, 0xFF, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0xFA, 0x03, 0x86, 0x1E, 0x06, 0x78, 0x04, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC4, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x20,
  0x00, 0x08, 0x01, 0x00, 0x20, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x1F, 0x07,
  0xE0, 0xF8, 0x03, 0xF8, 0xFF, 0x1F, 0xC0, 0x3F, 0x9F, 0xFB, 0xFF, 0xC7,
  0xFF, 0x3F, 0xE7, 0xF8, 0x8F, 0xC1, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x81,
  0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x81,
  0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00,
  0xFC, 0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xFC, 0x1F, 0x11, 0xFE, 0x3F, 0xE1,
  0xFE, 0x3F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0x80,
  0xF0, 0x0F, 0xC0, 0x30, 0x06, 0x00, 0x38, 0x03, 0x00, 0x20, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0xE0, 0xFC,
  0x03, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0xF1, 0x7F, 0x8F, 0xF1, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x7F, 0x03, 0xE0,
  0x7F, 0xC1, 0xFB, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x1F,
  0x80, 0x60, 0x07, 0x80, 0x20, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x03, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0x1F, 0xC0, 0xF8,
  0x7F, 0x07, 0xC3, 0xFC, 0x3E, 0x0F, 0xE1, 0xF0, 0x3F, 0x8F, 0x80, 0xFC,
  0x7C, 0x07, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xC3,
  0xF0, 0x1E, 0x3F, 0xC0, 0xE3, 0xFF, 0x8E, 0x07, 0xFE, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7E, 0x00, 0xC0, 0x7F, 0x01, 0xC0, 0x7F, 0x87, 0xE0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0x81, 0xFC,
  0x0F, 0x81, 0xFC, 0x0F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x0F, 0xC0, 0x3C,
  0x3F, 0xC0, 0x78, 0x7F, 0xE0, 0x70, 0xFF, 0xF8, 0x60, 0xFF, 0xFC, 0xC0,
  0x87, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x9C, 0x00,
  0x07, 0x88, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xBF,
  0xC0, 0x18, 0xFF, 0xC1, 0x83, 0xFF, 0x1C, 0x0F, 0xE1, 0xE0, 0x3F, 0x1E,
  0x01, 0xF8, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8,
  0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xFC, 0x1F, 0x87, 0xF9, 0xFC,
  0x1F, 0xF3, 0xE0, 0xFF, 0x1F, 0x03, 0xE0, 0xF8, 0x0E, 0x07, 0xC0, 0x20,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x01, 0x83, 0xE0, 0x70, 0xFC,
  0x3C, 0x7F, 0x9F, 0x9F, 0xEF, 0xE9, 0xFF, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F,
  0x03, 0xE1, 0x80, 0xF8, 0x40, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x40, 0xFF, 0xE0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x40, 0x10, 0x0E, 0x01, 0x01, 0xF0, 0x30, 0x7F, 0xE7, 0x0F,
  0xFF, 0xF1, 0x8F, 0xFE, 0x30, 0x3F, 0xC7, 0x00, 0xF8, 0x70, 0x02, 0x07,
  0x00, 0x60, 0xF8, 0x0E, 0x0F, 0xC1, 0xF0, 0x7E, 0x3F, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xF0, 0xFE, 0x0E, 0x07, 0xE0, 0xE0, 0x3E, 0x0C, 0x01,
  0xE0, 0x80, 0x0E, 0x3E, 0x00, 0xC7, 0xF8, 0x18, 0xFF, 0xE1, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF8, 0x87, 0xFA,
  0x1F, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x0E, 0x00, 0x30, 0x07, 0x80, 0x3C, 0x07, 0xE0, 0x1F, 0x03, 0xF8,
  0x1F, 0xC3, 0xFC, 0x1F, 0xF2, 0x3E, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0,
  0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xF2, 0x3F, 0xED,
  0xFE, 0x3F, 0xFC, 0xFF, 0x01, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1C,
  0x03, 0x80, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x40, 0x38, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x1F, 0xF8, 0x7F, 0x63, 0xFC, 0x7F, 0x81, 0xFC, 0x3F,
  0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1F, 0x01,
  0xE0, 0x1F, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x3E, 0x01,
  0x80, 0x3C, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x70, 0x07, 0xF0, 0x60, 0x07,
  0xFC, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0x00, 0x18, 0x1F, 0xC0, 0x78, 0x07, 0x03,
  0xFC, 0x1F, 0x81, 0xF0, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF9, 0xFF, 0x7F,
  0xF0, 0x7F, 0x47, 0xF0, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x01, 0xF8, 0x3E,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0xF8, 0x1F, 0x80, 0x7C,
  0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xE0, 0x7E, 0x01, 0xE0, 0x7C, 0x0F, 0xC0,
  0x3C, 0x0F, 0x81, 0xF8, 0x07, 0x81, 0xF0, 0x3F, 0x01, 0xE0, 0x3E, 0x07,
  0xE0, 0x3C, 0x0F, 0xC0, 0xFC, 0x07, 0x01, 0xF8, 0x1F, 0xC1, 0xC0, 0x3F,
  0x07, 0xFE, 0x30, 0x0F, 0xF1, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x06, 0x01, 0x01, 0xE0, 0x30, 0x3F,
  0x0E, 0x0F, 0xE3, 0xE1, 0xFE, 0xFC, 0x4F, 0xFF, 0xC1, 0xFD, 0xF8, 0x1F,
  0x1E, 0x03, 0xE3, 0x80, 0x7C, 0x20, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC2, 0x01, 0xFE,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xC7, 0xC0, 0x30, 0x70,
  0x04, 0x02, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x40, 0xC0, 0x3C, 0x0E, 0x0F, 0xC0, 0x7F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x08, 0x0F, 0xC0, 0x30, 0x1F, 0xE0, 0xF0, 0x3F,
  0xC7, 0xF0, 0x3F, 0x9F, 0xF0, 0x3F, 0xCF, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1E,
  0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xE0, 0xFE, 0x63, 0xC3,
  0xFF, 0x07, 0x01, 0xFC, 0x1C, 0x00, 0xF0, 0x38, 0x00, 0xC0, 0xE0, 0x00,
  0x81, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3B,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x03, 0x06, 0x04, 0x1F, 0x98, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x05, 0xFC, 0x08, 0xFE, 0x18, 0x7E, 0x10, 0x7E, 0x30,
  0x3E, 0x30, 0x3F, 0x60, 0x3F, 0x60, 0x1F, 0x60, 0x1F, 0x60, 0x1E, 0xE0,
  0x1E, 0xE0, 0x1E, 0x60, 0x1E, 0x60, 0x1C, 0x60, 0x38, 0x30, 0x38, 0x30,
  0x30, 0x18, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 10, 40, 13, 1, -39 },
  { 51, 19, 15, 22, 1, -39 },
  { 87, 24, 31, 28, 2, -35 },
  { 180, 18, 43, 23, 2, -41 },
  { 277, 36, 38, 39, 1, -38 },
  { 448, 28, 34, 31, 2, -33 },
  { 567, 8, 15, 11, 1, -39 },
  { 582, 12, 44, 13, 1, -43 },
  { 648, 12, 44, 13, 1, -42 },
  { 714, 18, 20, 19, 0, -40 },
  { 759, 18, 19, 21, 2, -27 },
  { 802, 9, 15, 10, 0, -8 },
  { 819, 15, 10, 16, 1, -21 },
  { 838, 9, 9, 11, 1, -8 },
  { 849, 26, 42, 28, 1, -40 },
  { 986, 24, 39, 25, 1, -38 },
  { 1103, 16, 37, 17, 1, -37 },
  { 1177, 22, 37, 24, 1, -37 },
  { 1279, 23, 37, 25, 1, -37 },
  { 1386, 23, 37, 25, 1, -37 },
  { 1493, 23, 38, 25, 1, -38 },
  { 1603, 23, 38, 25, 1, -38 },
  { 1713, 22, 37, 23, 1, -37 },
  { 1815, 23, 38, 25, 1, -38 },
  { 1925, 23, 38, 25, 1, -38 },
  { 2035, 9, 27, 11, 1, -26 },
  { 2066, 10, 33, 9, 0, -26 },
  { 2108, 15, 20, 16, 0, -25 },
  { 2146, 19, 12, 21, 1, -22 },
  { 2175, 15, 20, 16, 0, -25 },
  { 2213, 20, 39, 25, 2, -38 },
  { 2311, 31, 32, 33, 1, -25 },
  { 2435, 42, 39, 44, 1, -38 },
  { 2640, 47, 40, 48, 0, -39 },
  { 2875, 35, 40, 37, 1, -39 },
  { 3050, 41, 41, 44, 1, -39 },
  { 3261, 36, 40, 38, 1, -39 },
  { 3441, 39, 47, 41, 1, -40 },
  { 3671, 39, 40, 42, 1, -39 },
  { 3866, 38, 49, 40, 1, -42 },
  { 4099, 35, 46, 37, 1, -39 },
  { 4301, 36, 53, 38, 1, -39 },
  { 4540, 42, 39, 44, 1, -38 },
  { 4745, 29, 39, 31, 1, -38 },
  { 4887, 57, 41, 60, 1, -38 },
  { 5180, 45, 39, 48, 1, -38 },
  { 5400, 38, 40, 41, 1, -39 },
  { 5590, 46, 47, 48, 1, -38 },
  { 5861, 41, 43, 43, 1, -39 },
  { 6082, 48, 40, 50, 1, -39 },
  { 6322, 39, 40, 41, 1, -39 },
  { 6517, 38, 39, 40, 1, -38 },
  { 6703, 36, 41, 39, 1, -38 },
  { 6888, 46, 40, 48, 1, -39 },
  { 7118, 56, 40, 58, 1, -39 },
  { 7398, 37, 40, 39, 1, -39 },
  { 7583, 44, 48, 46, 1, -40 },
  { 7847, 34, 46, 36, 1, -39 },
  { 8043, 7, 43, 10, 1, -40 },
  { 8081, 33, 38, 6, -10, -35 },
  { 8238, 7, 43, 10, 1, -40 },
  { 8276, 20, 14, 23, 1, -38 },
  { 8311, 25, 4, 25, 0, 6 },
  { 8324, 8, 10, 27, 9, -38 },
  { 8334, 23, 30, 25, 1, -28 },
  { 8421, 22, 39, 24, 1, -37 },
  { 8529, 17, 28, 19, 1, -27 },
  { 8589, 23, 39, 25, 1, -38 },
  { 8702, 17, 28, 20, 1, -27 },
  { 8762, 16, 48, 13, 0, -39 },
  { 8858, 23, 39, 25, 1, -28 },
  { 8971, 22, 47, 24, 1, -38 },
  { 9101, 13, 39, 15, 1, -38 },
  { 9165, 16, 48, 13, -3, -38 },
  { 9261, 15, 39, 18, 1, -38 },
  { 9335, 15, 39, 15, 1, -38 },
  { 9409, 36, 29, 38, 1, -28 },
  { 9540, 25, 29, 27, 1, -28 },
  { 9631, 21, 29, 22, 0, -28 },
  { 9708, 24, 43, 24, 0, -32 },
  { 9837, 21, 39, 23, 1, -28 },
  { 9940, 18, 29, 20, 1, -28 },
  { 10006, 20, 35, 23, 1, -34 },
  { 10094, 15, 36, 17, 1, -35 },
  { 10162, 25, 29, 27, 1, -28 },
  { 10253, 24, 32, 24, -1, -31 },
  { 10349, 35, 33, 37, 1, -32 },
  { 10494, 19, 39, 21, 1, -28 },
  { 10587, 23, 41, 25, 1, -32 },
  { 10705, 16, 38, 18, 1, -28 },
  { 10781, 15, 43, 18, 1, -42 },
  { 10862, 3, 45, 9, 3, -42 },
  { 10879, 15, 43, 18, 1, -42 },
  { 10960, 18, 4, 20, 1, -18 },
};

const GFXfont UnifrakturMaguntia_Regular54pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular54pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular54pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR54PT7B_H_
