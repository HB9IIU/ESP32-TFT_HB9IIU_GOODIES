#ifndef _UNIFRAKTURMAGUNTIA_REGULAR9PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0x3A, 0x8C, 0xF4, 0x76, 0xF0, 0x4E, 0xBB, 0x50, 0x42, 0x9A, 0x97,
  0x2D, 0x38, 0xC0, 0x23, 0x97, 0x69, 0x3C, 0xE0, 0xEA, 0xAC, 0x95, 0x58,
  0x5F, 0x80, 0x5D, 0x20, 0xC0, 0x38, 0xC0, 0x08, 0x88, 0x44, 0x22, 0x00,
  0x65, 0x99, 0x95, 0x60, 0x59, 0x25, 0xC0, 0x69, 0x12, 0x5F, 0x79, 0x25,
  0x96, 0x2E, 0xAF, 0x27, 0x78, 0x69, 0x96, 0x65, 0x8F, 0x9D, 0x60, 0xFA,
  0x22, 0x44, 0xF9, 0xE9, 0x96, 0x69, 0x99, 0x7A, 0x60, 0xC3, 0xC2, 0x80,
  0x64, 0xFC, 0x98, 0x69, 0x96, 0x66, 0x20, 0x32, 0x6F, 0xBF, 0xC5, 0xC0,
  0xF7, 0x2B, 0x53, 0x22, 0x4F, 0xC0, 0x24, 0xDA, 0x93, 0x96, 0x61, 0x31,
  0x5E, 0x21, 0x7A, 0x2C, 0xD9, 0x43, 0xC0, 0x10, 0xFA, 0x9D, 0x9B, 0x2C,
  0x7F, 0x00, 0x21, 0x7A, 0x2F, 0xD9, 0x43, 0xC0, 0x79, 0x3E, 0x54, 0xF6,
  0x89, 0x92, 0x18, 0x7D, 0x6A, 0xF6, 0x95, 0x47, 0x80, 0x01, 0xE4, 0x9F,
  0x26, 0x56, 0x46, 0x72, 0x78, 0xA2, 0x68, 0x1E, 0x4E, 0x72, 0x78, 0xA2,
  0x68, 0x10, 0x79, 0x38, 0x3C, 0xFD, 0x99, 0xC1, 0x5C, 0xC0, 0x7A, 0x54,
  0x84, 0x5C, 0x7F, 0xA6, 0xA8, 0xAD, 0xAC, 0x15, 0x1F, 0x30, 0x7E, 0x9A,
  0xCB, 0x2C, 0x14, 0x63, 0x39, 0x8B, 0x11, 0x24, 0x57, 0x00, 0xFC, 0x96,
  0x93, 0x71, 0x12, 0x6E, 0x10, 0x00, 0x39, 0x8B, 0x11, 0x24, 0xD7, 0xC0,
  0x00, 0x00, 0x7E, 0x8B, 0x8C, 0x6A, 0x12, 0x73, 0x7D, 0x03, 0x75, 0x94,
  0x47, 0x00, 0x71, 0x3E, 0x82, 0x80, 0x9E, 0x0F, 0x00, 0x6D, 0x26, 0x92,
  0x4A, 0xF0, 0x00, 0x00, 0xFE, 0x92, 0x92, 0x72, 0x73, 0x1C, 0x7F, 0xCA,
  0x65, 0x4E, 0x56, 0x48, 0xD8, 0x01, 0xF9, 0x27, 0x70, 0x66, 0xC0, 0x00,
  0xFE, 0x92, 0x94, 0x76, 0x22, 0x1A, 0x7E, 0x39, 0x28, 0x96, 0x2C, 0x1E,
  0x8C, 0xFE, 0x04, 0x21, 0x08, 0x42, 0x00, 0xFE, 0x4B, 0xF0, 0xC0, 0x4B,
  0xAA, 0x70, 0xE6, 0x75, 0x5E, 0x56, 0x46, 0x86, 0x55, 0x5E, 0x57, 0x46,
  0x73, 0x25, 0x24, 0x80, 0x4B, 0xAA, 0x71, 0xE0, 0xE6, 0x65, 0x5E, 0x48,
  0x6D, 0x50, 0x65, 0x56, 0xEB, 0xA5, 0x80, 0xE9, 0x25, 0x80, 0xA9, 0x55,
  0x55, 0x74, 0xAD, 0x55, 0x50, 0x2E, 0xAB, 0x40, 0xA7, 0x55, 0xE8, 0x80,
  0x4B, 0xAA, 0x62, 0x20, 0xBD, 0x2E, 0x47, 0xAE, 0xA4, 0x4B, 0xA5, 0xC0,
  0xAD, 0x55, 0x70, 0xAF, 0x59, 0xE0, 0x89, 0xD5, 0x55, 0x58, 0xAD, 0x27,
  0x18, 0xA5, 0x55, 0x62, 0xC0, 0x5B, 0xDB, 0x80, 0x69, 0x44, 0x98, 0xFE,
  0x89, 0x14, 0xB0, 0xE0,
};

const GFXglyph UnifrakturMaguntia_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 4, 3, 5, 0, -5 },
  { 6, 3, 7, 4, 0, -7 },
  { 9, 6, 7, 6, 0, -7 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 2, 2, 2, 0, -6 },
  { 20, 2, 7, 2, 0, -7 },
  { 22, 2, 7, 2, 0, -7 },
  { 24, 3, 3, 3, 0, -6 },
  { 26, 3, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 3, 2, 3, 0, -4 },
  { 30, 2, 1, 2, 0, -1 },
  { 31, 5, 7, 5, 0, -7 },
  { 36, 4, 7, 4, 0, -7 },
  { 40, 3, 6, 3, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 4, 7, 4, 0, -7 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 2, 5, 2, 0, -4 },
  { 72, 2, 3, 3, 0, -4 },
  { 73, 3, 2, 3, 0, -4 },
  { 74, 2, 3, 3, 0, -4 },
  { 75, 4, 7, 4, 0, -7 },
  { 79, 5, 7, 5, 0, -5 },
  { 84, 7, 6, 7, 0, -6 },
  { 90, 8, 7, 8, 0, -7 },
  { 97, 6, 7, 6, 0, -7 },
  { 103, 7, 7, 7, 0, -7 },
  { 110, 6, 7, 6, 0, -7 },
  { 116, 7, 8, 7, 0, -7 },
  { 123, 7, 6, 7, 0, -6 },
  { 129, 6, 8, 7, 0, -7 },
  { 135, 6, 8, 6, 0, -7 },
  { 141, 6, 9, 6, 0, -7 },
  { 148, 7, 6, 7, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 10, 6, 10, 0, -6 },
  { 166, 8, 6, 8, 0, -6 },
  { 172, 7, 6, 7, 0, -6 },
  { 178, 8, 8, 8, 0, -6 },
  { 186, 7, 7, 7, 0, -6 },
  { 193, 8, 7, 8, 0, -7 },
  { 200, 7, 6, 7, 0, -6 },
  { 206, 7, 7, 7, 0, -7 },
  { 213, 6, 7, 6, 0, -6 },
  { 219, 8, 7, 8, 0, -7 },
  { 226, 9, 6, 10, 0, -6 },
  { 233, 6, 7, 6, 0, -7 },
  { 239, 8, 8, 8, 0, -7 },
  { 247, 6, 8, 6, 0, -7 },
  { 253, 1, 7, 2, 0, -7 },
  { 254, 6, 6, 1, -2, -6 },
  { 259, 1, 7, 2, 0, -7 },
  { 260, 4, 2, 4, 0, -6 },
  { 261, 4, 1, 4, 0, 1 },
  { 262, 2, 1, 5, 1, -6 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 4, 6, 4, 0, -6 },
  { 269, 3, 5, 3, 0, -5 },
  { 271, 4, 6, 4, 0, -6 },
  { 274, 3, 5, 3, 0, -5 },
  { 276, 3, 9, 2, 0, -7 },
  { 280, 4, 7, 4, 0, -5 },
  { 284, 4, 8, 4, 0, -6 },
  { 288, 2, 6, 2, 0, -6 },
  { 290, 2, 8, 2, 0, -6 },
  { 292, 3, 6, 3, 0, -6 },
  { 295, 3, 6, 2, 0, -6 },
  { 298, 6, 5, 6, 0, -5 },
  { 302, 4, 5, 5, 0, -5 },
  { 305, 4, 5, 4, 0, -5 },
  { 308, 4, 7, 4, 0, -5 },
  { 312, 4, 7, 4, 0, -5 },
  { 316, 3, 5, 3, 0, -5 },
  { 318, 4, 6, 4, 0, -6 },
  { 321, 3, 6, 3, 0, -6 },
  { 324, 4, 5, 5, 0, -5 },
  { 327, 4, 5, 4, 0, -5 },
  { 330, 6, 5, 6, 0, -5 },
  { 334, 3, 7, 4, 0, -5 },
  { 337, 4, 7, 4, 0, -5 },
  { 341, 3, 6, 3, 0, -4 },
  { 344, 3, 7, 3, 0, -7 },
  { 347, 1, 7, 1, 0, -7 },
  { 348, 3, 7, 3, 0, -7 },
  { 351, 3, 1, 3, 0, -3 },
};

const GFXfont UnifrakturMaguntia_Regular9pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular9pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular9pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR9PT7B_H_
