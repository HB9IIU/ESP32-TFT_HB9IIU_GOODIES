#ifndef _UNIFRAKTURMAGUNTIA_REGULAR8PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xBA, 0x30, 0xD4, 0x00, 0x6F, 0x6F, 0x57, 0x3A, 0x80, 0x4E, 0x74,
  0x75, 0xCC, 0x66, 0x5B, 0xF0, 0xC0, 0xEA, 0xB0, 0x95, 0x60, 0x5D, 0x80,
  0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x4A, 0x99, 0xAE, 0x75,
  0xC0, 0xE4, 0xBE, 0x4A, 0x26, 0x1E, 0x2E, 0xA7, 0x60, 0xAC, 0x69, 0x1E,
  0x6A, 0xAE, 0xAE, 0xE5, 0x24, 0x6A, 0x6A, 0x9E, 0x4A, 0xAA, 0x6E, 0x90,
  0x98, 0x64, 0xE0, 0x98, 0x75, 0xC6, 0xC0, 0x37, 0xBB, 0xFF, 0x00, 0x66,
  0x79, 0x59, 0x44, 0xF0, 0x6D, 0x2A, 0x5B, 0x52, 0x2B, 0x80, 0x6D, 0xA9,
  0x25, 0x3C, 0x33, 0xBA, 0x65, 0x67, 0xE0, 0x6D, 0xAB, 0x25, 0x3C, 0x72,
  0x79, 0xA5, 0x69, 0x27, 0x00, 0x6A, 0xFA, 0xA5, 0x55, 0xE0, 0x31, 0x45,
  0x8B, 0x27, 0xA1, 0x00, 0x74, 0xE4, 0xF0, 0xA6, 0xC0, 0x72, 0x69, 0x1E,
  0x08, 0x24, 0xAC, 0x19, 0xF6, 0xCB, 0x3B, 0x90, 0x2D, 0x56, 0x4F, 0x6A,
  0x5A, 0xA5, 0x6A, 0xC1, 0x63, 0xCC, 0x65, 0x7A, 0x5A, 0xA1, 0x4C, 0xC0,
  0x13, 0xE8, 0x59, 0x4B, 0xE0, 0x69, 0x7A, 0x5A, 0x91, 0x2F, 0x84, 0x00,
  0x13, 0xE8, 0x59, 0x4B, 0xF0, 0x00, 0x25, 0xBE, 0x55, 0x65, 0x4C, 0xC0,
  0x13, 0xB8, 0xAD, 0xC5, 0xE0, 0x62, 0x7A, 0x14, 0xD0, 0xE0, 0x4A, 0xE4,
  0x9A, 0x4B, 0xE0, 0x00, 0x6D, 0x2A, 0x5B, 0x22, 0x2B, 0x80, 0x6A, 0x9D,
  0x9A, 0x75, 0x65, 0x3F, 0x6E, 0xC9, 0x1E, 0x11, 0xE0, 0x6D, 0x2A, 0x5B,
  0xA2, 0x46, 0x9F, 0x00, 0x36, 0x54, 0x70, 0xE4, 0xC0, 0xFC, 0x08, 0x88,
  0x88, 0x00, 0xFC, 0x56, 0x80, 0xF0, 0xC0, 0x4A, 0xA7, 0x52, 0xFA, 0x80,
  0x56, 0x30, 0x8C, 0x2E, 0xB6, 0x57, 0x30, 0x6E, 0xA8, 0x6A, 0xA6, 0x2C,
  0x3A, 0xFB, 0xD0, 0xBE, 0x90, 0x9E, 0xAC, 0x7E, 0xB0, 0x6A, 0xB0, 0xFB,
  0x5A, 0xF0, 0xA7, 0x6D, 0xD6, 0xA0, 0x97, 0xD5, 0x20, 0x56, 0xB2, 0x40,
  0xA9, 0x60, 0x6F, 0x54, 0x75, 0xC0, 0xA7, 0x6D, 0x97, 0xDC, 0x87, 0x5E,
  0xD5, 0x00, 0x79, 0x38, 0xC0, 0x8E, 0x55, 0xE4, 0x7F, 0xC0, 0x5A, 0x50,
  0xFC, 0x95, 0x60, 0xE0,
};

const GFXglyph UnifrakturMaguntia_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 3, 3, 0, -6 },
  { 5, 4, 4, 4, 0, -5 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 5, 6, 6, 0, -6 },
  { 14, 4, 5, 5, 0, -5 },
  { 17, 1, 3, 2, 0, -6 },
  { 18, 2, 6, 2, 0, -6 },
  { 20, 2, 6, 2, 0, -6 },
  { 22, 3, 3, 3, 0, -6 },
  { 24, 3, 3, 3, 0, -4 },
  { 26, 1, 2, 1, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 4, 6, 4, 0, -6 },
  { 32, 4, 6, 4, 0, -6 },
  { 35, 2, 5, 3, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 3, 5, 3, 0, -5 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 1, 4, 2, 0, -4 },
  { 60, 1, 5, 1, 0, -4 },
  { 61, 2, 3, 2, 0, -4 },
  { 62, 3, 1, 3, 0, -3 },
  { 63, 2, 3, 2, 0, -4 },
  { 64, 3, 6, 4, 0, -6 },
  { 67, 5, 5, 5, 0, -4 },
  { 71, 6, 6, 7, 0, -6 },
  { 76, 7, 6, 7, 0, -6 },
  { 82, 5, 6, 6, 0, -6 },
  { 86, 6, 6, 6, 0, -6 },
  { 91, 5, 6, 6, 0, -6 },
  { 95, 6, 7, 6, 0, -6 },
  { 101, 6, 6, 6, 0, -6 },
  { 106, 6, 7, 6, 0, -6 },
  { 112, 5, 7, 5, 0, -6 },
  { 117, 6, 8, 6, 0, -6 },
  { 123, 6, 6, 7, 0, -6 },
  { 128, 4, 6, 5, 0, -6 },
  { 131, 9, 6, 9, 0, -6 },
  { 138, 7, 6, 7, 0, -6 },
  { 144, 6, 6, 6, 0, -6 },
  { 149, 7, 7, 7, 0, -6 },
  { 156, 6, 7, 6, 0, -6 },
  { 162, 7, 6, 7, 0, -6 },
  { 168, 6, 6, 6, 0, -6 },
  { 173, 6, 6, 6, 0, -6 },
  { 178, 6, 7, 6, 0, -6 },
  { 184, 7, 6, 7, 0, -6 },
  { 190, 8, 6, 9, 0, -6 },
  { 196, 6, 6, 6, 0, -6 },
  { 201, 7, 7, 7, 0, -6 },
  { 208, 5, 7, 5, 0, -6 },
  { 213, 1, 6, 1, 0, -6 },
  { 214, 5, 5, 1, -2, -5 },
  { 218, 1, 6, 1, 0, -6 },
  { 219, 3, 3, 3, 0, -6 },
  { 221, 4, 1, 4, 0, 1 },
  { 222, 1, 2, 4, 1, -6 },
  { 223, 4, 4, 4, 0, -4 },
  { 225, 3, 6, 4, 0, -6 },
  { 228, 3, 4, 3, 0, -4 },
  { 230, 4, 6, 4, 0, -6 },
  { 233, 3, 4, 3, 0, -4 },
  { 235, 2, 7, 2, 0, -6 },
  { 237, 4, 6, 4, 0, -4 },
  { 240, 3, 7, 4, 0, -6 },
  { 243, 2, 6, 2, 0, -6 },
  { 245, 2, 7, 2, 0, -6 },
  { 247, 2, 6, 3, 0, -6 },
  { 249, 2, 6, 2, 0, -6 },
  { 251, 5, 4, 6, 0, -4 },
  { 254, 4, 4, 4, 0, -4 },
  { 256, 3, 4, 3, 0, -4 },
  { 258, 3, 7, 4, 0, -5 },
  { 261, 3, 6, 3, 0, -4 },
  { 264, 3, 4, 3, 0, -4 },
  { 266, 3, 5, 3, 0, -5 },
  { 268, 2, 5, 2, 0, -5 },
  { 270, 4, 4, 4, 0, -4 },
  { 272, 3, 5, 4, 0, -5 },
  { 274, 5, 5, 6, 0, -5 },
  { 278, 3, 6, 3, 0, -4 },
  { 281, 4, 6, 4, 0, -5 },
  { 284, 2, 5, 3, 0, -4 },
  { 286, 2, 6, 3, 0, -6 },
  { 288, 1, 6, 1, 0, -6 },
  { 289, 2, 6, 3, 0, -6 },
  { 291, 3, 1, 3, 0, -3 },
};

const GFXfont UnifrakturMaguntia_Regular8pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular8pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular8pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR8PT7B_H_
