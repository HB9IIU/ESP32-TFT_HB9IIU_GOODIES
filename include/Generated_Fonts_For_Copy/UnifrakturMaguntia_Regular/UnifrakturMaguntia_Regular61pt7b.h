#ifndef _UNIFRAKTURMAGUNTIA_REGULAR61PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0x60, 0x0F, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0x7F, 0xE3,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0xF0, 0x1F, 0x83,
  0xFE, 0x7F, 0xC0, 0xF0, 0x06, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x38, 0x03, 0x01, 0xF0, 0x1E, 0x0F, 0xE0, 0xFC, 0x7F, 0xCF, 0xFC, 0xFF,
  0x0F, 0xF0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x0E, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x60, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x07,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xF0,
  0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x7E, 0x00,
  0xF3, 0xFC, 0x03, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xB8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E,
  0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x18, 0x00, 0x78, 0xE0, 0x07, 0x83, 0x80,
  0x78, 0x0F, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x1E,
  0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x7C, 0x3E, 0x00,
  0x00, 0x30, 0x7C, 0x1F, 0x00, 0x00, 0x70, 0xFC, 0x1F, 0x00, 0x00, 0xE0,
  0xFC, 0x1F, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x80, 0x03, 0x80, 0xFC, 0x1F,
  0x80, 0x07, 0x00, 0xFC, 0x1F, 0x80, 0x0E, 0x00, 0xFC, 0x1F, 0x80, 0x0C,
  0x00, 0xFC, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x1F, 0x80, 0x38, 0x00, 0xFC,
  0x1F, 0x00, 0x70, 0x00, 0xFC, 0x1F, 0x00, 0xE0, 0x00, 0x7C, 0x1F, 0x01,
  0xC0, 0x00, 0x7C, 0x3E, 0x03, 0x80, 0x00, 0x3C, 0x3C, 0x07, 0x00, 0x00,
  0x1E, 0x3C, 0x06, 0x00, 0x00, 0x0F, 0xF8, 0x0E, 0x07, 0xC0, 0x03, 0xE0,
  0x1C, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x3C, 0xF8, 0x00, 0x00, 0x70, 0x78,
  0x78, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x00,
  0x01, 0x81, 0xF8, 0x3E, 0x00, 0x03, 0x81, 0xF8, 0x3E, 0x00, 0x07, 0x01,
  0xF8, 0x3F, 0x00, 0x0E, 0x01, 0xF8, 0x3F, 0x00, 0x1C, 0x01, 0xF8, 0x3F,
  0x00, 0x38, 0x01, 0xF8, 0x3F, 0x00, 0x70, 0x01, 0xF8, 0x3F, 0x00, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0xC0, 0x01, 0xF8, 0x3E, 0x01, 0xC0, 0x01, 0xF8,
  0x3E, 0x03, 0x80, 0x00, 0xF8, 0x3E, 0x07, 0x00, 0x00, 0xF8, 0x7C, 0x0E,
  0x00, 0x00, 0x78, 0x7C, 0x1C, 0x00, 0x00, 0x3C, 0xF8, 0x38, 0x00, 0x00,
  0x1F, 0xF0, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x0F, 0xE1,
  0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x1F, 0xCE, 0x00, 0x00, 0x3F, 0xB8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x07,
  0x80, 0xE7, 0xF8, 0x06, 0x03, 0xC7, 0xF0, 0x0C, 0x0F, 0x0F, 0xF0, 0x18,
  0x3E, 0x0F, 0xE0, 0x20, 0x7C, 0x1F, 0xE0, 0xC1, 0xF8, 0x1F, 0xC1, 0x83,
  0xF0, 0x3F, 0xC2, 0x07, 0xE0, 0x3F, 0x8C, 0x0F, 0xC0, 0x7F, 0x98, 0x1F,
  0xC0, 0x7F, 0x60, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x05, 0xFE, 0x01, 0xFE, 0x39, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF1, 0xFE, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x0C, 0x03, 0x01, 0xE0, 0xFC, 0xFF, 0xCF, 0xF1, 0xF8,
  0x3E, 0x07, 0x81, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x80, 0x60, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xCF, 0x98, 0xFC, 0xF3,
  0xF7, 0xC7, 0x3F, 0x7E, 0x63, 0xE7, 0xF6, 0x7E, 0x3F, 0xEF, 0xE2, 0x1F,
  0x82, 0x40, 0xF0, 0x27, 0xFF, 0xFE, 0x7F, 0x2F, 0xE7, 0xE6, 0x7E, 0x7E,
  0x73, 0xFF, 0xC7, 0x3F, 0x0C, 0xFB, 0x80, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x04, 0x03, 0x81, 0xE0, 0xFE, 0x7F, 0xCF, 0xF1, 0xFC, 0x3F,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x40, 0x20, 0x00, 0x1F,
  0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0xFC, 0x00, 0x08, 0x03,
  0x01, 0xE0, 0xFC, 0xFF, 0x9F, 0xF3, 0xE0, 0x70, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0,
  0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3,
  0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xC0,
  0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0C, 0x7F, 0x02, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xF8, 0x3F, 0xF0, 0xF0, 0x07, 0xFC, 0x70,
  0x01, 0xFE, 0x70, 0x00, 0xFF, 0x30, 0x00, 0x3F, 0xD8, 0x00, 0x1F, 0xE8,
  0x00, 0x0F, 0xF4, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x02, 0x01, 0xC0, 0x01, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0xC1,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x38,
  0x1F, 0xF8, 0x1C, 0x01, 0xFF, 0x0C, 0x00, 0x3F, 0xC2, 0x00, 0x07, 0xF1,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0x7F, 0x00,
  0x1E, 0x0F, 0xC0, 0x0F, 0x03, 0xF0, 0x07, 0x80, 0x7F, 0x07, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x37, 0xF0, 0x00,
  0x0D, 0xFC, 0x00, 0x06, 0x7F, 0x00, 0x03, 0x1F, 0xC0, 0x00, 0xC7, 0xF0,
  0x00, 0x61, 0xFC, 0x00, 0x30, 0x7F, 0x00, 0x0C, 0x1F, 0xC0, 0x06, 0x07,
  0xF0, 0x03, 0x81, 0xFC, 0x00, 0xC0, 0x7F, 0x00, 0x60, 0x1F, 0xC0, 0x38,
  0x07, 0xF0, 0x0C, 0x01, 0xFC, 0x06, 0x00, 0x7F, 0x03, 0x80, 0x1F, 0xC0,
  0xC0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x02, 0x01, 0xF0, 0x03, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x1F,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x38, 0x00,
  0xFF, 0x0E, 0x00, 0x0F, 0xE1, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3E, 0x7F, 0x00, 0x07,
  0xC7, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x3C, 0x0F, 0xC0, 0x0F, 0x00, 0xFC,
  0x03, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x1F, 0x80, 0x07,
  0x03, 0xF0, 0x03, 0xC0, 0x7E, 0x01, 0xE0, 0x1F, 0xC0, 0xF8, 0x07, 0xF0,
  0x3E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF0, 0xFC, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xC7, 0xFE, 0x07,
  0xF3, 0x0F, 0xC1, 0xFD, 0x81, 0xF8, 0x7F, 0x40, 0x7F, 0x1F, 0xF0, 0x0F,
  0xCF, 0xF8, 0x03, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x3F, 0xBF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x80, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x07, 0xE0, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x03,
  0xE0, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x1E, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x1F, 0x80, 0x01, 0xC7, 0xE0, 0x00, 0xF1, 0xFC, 0x00, 0x3C,
  0x3F, 0x80, 0x0F, 0x0F, 0xF0, 0x07, 0x83, 0xFF, 0x01, 0xC0, 0xFF, 0xF0,
  0xE0, 0x1F, 0xFE, 0x70, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x6F, 0xFF, 0x00, 0x30, 0xFF, 0xE0,
  0x38, 0x0F, 0xFC, 0x1C, 0x01, 0xFF, 0x0F, 0x00, 0x1F, 0xE3, 0x80, 0x03,
  0xF9, 0xE0, 0x00, 0x7E, 0x78, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xC3, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0xC0, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x1E, 0x07, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0xFF, 0x9F, 0xC0, 0x2F, 0xE3, 0xF8, 0x0B, 0xF8, 0xFE, 0x04, 0xFE, 0x1F,
  0xC2, 0x3F, 0x83, 0xFF, 0x8F, 0xE0, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x70, 0x01,
  0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xC1, 0xFC,
  0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3C, 0x01, 0xF8, 0x0F, 0x00,
  0x7E, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x08, 0x03, 0x01, 0xE0, 0xFC, 0x7F, 0xBF, 0xF3, 0xF0, 0x78, 0x0C,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x03, 0x01, 0xE0, 0xFC, 0xFF, 0x9F, 0xF3, 0xE0, 0x70,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x3C, 0x0F, 0xC3, 0xFC, 0xFF, 0xC7,
  0xE0, 0x78, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x07, 0x81, 0xFC,
  0x7F, 0xC7, 0xF8, 0x7F, 0x07, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x10, 0x04, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7C, 0x0F, 0xC1, 0xE0,
  0x0F, 0xC7, 0x80, 0x0F, 0xCE, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xE1, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x60, 0x3C, 0x00, 0x80, 0x7C, 0x03, 0x00, 0x78,
  0x04, 0x00, 0xFC, 0x38, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x03, 0x83, 0xE0, 0x07, 0xDE, 0x38, 0x3C, 0x01, 0xFF,
  0xE3, 0xC7, 0xC0, 0x7C, 0xFE, 0x3C, 0x78, 0x0F, 0x87, 0xC3, 0xC7, 0x81,
  0xF0, 0x7C, 0x3C, 0xF8, 0x1F, 0x07, 0xC3, 0xCF, 0x83, 0xE0, 0xF8, 0x3C,
  0xF0, 0x7E, 0x0F, 0x83, 0xCF, 0x07, 0xC0, 0xF8, 0x38, 0xF0, 0xFC, 0x1F,
  0x07, 0x8F, 0x0F, 0x81, 0xF0, 0x78, 0xF0, 0xF8, 0x3F, 0x0F, 0x0F, 0x0F,
  0x87, 0xF1, 0xF0, 0xF0, 0xF8, 0xFE, 0x1E, 0x07, 0x8F, 0x9F, 0xE7, 0xC0,
  0x78, 0xFF, 0xFF, 0xF8, 0xE7, 0x87, 0xFB, 0xFF, 0x1E, 0x38, 0x3E, 0x1F,
  0xC1, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xF0, 0x7F, 0xFC, 0x01, 0xFC, 0x03,
  0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x0E, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x18,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x60, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0xC0,
  0x00, 0x1F, 0xF0, 0x7F, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0xFE, 0x07, 0x00,
  0x00, 0x3F, 0xC1, 0xFC, 0x0E, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x1C, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x38, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x38, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x80,
  0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x7E, 0x03, 0xF8, 0x01, 0xFF, 0x80,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x1F, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x7F, 0x00, 0x00, 0x60, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0x81, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x1B, 0xFC, 0x20, 0x00, 0xFF, 0xF8, 0x67,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x30, 0x7F, 0xC0, 0x07, 0xFF,
  0xFF, 0xF9, 0x01, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xD8, 0x07, 0xF8, 0x07,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x3E, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x1E, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFE, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF1, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0xFC, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x07, 0x80,
  0x0C, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x3F,
  0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x87, 0xFF, 0xF8, 0x0F, 0x00, 0x30, 0x78,
  0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0x03, 0xC7, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x67, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xC0,
  0x61, 0xFF, 0x00, 0x1F, 0x00, 0x47, 0xFF, 0xF0, 0x7C, 0x00, 0xDF, 0xFF,
  0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0x8F, 0xF8, 0x0F, 0xC0,
  0x1C, 0x03, 0xE0, 0x1F, 0x80, 0x70, 0x01, 0x80, 0x7E, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x00, 0x3F, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0xF0,
  0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x7F,
  0xFF, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x0C,
  0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x30, 0x0F, 0xFF, 0x01, 0xF0, 0x01, 0xC0,
  0x07, 0xFF, 0x07, 0xC0, 0x07, 0x80, 0x07, 0xFE, 0x0F, 0x00, 0x1F, 0x00,
  0x03, 0xFE, 0x1C, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x38, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF9, 0xC0, 0x07, 0xFC, 0x00,
  0x07, 0xF3, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xF7, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xE6, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xCC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0x98, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x30, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x30, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0xF0, 0x00,
  0x7C, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0xC0, 0x00,
  0xE0, 0x3C, 0x78, 0x3F, 0x80, 0x01, 0xC0, 0x1F, 0xE0, 0x3E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x18, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x07,
  0x0F, 0xFF, 0xFE, 0x0E, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1C, 0x00, 0x00, 0x7F,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x18, 0x7F, 0xC0, 0x03, 0xE0, 0x08, 0xFF,
  0xFE, 0x07, 0xC0, 0x0D, 0xFF, 0xFC, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x0F,
  0x80, 0x0E, 0x3F, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xC0, 0x1F, 0x00, 0x70,
  0x01, 0x80, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x0F,
  0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xF8, 0x07,
  0x80, 0xFE, 0x0F, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xFE, 0x1F, 0xF2, 0xFE,
  0x07, 0xFF, 0x3F, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFF,
  0xE7, 0xFC, 0xFF, 0x00, 0xFF, 0xE1, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0xF0,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x01,
  0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x88, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x3C, 0x00, 0x00,
  0xCF, 0xFC, 0x03, 0x80, 0x00, 0x18, 0x3F, 0x80, 0x78, 0x00, 0x03, 0x80,
  0xF0, 0x07, 0x00, 0x00, 0x70, 0x04, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x06,
  0x00, 0x01, 0xFE, 0x00, 0x60, 0x60, 0x00, 0x1F, 0xE0, 0x07, 0x06, 0x00,
  0x01, 0xFF, 0x00, 0xF8, 0x70, 0x00, 0x1F, 0xF8, 0x1F, 0xC3, 0x00, 0x00,
  0xFF, 0xC3, 0xFE, 0x30, 0x00, 0x0F, 0xFE, 0x7F, 0xF3, 0x80, 0x00, 0x7F,
  0xE7, 0xFE, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x3F, 0xF8,
  0x78, 0x07, 0x00, 0x31, 0xFF, 0x83, 0x00, 0x1F, 0x3F, 0x1F, 0xFC, 0x20,
  0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x30, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x13, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xBF, 0xF0, 0x01, 0xF0, 0x00, 0xE7,
  0xFF, 0x00, 0x7E, 0x00, 0x30, 0x7F, 0xF0, 0x0F, 0x80, 0x0C, 0x07, 0xFF,
  0x03, 0xF0, 0x07, 0x00, 0x7F, 0xF0, 0xFC, 0x03, 0xC0, 0x07, 0xFE, 0x1F,
  0x80, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xC0, 0xFE, 0x07,
  0xE0, 0x00, 0x60, 0x1F, 0xC1, 0xFC, 0x00, 0x38, 0x03, 0xF8, 0x3F, 0x80,
  0x0E, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF,
  0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0x8F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF9, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xDF, 0xF0, 0x01, 0xFC, 0x03, 0xF9, 0xFE,
  0x00, 0x1F, 0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xE0, 0x0F, 0xE7, 0xFC, 0x00,
  0x78, 0x01, 0xF8, 0x7F, 0xC0, 0x1E, 0x00, 0x3F, 0x07, 0xF8, 0x07, 0x00,
  0x07, 0xC0, 0x7F, 0x81, 0xC0, 0x01, 0xF0, 0x0F, 0xF8, 0x20, 0x00, 0x3E,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xE0, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1D,
  0xFF, 0xC0, 0x00, 0x00, 0x06, 0x0F, 0xFE, 0x80, 0x00, 0x01, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0xFF, 0x00,
  0x07, 0xFE, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x7C, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0x80,
  0x07, 0xE1, 0xFF, 0x80, 0xE0, 0x00, 0xFC, 0x7F, 0xF8, 0x18, 0x00, 0x1F,
  0x9F, 0xFF, 0x83, 0x00, 0x03, 0xE0, 0x3F, 0xF9, 0xC0, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x0F,
  0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xFF, 0xCC,
  0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0xE0, 0x00,
  0x03, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xE0,
  0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x0C, 0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0xFE, 0x00, 0x01, 0xF1, 0xFF, 0xFE, 0x00, 0x03, 0xE7, 0x1F, 0xFE,
  0x00, 0x07, 0x88, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0x1F, 0xFE, 0x00, 0x1C,
  0x00, 0x1F, 0xFE, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0xDE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0x00, 0x00,
  0x3F, 0xFC, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x1C,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xE0, 0x0C,
  0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x78,
  0x1F, 0xFE, 0x00, 0x00, 0x38, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x1F, 0xFF,
  0xE0, 0x00, 0x1C, 0x18, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x06, 0x00,
  0x00, 0x3F, 0xFC, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x80, 0xFF, 0x80,
  0x38, 0x00, 0x3F, 0x07, 0xFF, 0xC0, 0x78, 0x00, 0x7C, 0x1F, 0xFF, 0xC0,
  0x70, 0x01, 0xF8, 0x7F, 0xFF, 0xC0, 0xF0, 0x03, 0xF0, 0xE0, 0xFF, 0xC0,
  0xE0, 0x07, 0xE1, 0x80, 0xFF, 0x81, 0xC0, 0x1F, 0xC6, 0x00, 0xFF, 0x83,
  0x80, 0x3F, 0x88, 0x00, 0xFF, 0x07, 0x80, 0x7F, 0x90, 0x01, 0xFF, 0x0F,
  0x00, 0xFF, 0x20, 0x01, 0xFE, 0x1E, 0x01, 0xFF, 0x40, 0x03, 0xFF, 0x3C,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x70, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0xE0,
  0x07, 0xFF, 0x00, 0x03, 0xC1, 0x80, 0x07, 0xFE, 0x00, 0x0E, 0x07, 0x00,
  0x0F, 0xFE, 0x00, 0x30, 0x1C, 0x00, 0x0F, 0xFC, 0x01, 0xE0, 0x70, 0x00,
  0x1F, 0xFC, 0x0F, 0xE1, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xE6, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x78, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0x03, 0x00, 0x0F, 0xF8, 0x23, 0xFF, 0x0C,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE3, 0xFE,
  0x00, 0x03, 0xF0, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x00, 0xFC, 0x3F,
  0xF0, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x3F, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x8C, 0x7F, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF0, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x2F, 0xFF, 0xFE, 0x00, 0x30, 0x0F, 0xFF, 0xC0, 0x30, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0x9C, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x71, 0xFF, 0xD8, 0x1F, 0xE0, 0x3F,
  0x9F, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0x78, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x70, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0xE0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0xC0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x80,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x80, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x80, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x01, 0xE0, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x06, 0x00, 0x3F,
  0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x0E, 0x00, 0x3F, 0xFF, 0x00, 0xFC, 0x01,
  0xF8, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x03,
  0xF3, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xE1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE1, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xC1, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x81, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x81, 0xFF, 0x00, 0x01, 0xF8, 0x03, 0x8E, 0x03,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0x3F, 0x03, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x06, 0x7F, 0x86, 0x00, 0x7F, 0xC3, 0x1F, 0xFF, 0x06, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x31, 0xFF, 0x9D, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x20,
  0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF3, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE2, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE3, 0x83, 0xFE, 0x07, 0xE0, 0x7F, 0xFC,
  0xC0, 0x7F, 0x81, 0xE0, 0x07, 0xFF, 0x60, 0x0F, 0xF0, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xFC, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x0C, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x80, 0x00,
  0x0F, 0xF8, 0x01, 0xFE, 0x20, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE8, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x78, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x1F, 0xC0, 0x0E, 0x01, 0xC0, 0xF0, 0x07, 0xF0, 0x07, 0x00,
  0x7F, 0xFE, 0x00, 0xFC, 0x01, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0xE0,
  0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x78, 0x00, 0x3F, 0xFC, 0x03, 0xE0, 0x3C,
  0x00, 0x01, 0xC3, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x10, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x38, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x0C, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x06, 0x00, 0x1F, 0xF8, 0xC7, 0xFF,
  0xC3, 0x80, 0x03, 0xFF, 0xE3, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x1E, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xC7, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xE3, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x01, 0xF1, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x70, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x7F, 0xFF, 0xC0, 0x00, 0x0C, 0x0C, 0x7F, 0xFF, 0x00, 0x01, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0xEF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0x8F, 0xF8, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x0E, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0xF0, 0x0C, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0x80, 0xC0, 0x00, 0x0F, 0xF0,
  0x3F, 0xFC, 0x0C, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0xC0, 0x00, 0x0F,
  0xF0, 0x0F, 0xFF, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0xC0, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0xC6, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x60,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE3, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE,
  0x18, 0x00, 0x87, 0xF0, 0x00, 0x1F, 0xF0, 0xE0, 0x18, 0x7F, 0x00, 0x00,
  0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x06, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x01, 0xF1, 0x00, 0x03, 0xC3, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xDC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x05, 0x1F, 0xFF, 0xC2, 0x0F,
  0xF8, 0x30, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x30, 0x3F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0xF6, 0x01, 0xFF, 0x00,
  0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xC1, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC6, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0x81, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x80,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0xFC, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x0F, 0x00, 0x60, 0x3E, 0x7F, 0xF0, 0x00,
  0x0F, 0x8E, 0x00, 0xFA, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xF8,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x18, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x18, 0x00, 0x0F, 0xFC, 0x41, 0x3F,
  0xFC, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x08, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x07,
  0x80, 0x80, 0x3F, 0xFF, 0xF0, 0x78, 0x0C, 0x0F, 0xFF, 0xFF, 0x87, 0x80,
  0x63, 0xFF, 0xFF, 0xF8, 0x78, 0x03, 0xFF, 0xFF, 0x00, 0xC7, 0xC0, 0x3F,
  0xFF, 0xC0, 0x04, 0x7C, 0x01, 0xFF, 0xF0, 0x00, 0x67, 0xC0, 0x0F, 0xFE,
  0x00, 0x02, 0x7E, 0x00, 0x7F, 0x80, 0x00, 0x27, 0xE0, 0x01, 0xC0, 0x00,
  0x02, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x27, 0xF0, 0x00, 0x00, 0x00, 0x02,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x63, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x30, 0x00, 0x01, 0xFF, 0xF8, 0x6C,
  0x00, 0x00, 0xCF, 0xFF, 0xF9, 0x80, 0x00, 0x70, 0xFF, 0xFE, 0x30, 0x00,
  0x1C, 0x07, 0xFF, 0x8C, 0x00, 0x07, 0x80, 0x7F, 0xE1, 0x80, 0x01, 0xF0,
  0x03, 0xF8, 0x30, 0x00, 0x7F, 0x00, 0x08, 0x02, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x60, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x0C, 0x04, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F,
  0xFC, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x01, 0xFF, 0xFC,
  0x0F, 0x00, 0x00, 0x63, 0xFF, 0xC3, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xE3, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0x00,
  0x3C, 0x06, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x40, 0x7F, 0xC0, 0x1F, 0x80, 0x60, 0x7F,
  0xE0, 0x1F, 0xC0, 0x60, 0x1F, 0xE0, 0x0F, 0xE0, 0x20, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xF8,
  0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xF8, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x0D, 0xFC,
  0x07, 0xFF, 0xF8, 0x0C, 0xFF, 0x06, 0x0F, 0xFF, 0x1C, 0x7F, 0xFC, 0x03,
  0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x61, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xCC, 0x0F, 0xF8, 0x01, 0xF8, 0x3F, 0xFE, 0x80, 0x7F,
  0x80, 0x3E, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x70, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x0E, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0xC1, 0xF0,
  0x07, 0xF8, 0x00, 0xF0, 0x38, 0x1E, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x01,
  0xC0, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xF0, 0x01, 0xC7, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x10, 0x1F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x1F, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x7F,
  0x0C, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF9, 0x83, 0x30, 0x3F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0xF0, 0x0E, 0x00, 0x7F, 0xC0, 0x3E,
  0x00, 0x3F, 0xF0, 0x38, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x3F, 0xE0, 0x70,
  0x00, 0xFF, 0x81, 0xC0, 0x00, 0x3F, 0xE1, 0xE0, 0x00, 0xFF, 0x03, 0x80,
  0x00, 0x3F, 0xC3, 0xE0, 0x01, 0xFF, 0x0E, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xFF, 0x9C, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFF, 0x38, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF0, 0x30, 0x00, 0x00, 0xFC, 0x7F, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x03, 0xF1, 0xFF, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0xE3, 0xFF, 0x00,
  0x78, 0x01, 0x80, 0x00, 0x07, 0xC3, 0xFE, 0x01, 0xF0, 0x03, 0x00, 0x00,
  0x1F, 0x07, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x08, 0x3E, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0x80, 0x60, 0x78, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFC, 0x01, 0xC0, 0x0F, 0xF0, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x1C, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xC0, 0x60, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0x10, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xE0, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xE2,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0xFF,
  0x8F, 0xFE, 0x0F, 0x00, 0x1F, 0xE6, 0x1F, 0x07, 0x80, 0x03, 0xF9, 0x01,
  0x01, 0xC0, 0x00, 0x7F, 0x40, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x18,
  0x00, 0x03, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xE0,
  0x1C, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xE7, 0xFF, 0xFE, 0x00, 0x03, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x4F, 0xF0, 0x00,
  0x01, 0xF0, 0x33, 0xFE, 0x00, 0x00, 0xFE, 0x08, 0x7F, 0xC0, 0x00, 0x7F,
  0xC6, 0x1F, 0xFE, 0x70, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x43, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE1, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0xC0, 0xFF,
  0x80, 0xFE, 0x07, 0xFF, 0xA0, 0x1F, 0xF0, 0x3E, 0x00, 0x7F, 0xF8, 0x07,
  0xFC, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xE1, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0xE0, 0x00, 0x07, 0xF8,
  0x03, 0xFE, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xCE, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x60, 0x00, 0x01,
  0xF8, 0x00, 0x7C, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x1F, 0x80, 0x0E, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x30, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x10, 0x7C, 0x01, 0xF0, 0x00, 0xC0,
  0x0C, 0x1F, 0x00, 0xFE, 0x00, 0x1C, 0x0E, 0x07, 0x80, 0x7F, 0x80, 0x03,
  0xFE, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x0D, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xFC, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x0E, 0x00, 0x00, 0x7F,
  0x80, 0x38, 0x00, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0x80,
  0x00, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x00, 0x7E,
  0x00, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xFE, 0x00, 0x00, 0x3E, 0x3F,
  0xFC, 0x00, 0x00, 0xF9, 0xFF, 0xF8, 0x00, 0x03, 0xCE, 0xFF, 0xF0, 0x00,
  0x0F, 0x20, 0xFF, 0xE0, 0x00, 0x38, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x03,
  0xFF, 0x80, 0x0E, 0x00, 0x07, 0xFF, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0x03,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xBF, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x07,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x7C, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0x80, 0xC0, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x19, 0xFF, 0xC0, 0x0C, 0x3F,
  0xF8, 0x07, 0x03, 0xFC, 0x03, 0x80, 0x7F, 0x01, 0xE0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x31,
  0xFF, 0x7F, 0xF8, 0x3F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xF8, 0x1F,
  0x80, 0x3C, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x08, 0x3C, 0x00, 0x02,
  0x3C, 0x00, 0x01, 0xBE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x04,
  0x00, 0xFC, 0x06, 0x00, 0x7E, 0x07, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x8F,
  0xF0, 0x0F, 0xDF, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C,
  0x1F, 0x80, 0x3C, 0x0F, 0xC0, 0x1C, 0x07, 0xE0, 0x1E, 0x07, 0xF8, 0x0E,
  0x03, 0xFF, 0x0E, 0x03, 0xFF, 0xC4, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x03, 0xFC,
  0x01, 0xDF, 0x80, 0x73, 0xF8, 0x1C, 0x3F, 0x07, 0x87, 0xF0, 0xF0, 0x7E,
  0x3C, 0x0F, 0xE7, 0x80, 0xE1, 0xF0, 0x10, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x87, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x37, 0xFE, 0x00, 0x10, 0x7F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F,
  0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC,
  0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x0F, 0xC0, 0x0E, 0x03, 0xF0, 0x03, 0x81,
  0xFF, 0x00, 0xC0, 0xFF, 0xE0, 0x70, 0x3F, 0xFE, 0x18, 0x01, 0xFF, 0xEC,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0x00, 0x3B, 0xF0, 0x07, 0x3F, 0x80, 0xE1, 0xF8, 0x1E, 0x1F, 0xC1, 0xE0,
  0xFC, 0x3C, 0x0F, 0xC3, 0xC0, 0xFE, 0x7C, 0x07, 0xE7, 0xC0, 0x7F, 0x7C,
  0x03, 0xC7, 0xC0, 0xE0, 0x7C, 0x78, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x20, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x04, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x01, 0x87, 0xC0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x09, 0xFF, 0x80, 0x06,
  0x7F, 0xFC, 0x07, 0x07, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x0F, 0xE0,
  0x78, 0x00, 0xF0, 0x3E, 0x00, 0x1C, 0x1F, 0x80, 0x0F, 0x07, 0xE0, 0x07,
  0x81, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0x7F, 0x01, 0xFF,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1E, 0x00, 0xFC, 0x03, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0xE0, 0x1F, 0x00,
  0x70, 0x07, 0xE0, 0x38, 0x00, 0xFC, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00,
  0x18, 0x3E, 0x00, 0x06, 0x3E, 0x00, 0x01, 0x3E, 0x00, 0x00, 0xDF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x04, 0x00, 0x7E, 0x06, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xDF, 0xF8, 0x07, 0xF3, 0xFE, 0x03,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0xFE,
  0x21, 0xE0, 0xFF, 0xF0, 0xF0, 0x7F, 0xF0, 0xF0, 0x0F, 0xF0, 0x78, 0x03,
  0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x30, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xF3, 0x7F, 0x88,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE4, 0x3F, 0xF0, 0x7F,
  0x81, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x05, 0xFE, 0x04, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xE8, 0x01, 0xF2, 0x01, 0xF1, 0x80, 0xF0, 0x40, 0xF0, 0x11, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x83, 0x03, 0xC0,
  0x61, 0xE0, 0x08, 0xF8, 0x21, 0x7E, 0x38, 0x7F, 0x1E, 0x1F, 0xCF, 0x83,
  0xF3, 0xE0, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0xBF, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE1, 0x07, 0xFC, 0x83, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x1E,
  0x18, 0x1E, 0x06, 0x1E, 0x01, 0x1F, 0x00, 0xDF, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x10, 0xFF, 0x90, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1C, 0x00, 0xE0,
  0x0C, 0x00, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0x3F, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x87, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF1,
  0xFF, 0x9F, 0xFC, 0x9F, 0xE0, 0xFF, 0x0F, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xF3, 0x3F, 0xF1, 0xFF, 0x83, 0xFE,
  0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x07, 0x80,
  0x3C, 0x01, 0xF8, 0x03, 0x00, 0x38, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00,
  0x30, 0x0C, 0x00, 0x40, 0x00, 0xE0, 0x06, 0x00, 0x1F, 0x80, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0xC3, 0xFE, 0x07, 0xFE, 0xFF, 0xFC, 0x5F, 0xF8,
  0xFF, 0x88, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xF0, 0x3F, 0x01, 0xFF, 0x03, 0xF9, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0x03, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x3C, 0x00, 0xFC, 0x01, 0x80,
  0x07, 0x80, 0x18, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0x0F, 0xF0, 0x3F,
  0x0F, 0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0x07, 0xFC, 0x3F, 0x03, 0xFC, 0x3F,
  0x01, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F,
  0x80, 0x78, 0x3F, 0xC0, 0x70, 0xFF, 0xF0, 0xE0, 0x7F, 0xF8, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x20, 0x1F, 0xE0, 0x1C, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0xC1, 0xF8, 0x07,
  0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3C,
  0x1F, 0xF0, 0x07, 0x87, 0xFF, 0x01, 0xE1, 0xFF, 0xF8, 0x38, 0x3F, 0xFF,
  0x8E, 0x06, 0x3F, 0xFD, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x3E, 0x20, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xBF, 0xF0, 0x03, 0x1F, 0xFC, 0x07,
  0x0F, 0xFF, 0x0E, 0x07, 0xFC, 0x1E, 0x01, 0xF8, 0x3C, 0x01, 0xF8, 0x3C,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x7F, 0x81, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0x80, 0xF8, 0x01,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x0C, 0x00, 0x81, 0xF0, 0x18, 0x1F, 0x83, 0xC3, 0xFC, 0x7C,
  0x3F, 0xCF, 0xE7, 0xFE, 0xFE, 0xCF, 0xFF, 0xF0, 0xFF, 0x7E, 0x07, 0xE3,
  0xE0, 0x7E, 0x1C, 0x07, 0xE1, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE1, 0x00, 0xFF, 0xA0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x18, 0x03, 0x00, 0xF8, 0x06,
  0x03, 0xFC, 0x0C, 0x0F, 0xFF, 0xF8, 0x37, 0xFF, 0xE0, 0x87, 0xFF, 0xC3,
  0x03, 0xFF, 0x0C, 0x01, 0xF8, 0x38, 0x00, 0x60, 0x78, 0x00, 0x80, 0xF0,
  0x03, 0x01, 0xF0, 0x0E, 0x03, 0xF0, 0x3E, 0x07, 0xF8, 0xFE, 0x0F, 0xFB,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0x81, 0xFC, 0x0E, 0x01,
  0xF8, 0x18, 0x01, 0xF0, 0x20, 0x03, 0xE0, 0xC0, 0x03, 0x83, 0xE0, 0x06,
  0x0F, 0xF0, 0x08, 0x3F, 0xF8, 0x30, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE1, 0x07, 0xF9, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0xC0, 0x0F,
  0x00, 0x1C, 0x01, 0xF8, 0x01, 0xE0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x07,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC4, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x07, 0xF1, 0x0F,
  0xF8, 0xFF, 0xB1, 0xFF, 0xF3, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0x00, 0x78, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x08, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0x8F, 0xFE, 0x0F, 0xF3, 0x1F, 0xE1, 0xFF, 0x81,
  0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x0F, 0x00, 0x7E, 0x01,
  0xE0, 0x0F, 0x80, 0x38, 0x01, 0xF0, 0x07, 0x00, 0x3E, 0x00, 0xE0, 0x07,
  0x80, 0x38, 0x01, 0xF0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x3F,
  0x81, 0xC0, 0x0F, 0xFC, 0x30, 0x01, 0xFF, 0xEC, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x10, 0x3F, 0x80, 0x1C, 0x00, 0x60,
  0x7F, 0xC0, 0x7C, 0x03, 0xC0, 0xFF, 0x81, 0xFC, 0x0F, 0xC0, 0xFF, 0x87,
  0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0xFB, 0xFF, 0xC0, 0xFE, 0xC7, 0xF8, 0x3F,
  0x80, 0xFF, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x00,
  0xFC, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x01, 0xF0, 0x7E,
  0x03, 0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xF0, 0x07, 0xC1, 0xF8, 0x0F, 0xE0,
  0x0F, 0x83, 0xF0, 0x1F, 0xC0, 0x1F, 0x07, 0xE0, 0x3F, 0x80, 0x3E, 0x0F,
  0xC0, 0x7F, 0x00, 0x78, 0x1F, 0x80, 0xFE, 0x01, 0xF0, 0x3F, 0x01, 0xFC,
  0x03, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0x00, 0xFE, 0x07, 0xF8, 0x1C, 0x01,
  0xFC, 0x1F, 0xFC, 0x30, 0x07, 0xF8, 0x7F, 0xFC, 0xC0, 0x1F, 0xF8, 0x1F,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1E,
  0x01, 0x80, 0x7C, 0x0E, 0x03, 0xF8, 0x7C, 0x0F, 0xF3, 0xF0, 0x7F, 0xCF,
  0xE3, 0x7F, 0xFF, 0xC8, 0xFF, 0x7F, 0x03, 0xF8, 0xF8, 0x0F, 0xE3, 0xC0,
  0x3F, 0x86, 0x00, 0xFE, 0x10, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x40, 0x0F, 0xF2, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0x0F, 0x80, 0x18, 0x0E, 0x00,
  0x60, 0x10, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x06, 0x00, 0xF8, 0x0E, 0x0F,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x01, 0xFE,
  0x01, 0xC0, 0x7F, 0xC1, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0xFF, 0xC0,
  0x7F, 0xC7, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8,
  0x03, 0xE0, 0x7E, 0x00, 0xF0, 0x3F, 0x88, 0x7C, 0x1F, 0xFC, 0x1E, 0x07,
  0xFE, 0x07, 0x80, 0x7F, 0x03, 0xC0, 0x07, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x10, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x0C, 0x1C, 0x0C, 0x0F, 0xCC, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x67,
  0xF8, 0x31, 0xFE, 0x0C, 0x3F, 0x86, 0x07, 0xE3, 0x81, 0xFC, 0xC0, 0x7F,
  0x30, 0x0F, 0xDC, 0x03, 0xF7, 0x00, 0xFD, 0x80, 0x3F, 0x60, 0x0F, 0xD8,
  0x03, 0xE6, 0x00, 0xF9, 0x80, 0x3E, 0x60, 0x0F, 0x1C, 0x03, 0x83, 0x00,
  0xE0, 0xC0, 0x70, 0x18, 0x18, 0x03, 0x0C, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 12, 45, 14, 1, -44 },
  { 69, 22, 16, 25, 1, -43 },
  { 113, 27, 35, 31, 2, -39 },
  { 232, 21, 49, 26, 2, -46 },
  { 361, 40, 42, 44, 2, -43 },
  { 571, 31, 39, 35, 2, -38 },
  { 723, 10, 16, 12, 1, -43 },
  { 743, 13, 50, 15, 1, -48 },
  { 825, 13, 50, 15, 1, -48 },
  { 907, 20, 24, 21, 0, -46 },
  { 967, 20, 22, 24, 2, -31 },
  { 1022, 10, 16, 11, 0, -9 },
  { 1042, 16, 12, 18, 2, -24 },
  { 1066, 10, 10, 12, 1, -9 },
  { 1079, 29, 49, 32, 2, -46 },
  { 1257, 27, 44, 29, 1, -43 },
  { 1406, 18, 42, 20, 1, -42 },
  { 1501, 25, 42, 27, 1, -42 },
  { 1633, 26, 42, 28, 1, -42 },
  { 1770, 26, 42, 28, 1, -42 },
  { 1907, 27, 43, 28, 1, -43 },
  { 2053, 26, 43, 28, 1, -43 },
  { 2193, 25, 42, 26, 1, -42 },
  { 2325, 26, 43, 29, 1, -43 },
  { 2465, 26, 43, 28, 1, -43 },
  { 2605, 10, 30, 12, 1, -29 },
  { 2643, 11, 36, 10, 0, -29 },
  { 2693, 17, 22, 18, 0, -28 },
  { 2740, 21, 13, 24, 1, -25 },
  { 2775, 17, 22, 18, 0, -28 },
  { 2822, 23, 45, 28, 2, -44 },
  { 2952, 36, 36, 37, 1, -28 },
  { 3114, 47, 44, 50, 1, -43 },
  { 3373, 53, 45, 55, 0, -44 },
  { 3672, 39, 45, 42, 2, -44 },
  { 3892, 47, 47, 49, 1, -45 },
  { 4169, 40, 45, 43, 2, -44 },
  { 4394, 44, 52, 46, 1, -45 },
  { 4680, 43, 46, 47, 2, -44 },
  { 4928, 43, 55, 45, 1, -47 },
  { 5224, 39, 52, 42, 1, -45 },
  { 5478, 41, 60, 43, 1, -45 },
  { 5786, 47, 44, 50, 1, -43 },
  { 6045, 33, 44, 35, 1, -43 },
  { 6227, 64, 46, 67, 2, -43 },
  { 6595, 50, 44, 54, 2, -43 },
  { 6870, 44, 45, 46, 1, -44 },
  { 7118, 52, 53, 54, 1, -43 },
  { 7463, 46, 48, 49, 1, -44 },
  { 7739, 54, 45, 57, 1, -44 },
  { 8043, 44, 45, 46, 1, -44 },
  { 8291, 43, 44, 46, 1, -43 },
  { 8528, 41, 47, 43, 1, -43 },
  { 8769, 52, 46, 54, 1, -45 },
  { 9068, 63, 45, 66, 1, -44 },
  { 9423, 42, 46, 44, 1, -45 },
  { 9665, 50, 55, 52, 1, -45 },
  { 10009, 38, 53, 41, 1, -45 },
  { 10261, 9, 48, 11, 1, -45 },
  { 10315, 37, 43, 7, -11, -40 },
  { 10514, 9, 48, 11, 1, -45 },
  { 10568, 23, 16, 26, 1, -43 },
  { 10614, 29, 4, 28, -1, 7 },
  { 10629, 9, 12, 31, 10, -43 },
  { 10643, 26, 33, 28, 1, -31 },
  { 10751, 25, 44, 27, 1, -42 },
  { 10889, 19, 32, 22, 1, -31 },
  { 10965, 26, 43, 28, 1, -42 },
  { 11105, 20, 32, 22, 1, -31 },
  { 11185, 19, 55, 15, -1, -44 },
  { 11316, 26, 45, 28, 1, -32 },
  { 11463, 25, 54, 27, 1, -43 },
  { 11632, 14, 43, 17, 1, -42 },
  { 11708, 17, 54, 15, -3, -43 },
  { 11823, 18, 44, 20, 1, -43 },
  { 11922, 17, 44, 17, 1, -43 },
  { 12016, 40, 33, 43, 2, -32 },
  { 12181, 28, 32, 31, 1, -31 },
  { 12293, 24, 32, 25, 0, -31 },
  { 12389, 27, 48, 27, 0, -36 },
  { 12551, 24, 45, 26, 1, -32 },
  { 12686, 20, 32, 22, 1, -31 },
  { 12766, 23, 39, 25, 1, -38 },
  { 12879, 17, 40, 19, 1, -39 },
  { 12964, 28, 33, 31, 1, -32 },
  { 13080, 27, 36, 28, -1, -35 },
  { 13202, 39, 38, 42, 2, -36 },
  { 13388, 22, 45, 24, 1, -32 },
  { 13512, 26, 47, 29, 1, -37 },
  { 13665, 18, 43, 20, 1, -32 },
  { 13762, 17, 48, 20, 1, -47 },
  { 13864, 4, 51, 10, 3, -48 },
  { 13890, 17, 48, 20, 1, -47 },
  { 13992, 20, 4, 22, 1, -20 },
};

const GFXfont UnifrakturMaguntia_Regular61pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular61pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular61pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR61PT7B_H_
