#ifndef _UNIFRAKTURMAGUNTIA_REGULAR34PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC7, 0x3F, 0x79, 0xE7, 0x9C, 0x30, 0xC3, 0x0C, 0x30, 0xC2,
  0x08, 0x20, 0x00, 0x00, 0x20, 0xC7, 0x9C, 0x30, 0x20, 0x87, 0x0C, 0xFB,
  0xF7, 0x8E, 0x38, 0x61, 0x06, 0x10, 0x42, 0x04, 0x20, 0x80, 0x06, 0x38,
  0x0C, 0x70, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x0F, 0xFF, 0xDF, 0xFF, 0x87,
  0x18, 0x0C, 0x70, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0x8F, 0xFF, 0xDF, 0xFF,
  0x87, 0x18, 0x0E, 0x30, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0x81, 0xC7, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0xF8, 0x18, 0xC3, 0x06, 0x60, 0x66, 0x06,
  0x70, 0x67, 0x06, 0x7C, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7E,
  0x41, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0x60, 0x66, 0x06, 0x20, 0xC1, 0xF8,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x1E, 0x00, 0x04, 0xCC, 0x00, 0x26,
  0x38, 0x01, 0x38, 0xE0, 0x0C, 0xE3, 0x80, 0x63, 0x8E, 0x03, 0x0E, 0x38,
  0x18, 0x38, 0xE0, 0x40, 0xE3, 0x82, 0x01, 0x8E, 0x10, 0x03, 0x30, 0xC0,
  0x07, 0x86, 0x38, 0x00, 0x33, 0xB8, 0x01, 0x8C, 0x60, 0x0C, 0x71, 0xC0,
  0x21, 0xC7, 0x01, 0x07, 0x1C, 0x08, 0x1C, 0x70, 0x60, 0x71, 0xC3, 0x01,
  0xC7, 0x18, 0x07, 0x1C, 0xC0, 0x0C, 0x62, 0x00, 0x3B, 0x90, 0x00, 0x38,
  0x03, 0xE0, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0E, 0x30, 0x03,
  0x8C, 0x00, 0xF6, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xE1, 0xF8,
  0x30, 0xDF, 0x08, 0x73, 0xC2, 0x38, 0xF8, 0x8E, 0x1E, 0x43, 0xC7, 0xD0,
  0xF0, 0xF8, 0x3C, 0x3E, 0x07, 0x87, 0xCC, 0xF1, 0xFE, 0x1F, 0x8E, 0x00,
  0x23, 0xBE, 0xF3, 0x98, 0xC4, 0x40, 0x03, 0x04, 0x08, 0x18, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x08, 0x0C, 0x03, 0x40, 0x30,
  0x18, 0x08, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x18,
  0x10, 0x60, 0x04, 0x01, 0xC0, 0xFE, 0x73, 0x77, 0x5E, 0xFF, 0x81, 0x93,
  0xFF, 0x75, 0xFE, 0xDC, 0xBE, 0x0F, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x61, 0xFF, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0xC7, 0xCE, 0x18, 0x61, 0x04, 0x20, 0x3F, 0x9F, 0x90, 0x01,
  0xE7, 0xE7, 0xE0, 0x10, 0xE7, 0xCE, 0x10, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x73, 0x83, 0x87, 0x0E, 0x1C, 0x78, 0x79, 0xE1, 0xEF, 0x83, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x38, 0x70,
  0xE1, 0xC1, 0xCE, 0x01, 0xE0, 0x02, 0x00, 0xC0, 0x38, 0x0F, 0x03, 0xE0,
  0xFC, 0x23, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x3F, 0x1F,
  0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xC3, 0xE3, 0x03, 0xE4, 0x03, 0xC8, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x02, 0x18, 0x04, 0x20,
  0x10, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x00, 0x0F, 0xC0, 0x87,
  0xC4, 0x0F, 0xA0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xE0, 0x0F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x40, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x31, 0xC1, 0x81,
  0xF8, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x5C, 0x01, 0x38, 0x06, 0x70, 0x08, 0xE0, 0x21, 0xC0, 0xC3, 0x81, 0x07,
  0x04, 0x0E, 0x18, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x40, 0x10,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x2F, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x2F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x70, 0xFD, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x1D, 0x00, 0x7E, 0x01, 0xFC, 0x06, 0xF0, 0x3B, 0xC0,
  0xC7, 0x06, 0x07, 0xE0, 0x07, 0xC0, 0x33, 0xC1, 0x87, 0x0E, 0x1E, 0x38,
  0x79, 0xC0, 0xE7, 0x02, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x8F, 0x4F, 0x3E,
  0x1E, 0xF8, 0x7B, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0x9C, 0x0E, 0x78, 0x30, 0xE1, 0xC1, 0x86, 0x03, 0xE0, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0x80, 0x28, 0x03, 0x40, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x60, 0x83, 0x03, 0x18, 0x06, 0xE0, 0x1B, 0x80, 0x6F, 0x01,
  0x9E, 0x0C, 0x7E, 0x31, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x17, 0xF0, 0x87,
  0xE6, 0x07, 0xB0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x19, 0x80, 0xE3, 0x07, 0x07, 0xE0, 0x0F, 0x80, 0x63, 0x83, 0x0E, 0x1C,
  0x1C, 0x70, 0x7B, 0xC1, 0xEE, 0x07, 0xB8, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0xFD, 0xE5, 0xE3, 0xF7, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xEF, 0x07, 0x3C, 0x1C, 0xF0, 0x61, 0xC3, 0x83, 0x8C, 0x07, 0xC0,
  0x10, 0xC7, 0xCE, 0x10, 0x00, 0x00, 0x00, 0x00, 0x04, 0x39, 0xF3, 0x84,
  0x10, 0xC7, 0xCE, 0x10, 0x00, 0x00, 0x00, 0x00, 0x08, 0x31, 0xF3, 0x86,
  0x18, 0x41, 0x08, 0x00, 0x81, 0x81, 0xC1, 0xC3, 0xC3, 0xC3, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x60, 0x08, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x1E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x00, 0x0F, 0xC1, 0x87, 0x98, 0x1D,
  0x80, 0xFE, 0x03, 0xF8, 0x3D, 0xC1, 0xE0, 0x1F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x78, 0x03, 0x80, 0x1C, 0x10, 0xE0, 0x83, 0x88, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x30, 0x03, 0xE0, 0x2E, 0x00, 0x20, 0x01, 0xFC,
  0x00, 0xE0, 0xE0, 0x70, 0x0E, 0x1C, 0x00, 0xC3, 0x00, 0x0C, 0xC1, 0xFD,
  0xB8, 0x67, 0x36, 0x1C, 0xE2, 0xC7, 0x1C, 0xD9, 0xE3, 0x9B, 0x38, 0xE3,
  0x67, 0x1C, 0x4C, 0xE7, 0x99, 0x9D, 0xF6, 0x31, 0xEF, 0x1F, 0x00, 0x03,
  0x60, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x0C, 0x07, 0x07, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0x87, 0xFE, 0x01, 0xC3, 0x1F, 0xC1, 0xE1, 0x01, 0xF9,
  0xF8, 0xC0, 0x3E, 0x3E, 0x20, 0x07, 0xCF, 0x88, 0x01, 0xF3, 0xE2, 0x00,
  0x7C, 0xF8, 0xC0, 0x0F, 0x3E, 0x3C, 0x03, 0x8F, 0x8F, 0xC0, 0xE3, 0xE1,
  0xF8, 0x78, 0xF8, 0x1F, 0x1C, 0x3E, 0x01, 0x86, 0x0F, 0x80, 0x23, 0x03,
  0xE0, 0x11, 0x80, 0xF8, 0x00, 0xC0, 0x3E, 0x00, 0x60, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x1F, 0xF8, 0x7E, 0x40, 0x7F, 0xE7, 0xE0,
  0x07, 0xF1, 0xF0, 0x00, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x04, 0x00, 0x3F, 0xE0, 0xFC, 0x01, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xA1,
  0xF0, 0x78, 0x3F, 0x83, 0xC1, 0x80, 0x7E, 0x0F, 0x86, 0x00, 0xF8, 0x3E,
  0x30, 0x01, 0xE0, 0x7C, 0xC0, 0x07, 0x81, 0xE1, 0x00, 0x1E, 0x02, 0x04,
  0x00, 0x78, 0x78, 0x18, 0x01, 0xC7, 0xF8, 0x30, 0x27, 0x7F, 0xF0, 0x7F,
  0x18, 0x0F, 0xE0, 0x00, 0x40, 0x0F, 0x80, 0x02, 0x00, 0x1E, 0x00, 0x10,
  0x00, 0x78, 0x01, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0x80, 0xFF, 0x00,
  0x0E, 0x04, 0xFE, 0x00, 0x30, 0x00, 0xFE, 0x01, 0x80, 0x01, 0xFC, 0x0C,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x87, 0x00, 0xC1, 0x7F, 0xC7, 0x03, 0xFE, 0x38,
  0x10, 0xE0, 0xE1, 0x81, 0x07, 0x8E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0,
  0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x80, 0x3C, 0x3F, 0x00, 0xF8, 0x7E, 0x03,
  0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xF0,
  0x1C, 0x03, 0xE0, 0x70, 0x0F, 0xC3, 0x00, 0x1F, 0x98, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x81, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0x07,
  0xFC, 0x1E, 0x04, 0x3F, 0x8E, 0x02, 0x03, 0xE3, 0x01, 0x80, 0x7C, 0xC0,
  0xE0, 0x0F, 0x20, 0x3C, 0x01, 0xE8, 0x0F, 0x80, 0x7A, 0x03, 0xF0, 0x0E,
  0x80, 0x7E, 0x01, 0x90, 0x0F, 0xC0, 0x76, 0x01, 0xF0, 0x18, 0xC2, 0x3C,
  0x06, 0x07, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x80, 0x10, 0x0F,
  0x40, 0x04, 0x07, 0xF8, 0x02, 0x07, 0xFF, 0x01, 0x03, 0x3F, 0xF8, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1,
  0x00, 0x1C, 0x87, 0x00, 0xC1, 0x7F, 0xC7, 0x03, 0xFE, 0x38, 0x10, 0xE0,
  0xE1, 0x81, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xE0, 0x03, 0xC7,
  0xC3, 0x8F, 0x1F, 0x9F, 0xFC, 0x3F, 0xFE, 0xF0, 0x7E, 0x7B, 0xE0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1C, 0x03,
  0xE0, 0x70, 0x0F, 0xC3, 0x00, 0x1F, 0x98, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x81, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF9, 0x38, 0x0F, 0xFE, 0x70, 0x07,
  0xFC, 0x60, 0x0C, 0xF0, 0xC0, 0x18, 0x20, 0xC0, 0x18, 0x00, 0x80, 0x3C,
  0x00, 0x80, 0x3E, 0x0C, 0xC0, 0x3F, 0x1E, 0x40, 0x1F, 0x3F, 0x40, 0x1F,
  0xFE, 0x30, 0x0F, 0xCC, 0x1F, 0xE7, 0xE8, 0x00, 0x07, 0xE0, 0x10, 0x03,
  0xE0, 0x0E, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x01,
  0xC0, 0x07, 0x01, 0x80, 0x03, 0x87, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0xE0, 0x06, 0x09, 0xE0, 0x1C, 0x07, 0xF0, 0x1C, 0x08, 0xFC, 0x38, 0x10,
  0x7E, 0x78, 0x60, 0x3E, 0x78, 0xE0, 0x18, 0x71, 0xE0, 0x30, 0xF1, 0xF0,
  0x70, 0xF0, 0xF1, 0xFC, 0xF0, 0xFB, 0xFE, 0xF0, 0xFC, 0x3E, 0xF8, 0x7E,
  0x1F, 0xF8, 0x3E, 0x0F, 0xF8, 0x1F, 0x0F, 0xF8, 0x1F, 0x0F, 0x7C, 0x0F,
  0x0F, 0x7C, 0x0E, 0x0F, 0x3C, 0x0C, 0x0E, 0x3E, 0x18, 0x0E, 0x1F, 0x20,
  0x1C, 0x0F, 0x80, 0x18, 0x03, 0xC0, 0x30, 0x01, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x8F, 0xE0, 0x01, 0x07, 0xC0, 0x02, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x40, 0x0F, 0x00, 0x60, 0x0F, 0x81, 0xF0, 0x0F, 0x83,
  0xF8, 0x07, 0xCF, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x3C,
  0x0F, 0x08, 0x1C, 0x0F, 0x3E, 0x18, 0x0F, 0x7F, 0x10, 0x0E, 0x9F, 0xA0,
  0x0E, 0x0F, 0xC0, 0x1C, 0x07, 0x80, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0E, 0x0F, 0xE0, 0x30, 0x0F, 0xF9,
  0x80, 0x1F, 0xC6, 0x00, 0x1C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80,
  0x0C, 0x06, 0x00, 0x78, 0x0C, 0x01, 0xE0, 0x18, 0x07, 0x80, 0x38, 0xDF,
  0x00, 0x3C, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x70, 0x01, 0xE7, 0xF0,
  0x03, 0x3F, 0xE0, 0x0C, 0x0F, 0xC0, 0x60, 0x1F, 0x81, 0x00, 0x3F, 0x98,
  0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xF0, 0x0E, 0x0F, 0xE0, 0x30, 0x1F, 0xF9, 0x80, 0x1F, 0xC6, 0x00,
  0x1C, 0x10, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x0E, 0x06, 0x00, 0x78,
  0x08, 0x01, 0xE0, 0x10, 0x07, 0xC0, 0x30, 0xDF, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x63, 0xF0, 0x03, 0xBF, 0xE0, 0x0C, 0x9F,
  0xC0, 0x20, 0x3F, 0x81, 0x80, 0x3F, 0x08, 0x00, 0x7F, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x00, 0xC0, 0x18, 0x7E, 0x18, 0x07, 0x1F, 0xE1, 0x80, 0xE6, 0x3E,
  0x30, 0x3C, 0x83, 0xE2, 0x07, 0xA0, 0x7C, 0x60, 0xFC, 0x07, 0xCC, 0x1F,
  0x80, 0xFD, 0x01, 0xF8, 0x0C, 0x60, 0x3F, 0x03, 0x08, 0x03, 0xF1, 0xE2,
  0x00, 0x3E, 0x7E, 0x80, 0x07, 0xF7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0x87, 0x80, 0x20, 0x70, 0xF8, 0x1F, 0x0C, 0x1F, 0x07, 0xF1, 0x81, 0xF1,
  0x3F, 0x20, 0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0x3C, 0x00, 0x38, 0x00, 0x00,
  0x02, 0x00, 0x01, 0xF8, 0x03, 0x83, 0x81, 0xC0, 0x70, 0xE0, 0x0E, 0x38,
  0x03, 0x9E, 0x00, 0xE7, 0x80, 0x39, 0xF0, 0x0E, 0x7E, 0x03, 0x8F, 0x80,
  0xE3, 0xE0, 0x70, 0x7D, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x02, 0xFF,
  0xC0, 0xC3, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x70, 0x1C, 0x01, 0xFF, 0x1F, 0xC7, 0xF0, 0x3F, 0xFB, 0xFE, 0xCF,
  0x87, 0xFF, 0xE3, 0xF8, 0x78, 0x40, 0x7E, 0x1F, 0x07, 0x88, 0x03, 0xE0,
  0xF8, 0x7C, 0x80, 0x1F, 0x0F, 0x87, 0xC8, 0x00, 0xF0, 0x78, 0x3E, 0x80,
  0x0F, 0x07, 0x83, 0xF8, 0x00, 0x78, 0x78, 0x18, 0x80, 0x07, 0x83, 0x83,
  0x07, 0xF8, 0x78, 0x38, 0x60, 0x7F, 0x87, 0x83, 0x8C, 0x01, 0xF8, 0x70,
  0x38, 0xC0, 0x00, 0x83, 0x03, 0x9C, 0x00, 0x00, 0x70, 0x31, 0xC0, 0x00,
  0x06, 0x03, 0x3C, 0x00, 0x00, 0x60, 0x33, 0xE0, 0x00, 0x04, 0x02, 0x1E,
  0x00, 0xF0, 0xDC, 0x41, 0xF0, 0x3F, 0x8B, 0xE4, 0x1F, 0xB6, 0xFD, 0x7F,
  0x80, 0xFE, 0x07, 0xEF, 0xF0, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x30, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x01,
  0xFF, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0x87, 0xBF, 0xC8, 0x78, 0xC0, 0x7F,
  0x07, 0xC8, 0x03, 0xF0, 0x7C, 0x80, 0x1F, 0x03, 0xC8, 0x00, 0xF0, 0x3E,
  0x80, 0x0F, 0x83, 0xF8, 0x00, 0x78, 0x18, 0xC0, 0x07, 0x83, 0x07, 0xF8,
  0x78, 0x20, 0x3F, 0x87, 0x86, 0x01, 0xE8, 0x30, 0xE0, 0x00, 0x83, 0x1C,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x61, 0xE0, 0x00,
  0x04, 0x1E, 0x01, 0xF0, 0xC1, 0xF0, 0x3F, 0x88, 0x0F, 0xF4, 0xFF, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x0C, 0x0F, 0xF0, 0x30, 0x03, 0xF8, 0x70, 0x00, 0xFC, 0x60, 0x00, 0x7C,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xFE, 0x00, 0x0E, 0x7F, 0x80, 0x0E,
  0x7F, 0xC0, 0x0E, 0x1F, 0xE0, 0x06, 0x07, 0xE0, 0x06, 0x01, 0xC0, 0x06,
  0x00, 0xC0, 0x06, 0x0C, 0x80, 0x04, 0x3F, 0x00, 0x0C, 0x7F, 0x80, 0x08,
  0x9F, 0xE0, 0x10, 0x0F, 0xF8, 0x60, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x04, 0x00, 0xFF, 0x80, 0xE0, 0x1F, 0xFE,
  0x1F, 0x00, 0xE3, 0xFB, 0xF8, 0x0C, 0x07, 0xE7, 0xE0, 0x40, 0x1F, 0x1F,
  0x82, 0x00, 0xF8, 0xFE, 0x10, 0x03, 0xC3, 0xF8, 0x80, 0x1E, 0x0F, 0xE4,
  0x00, 0xF0, 0x3F, 0xA0, 0x07, 0x80, 0xFC, 0xC1, 0x3C, 0x01, 0xE3, 0xF9,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0,
  0x06, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x01, 0x00, 0x0F, 0x80, 0x08,
  0x00, 0xFE, 0x00, 0x80, 0x1F, 0xFC, 0x08, 0x00, 0x8F, 0xFF, 0x80, 0x08,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xC0, 0xFF, 0x01, 0x80, 0x1F, 0xC1, 0xC0,
  0x03, 0xF0, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3F,
  0x80, 0x03, 0x8F, 0xF0, 0x01, 0xC7, 0xFC, 0x00, 0xE0, 0xFF, 0x00, 0x30,
  0x1F, 0x80, 0x18, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x06, 0x40, 0x62,
  0x0F, 0xC0, 0x7F, 0x0F, 0xF0, 0x7F, 0x09, 0xFE, 0xC7, 0xC8, 0x7F, 0xC3,
  0xF8, 0x0F, 0xFE, 0xF8, 0x01, 0xFE, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xFF, 0x83,
  0xF0, 0x0F, 0xFF, 0x1F, 0xE0, 0x7F, 0xFE, 0x87, 0xC1, 0x81, 0xFA, 0x0F,
  0x8C, 0x01, 0xF8, 0x3E, 0x30, 0x03, 0xC0, 0xF8, 0x80, 0x07, 0x81, 0xFA,
  0x00, 0x1E, 0x03, 0x88, 0x00, 0x78, 0x08, 0x20, 0x00, 0xE0, 0xC0, 0x40,
  0x03, 0x8E, 0x01, 0x80, 0x0E, 0x7C, 0x03, 0x8C, 0x3B, 0xF0, 0x01, 0x40,
  0xE3, 0xE0, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x30,
  0x7C, 0x01, 0x80, 0x81, 0xF0, 0x0F, 0x84, 0x07, 0xC0, 0x7E, 0x10, 0x0F,
  0x82, 0xFF, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x02, 0x03, 0xFF,
  0xFC, 0x06, 0x1F, 0xF8, 0x08, 0x07, 0xF0, 0x10, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0xE0, 0xE0, 0x07, 0xF8, 0xE2, 0x0F,
  0xFC, 0xE1, 0x7F, 0xFE, 0xE0, 0xFF, 0x02, 0xE0, 0xFE, 0x01, 0xE0, 0x38,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x7C, 0x00, 0x02, 0x7E, 0x00,
  0x06, 0x3F, 0x80, 0x1C, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x30, 0x7F,
  0xC0, 0x40, 0x1F, 0xF0, 0xC0, 0x07, 0xFF, 0x80, 0x11, 0xFC, 0x80, 0x60,
  0xF8, 0x80, 0xE0, 0x00, 0x80, 0xF0, 0x00, 0x80, 0xF8, 0x00, 0x40, 0xFC,
  0x00, 0x3B, 0x7E, 0x00, 0x04, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x0E, 0x07, 0x80, 0x3F, 0x07, 0x00, 0x7F, 0x84, 0x00, 0x8F, 0xD8,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x04, 0x01, 0xFE, 0x18, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x08, 0x31, 0x00, 0x61, 0x82, 0x07,
  0x0E, 0x08, 0x7C, 0x38, 0x63, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x1E, 0x0F,
  0x80, 0x78, 0x3F, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0xF8, 0x1E, 0x01, 0xF0,
  0x78, 0x07, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x30, 0x1E, 0x01, 0x80, 0x78,
  0x04, 0x01, 0xE0, 0x20, 0x07, 0x83, 0xE0, 0x1E, 0x1F, 0xC0, 0xF8, 0xBF,
  0x85, 0xF0, 0x3F, 0xE7, 0xF0, 0x7F, 0x0F, 0x80, 0xF8, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x1F,
  0xF8, 0xFF, 0x07, 0xFF, 0xD0, 0xF0, 0x70, 0x7F, 0x0F, 0x8C, 0x03, 0xF0,
  0x78, 0xC0, 0x1F, 0x07, 0xE8, 0x00, 0xF0, 0x38, 0x80, 0x0F, 0x01, 0x08,
  0x00, 0xF0, 0x20, 0x80, 0x07, 0x06, 0x04, 0x00, 0x60, 0xF0, 0x60, 0x4E,
  0x0F, 0x01, 0xF8, 0xC0, 0xFC, 0x00, 0x0C, 0x0F, 0xC0, 0x01, 0x80, 0x7E,
  0x00, 0x10, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xE0, 0xFF,
  0xC0, 0x0E, 0x11, 0xFE, 0x00, 0xC0, 0x07, 0xF0, 0x08, 0x00, 0x3F, 0xC1,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0xC1, 0xF8, 0x03, 0xFF, 0x3C, 0xDF, 0x80, 0xFF, 0xF8, 0x60, 0xF8,
  0x3C, 0x7F, 0x0C, 0x1F, 0x0E, 0x03, 0xE3, 0x01, 0xF1, 0x80, 0x3E, 0x60,
  0x3E, 0x20, 0x03, 0xCE, 0x03, 0xE4, 0x00, 0x7B, 0xC0, 0x3A, 0x80, 0x0F,
  0x7C, 0x06, 0x10, 0x00, 0xE7, 0xC1, 0x81, 0x00, 0x1C, 0xF8, 0x70, 0x30,
  0x23, 0x1F, 0x8F, 0x01, 0xB8, 0xE1, 0xF1, 0xF0, 0x08, 0x18, 0x1E, 0x3F,
  0x80, 0x02, 0x03, 0xC3, 0xF0, 0x00, 0x80, 0x38, 0x3E, 0x00, 0x20, 0x06,
  0x03, 0xE0, 0xFC, 0x00, 0xC0, 0x38, 0x3F, 0xC0, 0x1C, 0x03, 0x09, 0xFC,
  0x07, 0xC0, 0x40, 0x0F, 0xC1, 0xFC, 0x18, 0x00, 0xFE, 0xFF, 0xC2, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xC8, 0xFF, 0xC3, 0xFB, 0xFF, 0xCF,
  0xE7, 0x0F, 0x9F, 0x9C, 0x0F, 0xA6, 0x30, 0x0F, 0x80, 0x40, 0x0F, 0x00,
  0x80, 0x1E, 0x01, 0x00, 0x38, 0x01, 0x00, 0x7F, 0xC3, 0x01, 0xFF, 0x81,
  0xF7, 0xFE, 0x00, 0x13, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x78, 0x01, 0xC4,
  0xF8, 0x07, 0xE9, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC1, 0xF8, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xFE, 0x0F, 0xC0, 0xFF,
  0xE3, 0xFC, 0x3F, 0xFE, 0x87, 0xC7, 0x07, 0xF0, 0xF9, 0x80, 0x7E, 0x0F,
  0x20, 0x07, 0xC1, 0xF4, 0x00, 0x78, 0x3E, 0x80, 0x0F, 0x03, 0xF0, 0x01,
  0xE0, 0x32, 0x00, 0x1C, 0x08, 0x20, 0x03, 0x07, 0x02, 0x0C, 0xE0, 0xE0,
  0x3E, 0x1C, 0x3E, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x60, 0xFC, 0x00, 0x18,
  0x0F, 0x80, 0x02, 0x01, 0xF8, 0x00, 0x80, 0x1F, 0x00, 0x30, 0x03, 0xE0,
  0x0F, 0x84, 0x3E, 0x03, 0xFF, 0x07, 0xC0, 0xFF, 0xC0, 0xF0, 0x01, 0xF0,
  0x1E, 0x00, 0x1C, 0x03, 0x80, 0x80, 0x00, 0x70, 0x08, 0x00, 0x1C, 0x00,
  0xC0, 0x07, 0x00, 0x06, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1C, 0x0F, 0xC1, 0x80, 0x3E, 0x0C,
  0x00, 0xF0, 0x40, 0x03, 0x82, 0x00, 0x1C, 0x10, 0x01, 0xE0, 0xC0, 0x0E,
  0x03, 0x00, 0xC0, 0x0E, 0x0C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x19, 0xFC, 0x00, 0xD7, 0xF0,
  0x0C, 0x0F, 0xC0, 0x60, 0x3F, 0x04, 0x00, 0xFE, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0, 0x06, 0x00, 0x60, 0x0F, 0x01,
  0xF8, 0x3B, 0xC3, 0x0C, 0x60, 0x6C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0x38, 0xE3, 0x0C, 0x03, 0x00, 0x1E, 0x00, 0xFC, 0x04, 0xFC,
  0x31, 0xF9, 0x83, 0xC6, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF0, 0xF1, 0xE3, 0xD7, 0xDF, 0x8F, 0x9E, 0x18, 0x70, 0x40,
  0x40, 0x07, 0x82, 0x70, 0x0B, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x84, 0x0E, 0x38, 0x3B, 0xF0, 0xF3, 0xC3, 0x87, 0x8E, 0x1E, 0x38, 0x38,
  0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xC3, 0x82, 0x1F, 0x90,
  0xBF, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x80, 0x07, 0x07, 0xE3, 0x39, 0x8F,
  0x63, 0xF8, 0x4E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E,
  0x07, 0xE4, 0xFE, 0x0E, 0x01, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0xCF, 0x8E, 0x1E, 0x38, 0x3C, 0xE0, 0xF3, 0x81, 0xCE, 0x07, 0x38, 0x18,
  0xE0, 0x63, 0x81, 0x9F, 0x04, 0x7E, 0x32, 0x7F, 0x80, 0xFC, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x03, 0xF0, 0xDE, 0x31, 0xC6, 0x3D, 0xC3, 0xB8, 0x77,
  0x10, 0xFC, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1F, 0x91, 0xFC,
  0x0E, 0x00, 0x80, 0x08, 0x07, 0xF1, 0xF8, 0xDE, 0x20, 0x08, 0x02, 0x00,
  0xE0, 0x7F, 0xAF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0,
  0x13, 0xF8, 0xC3, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x63, 0x81, 0x8E, 0x0F,
  0x3C, 0x3C, 0xF0, 0xF1, 0xC3, 0xC7, 0x87, 0x9E, 0x3E, 0x3F, 0x78, 0x60,
  0xE2, 0x03, 0x80, 0x0E, 0x00, 0x39, 0x80, 0xC7, 0x06, 0x0E, 0x30, 0x1F,
  0x00, 0x01, 0xC0, 0x70, 0x27, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x18, 0x39, 0xE1, 0xFF, 0x0E, 0x3C, 0x70, 0xF3, 0x87, 0x9C, 0x3C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x3F,
  0xBB, 0xF1, 0x83, 0x08, 0x08, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x08, 0x0F, 0x07, 0x83, 0x81, 0x80, 0x00, 0x40, 0x30, 0x3C,
  0x3F, 0x17, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xD0, 0xF8, 0x7C, 0x1C, 0x04, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x38, 0x1F, 0x07, 0xE2, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x32, 0x18, 0x7C, 0x00, 0x01, 0x83, 0x23,
  0x0B, 0x17, 0x99, 0xDC, 0xF8, 0x78, 0x3F, 0xFF, 0xCE, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xD3, 0xF8, 0x78, 0x18,
  0x04, 0x00, 0x01, 0x83, 0x27, 0x0B, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xD3, 0xF0, 0x78, 0x18, 0x08, 0x00, 0x00, 0x01, 0x00, 0xC1, 0x87,
  0x07, 0x9F, 0x3E, 0x3F, 0xFF, 0xFE, 0xBC, 0x78, 0xF0, 0xF1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7,
  0x8F, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F,
  0x5F, 0xBF, 0x1F, 0x3C, 0x78, 0x78, 0x60, 0xC0, 0xE1, 0x02, 0x00, 0x00,
  0x20, 0x40, 0xF1, 0xC1, 0xE7, 0xF5, 0xF3, 0xC3, 0xC7, 0x87, 0x87, 0x0F,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3,
  0x87, 0x87, 0x1F, 0x8F, 0x9E, 0x1E, 0x18, 0x1C, 0x20, 0x10, 0x00, 0xC0,
  0x3E, 0x1E, 0xF8, 0xF3, 0xE7, 0x9F, 0x3C, 0x7D, 0xE1, 0xEF, 0x07, 0x78,
  0x3B, 0xC1, 0xDE, 0x0E, 0xF0, 0x67, 0x83, 0x7F, 0x30, 0xFE, 0x01, 0xE0,
  0x06, 0x00, 0x20, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x07, 0xC1, 0x07,
  0xCF, 0x0F, 0xBE, 0x0F, 0x9E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x3C, 0x70,
  0x78, 0xE0, 0xF1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x3E, 0x0C, 0xFF, 0x31,
  0x3F, 0xC0, 0x7F, 0x00, 0xEC, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x01, 0xE0,
  0x1F, 0x81, 0x3F, 0x90, 0xF9, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCF, 0x0E, 0x78, 0x73, 0xE3, 0x8F, 0xFC, 0x3C, 0xE0, 0xC7,
  0x04, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x00, 0x0E, 0x11, 0xE7, 0x7D, 0xEB, 0xDE, 0x7B, 0x8F, 0x21, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x23, 0xF8, 0x1E, 0x01,
  0x80, 0x10, 0x00, 0x07, 0x80, 0x06, 0x00, 0x10, 0x01, 0x0E, 0x11, 0xFB,
  0x2F, 0xF4, 0x3E, 0xC0, 0x4C, 0x08, 0xE1, 0x8F, 0xBC, 0x7F, 0xE3, 0x8F,
  0x30, 0x72, 0x06, 0x78, 0x6F, 0xE4, 0x7F, 0x80, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x40, 0x10, 0x18, 0x0E, 0x07, 0x83, 0xFD, 0xFF, 0x9C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE8,
  0xFE, 0x0F, 0x01, 0x80, 0x20, 0x00, 0x20, 0x60, 0x61, 0xE0, 0xE7, 0xC7,
  0xEB, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0xBF, 0x5F, 0x1F,
  0x3C, 0x0C, 0x38, 0x10, 0x00, 0x20, 0x00, 0x80, 0x43, 0x81, 0x87, 0x8F,
  0x8F, 0x3F, 0x9F, 0x8F, 0x1F, 0x0F, 0x1E, 0x1E, 0x1C, 0x1C, 0x38, 0x38,
  0x30, 0x70, 0x60, 0xE0, 0xC1, 0xC1, 0x03, 0x06, 0x0E, 0x0F, 0x18, 0x3F,
  0xC0, 0x1F, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3C, 0x18, 0x10, 0xF8, 0x70, 0xE1, 0xF7, 0xEF, 0xC3,
  0xE7, 0xCF, 0x8F, 0x0E, 0x1E, 0x3C, 0x38, 0x38, 0xF0, 0xE0, 0xF3, 0xC3,
  0x83, 0xC7, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xE3, 0xC3, 0x83,
  0x0F, 0x0F, 0x08, 0x3C, 0x7E, 0x41, 0xF8, 0xFE, 0x03, 0xC0, 0xF0, 0x06,
  0x00, 0xC0, 0x08, 0x02, 0x00, 0x10, 0x43, 0x84, 0x3C, 0xE7, 0xFE, 0x1E,
  0xF1, 0xE6, 0x1E, 0x41, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0xC3, 0xF0, 0x7F, 0x0C, 0x60, 0x84, 0x08, 0x00, 0x80,
  0x04, 0x08, 0x61, 0xC1, 0xFC, 0x00, 0x00, 0x60, 0x01, 0x00, 0x0E, 0x00,
  0x3E, 0x18, 0xF9, 0xE1, 0xFF, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0xC1, 0xCF, 0x06, 0x3C,
  0x39, 0xFC, 0xE3, 0xE3, 0x03, 0x18, 0x08, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x00, 0x08, 0x07, 0x03, 0xE1, 0xFC, 0x0F, 0x01,
  0x80, 0xC0, 0x20, 0x10, 0x9F, 0xCF, 0xE0, 0x7C, 0x1F, 0x89, 0xE4, 0x39,
  0x0E, 0xC3, 0xE0, 0xE8, 0x3A, 0x0E, 0x83, 0x30, 0xC4, 0x20, 0xF0, 0x07,
  0x86, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x06, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x38, 0x0C, 0x03, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x18, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x07, 0x01, 0x80, 0x70, 0x1C, 0x30, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x38, 0x20, 0x00, 0xFF, 0xFF, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 25, 8, 1, -25 },
  { 20, 12, 9, 14, 1, -24 },
  { 34, 15, 20, 18, 1, -22 },
  { 72, 12, 28, 14, 1, -26 },
  { 114, 22, 24, 24, 1, -24 },
  { 180, 18, 21, 19, 1, -21 },
  { 228, 5, 9, 7, 1, -24 },
  { 234, 8, 28, 8, 0, -27 },
  { 262, 8, 28, 8, 0, -27 },
  { 290, 11, 13, 12, 0, -25 },
  { 308, 11, 12, 13, 1, -17 },
  { 325, 6, 9, 6, 0, -5 },
  { 332, 9, 6, 10, 1, -13 },
  { 339, 6, 5, 7, 0, -5 },
  { 343, 16, 26, 18, 1, -25 },
  { 395, 14, 24, 16, 1, -24 },
  { 437, 11, 23, 11, 0, -23 },
  { 469, 15, 23, 15, 0, -23 },
  { 513, 14, 23, 16, 1, -23 },
  { 554, 15, 23, 16, 0, -23 },
  { 598, 14, 24, 16, 1, -24 },
  { 640, 14, 24, 15, 1, -24 },
  { 682, 13, 23, 15, 1, -23 },
  { 720, 14, 24, 16, 1, -24 },
  { 762, 14, 24, 15, 1, -24 },
  { 804, 6, 16, 7, 0, -16 },
  { 816, 6, 20, 6, 0, -16 },
  { 831, 9, 13, 10, 0, -16 },
  { 846, 11, 7, 13, 1, -14 },
  { 856, 9, 13, 10, 0, -16 },
  { 871, 13, 24, 15, 1, -24 },
  { 910, 19, 21, 21, 1, -16 },
  { 960, 26, 25, 28, 1, -24 },
  { 1042, 30, 26, 30, 0, -25 },
  { 1140, 22, 25, 23, 1, -25 },
  { 1209, 26, 26, 28, 1, -25 },
  { 1294, 22, 25, 24, 1, -25 },
  { 1363, 24, 29, 26, 1, -25 },
  { 1450, 24, 25, 26, 1, -24 },
  { 1525, 24, 31, 25, 0, -26 },
  { 1618, 22, 29, 23, 1, -25 },
  { 1698, 22, 33, 24, 1, -25 },
  { 1789, 27, 25, 28, 0, -24 },
  { 1874, 18, 25, 19, 1, -24 },
  { 1931, 36, 26, 38, 1, -24 },
  { 2048, 28, 25, 30, 1, -24 },
  { 2136, 24, 25, 26, 1, -24 },
  { 2211, 29, 30, 30, 1, -24 },
  { 2320, 25, 26, 27, 1, -24 },
  { 2402, 30, 26, 32, 1, -25 },
  { 2500, 24, 24, 26, 1, -24 },
  { 2572, 24, 24, 25, 1, -24 },
  { 2644, 22, 26, 24, 1, -24 },
  { 2716, 28, 26, 30, 1, -25 },
  { 2807, 35, 25, 37, 1, -24 },
  { 2917, 23, 26, 25, 1, -25 },
  { 2992, 27, 30, 29, 1, -25 },
  { 3094, 21, 29, 23, 1, -25 },
  { 3171, 4, 27, 6, 1, -25 },
  { 3185, 20, 24, 4, -6, -22 },
  { 3245, 4, 27, 6, 1, -25 },
  { 3259, 12, 9, 14, 1, -24 },
  { 3273, 16, 2, 16, 0, 4 },
  { 3277, 5, 6, 17, 6, -24 },
  { 3281, 14, 18, 16, 1, -17 },
  { 3313, 14, 24, 15, 1, -23 },
  { 3355, 10, 18, 12, 1, -17 },
  { 3378, 14, 25, 15, 1, -24 },
  { 3422, 11, 18, 12, 1, -17 },
  { 3447, 10, 30, 8, 0, -24 },
  { 3485, 14, 25, 16, 1, -18 },
  { 3529, 13, 30, 15, 1, -24 },
  { 3578, 9, 25, 9, 0, -24 },
  { 3607, 10, 30, 8, -2, -24 },
  { 3645, 9, 25, 11, 1, -24 },
  { 3674, 9, 25, 9, 1, -24 },
  { 3703, 22, 19, 24, 1, -18 },
  { 3756, 15, 18, 17, 1, -17 },
  { 3790, 13, 18, 14, 0, -17 },
  { 3820, 15, 27, 15, 0, -20 },
  { 3871, 13, 25, 15, 1, -18 },
  { 3912, 11, 19, 12, 1, -18 },
  { 3939, 12, 22, 14, 1, -21 },
  { 3972, 10, 23, 11, 0, -22 },
  { 4001, 15, 19, 17, 1, -18 },
  { 4037, 15, 20, 15, 0, -19 },
  { 4075, 22, 21, 23, 1, -20 },
  { 4133, 12, 25, 13, 1, -18 },
  { 4171, 14, 26, 16, 1, -20 },
  { 4217, 10, 24, 11, 1, -18 },
  { 4247, 9, 27, 11, 1, -26 },
  { 4278, 2, 29, 5, 2, -27 },
  { 4286, 9, 27, 11, 1, -26 },
  { 4317, 11, 2, 12, 1, -11 },
};

const GFXfont UnifrakturMaguntia_Regular34pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular34pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular34pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR34PT7B_H_
