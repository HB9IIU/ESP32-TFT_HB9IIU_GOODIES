#ifndef _UNIFRAKTURMAGUNTIA_REGULAR37PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0xE7, 0xE7, 0xEF, 0x9E, 0x1C, 0x38, 0x70, 0xC1, 0x83,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x1C, 0xFC, 0x70,
  0x40, 0x00, 0x30, 0x41, 0x87, 0x3F, 0x7E, 0xF9, 0xF3, 0x87, 0x0C, 0x18,
  0x60, 0xC2, 0x04, 0x20, 0x41, 0x02, 0x00, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x87, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x0C, 0x30, 0x0E, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0x01, 0x86,
  0x18, 0x18, 0xC0, 0xCE, 0x06, 0x70, 0x3B, 0x81, 0x9E, 0x08, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFA, 0x0F, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xB0, 0x1D, 0x80, 0xC4, 0x0E, 0x30, 0xE0, 0x7E, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x1E, 0x00, 0x03, 0x33, 0x80, 0x02, 0x71,
  0x80, 0x04, 0x71, 0xC0, 0x0C, 0xF1, 0xC0, 0x18, 0xF1, 0xC0, 0x30, 0xF1,
  0xC0, 0x60, 0xF1, 0xC0, 0xC0, 0xF1, 0xC0, 0x80, 0x71, 0xC1, 0x00, 0x71,
  0x83, 0x00, 0x33, 0x86, 0x00, 0x1E, 0x0C, 0x78, 0x00, 0x18, 0xCC, 0x00,
  0x31, 0xCE, 0x00, 0x63, 0xC7, 0x00, 0x43, 0xC7, 0x00, 0x83, 0xC7, 0x01,
  0x83, 0xC7, 0x03, 0x03, 0xC7, 0x06, 0x03, 0xC7, 0x0C, 0x03, 0xC7, 0x18,
  0x01, 0xCE, 0x10, 0x00, 0xCC, 0x20, 0x00, 0x78, 0x40, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1E,
  0x30, 0x03, 0xCE, 0x00, 0x79, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0xFC, 0x3F,
  0x0F, 0x0F, 0xE0, 0xC3, 0xBE, 0x18, 0xE7, 0xC2, 0x1C, 0x7C, 0x47, 0x8F,
  0x98, 0xF0, 0xFA, 0x1E, 0x1F, 0x83, 0xC1, 0xF0, 0x3C, 0x3F, 0x17, 0x83,
  0xFC, 0x78, 0x7F, 0x87, 0xF1, 0xC0, 0x23, 0xBE, 0xF3, 0x8C, 0x42, 0x22,
  0x00, 0x06, 0x08, 0x18, 0x30, 0x30, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x30, 0x30, 0x18, 0x0C, 0x06, 0xC0, 0x20, 0x10, 0x18, 0x1C,
  0x1C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x18, 0x10, 0x30,
  0xC0, 0x00, 0x00, 0x60, 0x0F, 0x02, 0xFC, 0xF6, 0x77, 0x2F, 0x7B, 0xE0,
  0x62, 0x7B, 0xE7, 0x2F, 0xF6, 0x71, 0xF4, 0x0F, 0x80, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00, 0xC7,
  0xBF, 0x3C, 0x71, 0x86, 0x10, 0x80, 0x00, 0x47, 0xF3, 0xF8, 0x80, 0x00,
  0x0F, 0xE7, 0xF3, 0xF0, 0x00, 0x87, 0x3E, 0x70, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0C, 0x70, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x3C,
  0x38, 0x3C, 0x38, 0x38, 0x1C, 0x38, 0x0C, 0x70, 0x07, 0xC0, 0x03, 0x00,
  0x60, 0x1C, 0x07, 0x81, 0xF0, 0x7E, 0x13, 0xC4, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xFC, 0x7F, 0xE0, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE3, 0x87, 0xE6, 0x07, 0xD8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x08, 0x40, 0x11, 0x00,
  0x27, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xF8,
  0x30, 0xFC, 0x40, 0x7C, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0x70, 0x18, 0x78, 0x30, 0x1F, 0xC0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0x70,
  0x02, 0x70, 0x04, 0x70, 0x04, 0x70, 0x08, 0x70, 0x18, 0x70, 0x10, 0x70,
  0x20, 0x70, 0x60, 0x70, 0x40, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x03, 0xFF, 0x38, 0x3C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x2F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xFC, 0x70, 0x7E, 0x60, 0x3E, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1C, 0xF0, 0x1C,
  0x70, 0x38, 0x38, 0x70, 0x0F, 0xC0, 0x03, 0xE0, 0x18, 0xF0, 0x70, 0xF0,
  0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x07, 0x3C, 0x00, 0xF8, 0x01, 0xE1,
  0xC3, 0xCF, 0xC7, 0xB3, 0xEF, 0x43, 0xDF, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xCF, 0x03, 0x8E,
  0x0E, 0x1C, 0x18, 0x1C, 0x60, 0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF0, 0x02, 0x80, 0x0A, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xE0, 0x30, 0x60, 0xC0, 0x63, 0x80, 0x66, 0x00,
  0xDE, 0x01, 0xBC, 0x03, 0x3C, 0x06, 0x7C, 0x18, 0xFE, 0x60, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x83, 0x7F, 0x8C, 0x3F, 0x30, 0x3F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x38, 0x0E,
  0x38, 0x30, 0x1F, 0x80, 0x07, 0xC0, 0x30, 0xC0, 0xE1, 0xC1, 0x81, 0xC7,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xDF, 0x2F, 0x9F, 0xDF, 0x0E, 0x3C,
  0x00, 0x78, 0x00, 0xF3, 0x01, 0xEF, 0x03, 0x9F, 0x07, 0x1E, 0x0C, 0x3C,
  0x30, 0x38, 0x60, 0x1F, 0x00, 0x00, 0x87, 0x3E, 0x70, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x87, 0x3E, 0x70, 0x80, 0x00, 0x00, 0x20, 0xE3, 0xE3,
  0x82, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x1E, 0x7E, 0x3C, 0x38,
  0x60, 0xC1, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x1F, 0x0F,
  0x81, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x7C, 0x1E, 0x0F, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x00, 0x0F, 0xE0, 0xE1, 0xC6, 0x03, 0xB8, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x83, 0xDC, 0x0F, 0x00, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x04, 0x18, 0x10, 0x70, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38, 0x01, 0xF8, 0x03, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3C, 0x1C, 0x03, 0x80, 0x30, 0x30,
  0x00, 0xC3, 0x80, 0x06, 0x38, 0x3F, 0x99, 0x83, 0x3C, 0xDC, 0x39, 0xE6,
  0xE3, 0x8E, 0x36, 0x3C, 0x71, 0xB1, 0xC3, 0x8D, 0x8E, 0x3C, 0x6C, 0xF1,
  0xC6, 0x67, 0x1E, 0x33, 0x3D, 0xF3, 0x1C, 0xFB, 0xB3, 0x67, 0x9F, 0x3B,
  0x80, 0x01, 0x8C, 0x00, 0x18, 0x38, 0x01, 0x80, 0xF0, 0x30, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x61, 0xFF, 0xC0, 0x1C, 0x39, 0xFE, 0x07, 0x86,
  0x03, 0xF1, 0xF8, 0x40, 0x1F, 0xAF, 0x8C, 0x01, 0xF8, 0xF8, 0x80, 0x0F,
  0x8F, 0x88, 0x00, 0xF8, 0xF8, 0xC0, 0x07, 0x8F, 0x8E, 0x00, 0x78, 0xF8,
  0xFC, 0x07, 0x8F, 0x87, 0xE0, 0x70, 0xF8, 0x3F, 0x0F, 0x0F, 0x81, 0xF0,
  0xE0, 0xF8, 0x03, 0x0C, 0x0F, 0x80, 0x31, 0x80, 0xF8, 0x02, 0x30, 0x0F,
  0x80, 0x02, 0x00, 0xF8, 0x00, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xF8, 0x0F, 0x80, 0xFF, 0xC1, 0xF8, 0x09, 0xFE, 0x2F, 0xF0, 0x0F, 0xFC,
  0x7E, 0x00, 0x3F, 0x87, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0x1F, 0xF0,
  0x3F, 0xFF, 0xA1, 0xF0, 0x3C, 0x1F, 0xA1, 0xF8, 0x70, 0x0F, 0xC0, 0xF8,
  0x60, 0x07, 0xC0, 0xF8, 0x40, 0x03, 0xC0, 0x7C, 0xC0, 0x03, 0xC0, 0x7E,
  0x40, 0x03, 0xC0, 0x38, 0x40, 0x01, 0xC0, 0x60, 0x60, 0x01, 0xC1, 0xF0,
  0x60, 0x01, 0xC7, 0xF8, 0x30, 0x33, 0x9F, 0xFE, 0x1F, 0xC3, 0x00, 0xFE,
  0x00, 0x03, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x0F,
  0x00, 0x10, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x0F,
  0x03, 0xFF, 0x00, 0x0E, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0x1F, 0xE0, 0x18,
  0x00, 0x0F, 0xF8, 0x30, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x40, 0x07, 0x18, 0xF0, 0x0E, 0x09,
  0xFE, 0x1C, 0x07, 0xFE, 0x3C, 0x08, 0x78, 0x38, 0x30, 0x10, 0x78, 0x70,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFE, 0x00, 0xF8, 0x7F, 0x00, 0xF8, 0x3F, 0x80, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7E, 0x03,
  0xC0, 0x3E, 0x03, 0x80, 0x3F, 0x03, 0x00, 0x1F, 0x86, 0x00, 0x0F, 0xE8,
  0x00, 0x07, 0xF0, 0x02, 0x07, 0xFE, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0x07, 0xC0, 0x87, 0xF8, 0x70, 0x1C,
  0x1F, 0x8E, 0x03, 0x00, 0xFC, 0xC0, 0x70, 0x07, 0xCC, 0x0F, 0x80, 0x3E,
  0xC0, 0xFC, 0x01, 0xE8, 0x0F, 0xE0, 0x0E, 0x80, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0x40, 0x1F, 0x80, 0x76, 0x00, 0xF8, 0x07, 0x30, 0x07, 0x80,
  0x70, 0xFC, 0x38, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00,
  0x0C, 0x00, 0x40, 0x3F, 0x80, 0x0C, 0x07, 0xFC, 0x00, 0x81, 0xFF, 0xF0,
  0x10, 0x30, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x40, 0x07, 0x18, 0xF0, 0x0E, 0x09, 0xFF,
  0x1C, 0x07, 0xFE, 0x3C, 0x08, 0x78, 0x38, 0x30, 0x10, 0x78, 0x70, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF8, 0x30, 0xF8, 0xFC, 0x78,
  0xF8, 0xFE, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0x9C, 0xF8, 0x1F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7E, 0x03, 0xC0,
  0x3E, 0x03, 0x80, 0x3F, 0x03, 0x00, 0x1F, 0x86, 0x00, 0x0F, 0xE8, 0x00,
  0x07, 0xF0, 0x02, 0x03, 0xFE, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0x01, 0xFF, 0xE7, 0x00, 0x1F, 0xF1, 0x80,
  0x09, 0xF0, 0xC0, 0x04, 0x18, 0x30, 0x03, 0x80, 0x0C, 0x01, 0xE0, 0x03,
  0x00, 0x7C, 0x08, 0xC0, 0x1F, 0x87, 0xB0, 0x07, 0xF3, 0xF4, 0x00, 0xFC,
  0xFD, 0x80, 0x1F, 0xFE, 0x30, 0x07, 0xF3, 0x03, 0xBC, 0xFC, 0x00, 0x10,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0xFC, 0x01, 0xE0, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x01, 0xE0,
  0x30, 0x00, 0x3C, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0x06, 0x00, 0x1C, 0x11, 0xE0, 0x07, 0x01, 0xFE, 0x01, 0xC0, 0x67,
  0xE0, 0x78, 0x10, 0x7F, 0x0E, 0x0E, 0x07, 0xE3, 0xC3, 0x80, 0x78, 0x78,
  0xF0, 0x04, 0x0F, 0x1E, 0x03, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x7E, 0x7F,
  0x8F, 0x87, 0xDF, 0xF9, 0xF0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC1, 0xF7, 0xC0,
  0xFC, 0x3E, 0xF8, 0x0F, 0x83, 0xDF, 0x81, 0xF0, 0x79, 0xF0, 0x1E, 0x0F,
  0x3E, 0x03, 0xC1, 0xE3, 0xE0, 0x70, 0x3C, 0x7C, 0x0C, 0x07, 0x07, 0xC2,
  0x01, 0xE0, 0x7C, 0x80, 0x38, 0x07, 0xC0, 0x0E, 0x00, 0x7E, 0x03, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x31, 0xF8, 0x00, 0x18, 0x3F, 0x80, 0x0C, 0x07, 0x80, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x01, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0,
  0xFC, 0x01, 0xF8, 0xFF, 0x80, 0x7E, 0x67, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x78, 0x38,
  0x0F, 0x3F, 0x0C, 0x03, 0xDF, 0xE2, 0x00, 0xE1, 0xFF, 0x00, 0x78, 0x3F,
  0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1C, 0x1F, 0xE0, 0x38, 0x07,
  0xF6, 0x30, 0x03, 0xFC, 0x60, 0x01, 0xF0, 0x60, 0x00, 0x20, 0x60, 0x00,
  0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x30, 0x03, 0xC0, 0x30, 0x03,
  0xE0, 0x18, 0x03, 0xE0, 0x0F, 0x1B, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x7F, 0x80,
  0x1C, 0xFF, 0xC0, 0x1C, 0x0F, 0xE0, 0x18, 0x07, 0xF0, 0x30, 0x03, 0xFC,
  0x60, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x3C, 0x1F, 0xE0, 0x30, 0x0F, 0xFE, 0x70, 0x03,
  0xFC, 0x60, 0x01, 0xF0, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00,
  0xC0, 0x60, 0x01, 0xC0, 0x20, 0x03, 0xE0, 0x30, 0x03, 0xE0, 0x18, 0x03,
  0xE0, 0x0E, 0x19, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x3F, 0x00, 0x0E, 0x7F, 0xC0,
  0x0C, 0x9F, 0xE0, 0x08, 0x07, 0xF0, 0x18, 0x03, 0xF8, 0x30, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x3F,
  0x06, 0x00, 0xE3, 0xFE, 0x18, 0x0F, 0x3F, 0xF8, 0xC0, 0x79, 0x07, 0xC3,
  0x03, 0xD0, 0x3F, 0x18, 0x1E, 0x80, 0xF8, 0xC0, 0xFC, 0x07, 0xE6, 0x07,
  0xE0, 0x1F, 0xB0, 0x3F, 0x80, 0x63, 0x00, 0xFC, 0x04, 0x10, 0x07, 0xF0,
  0xF1, 0x00, 0x1F, 0x9F, 0x90, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0xE0, 0xE0, 0xF8, 0x1F,
  0x86, 0x07, 0xC1, 0xFE, 0x30, 0x1F, 0x03, 0xFB, 0x00, 0xFF, 0x0F, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x20, 0x01, 0xFE, 0x00,
  0xE0, 0xF0, 0x38, 0x0F, 0x0E, 0x00, 0xE3, 0xC0, 0x1E, 0xF8, 0x01, 0xDF,
  0x00, 0x3B, 0xE0, 0x07, 0x7E, 0x00, 0xEF, 0xC0, 0x3C, 0xFC, 0x07, 0x1F,
  0x81, 0xC1, 0xFB, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x67, 0xFC, 0x18, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x40, 0x00, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1F, 0xF0, 0xFE, 0x1F, 0xC0,
  0xFF, 0xF3, 0xFE, 0x4F, 0x81, 0xFF, 0xFC, 0xFF, 0x0F, 0x86, 0x07, 0xF0,
  0x7C, 0x0F, 0x18, 0x03, 0xF0, 0xFC, 0x1F, 0x20, 0x03, 0xE0, 0xF8, 0x3E,
  0x40, 0x07, 0xE0, 0xF0, 0x7C, 0x80, 0x07, 0xC1, 0xE0, 0x7F, 0x00, 0x07,
  0x83, 0xE0, 0xF2, 0x00, 0x0F, 0x03, 0xC0, 0x86, 0x00, 0x1E, 0x07, 0x82,
  0x07, 0xFC, 0x3C, 0x0E, 0x0C, 0x07, 0xF8, 0x38, 0x1C, 0x30, 0x07, 0xF0,
  0x70, 0x38, 0xE0, 0x00, 0x20, 0xE0, 0x71, 0xC0, 0x00, 0x01, 0x80, 0xE7,
  0x80, 0x00, 0x03, 0x01, 0x8F, 0x00, 0x00, 0x04, 0x03, 0x1E, 0x00, 0x00,
  0x18, 0x04, 0x3E, 0x00, 0x70, 0x20, 0x18, 0x7C, 0x03, 0xF0, 0xDE, 0x20,
  0xFC, 0x0F, 0xF1, 0x7E, 0xC0, 0xFF, 0xB3, 0xFD, 0xFF, 0x00, 0xFE, 0x07,
  0xF2, 0xFC, 0x01, 0xF0, 0x07, 0xC8, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0xF0, 0x3F, 0x80, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xF3, 0x0F, 0x06, 0x03,
  0xF4, 0x1F, 0x18, 0x03, 0xF0, 0x3E, 0x20, 0x03, 0xE0, 0x3C, 0x40, 0x03,
  0xE0, 0x7C, 0x80, 0x07, 0xC0, 0xFD, 0x00, 0x07, 0x80, 0xE2, 0x00, 0x0F,
  0x01, 0x86, 0x00, 0x1E, 0x06, 0x07, 0xFC, 0x1C, 0x18, 0x07, 0xF8, 0x38,
  0x30, 0x07, 0xF0, 0x70, 0xE0, 0x00, 0x20, 0xE3, 0xC0, 0x00, 0x01, 0x87,
  0x80, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x06, 0x3E, 0x00, 0x00, 0x18, 0x3C,
  0x00, 0x70, 0x30, 0x7C, 0x03, 0xF0, 0xC0, 0xFC, 0x0F, 0xF1, 0x00, 0xFF,
  0xA3, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0x83, 0xFF, 0x01,
  0x80, 0x1F, 0xE0, 0xC0, 0x01, 0xFC, 0x70, 0x00, 0x3F, 0x1C, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1E, 0xFF, 0x00, 0x03, 0x9F, 0xF0,
  0x00, 0xE3, 0xFE, 0x00, 0x3C, 0x7F, 0xC0, 0x06, 0x07, 0xF0, 0x01, 0x80,
  0x3C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x00, 0x04, 0x1F, 0x00, 0x03,
  0x0F, 0xE0, 0x00, 0x8F, 0xFE, 0x00, 0x40, 0x3F, 0xC0, 0x20, 0x07, 0xFC,
  0x10, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0x00, 0x3F, 0xF0, 0x0E, 0x00, 0xFF, 0xF0, 0x78, 0x03, 0xCF,
  0xF3, 0xF8, 0x0E, 0x07, 0xF9, 0xF8, 0x18, 0x07, 0xE3, 0xF8, 0x20, 0x07,
  0xC3, 0xF8, 0x40, 0x07, 0x87, 0xF8, 0x80, 0x0F, 0x87, 0xF9, 0x00, 0x1F,
  0x07, 0xFA, 0x00, 0x3E, 0x03, 0xF2, 0x00, 0x7C, 0x03, 0xF6, 0x04, 0xF8,
  0x03, 0xE3, 0xF1, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x80, 0x0F, 0xFC, 0x02,
  0x00, 0x3F, 0xFE, 0x08, 0x00, 0x83, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x06, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x7F, 0xC0,
  0x18, 0x01, 0xFE, 0x03, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x3F, 0x0F, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x78, 0xFF, 0x00, 0x07,
  0x87, 0xFC, 0x00, 0x38, 0x3F, 0xE0, 0x03, 0x81, 0xFF, 0x00, 0x38, 0x07,
  0xF0, 0x01, 0x80, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x1F, 0x00, 0x7B, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0xE3, 0xFE, 0x10,
  0xFF, 0x01, 0xF6, 0x07, 0xFE, 0x3F, 0xC0, 0x1F, 0xFE, 0xF8, 0x00, 0x7F,
  0x87, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xFF, 0x03, 0xF8,
  0x03, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xF2, 0x1F, 0x03, 0x81, 0xFE, 0x07,
  0xC3, 0x80, 0x7F, 0x03, 0xE1, 0x80, 0x0F, 0x81, 0xF8, 0xC0, 0x07, 0xC0,
  0x7E, 0x40, 0x01, 0xE0, 0x1F, 0x20, 0x00, 0xF0, 0x06, 0x10, 0x00, 0x3C,
  0x0C, 0x0C, 0x00, 0x1E, 0x08, 0x02, 0x00, 0x0F, 0x1C, 0x01, 0x80, 0x07,
  0x9F, 0x00, 0x30, 0xC3, 0xFF, 0x80, 0x07, 0x81, 0xC3, 0xE0, 0x00, 0x00,
  0xE1, 0xF0, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x00, 0x30, 0x3E, 0x00, 0x00,
  0x18, 0x1F, 0x00, 0x1C, 0x08, 0x0F, 0x80, 0x3F, 0x0C, 0x07, 0xE0, 0x3F,
  0xC4, 0x01, 0xFA, 0x27, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFC, 0x08, 0x07, 0xFF, 0xEE, 0x03, 0x1F, 0xFE,
  0x01, 0x00, 0xFF, 0x01, 0x80, 0x0F, 0x80, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x83, 0x80, 0x0F, 0xF8, 0xE1,
  0x0F, 0xFF, 0x38, 0x7F, 0xFE, 0x6E, 0x0F, 0xFC, 0x0B, 0x81, 0xFC, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x05, 0xF0, 0x00,
  0x03, 0x7E, 0x00, 0x01, 0x8F, 0xE0, 0x00, 0xE1, 0xFF, 0x01, 0xF0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0xFF,
  0xC0, 0x60, 0x0F, 0xF8, 0x30, 0x02, 0xFF, 0xB8, 0x01, 0x8F, 0xF2, 0x00,
  0xC1, 0xF8, 0x80, 0x78, 0x1C, 0x20, 0x1F, 0x00, 0x08, 0x07, 0xE0, 0x01,
  0x01, 0xFC, 0x00, 0x20, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0x03, 0xC0, 0x07, 0xE0, 0xF0, 0x07, 0xFC,
  0x30, 0x03, 0x7F, 0x98, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x30, 0x03, 0xFC, 0x18, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xC0, 0x02, 0x07, 0x10, 0x03, 0x07, 0x04, 0x07, 0x07, 0x82,
  0x0F, 0x03, 0xC1, 0x1F, 0x81, 0xE1, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C,
  0x00, 0xF0, 0x3F, 0x00, 0x78, 0x0F, 0xC0, 0x3C, 0x07, 0xF0, 0x1E, 0x01,
  0xF8, 0x0F, 0x00, 0x7E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x07, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x03, 0x00, 0x3C, 0x01, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x03, 0xF0, 0x0F, 0x83, 0xFC, 0x0B, 0xC2, 0x3F, 0x99,
  0xF4, 0x0F, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xF0, 0x7F,
  0x00, 0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0xF2, 0x3F, 0x07, 0x87, 0xF8, 0x3E,
  0x1C, 0x03, 0xF0, 0x7E, 0x30, 0x03, 0xE0, 0x7E, 0x40, 0x03, 0xC0, 0xF8,
  0x80, 0x07, 0x80, 0xE1, 0x00, 0x0F, 0x00, 0x82, 0x00, 0x0E, 0x06, 0x06,
  0x00, 0x1C, 0x0C, 0x04, 0x00, 0x38, 0x3C, 0x04, 0x0C, 0x60, 0x7C, 0x07,
  0xE1, 0xC0, 0xFC, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x0C, 0x01, 0xF8, 0x00,
  0x10, 0x01, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xE0, 0x7F,
  0xC0, 0x03, 0x81, 0xFF, 0xC0, 0x07, 0x02, 0x1F, 0xE0, 0x0C, 0x00, 0x1F,
  0xE0, 0x10, 0x00, 0x1F, 0xF0, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC1, 0xC1, 0xFC, 0x01, 0xFF, 0xCF, 0x9B, 0xF8, 0x0F, 0xFF, 0xA1, 0x83,
  0xF0, 0x7C, 0xFF, 0x06, 0x07, 0xC3, 0xC0, 0x7E, 0x30, 0x1F, 0x8C, 0x00,
  0xF8, 0xC0, 0x3E, 0x30, 0x03, 0xE7, 0x00, 0xFC, 0x80, 0x07, 0x9E, 0x01,
  0xFA, 0x00, 0x1E, 0x78, 0x03, 0x08, 0x00, 0x39, 0xF0, 0x08, 0x30, 0x00,
  0xE7, 0xE0, 0x60, 0x40, 0x03, 0x8F, 0x83, 0x80, 0x80, 0x8C, 0x3F, 0x1F,
  0x01, 0xDC, 0x30, 0x7C, 0x7E, 0x00, 0x81, 0x81, 0xF0, 0xFE, 0x00, 0x04,
  0x03, 0xC3, 0xF8, 0x00, 0x20, 0x0F, 0x07, 0xF0, 0x01, 0x00, 0x1C, 0x0F,
  0xC0, 0x7C, 0x00, 0x60, 0x1F, 0x07, 0xF8, 0x01, 0x80, 0x38, 0x3F, 0xF0,
  0x0F, 0x80, 0x63, 0x0F, 0xC0, 0x3F, 0x01, 0x00, 0x1F, 0xC3, 0xFE, 0x08,
  0x00, 0x3F, 0xFB, 0xFC, 0x40, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x1C, 0x47, 0xFE, 0x1F, 0xE7, 0xFF, 0x8F, 0xE7, 0xCF, 0xCF, 0xF3, 0x01,
  0xF4, 0x73, 0x00, 0x7A, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0x0F, 0x00, 0x60,
  0x07, 0x80, 0x10, 0x03, 0xC0, 0x08, 0x01, 0xFF, 0x82, 0x01, 0xFF, 0x80,
  0xFD, 0xFF, 0xC0, 0x01, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x78,
  0x00, 0x20, 0xBE, 0x00, 0x7C, 0x9F, 0x84, 0x3F, 0xC7, 0xFC, 0x3F, 0xE3,
  0xFE, 0x1F, 0xE0, 0xFE, 0x11, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x0E, 0x00, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0xC7, 0xFC, 0x0F, 0xFF,
  0x90, 0xF8, 0x70, 0x7F, 0x83, 0xE3, 0x80, 0x7E, 0x0F, 0xCC, 0x00, 0xF8,
  0x1F, 0x20, 0x01, 0xE0, 0x7C, 0x80, 0x07, 0x80, 0xFE, 0x00, 0x0E, 0x03,
  0xC8, 0x00, 0x38, 0x04, 0x30, 0x00, 0xE0, 0x60, 0x40, 0x03, 0x83, 0x80,
  0x81, 0x8C, 0x1F, 0x01, 0xF8, 0x70, 0x7C, 0x00, 0x01, 0xC1, 0xF0, 0x00,
  0x06, 0x07, 0xE0, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0x80, 0x3F, 0x00, 0x04,
  0x00, 0xFC, 0x00, 0x30, 0x01, 0xF8, 0x00, 0xE0, 0x87, 0xE0, 0x0F, 0xC3,
  0x0F, 0x80, 0x7F, 0xF0, 0x3E, 0x01, 0x7F, 0x80, 0xF8, 0x00, 0x7E, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x80, 0x00, 0x38, 0x01, 0x00, 0x01, 0xC0,
  0x02, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x78, 0x1F, 0x80, 0xC0, 0x0F, 0x83, 0x00, 0x0F, 0x06, 0x00, 0x1E, 0x0C,
  0x00, 0x3C, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x20, 0x03, 0x80, 0x30,
  0x0C, 0x00, 0x38, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC3, 0x00, 0x07, 0x1F, 0x80, 0x0E,
  0xFF, 0x80, 0x1D, 0x3F, 0x80, 0x30, 0x3F, 0x80, 0xC0, 0x3F, 0x83, 0x00,
  0x3F, 0xCC, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDF,
  0xFF, 0x80, 0x02, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x1C, 0x71,
  0xC1, 0xCC, 0x06, 0xC0, 0x1C, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE7, 0xBC, 0xE3, 0x8C, 0x20, 0x01, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x3F, 0x81, 0x9F, 0xC6, 0x1F, 0x1C, 0x1E, 0x38, 0x3C, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3E, 0x1E, 0x3E,
  0x3D, 0x7F, 0xFE, 0x7C, 0xF8, 0x70, 0xE0, 0x40, 0x40, 0x00, 0x00, 0x0F,
  0x02, 0x30, 0x02, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x10,
  0x3C, 0x20, 0x79, 0xE0, 0xFF, 0xE1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0x71, 0xE0, 0xE3, 0xC1,
  0x87, 0x86, 0x1F, 0xC8, 0x5F, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x04, 0x00,
  0x01, 0x80, 0xF0, 0x6F, 0x19, 0xE7, 0x1E, 0xE3, 0xD8, 0x47, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3F, 0xE3,
  0xF0, 0x3C, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0B,
  0xF0, 0x63, 0xE3, 0xC3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x07, 0x3C, 0x0E,
  0x78, 0x1C, 0xF0, 0x39, 0xE0, 0x63, 0xC0, 0xCF, 0xC1, 0x1F, 0xE4, 0x0F,
  0xF0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x78, 0x1B, 0xC3,
  0x3C, 0x71, 0xC7, 0x1E, 0x61, 0xEE, 0x0E, 0xE1, 0x8F, 0xE0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0xE1, 0xF8, 0x0F, 0x00,
  0x40, 0x00, 0x03, 0xE4, 0x7F, 0x0F, 0xE1, 0x38, 0x40, 0x08, 0x01, 0x80,
  0x38, 0x0F, 0xF2, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x7F, 0x81, 0x9F, 0xC6, 0x1F, 0x9C, 0x0E,
  0x38, 0x0C, 0xF0, 0x39, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x1E, 0x1F, 0x3C, 0x1E, 0x3C, 0x7C, 0x7F, 0x78, 0x70, 0x70, 0x80,
  0xE0, 0x01, 0xC0, 0x03, 0x98, 0x06, 0x38, 0x1C, 0x78, 0x20, 0x79, 0x80,
  0x0C, 0x00, 0x00, 0xE0, 0x0E, 0x02, 0x30, 0x02, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x10, 0x3C, 0xE0, 0x7B, 0xE0, 0xFF, 0xE1, 0xE3,
  0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x83, 0x8F, 0x46, 0x3F, 0x9C, 0x3E,
  0x30, 0x38, 0xC0, 0x21, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x04, 0x0F, 0x07, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x18,
  0x1F, 0x1F, 0xD3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x7A, 0x3F, 0x0F, 0x03, 0x80, 0x80, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x60, 0x00, 0x01, 0x00, 0x70, 0x0F, 0x03, 0xF0, 0xFF,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x1D, 0x03, 0x10, 0xC0, 0xE0, 0x00, 0x00, 0xC1, 0xC8, 0xE1, 0x71,
  0x7D, 0xCF, 0x73, 0xFC, 0xF8, 0x3C, 0x0F, 0xFF, 0xFC, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE9,
  0xFC, 0x1E, 0x01, 0x80, 0x40, 0x01, 0xC1, 0x88, 0xC1, 0x70, 0x7C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE9, 0xFC, 0x1E,
  0x01, 0x80, 0x40, 0x30, 0x20, 0x60, 0x38, 0x78, 0xF0, 0x7C, 0xFD, 0xF8,
  0xFF, 0x7E, 0xFE, 0x3E, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C,
  0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C,
  0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3D, 0x7F, 0x7E, 0x3F, 0x1C, 0x1C, 0x1E, 0x08, 0x18, 0x0C,
  0x08, 0x10, 0x04, 0x20, 0x20, 0x1C, 0x38, 0x1F, 0x3E, 0x0F, 0xBF, 0xCB,
  0xE3, 0xD1, 0xE1, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1E,
  0x07, 0x0F, 0x03, 0x87, 0x81, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x7C,
  0x79, 0x7E, 0x1F, 0x0E, 0x0F, 0x86, 0x03, 0x81, 0x00, 0x80, 0x00, 0x60,
  0x03, 0xC0, 0x7F, 0x83, 0xCF, 0x87, 0x8F, 0x8F, 0x1F, 0x1E, 0x1F, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCF, 0x03,
  0x1F, 0x0C, 0x7F, 0x90, 0x1F, 0xC0, 0x1E, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xF0, 0x10, 0xFC, 0x30, 0x7C, 0x78,
  0x3F, 0xFC, 0x1E, 0x3E, 0x1C, 0x3E, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x3E, 0x0E, 0x7E, 0x0C,
  0xFF, 0x98, 0x9F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x0E, 0x00, 0x7C, 0x02, 0xF8, 0x11, 0xFC, 0xC3, 0xE7, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0xC1, 0xCF, 0x87,
  0x1F, 0x3C, 0x7F, 0x78, 0xF9, 0xE1, 0x87, 0x04, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x20, 0x47,
  0x8C, 0x7D, 0xEF, 0xDE, 0xBE, 0xF3, 0xCE, 0x3C, 0x43, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xEC, 0x7F, 0x00,
  0xF0, 0x06, 0x00, 0x40, 0x01, 0x80, 0x09, 0xC0, 0x00, 0x80, 0x02, 0x06,
  0x08, 0x3C, 0x31, 0xFF, 0x89, 0xFE, 0x41, 0xF3, 0x01, 0x0E, 0x04, 0x3C,
  0x30, 0xF9, 0xE1, 0xFF, 0xC3, 0x8F, 0x8C, 0x1E, 0x20, 0x38, 0xC0, 0xC7,
  0xC2, 0x3F, 0xD0, 0x3F, 0x80, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x10, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xFF, 0x7F, 0xF3, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF4, 0x7F, 0x03, 0xE0, 0x18, 0x02, 0x00, 0x20, 0x08, 0x1C,
  0x0C, 0x1F, 0x0F, 0x1F, 0x8F, 0xCB, 0xC3, 0xC0, 0xE1, 0xE0, 0x70, 0xF0,
  0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x07, 0x0F, 0x03, 0x87, 0x81, 0xC3,
  0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x7C, 0xFD, 0x7F, 0x9F, 0x07, 0x8F, 0x01,
  0x83, 0x80, 0x80, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x30, 0xE0, 0x70,
  0xF0, 0xF8, 0xFB, 0x7C, 0xFC, 0x3E, 0x7C, 0x1E, 0x3E, 0x1F, 0x1E, 0x0F,
  0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x0C, 0x0E, 0x0C, 0x0E, 0x08, 0x0C,
  0x1C, 0x18, 0x1F, 0x10, 0x3F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x10,
  0xF8, 0x38, 0x30, 0xFC, 0x7C, 0x78, 0x7C, 0xFD, 0xFC, 0x3F, 0x3E, 0x3E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x1E, 0x1E, 0x1C, 0x1E, 0x0E, 0x1C, 0x1E, 0x0F,
  0x1C, 0x1E, 0x0E, 0x1C, 0x1E, 0x0E, 0x1C, 0x1E, 0x0E, 0x1C, 0x1E, 0x0C,
  0x1C, 0x1E, 0x0C, 0x1E, 0x3E, 0x18, 0x3E, 0x7F, 0x90, 0x3F, 0x0F, 0xE0,
  0x1C, 0x03, 0xC0, 0x0C, 0x01, 0x80, 0x08, 0x01, 0x00, 0x18, 0x21, 0xE3,
  0x8F, 0xBC, 0xBF, 0xF1, 0xF7, 0x07, 0x38, 0x38, 0x81, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x79, 0x03, 0xF8, 0x7F,
  0x83, 0xF8, 0x31, 0xC1, 0x04, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x1C,
  0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xF0,
  0x30, 0xF8, 0x70, 0xFC, 0xF8, 0x7F, 0x7C, 0x3C, 0x3C, 0x1C, 0x3E, 0x1C,
  0x1E, 0x1C, 0x1E, 0x1C, 0x1E, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x9C, 0x7F, 0x1C, 0x1E, 0x18, 0x0C,
  0x30, 0x04, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x07, 0x83, 0xF1, 0xFE, 0x07, 0x81, 0xC0, 0x60, 0x10, 0x08,
  0x46, 0x27, 0xF3, 0xFC, 0x1F, 0x85, 0xF2, 0x3D, 0x8F, 0x41, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x19, 0x04, 0x63, 0x07, 0x00, 0x00, 0xC0,
  0xC0, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x0E, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x1C, 0x01, 0x80,
  0x70, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0x38, 0x0F, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x60, 0x70, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 28, 9, 1, -27 },
  { 26, 13, 10, 15, 1, -26 },
  { 43, 17, 21, 19, 1, -24 },
  { 88, 13, 30, 16, 1, -28 },
  { 137, 24, 26, 26, 1, -26 },
  { 215, 19, 23, 21, 1, -23 },
  { 270, 5, 10, 7, 1, -26 },
  { 277, 8, 30, 9, 1, -29 },
  { 307, 8, 30, 9, 1, -29 },
  { 337, 12, 15, 13, 0, -28 },
  { 360, 13, 13, 15, 1, -19 },
  { 382, 6, 10, 7, 0, -6 },
  { 390, 10, 8, 11, 1, -15 },
  { 400, 6, 7, 7, 1, -6 },
  { 406, 18, 30, 19, 1, -28 },
  { 474, 16, 26, 17, 1, -26 },
  { 526, 11, 25, 12, 0, -25 },
  { 561, 15, 25, 17, 1, -25 },
  { 608, 16, 26, 17, 1, -26 },
  { 660, 16, 25, 17, 0, -25 },
  { 710, 16, 26, 17, 1, -26 },
  { 762, 15, 26, 17, 1, -26 },
  { 811, 14, 25, 16, 1, -25 },
  { 855, 15, 26, 17, 1, -26 },
  { 904, 15, 26, 17, 1, -26 },
  { 953, 6, 19, 7, 1, -18 },
  { 968, 7, 22, 6, 0, -18 },
  { 988, 10, 13, 11, 0, -17 },
  { 1005, 13, 8, 14, 1, -15 },
  { 1018, 10, 13, 11, 0, -17 },
  { 1035, 14, 27, 17, 1, -26 },
  { 1083, 21, 22, 23, 1, -17 },
  { 1141, 28, 27, 30, 1, -26 },
  { 1236, 32, 28, 33, 0, -27 },
  { 1348, 24, 27, 25, 1, -27 },
  { 1429, 28, 28, 30, 1, -27 },
  { 1527, 24, 27, 26, 1, -27 },
  { 1608, 26, 32, 28, 1, -28 },
  { 1712, 27, 28, 28, 1, -27 },
  { 1807, 26, 34, 27, 0, -29 },
  { 1918, 24, 31, 25, 1, -27 },
  { 2011, 24, 36, 26, 1, -27 },
  { 2119, 29, 27, 30, 0, -26 },
  { 2217, 19, 27, 21, 1, -26 },
  { 2282, 39, 28, 41, 1, -26 },
  { 2419, 31, 27, 33, 1, -26 },
  { 2524, 26, 28, 28, 1, -27 },
  { 2615, 31, 32, 33, 1, -26 },
  { 2739, 28, 30, 30, 1, -27 },
  { 2844, 33, 28, 34, 1, -27 },
  { 2960, 26, 27, 28, 1, -27 },
  { 3048, 26, 26, 28, 1, -26 },
  { 3133, 25, 28, 26, 1, -26 },
  { 3221, 31, 28, 33, 1, -27 },
  { 3330, 38, 28, 40, 1, -27 },
  { 3463, 25, 28, 27, 1, -27 },
  { 3551, 30, 33, 32, 1, -27 },
  { 3675, 23, 31, 25, 1, -27 },
  { 3765, 5, 29, 7, 1, -27 },
  { 3784, 23, 26, 4, -7, -24 },
  { 3859, 5, 29, 7, 1, -27 },
  { 3878, 13, 10, 15, 1, -26 },
  { 3895, 17, 3, 17, 0, 4 },
  { 3902, 5, 7, 19, 6, -26 },
  { 3907, 15, 20, 17, 1, -19 },
  { 3945, 15, 27, 16, 1, -26 },
  { 3996, 11, 20, 13, 1, -19 },
  { 4024, 15, 27, 17, 1, -26 },
  { 4075, 12, 20, 13, 1, -19 },
  { 4105, 11, 33, 9, 0, -27 },
  { 4151, 15, 27, 17, 1, -19 },
  { 4202, 15, 32, 16, 1, -26 },
  { 4262, 9, 27, 10, 0, -26 },
  { 4293, 11, 33, 9, -2, -26 },
  { 4339, 10, 27, 12, 1, -26 },
  { 4373, 10, 27, 10, 1, -26 },
  { 4407, 24, 20, 26, 1, -19 },
  { 4467, 17, 20, 19, 1, -19 },
  { 4510, 15, 20, 15, 0, -19 },
  { 4548, 16, 29, 17, 0, -22 },
  { 4606, 14, 27, 16, 1, -19 },
  { 4654, 12, 20, 13, 1, -19 },
  { 4684, 14, 24, 15, 1, -23 },
  { 4726, 11, 25, 11, 0, -24 },
  { 4761, 17, 20, 19, 1, -19 },
  { 4804, 16, 22, 17, 0, -21 },
  { 4848, 24, 23, 25, 1, -22 },
  { 4917, 13, 27, 15, 1, -19 },
  { 4961, 16, 28, 17, 1, -22 },
  { 5017, 10, 26, 12, 1, -19 },
  { 5050, 10, 30, 12, 1, -29 },
  { 5088, 2, 31, 6, 2, -29 },
  { 5096, 10, 30, 12, 1, -29 },
  { 5134, 12, 3, 14, 1, -13 },
};

const GFXfont UnifrakturMaguntia_Regular37pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular37pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular37pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR37PT7B_H_
