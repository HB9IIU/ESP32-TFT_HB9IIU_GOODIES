#ifndef _UNIFRAKTURMAGUNTIA_REGULAR26PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0x46, 0xFF, 0x66, 0x66, 0x64, 0x44, 0x40, 0x04, 0x6F, 0x20, 0x00,
  0x21, 0x3D, 0xEE, 0x72, 0x11, 0x09, 0x08, 0x88, 0x18, 0xC3, 0x10, 0x66,
  0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xCC, 0x11, 0x9F, 0xFF, 0xFF, 0x99,
  0x83, 0x30, 0x66, 0x0C, 0xC0, 0x08, 0x04, 0x02, 0x07, 0x86, 0x32, 0x0B,
  0x0D, 0xC7, 0xF1, 0x3E, 0x0F, 0x83, 0xE0, 0xFE, 0x1F, 0x07, 0x83, 0x43,
  0x13, 0x06, 0x01, 0x00, 0x80, 0x38, 0x01, 0xB6, 0x01, 0x33, 0x81, 0x99,
  0xC0, 0x8C, 0xE0, 0x86, 0x70, 0x83, 0x38, 0x80, 0xD8, 0x80, 0x38, 0x8E,
  0x00, 0xC9, 0x80, 0xCC, 0xC0, 0x46, 0x70, 0x47, 0x38, 0x43, 0x9C, 0x40,
  0xCE, 0x40, 0x66, 0x40, 0x13, 0x20, 0x0F, 0x00, 0x0F, 0x00, 0xCC, 0x06,
  0x20, 0x33, 0x01, 0x98, 0x0E, 0x80, 0x79, 0xE7, 0xC6, 0x6E, 0x26, 0x79,
  0x31, 0xC9, 0x8F, 0x8E, 0x3C, 0x71, 0xE5, 0xC7, 0xE7, 0xDE, 0x01, 0x1C,
  0x71, 0x08, 0x88, 0x1C, 0x43, 0x08, 0x61, 0x86, 0x18, 0xE3, 0x8E, 0x38,
  0xE1, 0x86, 0x18, 0x60, 0xC3, 0x04, 0x0C, 0x60, 0x41, 0x06, 0x18, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x61, 0x08, 0x40, 0x00,
  0x04, 0x17, 0x9D, 0x76, 0xF0, 0xC9, 0xFD, 0xD6, 0x3C, 0x8C, 0x00, 0x00,
  0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x26,
  0xF3, 0x32, 0x40, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x23, 0x9E, 0x40, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x01, 0x98, 0x38, 0xC3, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x70,
  0xE7, 0x0E, 0x30, 0xE3, 0x0C, 0x19, 0x80, 0xF0, 0x0C, 0x0C, 0x1C, 0x3C,
  0xDC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x7F, 0x0F, 0x87, 0xF9, 0x87, 0xA0, 0xF4, 0x0E, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x44, 0x09, 0xFF,
  0x7F, 0xFF, 0xFC, 0x1F, 0x82, 0x3C, 0x41, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x78, 0x0F, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x76, 0x06,
  0xF0, 0x67, 0x0C, 0x70, 0xC1, 0xF0, 0x01, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x0B, 0x80, 0xB8, 0x13, 0x82, 0x38, 0x23, 0x84, 0x38, 0x83, 0x8F, 0xFF,
  0xFF, 0xF0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0xFE, 0x20, 0x43, 0xFC,
  0x3F, 0x82, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x83, 0xFC, 0x3F, 0xE2, 0x1E,
  0x40, 0xF0, 0x07, 0x00, 0x76, 0x07, 0x70, 0x67, 0x0E, 0x30, 0xC1, 0xF0,
  0x0F, 0x83, 0x38, 0xC3, 0x18, 0x77, 0x0E, 0xE0, 0x1C, 0x03, 0xFE, 0x78,
  0xCE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x39, 0x86, 0x18, 0x81,
  0xE0, 0x7F, 0xEF, 0xF9, 0x01, 0x40, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xE0, 0x38,
  0x00, 0x1F, 0x83, 0x04, 0x60, 0x66, 0x06, 0x70, 0x67, 0x84, 0x3E, 0x83,
  0xF0, 0x1F, 0xC3, 0x3C, 0x61, 0xE4, 0x06, 0xC0, 0x6C, 0x06, 0x40, 0x66,
  0x06, 0x30, 0xC1, 0xF0, 0x0F, 0x02, 0x30, 0xC7, 0x38, 0x66, 0x0E, 0xC1,
  0xF8, 0x3F, 0x87, 0x70, 0xEE, 0x3C, 0xEB, 0x8E, 0x70, 0x0E, 0x01, 0xD8,
  0x33, 0x86, 0x71, 0x86, 0x30, 0x78, 0x00, 0x23, 0x9E, 0x40, 0x00, 0x00,
  0x23, 0x9E, 0x40, 0x23, 0x9E, 0x40, 0x00, 0x00, 0x23, 0x3C, 0x63, 0x11,
  0x00, 0x02, 0x18, 0x63, 0x8E, 0x0E, 0x06, 0x06, 0x02, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0xC0, 0xE0, 0xE0, 0xE3, 0x8C, 0x30, 0xC0,
  0x3F, 0x18, 0xEC, 0x1B, 0x07, 0xE1, 0xF8, 0x70, 0x78, 0x7C, 0x3E, 0x1C,
  0x06, 0x01, 0x84, 0x31, 0x07, 0x80, 0x00, 0x20, 0x0C, 0x07, 0x80, 0x40,
  0x03, 0xF0, 0x0C, 0x18, 0x18, 0x0C, 0x30, 0x04, 0x61, 0xF6, 0x63, 0x76,
  0x46, 0x66, 0xCE, 0x66, 0xCC, 0x64, 0xCC, 0xEC, 0x4D, 0xC8, 0x6E, 0xF3,
  0x60, 0x06, 0x30, 0x0C, 0x1C, 0x18, 0x07, 0xE0, 0x06, 0x00, 0x03, 0xF8,
  0x0E, 0x67, 0xC3, 0xC8, 0x1E, 0x78, 0x80, 0xF3, 0x88, 0x0F, 0x38, 0x80,
  0x73, 0x8C, 0x07, 0x38, 0xF0, 0x63, 0x87, 0x8E, 0x38, 0x3C, 0xC3, 0x80,
  0x88, 0x38, 0x11, 0x03, 0x80, 0x20, 0x38, 0x07, 0x03, 0x81, 0xF8, 0x38,
  0x27, 0xCF, 0xE0, 0x3F, 0x3E, 0x01, 0xE1, 0x80, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x3F, 0xCF, 0xC0, 0xFF, 0xE3, 0xC3, 0x07, 0xC3, 0x84, 0x07, 0x87,
  0x98, 0x07, 0x0F, 0x30, 0x0E, 0x0F, 0x60, 0x1C, 0x30, 0x40, 0x39, 0xF0,
  0xC2, 0x6F, 0xF0, 0x70, 0x81, 0xF0, 0x02, 0x00, 0xE0, 0x08, 0x01, 0xE0,
  0x30, 0x01, 0x81, 0xF8, 0x03, 0x05, 0xF8, 0x06, 0x00, 0xF8, 0x18, 0x00,
  0xFC, 0x40, 0x00, 0xFF, 0x00, 0x0F, 0x18, 0x18, 0xBF, 0x30, 0x7F, 0x70,
  0x8C, 0x63, 0x00, 0xE7, 0x00, 0xE7, 0x80, 0xE7, 0xC0, 0xE3, 0xE0, 0xE1,
  0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x30, 0x7C, 0x60, 0x3E,
  0xC0, 0x1F, 0x01, 0x0F, 0xFE, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xFC, 0x3C, 0x1F, 0xCE, 0x08, 0x79, 0x86, 0x07, 0xA0, 0xE0, 0x7C,
  0x1C, 0x07, 0x87, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0xC1, 0xB0, 0x38, 0x11,
  0xE6, 0x02, 0x00, 0xC0, 0xC1, 0x20, 0x10, 0xFC, 0x02, 0x3F, 0xE0, 0x88,
  0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x18, 0x0C, 0x5F, 0x8C,
  0x1F, 0xCE, 0x11, 0x86, 0x30, 0x07, 0x38, 0x03, 0x9E, 0x01, 0xCF, 0xBC,
  0xE3, 0xFF, 0xF0, 0xFB, 0x38, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1,
  0x81, 0xF1, 0x80, 0x7D, 0x00, 0x1F, 0x01, 0x07, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x9C, 0x1F, 0xE6, 0x02, 0xF8,
  0x80, 0xC4, 0x10, 0x18, 0x02, 0x07, 0x84, 0x40, 0x79, 0xE8, 0x0F, 0xFC,
  0x80, 0xFB, 0x08, 0xDF, 0x00, 0xE1, 0xE0, 0x38, 0x1E, 0x03, 0x83, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x78, 0x18, 0x07, 0x06, 0x00,
  0x61, 0x80, 0x03, 0xE0, 0x00, 0x02, 0x04, 0x03, 0x33, 0x03, 0x83, 0xE0,
  0xC1, 0x3C, 0x71, 0x87, 0x98, 0xC0, 0xCE, 0x70, 0x63, 0x9E, 0x3C, 0xE3,
  0xDF, 0xB8, 0xF8, 0xEE, 0x1E, 0x3F, 0x83, 0xC7, 0xF0, 0x71, 0xFC, 0x1C,
  0x77, 0x86, 0x1C, 0xE3, 0x06, 0x3C, 0x03, 0x83, 0x80, 0x80, 0x7D, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x01, 0x3C, 0x00,
  0x43, 0xC0, 0x18, 0x20, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x1E, 0x1F, 0x01,
  0xEF, 0xF0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x83, 0x80,
  0x78, 0x70, 0x07, 0x0E, 0x38, 0x41, 0xCF, 0x90, 0x3A, 0x7C, 0x06, 0x07,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x06, 0x1F, 0x06, 0x07, 0xF2, 0x00, 0xE1, 0x00, 0x20,
  0x80, 0x20, 0x40, 0x30, 0x30, 0x1C, 0x0C, 0x0E, 0x01, 0xF7, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x3C, 0x03, 0xBF,
  0x81, 0x83, 0xE0, 0x80, 0xF8, 0x80, 0x3F, 0x80, 0x06, 0x00, 0x07, 0xE0,
  0x07, 0xFE, 0x03, 0x87, 0xC0, 0x80, 0xFE, 0x20, 0x0E, 0x18, 0x01, 0x06,
  0x00, 0xC0, 0x80, 0x70, 0x20, 0x1C, 0x04, 0x07, 0x00, 0xFD, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x70, 0x06, 0x7E, 0x01, 0x27, 0xC0, 0xC0,
  0xF8, 0x20, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x40, 0x10, 0x0E, 0x30, 0x40, 0x67, 0xE3, 0x07, 0x27, 0x88, 0x3A,
  0x1E, 0x41, 0xD0, 0xF2, 0x0F, 0x83, 0xD0, 0x7C, 0x08, 0x81, 0xE1, 0x88,
  0x07, 0x9E, 0x80, 0x3D, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0x8E, 0x07, 0x18,
  0x78, 0x7C, 0x43, 0xC4, 0xFC, 0x0F, 0x87, 0x80, 0x38, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x60, 0x63, 0x81, 0xCE, 0x03, 0x38, 0x0D, 0xE0, 0x33, 0xC1,
  0xCF, 0x06, 0x1F, 0xF0, 0x78, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x00, 0x70,
  0x03, 0xF0, 0x37, 0xE1, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x0F,
  0x1F, 0x0F, 0xFB, 0xF6, 0xF1, 0x9F, 0x8F, 0x8E, 0x40, 0xF0, 0xE1, 0xC8,
  0x0F, 0x1E, 0x3D, 0x00, 0xE1, 0xC3, 0xE0, 0x1C, 0x38, 0x74, 0x01, 0xC7,
  0x08, 0xFC, 0x38, 0xE2, 0x0F, 0xC6, 0x0C, 0xC0, 0x08, 0xC1, 0x98, 0x00,
  0x18, 0x27, 0x00, 0x02, 0x0C, 0xE0, 0x00, 0x41, 0x9C, 0x07, 0x16, 0x23,
  0xC3, 0xF3, 0xF8, 0x3F, 0x9F, 0xBF, 0x07, 0xC1, 0xE9, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x87, 0xC3, 0xFE, 0x7F, 0x39, 0xFC, 0x39, 0x03,
  0xE1, 0xC8, 0x0F, 0x0F, 0x40, 0x38, 0x3E, 0x01, 0xC1, 0x90, 0x07, 0x08,
  0xFC, 0x38, 0x83, 0xF1, 0x8C, 0x00, 0x8C, 0x60, 0x00, 0x67, 0x00, 0x03,
  0x38, 0x00, 0x11, 0xE0, 0xF1, 0x0F, 0x0F, 0xC8, 0x3F, 0x9F, 0x80, 0xF0,
  0x78, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xC0,
  0x3F, 0xF8, 0x30, 0x3F, 0x18, 0x03, 0xCC, 0x00, 0x7B, 0x80, 0x0E, 0xF8,
  0x01, 0xBF, 0x80, 0x77, 0xF0, 0x1C, 0x7C, 0x03, 0x07, 0x00, 0x80, 0x80,
  0x23, 0x80, 0x13, 0xF8, 0x04, 0x3F, 0x02, 0x03, 0xFB, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0xC0, 0x7F, 0xC7, 0x01, 0x87, 0xBF, 0x02, 0x07,
  0x9F, 0x08, 0x07, 0x1F, 0x10, 0x0E, 0x3F, 0x20, 0x1C, 0x1F, 0x20, 0x38,
  0x1E, 0x21, 0x70, 0x1C, 0x3C, 0xE0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x20, 0x03, 0x00, 0x40, 0x06, 0x01, 0x00, 0x7E, 0x02, 0x01, 0xFF, 0x08,
  0x04, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0x03, 0x03, 0xF0, 0xC0, 0x1E, 0x30, 0x01, 0xE7, 0x00,
  0x1C, 0xF8, 0x01, 0x9F, 0xC0, 0x39, 0xFC, 0x07, 0x0F, 0x80, 0x60, 0x70,
  0x08, 0x04, 0x01, 0x0E, 0x07, 0xC7, 0xF1, 0xF8, 0x3F, 0x07, 0xA1, 0xFF,
  0xF8, 0x1F, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0x81, 0xFF, 0x1F, 0x83, 0xBF, 0x47, 0x8C, 0x0F, 0x0F, 0x10, 0x0E,
  0x0F, 0x20, 0x1E, 0x1F, 0x40, 0x1C, 0x18, 0x80, 0x38, 0x41, 0x00, 0x73,
  0x01, 0x04, 0xEF, 0x01, 0xF1, 0xEF, 0x00, 0x03, 0x1E, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x38, 0x0E, 0x10, 0x78, 0x3E, 0x40, 0xFC, 0x9F, 0x00, 0xF8,
  0x3C, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x61, 0xFC,
  0x20, 0x1E, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x78, 0xC8, 0x7F, 0x31,
  0x7F, 0x2C, 0x3F, 0x07, 0x07, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x17, 0x80,
  0x09, 0xF8, 0x0E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xC0,
  0x0F, 0xFC, 0x06, 0x1F, 0xC2, 0x01, 0xF9, 0x81, 0x9F, 0xA0, 0xE3, 0xC8,
  0x38, 0x02, 0x0F, 0x80, 0x41, 0xF0, 0x0E, 0x3C, 0x00, 0x07, 0x80, 0x60,
  0xC0, 0x7C, 0x30, 0x2F, 0x90, 0x01, 0xF0, 0x00, 0x3F, 0x04, 0x03, 0xF6,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x86, 0x20, 0xC3, 0x88, 0xF0, 0xE4, 0x78,
  0x38, 0x0E, 0x0F, 0x03, 0x81, 0xE0, 0xE0, 0x7C, 0x38, 0x0F, 0x0E, 0x01,
  0xC3, 0x80, 0x60, 0xE0, 0x10, 0x38, 0x08, 0x0E, 0x07, 0x03, 0x83, 0xE0,
  0xE1, 0x7C, 0xFD, 0x0F, 0xC7, 0x80, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0x01, 0xFC, 0x7E, 0x1F, 0xF4, 0x71, 0x83, 0xE3, 0xC8, 0x0F,
  0x0F, 0x40, 0x38, 0x72, 0x01, 0xC1, 0x10, 0x0E, 0x18, 0x80, 0x71, 0xC2,
  0x13, 0x0E, 0x0F, 0x18, 0x7C, 0x00, 0x81, 0xE0, 0x08, 0x07, 0x83, 0x80,
  0x3C, 0x7F, 0x00, 0xC4, 0xFC, 0x06, 0x01, 0xF0, 0x20, 0x07, 0xE2, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0x3F, 0x07,
  0xFD, 0x31, 0xE3, 0x8F, 0x88, 0x3C, 0xC0, 0xF2, 0x07, 0x20, 0x1D, 0xC1,
  0xE8, 0x07, 0x70, 0x32, 0x01, 0xDE, 0x08, 0x80, 0x77, 0x86, 0x10, 0x98,
  0xF3, 0xC3, 0xC6, 0x1C, 0xF8, 0x01, 0x07, 0x1F, 0x00, 0x80, 0xC3, 0xC1,
  0xC0, 0x30, 0x71, 0xF8, 0x08, 0x0C, 0xBF, 0x07, 0x82, 0x03, 0xE3, 0xF0,
  0x80, 0x7F, 0x3F, 0xC0, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE1, 0xF3, 0xFC, 0x7D, 0xC7, 0xBE, 0x40, 0xF0, 0x10, 0x1C, 0x04,
  0x07, 0x01, 0x01, 0xC0, 0x20, 0xFF, 0x07, 0xBF, 0x80, 0x17, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0B, 0x80, 0x72, 0xF0, 0x1F, 0x3F,
  0xCF, 0xC7, 0xC4, 0xE0, 0xE0, 0x06, 0x03, 0x01, 0xFC, 0x7E, 0x1F, 0xFC,
  0x79, 0x83, 0xE3, 0xC8, 0x0F, 0x0E, 0x40, 0x38, 0x7A, 0x01, 0xC1, 0xF0,
  0x0E, 0x08, 0x80, 0x70, 0x82, 0x13, 0x0E, 0x0F, 0x18, 0xF0, 0x00, 0x87,
  0xC0, 0x0C, 0x1E, 0x00, 0x40, 0xF8, 0x04, 0x03, 0xC0, 0x71, 0x1E, 0x07,
  0xF8, 0x70, 0x4F, 0x83, 0x80, 0x38, 0x18, 0x10, 0x01, 0xC0, 0x40, 0x0C,
  0x01, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0x07,
  0x83, 0x01, 0xC1, 0x00, 0x60, 0x80, 0x30, 0x40, 0x38, 0x30, 0x18, 0x06,
  0x10, 0x00, 0x7E, 0x00, 0xDF, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x06, 0x3C, 0x03, 0x3F, 0x01, 0x83, 0xC0, 0x80, 0xF0,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x00, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0x08, 0x0E, 0x0F, 0x06, 0xC6, 0x36, 0x0E, 0x02, 0xFF, 0xFF, 0xFF,
  0xCE, 0x63, 0x10, 0x0C, 0x03, 0x83, 0xF9, 0x9E, 0xC3, 0xB0, 0xEC, 0x3B,
  0x0E, 0xE3, 0xB8, 0xEF, 0x3D, 0xFF, 0x31, 0x88, 0x20, 0x0C, 0x2C, 0x0B,
  0x01, 0xC0, 0x70, 0x1C, 0x47, 0x71, 0xEE, 0x73, 0xDC, 0x77, 0x1D, 0xC3,
  0x70, 0xDC, 0x67, 0x1B, 0xE8, 0x3C, 0x03, 0x00, 0x80, 0x0C, 0x3E, 0x4E,
  0xC6, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x7F, 0x38, 0x10, 0x40,
  0x20, 0x0C, 0x03, 0xC0, 0xFC, 0x1F, 0xC0, 0xF8, 0x4F, 0x71, 0xDC, 0x37,
  0x0D, 0xC3, 0x70, 0xDC, 0x37, 0x0B, 0xF4, 0x1E, 0x03, 0x00, 0x0C, 0x3C,
  0x4E, 0xC6, 0xC7, 0xC4, 0xF8, 0xC0, 0xE0, 0xE0, 0x70, 0x7F, 0x38, 0x10,
  0x19, 0x3E, 0x3E, 0x40, 0x40, 0x20, 0xFE, 0x78, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x20, 0x20, 0x0C,
  0x03, 0xC0, 0xBE, 0x31, 0xEC, 0x19, 0x83, 0x30, 0xE6, 0x1C, 0xE3, 0x9C,
  0x71, 0x8F, 0x3E, 0xE3, 0x1C, 0x83, 0x80, 0x72, 0x0C, 0xE1, 0x0F, 0xC0,
  0x0E, 0x2C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x87, 0xF1, 0xCE, 0x73, 0x9C,
  0x77, 0x1D, 0xC7, 0x71, 0xDC, 0x77, 0x1D, 0xE6, 0xFD, 0x8C, 0xC2, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x18, 0x70, 0xE0, 0x00, 0x06, 0x1E, 0x5E,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x30, 0x00, 0x1C, 0x38,
  0x60, 0x01, 0x07, 0x0F, 0x2E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xE1, 0xC6, 0x70, 0x00, 0x0F, 0x22, 0xDB, 0xF7, 0xEE,
  0x1F, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3A, 0xF8, 0x30, 0x40,
  0x07, 0x98, 0x58, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3A, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x31, 0x8C, 0x3D,
  0xEF, 0x9F, 0x39, 0xE3, 0x1C, 0xE1, 0x8E, 0x70, 0xC7, 0x38, 0x63, 0x9C,
  0x31, 0xCE, 0x18, 0xE7, 0x1C, 0x73, 0x8F, 0x39, 0xD7, 0x3C, 0x71, 0x84,
  0x38, 0x63, 0x0F, 0x78, 0xFB, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE7, 0x9E, 0x20, 0xC2, 0x04, 0x03, 0x0F,
  0xC7, 0x79, 0xCE, 0x71, 0xDC, 0x77, 0x0D, 0xC3, 0x70, 0xDC, 0x6F, 0x90,
  0xF8, 0x08, 0x00, 0x00, 0x40, 0x18, 0x03, 0xC6, 0x39, 0xC3, 0xDC, 0x73,
  0xCE, 0x39, 0xC7, 0x38, 0x67, 0x0C, 0xE1, 0xBC, 0x6F, 0xC8, 0x7E, 0x0F,
  0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x06, 0x01, 0xE0, 0x5F,
  0x11, 0xF6, 0x18, 0xC3, 0x18, 0x67, 0x0C, 0x61, 0x8E, 0x31, 0xE6, 0x1F,
  0xC1, 0x98, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x62, 0xF6, 0xFF,
  0x76, 0x74, 0x70, 0x70, 0x70, 0x70, 0x70, 0x7C, 0xF8, 0x18, 0x00, 0x07,
  0x00, 0x30, 0x04, 0x31, 0x1F, 0xD9, 0xE4, 0x11, 0x8C, 0x77, 0x9F, 0xE3,
  0x1C, 0x83, 0x30, 0x9F, 0x41, 0xE0, 0x10, 0x02, 0x04, 0x04, 0x08, 0x38,
  0x7F, 0xB8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3A, 0x7C, 0x0C,
  0x08, 0x01, 0x06, 0x08, 0xF1, 0xCF, 0x3E, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xBE, 0xFD, 0xE1, 0x8C, 0x00, 0x00,
  0x40, 0x08, 0x23, 0x06, 0x73, 0xCF, 0x9C, 0xE3, 0xCE, 0x39, 0xC7, 0x18,
  0x63, 0x0C, 0x43, 0x18, 0x63, 0xC8, 0xFE, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xE1, 0x04, 0xF3, 0x9E, 0x75, 0xEE, 0x39, 0xC7, 0x31, 0xC7,
  0x31, 0xC3, 0x31, 0xC3, 0x31, 0xC3, 0x31, 0xC2, 0x31, 0xC6, 0x7B, 0xF4,
  0x78, 0xF8, 0x30, 0x30, 0x20, 0x20, 0x40, 0x39, 0x9F, 0xD7, 0x73, 0xB1,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xC7, 0xC4, 0xC2, 0x01, 0x00,
  0x80, 0x23, 0x8F, 0x80, 0x00, 0x18, 0x02, 0x00, 0x71, 0x8F, 0x78, 0xF7,
  0x0C, 0x71, 0x8E, 0x30, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x0C, 0xE9, 0x9E,
  0x61, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x30, 0xF2, 0x70, 0xE1,
  0x82, 0x19, 0xFC, 0x3C, 0x9E, 0x3C, 0x78, 0x70, 0xE1, 0xC6, 0x88, 0xE0,
  0x0C, 0x43, 0x0C, 0x70, 0xC3, 0x0C, 0x31, 0x8C, 0x08, 0x30, 0xC3, 0x0C,
  0x70, 0xC3, 0x06, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x83,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x60, 0xC4, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x18, 0x80, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 19, 6, 1, -19 },
  { 11, 9, 8, 10, 1, -19 },
  { 20, 11, 15, 13, 1, -17 },
  { 41, 9, 21, 11, 1, -20 },
  { 65, 17, 18, 19, 1, -18 },
  { 104, 13, 16, 15, 1, -16 },
  { 130, 5, 8, 5, 0, -19 },
  { 135, 6, 21, 6, 0, -20 },
  { 151, 6, 21, 6, 0, -20 },
  { 167, 9, 11, 9, 0, -20 },
  { 180, 9, 9, 10, 1, -13 },
  { 191, 4, 7, 5, 0, -4 },
  { 195, 7, 5, 8, 1, -10 },
  { 200, 5, 4, 5, 0, -4 },
  { 203, 12, 20, 14, 1, -19 },
  { 233, 12, 18, 12, 0, -18 },
  { 260, 8, 18, 8, 0, -18 },
  { 278, 11, 18, 12, 0, -18 },
  { 303, 12, 18, 12, 0, -18 },
  { 330, 12, 18, 12, 0, -18 },
  { 357, 12, 18, 12, 0, -18 },
  { 384, 11, 18, 12, 0, -18 },
  { 409, 11, 17, 11, 0, -17 },
  { 433, 12, 18, 12, 0, -18 },
  { 460, 11, 19, 12, 0, -19 },
  { 487, 5, 12, 5, 0, -12 },
  { 495, 5, 15, 4, 0, -12 },
  { 505, 7, 9, 8, 0, -12 },
  { 513, 9, 6, 10, 1, -11 },
  { 520, 7, 9, 8, 0, -12 },
  { 528, 10, 19, 12, 1, -19 },
  { 552, 16, 16, 16, 0, -12 },
  { 584, 20, 20, 21, 1, -19 },
  { 634, 23, 19, 23, 0, -19 },
  { 689, 16, 19, 18, 1, -19 },
  { 727, 19, 20, 21, 1, -19 },
  { 775, 17, 19, 18, 1, -19 },
  { 816, 19, 22, 20, 0, -19 },
  { 869, 18, 20, 20, 1, -19 },
  { 914, 19, 24, 19, 0, -20 },
  { 971, 17, 22, 18, 0, -19 },
  { 1018, 18, 25, 18, 0, -19 },
  { 1075, 21, 20, 21, 0, -19 },
  { 1128, 14, 19, 15, 0, -18 },
  { 1162, 27, 19, 29, 1, -18 },
  { 1227, 21, 19, 23, 1, -18 },
  { 1277, 18, 20, 20, 1, -19 },
  { 1322, 23, 22, 23, 0, -18 },
  { 1386, 19, 21, 21, 1, -19 },
  { 1436, 23, 19, 24, 1, -19 },
  { 1491, 18, 19, 20, 1, -19 },
  { 1534, 18, 18, 19, 1, -18 },
  { 1575, 18, 20, 19, 0, -18 },
  { 1620, 21, 20, 23, 1, -19 },
  { 1673, 26, 20, 28, 1, -19 },
  { 1738, 18, 19, 19, 0, -19 },
  { 1781, 21, 23, 22, 1, -19 },
  { 1842, 17, 22, 17, 0, -19 },
  { 1889, 4, 20, 5, 0, -19 },
  { 1899, 16, 18, 3, -5, -17 },
  { 1935, 4, 20, 5, 0, -19 },
  { 1945, 9, 7, 11, 1, -18 },
  { 1953, 12, 2, 12, 0, 3 },
  { 1956, 4, 5, 13, 4, -18 },
  { 1959, 10, 14, 12, 1, -13 },
  { 1977, 10, 19, 12, 1, -18 },
  { 2001, 8, 14, 9, 1, -13 },
  { 2015, 10, 18, 12, 1, -18 },
  { 2038, 8, 14, 9, 1, -13 },
  { 2052, 8, 23, 6, 0, -19 },
  { 2075, 11, 18, 12, 1, -13 },
  { 2100, 10, 23, 12, 1, -18 },
  { 2129, 7, 19, 7, 0, -18 },
  { 2146, 7, 23, 6, -1, -18 },
  { 2167, 7, 19, 8, 1, -18 },
  { 2184, 8, 19, 7, 0, -18 },
  { 2203, 17, 14, 18, 1, -14 },
  { 2233, 12, 14, 13, 1, -13 },
  { 2254, 10, 14, 11, 0, -13 },
  { 2272, 11, 20, 12, 0, -15 },
  { 2300, 11, 18, 11, 0, -13 },
  { 2325, 8, 14, 9, 1, -13 },
  { 2339, 10, 16, 11, 0, -16 },
  { 2359, 8, 18, 8, 0, -17 },
  { 2377, 12, 15, 13, 1, -14 },
  { 2400, 11, 16, 12, 0, -15 },
  { 2422, 16, 16, 18, 1, -15 },
  { 2454, 9, 19, 10, 1, -14 },
  { 2476, 11, 20, 12, 1, -16 },
  { 2504, 7, 18, 9, 1, -13 },
  { 2520, 6, 21, 9, 1, -20 },
  { 2536, 2, 21, 4, 1, -20 },
  { 2542, 6, 21, 9, 1, -20 },
  { 2558, 8, 2, 10, 1, -9 },
};

const GFXfont UnifrakturMaguntia_Regular26pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular26pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular26pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR26PT7B_H_
