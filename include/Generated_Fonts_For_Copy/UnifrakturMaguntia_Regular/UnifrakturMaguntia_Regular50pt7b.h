#ifndef _UNIFRAKTURMAGUNTIA_REGULAR50PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x03, 0x01, 0xE0, 0xFC, 0x7F, 0x9F, 0xC7, 0xF0, 0xFC, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0xF8, 0x7F, 0x8F, 0x81, 0xC0, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x01, 0x01, 0xC0, 0xE0, 0xF8, 0x7C, 0x7F, 0x3F, 0xCF,
  0xC7, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x03, 0x03, 0x80, 0xC0, 0xC0,
  0x20, 0x30, 0x08, 0x08, 0x04, 0x04, 0x01, 0x00, 0x01, 0xC1, 0xC0, 0x0F,
  0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC1, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x87,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x3E, 0x00,
  0x7F, 0xC0, 0x78, 0x70, 0x70, 0x1C, 0x38, 0x06, 0x38, 0x03, 0x9C, 0x03,
  0xCE, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x39, 0xF8, 0x18, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFC, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x39, 0x80, 0x1C, 0x60, 0x1C, 0x38, 0x1C, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x8F, 0xF0, 0x00, 0x01, 0x8F, 0x1C,
  0x00, 0x01, 0x87, 0x8F, 0x00, 0x01, 0x87, 0x87, 0x80, 0x01, 0xC3, 0xC3,
  0xE0, 0x01, 0xC1, 0xE1, 0xF0, 0x00, 0xC1, 0xF0, 0x78, 0x00, 0xC0, 0xF8,
  0x3C, 0x00, 0xC0, 0x7C, 0x1E, 0x00, 0xC0, 0x3E, 0x1F, 0x00, 0xC0, 0x0F,
  0x0F, 0x80, 0xE0, 0x07, 0x87, 0xC0, 0xE0, 0x03, 0xC3, 0xC0, 0xE0, 0x00,
  0xF1, 0xE0, 0x60, 0x00, 0x78, 0xE0, 0x60, 0x00, 0x1F, 0xE0, 0x60, 0xF8,
  0x03, 0xE0, 0x61, 0xFE, 0x00, 0x00, 0x61, 0xE7, 0x80, 0x00, 0x70, 0xF1,
  0xE0, 0x00, 0x70, 0xF0, 0xF0, 0x00, 0x30, 0x78, 0x7C, 0x00, 0x30, 0x7C,
  0x3E, 0x00, 0x30, 0x3E, 0x1F, 0x00, 0x30, 0x1F, 0x0F, 0x80, 0x30, 0x0F,
  0x87, 0xC0, 0x38, 0x07, 0xC3, 0xE0, 0x38, 0x03, 0xE1, 0xF0, 0x38, 0x01,
  0xF0, 0xF8, 0x18, 0x00, 0x78, 0x7C, 0x18, 0x00, 0x3C, 0x3C, 0x18, 0x00,
  0x0F, 0x1E, 0x18, 0x00, 0x07, 0x9E, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x87, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xF3, 0x80, 0x01, 0xFB,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x1F, 0x83, 0xFC, 0x1F,
  0xE0, 0x78, 0x3F, 0xF0, 0x18, 0x39, 0xFC, 0x0C, 0x3C, 0x7E, 0x06, 0x1E,
  0x3F, 0x82, 0x1E, 0x0F, 0xC3, 0x0F, 0x07, 0xF1, 0x07, 0xC1, 0xF9, 0x83,
  0xE0, 0xFE, 0xC1, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x6F, 0xC0, 0xFF, 0xE3, 0xF0, 0xFF, 0xF0, 0xFF, 0xEF,
  0xF0, 0x1F, 0xC1, 0xE0, 0x00, 0x18, 0x38, 0x7E, 0xFF, 0x3F, 0x1E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x08, 0x10, 0x10, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0E, 0xE0, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x03, 0x80, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0xFC, 0x01, 0xBF, 0xC7, 0xCE, 0x7D, 0xE6, 0x7C, 0xF9,
  0x3E, 0x7E, 0xBE, 0x31, 0xF1, 0x10, 0x70, 0x8F, 0xDF, 0xE7, 0xCB, 0xF3,
  0xCC, 0xFB, 0xE7, 0x3C, 0x37, 0xD1, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x08, 0x1C, 0x3E, 0x7F, 0x3F, 0x1F, 0x0F, 0x0E, 0x0E, 0x0C,
  0x08, 0x08, 0x10, 0x00, 0x0C, 0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x7F, 0xE3, 0xF8, 0x00, 0x00, 0x18, 0x38,
  0x7C, 0xFF, 0x7C, 0x38, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0xF0, 0x03,
  0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E,
  0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0x78,
  0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0xCF, 0xC2, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x1F, 0xF1, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xC1, 0xFE, 0x38, 0x07, 0xF9, 0x80, 0x1F, 0xCC, 0x00,
  0x7E, 0xC0, 0x03, 0xF6, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x10, 0x1C, 0x00,
  0xC1, 0xC0, 0x04, 0x1C, 0x00, 0x20, 0xC0, 0x01, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xFE, 0x01, 0xC1, 0xFC, 0x0C, 0x03, 0xF8, 0x60, 0x07, 0xF1,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBF, 0x00, 0x3C, 0xFC, 0x00, 0xF3, 0xF0, 0x07, 0x87, 0xC0, 0x1C, 0x0F,
  0x00, 0xE0, 0x1E, 0x06, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x06, 0xF8, 0x00, 0x13, 0xE0, 0x00, 0xCF, 0x80, 0x06, 0x3E, 0x00,
  0x10, 0xF8, 0x00, 0xC3, 0xE0, 0x06, 0x0F, 0x80, 0x10, 0x3E, 0x00, 0xC0,
  0xF8, 0x02, 0x03, 0xE0, 0x10, 0x0F, 0x80, 0xC0, 0x3E, 0x02, 0x00, 0xF8,
  0x18, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3E, 0x0F, 0xF0, 0xE0, 0x0F, 0xC2, 0x00, 0x1F, 0x90, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC,
  0x00, 0xF3, 0xF0, 0x03, 0xCF, 0xC0, 0x1E, 0x1F, 0x00, 0x70, 0x3E, 0x03,
  0x80, 0x78, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x3C,
  0x00, 0xC1, 0xF0, 0x0E, 0x07, 0xC0, 0xE0, 0x3E, 0x0F, 0x01, 0xF8, 0x78,
  0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xE1, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x3E, 0x3F, 0xC1, 0xF3, 0xFF, 0x1F, 0x98,
  0xFC, 0xFD, 0x83, 0xF7, 0xF8, 0x1F, 0xBF, 0xC0, 0xFD, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x03, 0xE3, 0xE0, 0x1E, 0x1F,
  0x00, 0xF0, 0x78, 0x07, 0x03, 0xE0, 0x70, 0x0F, 0x03, 0x00, 0x1C, 0x30,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x70,
  0x38, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x31, 0xE0, 0x01, 0xCF, 0x00,
  0x0E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x1F, 0xC0, 0x38, 0xFF, 0x03, 0x83,
  0xFE, 0x38, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xBF, 0xF8, 0x38, 0x7F, 0xE3, 0x80, 0xFF, 0x38,
  0x03, 0xF9, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x78, 0x00, 0x79, 0xC0,
  0x03, 0xC7, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x38, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x18, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x7C, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x9F,
  0x83, 0xFC, 0x7E, 0x37, 0xE1, 0xFF, 0x3F, 0x07, 0xF9, 0xF8, 0x0F, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0xF8, 0xF8,
  0x07, 0x87, 0xC0, 0x3C, 0x3F, 0x03, 0xC1, 0xF8, 0x1E, 0x07, 0xC0, 0xE0,
  0x3E, 0x06, 0x00, 0xF8, 0x60, 0x01, 0xFC, 0x00, 0x00, 0x18, 0x38, 0x7E,
  0xFF, 0x7C, 0x38, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x38, 0x7C, 0xFF, 0x7C, 0x38, 0x10, 0x00, 0x00, 0x06, 0x07,
  0x07, 0xE7, 0xF9, 0xF0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0x07, 0xC7, 0xF1, 0xF8, 0x7C, 0x1E,
  0x0E, 0x07, 0x03, 0x01, 0x00, 0x80, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x07, 0xF8, 0x03, 0x83, 0xC1, 0xC0, 0x3E, 0x70, 0x03, 0xCE, 0x00,
  0x7D, 0xC0, 0x0F, 0xBE, 0x00, 0xF7, 0xE0, 0x1E, 0xFC, 0x07, 0xEF, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x06, 0x07, 0x00, 0x80, 0x70, 0x30, 0x07, 0x0C,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x87, 0x80, 0xFF, 0x9C, 0x78, 0x0F,
  0xFC, 0x63, 0xC1, 0xF3, 0xE3, 0x9C, 0x1F, 0x1E, 0x1D, 0xE0, 0xF0, 0xF0,
  0xEF, 0x0F, 0x07, 0x87, 0x70, 0xF8, 0x78, 0x73, 0x87, 0x83, 0xC3, 0x9C,
  0x7C, 0x1E, 0x1C, 0xE3, 0xE1, 0xE1, 0xC7, 0x1E, 0x1F, 0x0E, 0x38, 0xF0,
  0xF8, 0xE1, 0xE7, 0xDF, 0xCE, 0x07, 0x1F, 0xDF, 0xE3, 0xB8, 0x78, 0xFC,
  0x39, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x70, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x7F, 0xFF, 0x80,
  0x1F, 0x01, 0xC1, 0xFF, 0x80, 0xFC, 0x06, 0x00, 0xFF, 0x87, 0xF8, 0x08,
  0x00, 0xFF, 0x9F, 0xF0, 0x30, 0x00, 0xFF, 0x0F, 0xE0, 0x40, 0x00, 0xFE,
  0x1F, 0xC1, 0x80, 0x00, 0xFC, 0x3F, 0x83, 0x00, 0x01, 0xFC, 0x7F, 0x06,
  0x00, 0x03, 0xF8, 0xFE, 0x0E, 0x00, 0x07, 0xF1, 0xFC, 0x1E, 0x00, 0x07,
  0xC3, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xF0, 0x3F, 0xC0, 0x1F, 0x0F, 0xE0,
  0x7F, 0xC0, 0x7C, 0x1F, 0xC0, 0x7F, 0xC0, 0xF8, 0x3F, 0x80, 0x3F, 0xC1,
  0xE0, 0x7F, 0x00, 0x3F, 0x83, 0x80, 0xFE, 0x00, 0x0F, 0x0F, 0x01, 0xFC,
  0x00, 0x0C, 0x1C, 0x03, 0xF8, 0x00, 0x10, 0x70, 0x07, 0xF0, 0x00, 0x41,
  0xC0, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x3F,
  0x80, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x0F,
  0xF0, 0x02, 0x1F, 0xFC, 0x67, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xF8, 0x00,
  0x0F, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x00, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x31, 0xFE, 0x01, 0xFF, 0xFF, 0xEC, 0x1F, 0xC0, 0x7E, 0x07,
  0xFD, 0x01, 0xFC, 0x0F, 0x00, 0x3F, 0xE0, 0x3F, 0x83, 0xC0, 0x03, 0xFC,
  0x07, 0xF0, 0x70, 0x00, 0x3F, 0x80, 0x7F, 0x0C, 0x00, 0x07, 0xF0, 0x0F,
  0xE1, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0x30, 0x00, 0x0F, 0xC0, 0x1F, 0xC6,
  0x00, 0x01, 0xF8, 0x01, 0xE0, 0xC0, 0x00, 0x1F, 0x00, 0x70, 0x18, 0x00,
  0x03, 0xE0, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x1F, 0xF0, 0x38, 0x00, 0x0F,
  0x0F, 0xFF, 0x03, 0x80, 0x61, 0xC7, 0xFF, 0xF0, 0x3C, 0x18, 0x79, 0xFF,
  0xFF, 0x01, 0xFC, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00,
  0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x02, 0x0F, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x8E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0x01, 0x80, 0x01, 0xF1, 0x83, 0xE0, 0x03, 0xC0,
  0x47, 0xF9, 0x07, 0x80, 0x5F, 0xFF, 0x0F, 0x80, 0x3F, 0xFE, 0x0F, 0x00,
  0x61, 0xF8, 0x1F, 0x01, 0x80, 0x70, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x7E, 0x1F,
  0xF0, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x7E, 0x0F, 0xFC, 0x00, 0x7E, 0x07,
  0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x1F, 0xE0,
  0x0E, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x07, 0xFC,
  0x60, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x00, 0xFF,
  0xF0, 0x1E, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xC7, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0xE0, 0xFF,
  0xC1, 0xF0, 0x06, 0x00, 0xFF, 0x87, 0x80, 0x38, 0x01, 0xFE, 0x3C, 0x01,
  0xE0, 0x03, 0xFC, 0xE0, 0x0F, 0x80, 0x03, 0xF3, 0x80, 0x3F, 0x00, 0x0F,
  0xEC, 0x00, 0xFE, 0x00, 0x1F, 0xB0, 0x03, 0xFC, 0x00, 0x3E, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x01, 0xF4, 0x00, 0x7F, 0xE0, 0x03,
  0xD8, 0x00, 0xFF, 0x80, 0x0F, 0x60, 0x01, 0xFF, 0x00, 0x3C, 0xC0, 0x03,
  0xFC, 0x00, 0x71, 0xC0, 0x07, 0xF0, 0x01, 0xC1, 0xE7, 0x0F, 0xC0, 0x07,
  0x01, 0xF0, 0x1E, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x30,
  0x01, 0xFE, 0x00, 0x01, 0x80, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0xFF, 0xFE,
  0x00, 0x30, 0x07, 0xFF, 0xFE, 0x01, 0x80, 0x70, 0xFF, 0xFF, 0x3C, 0x01,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0x80, 0x00, 0xF8, 0xC1, 0xF0, 0x00, 0xF0, 0x11, 0xFF,
  0x40, 0xF0, 0x0B, 0xFF, 0xE0, 0xF0, 0x03, 0xFF, 0xE0, 0x78, 0x03, 0x0F,
  0xC0, 0x7C, 0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xFC, 0x0E, 0x03, 0xF0, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F,
  0xCF, 0xFE, 0xFC, 0x1F, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0x3F, 0x03,
  0xFF, 0x1F, 0x1F, 0x80, 0xFF, 0xC7, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0x80, 0x07,
  0xF8, 0x03, 0x80, 0x01, 0xFE, 0x03, 0x80, 0x00, 0xFF, 0x83, 0x00, 0x00,
  0x3F, 0xE3, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x06,
  0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x71, 0xF8, 0x07, 0xFF, 0xFE,
  0x3E, 0x00, 0x0F, 0xFF, 0x83, 0x80, 0x01, 0xBF, 0xF0, 0x78, 0x00, 0x30,
  0xFC, 0x07, 0x00, 0x07, 0x03, 0x80, 0x60, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x30,
  0x60, 0x01, 0xFE, 0x03, 0x86, 0x00, 0x1F, 0xE0, 0x7C, 0x60, 0x00, 0xFF,
  0x0F, 0xE6, 0x00, 0x0F, 0xF9, 0xFF, 0x30, 0x00, 0x7F, 0xFF, 0xE3, 0x80,
  0x03, 0xFE, 0x7C, 0x1C, 0x00, 0x3F, 0xE3, 0x80, 0x70, 0x71, 0xFF, 0x10,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x07,
  0xCC, 0x07, 0x00, 0x00, 0xE0, 0x21, 0xF8, 0x00, 0x3C, 0x01, 0x3F, 0xC0,
  0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x78, 0x01, 0x1F, 0xF0, 0x0F, 0x00, 0x60,
  0xFF, 0x81, 0xF0, 0x0C, 0x07, 0xFC, 0x1F, 0x03, 0x80, 0x3F, 0xE3, 0xE0,
  0x78, 0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x06, 0x07, 0xE0, 0xF8, 0x01, 0xC0,
  0x7E, 0x1F, 0x80, 0x30, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0x7E, 0x1F, 0xC1,
  0xFF, 0x07, 0xE0, 0xFE, 0x3F, 0xF8, 0x7E, 0x0F, 0xF7, 0xFF, 0xCF, 0xE0,
  0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0x7E,
  0x7E, 0x01, 0xFE, 0x07, 0xF7, 0xF0, 0x0F, 0xE0, 0x3F, 0x7F, 0x00, 0x7F,
  0x03, 0xF7, 0xF0, 0x07, 0xF0, 0x3F, 0x7F, 0x00, 0x3F, 0x03, 0xF3, 0xF8,
  0x03, 0xE0, 0x3F, 0x3F, 0x80, 0x1E, 0x03, 0xE1, 0xFC, 0x03, 0xC0, 0x3E,
  0x1F, 0xC0, 0x30, 0x03, 0xE0, 0xFE, 0x06, 0x00, 0x3C, 0x07, 0xF0, 0x80,
  0x07, 0x80, 0x3F, 0x80, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0x87, 0xFD, 0x00, 0x00, 0x60, 0x7F, 0xC0, 0x00, 0x18, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0xF8, 0x01, 0xFE, 0x71, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x0F, 0x00,
  0x3E, 0x3F, 0x81, 0xC0, 0x07, 0xCF, 0xF8, 0x18, 0x01, 0xF3, 0xFF, 0x86,
  0x00, 0x3E, 0x0F, 0xFD, 0x80, 0x07, 0x80, 0x7F, 0xE0, 0x01, 0xF0, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x81, 0xFF, 0x80, 0x1E,
  0x00, 0x7F, 0xE0, 0x1C, 0x00, 0x3F, 0xFE, 0x18, 0x00, 0x1F, 0xF8, 0x38,
  0x00, 0x07, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x0F, 0x80, 0x18, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x1F, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0x03, 0xC1, 0xCF, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0xF0, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0x3C, 0xFF, 0xFC, 0x00, 0x3C, 0x83,
  0xFE, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x60, 0x00,
  0x7F, 0xF1, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x3F, 0xF8, 0x00,
  0xF0, 0x07, 0xFF, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x70, 0x00, 0x3F, 0xF0,
  0x38, 0x00, 0x0F, 0xF0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x18, 0x00, 0x0F,
  0xC0, 0x06, 0x00, 0x07, 0xE0, 0x01, 0x80, 0x03, 0xF8, 0x00, 0x78, 0x39,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x3E, 0x00, 0x00, 0x70, 0x7F, 0xC0, 0x00, 0x38, 0x7F, 0xF0, 0x00, 0x38,
  0x7F, 0xFC, 0x00, 0x1C, 0x43, 0xFF, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x0C,
  0x00, 0x1F, 0xF0, 0x0C, 0x00, 0x07, 0xFE, 0x0C, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x1E, 0x03, 0xF0, 0x1C, 0x00, 0x3C, 0x1F, 0xF0, 0x18,
  0x00, 0xF0, 0xFF, 0xF8, 0x38, 0x03, 0xE1, 0xFF, 0xF0, 0x30, 0x07, 0xC6,
  0x0F, 0xF0, 0x70, 0x0F, 0x88, 0x0F, 0xF0, 0xE0, 0x1F, 0x10, 0x0F, 0xE1,
  0xC0, 0x3F, 0x60, 0x0F, 0xC3, 0x80, 0x7E, 0x80, 0x1F, 0xC7, 0x00, 0xFF,
  0x00, 0x3F, 0xEE, 0x01, 0xFF, 0x00, 0x3F, 0x1C, 0x03, 0xFE, 0x00, 0x3C,
  0x30, 0x03, 0xFC, 0x00, 0x60, 0xC0, 0x07, 0xFC, 0x03, 0x03, 0x00, 0x07,
  0xFC, 0x1F, 0x0C, 0x00, 0x07, 0xF8, 0x7F, 0x30, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x03,
  0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xF8, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x1F,
  0xF0, 0x30, 0x07, 0xF0, 0x7F, 0xF0, 0xC0, 0x0F, 0xE0, 0x9F, 0xF3, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0x3E, 0x3F, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x78, 0xFE, 0x00, 0x1F, 0x1F,
  0xE0, 0x03, 0xE3, 0xFC, 0x00, 0x7C, 0x3F, 0xC0, 0x0F, 0x07, 0xF8, 0x03,
  0xE0, 0x7F, 0xA0, 0xF8, 0x0F, 0xF3, 0xFC, 0x00, 0xFE, 0x0E, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x05,
  0xFF, 0xFC, 0x00, 0x81, 0xFF, 0xE0, 0x60, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xE7, 0xFF,
  0x98, 0xFE, 0x01, 0xFF, 0xFF, 0xE3, 0xFE, 0x83, 0xF8, 0x1E, 0x07, 0xFE,
  0x07, 0xF8, 0x0F, 0xC1, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x0C, 0x00,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x40, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xC6,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x20, 0x00, 0x1F, 0xC0, 0x7E, 0x03,
  0xF9, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x60, 0x00, 0x0F, 0xC0, 0x7E, 0x01, 0xC1, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x0C, 0x0C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xC0, 0x7F, 0xF8,
  0x0F, 0x80, 0x78, 0x0C, 0x01, 0xFF, 0xE0, 0x7C, 0x03, 0xC0, 0xC0, 0x07,
  0xFF, 0x03, 0xE0, 0x1E, 0x0E, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x40, 0xF0, 0x07, 0x87, 0x80, 0x00, 0x02, 0x07, 0x80, 0x38,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x71, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x07, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x38, 0x7F, 0x00, 0x01,
  0xC0, 0x30, 0x01, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0x1E, 0x08, 0x0F, 0xE0,
  0x07, 0xFC, 0x1B, 0xF8, 0xC0, 0x7F, 0x84, 0x7F, 0xF1, 0x9F, 0xFC, 0x01,
  0xFF, 0xE6, 0x7F, 0xD9, 0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x9F, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x8F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x81, 0xF8, 0x0E, 0x03, 0xFF, 0x60, 0x7F, 0x07, 0x00, 0x3F, 0xF0, 0x0F,
  0xC1, 0x80, 0x07, 0xFC, 0x03, 0xF0, 0x40, 0x00, 0xFF, 0x00, 0xFE, 0x30,
  0x00, 0x1F, 0xC0, 0x3F, 0x88, 0x00, 0x03, 0xF0, 0x07, 0xF3, 0x00, 0x00,
  0xFE, 0x01, 0xFE, 0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x30, 0x00, 0x07, 0xE0,
  0x06, 0x04, 0x00, 0x01, 0xF8, 0x03, 0x01, 0x80, 0x00, 0x3E, 0x01, 0x80,
  0x3F, 0xF8, 0x0F, 0x80, 0xE0, 0x0F, 0xFF, 0x03, 0xE0, 0x70, 0x01, 0xFF,
  0xC0, 0xF8, 0x1C, 0x00, 0x1F, 0xB0, 0x3E, 0x0F, 0x00, 0x00, 0x04, 0x0F,
  0x07, 0xC0, 0x00, 0x01, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0x83, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0xFE, 0x00, 0x07, 0x80,
  0x60, 0x3F, 0x80, 0x07, 0xF8, 0x18, 0x07, 0xF0, 0x03, 0xFE, 0x0C, 0x01,
  0xFE, 0x31, 0xFF, 0xC6, 0x00, 0x3F, 0xF8, 0xC7, 0xFF, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xE1, 0xFF, 0xFC, 0x00, 0x30, 0x01, 0xFF, 0xE0, 0x0E, 0x00, 0x07,
  0xFE, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x00, 0xFF, 0x87, 0xC0,
  0x00, 0x07, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0xF0, 0x00,
  0x07, 0xE7, 0xFF, 0xC0, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0x03, 0xE1, 0xFF,
  0xF0, 0x00, 0x1E, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0x1E,
  0x00, 0x7F, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x40, 0x00, 0x18, 0x03, 0x88, 0x00, 0x01, 0x80, 0xFE,
  0x00, 0x00, 0x30, 0x1F, 0xF8, 0x00, 0x03, 0x07, 0xFF, 0xC0, 0x00, 0x60,
  0xDF, 0xFF, 0x00, 0x04, 0x00, 0x3F, 0xF8, 0x01, 0x80, 0x01, 0xFF, 0xF0,
  0x30, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3C, 0x00,
  0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0x03, 0xF7, 0xFF, 0x0F, 0xF8, 0x00, 0xF0,
  0x1F, 0xF7, 0x7F, 0x00, 0x38, 0x00, 0xFF, 0x8F, 0xF0, 0x06, 0x00, 0x0F,
  0xE1, 0xFF, 0x00, 0xC0, 0x01, 0xFC, 0x1F, 0xF0, 0x18, 0x00, 0x1F, 0x83,
  0xFF, 0x02, 0x00, 0x03, 0xF8, 0x3F, 0xF0, 0x40, 0x00, 0x7F, 0x03, 0xFF,
  0x0C, 0x00, 0x07, 0xE0, 0x3F, 0xF1, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x10,
  0x00, 0x1F, 0x80, 0x1F, 0xE3, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x30, 0x04,
  0x7E, 0x00, 0x1F, 0xC3, 0x81, 0x8F, 0xC0, 0x01, 0xF8, 0x1F, 0xC1, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xC0,
  0x18, 0x00, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x01, 0x81, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x73, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x0F, 0xFF, 0xC0, 0x00, 0xC0, 0x07,
  0xFF, 0x80, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x03,
  0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F,
  0xE0, 0x00, 0x01, 0xF0, 0x7F, 0xF0, 0x00, 0x07, 0xE1, 0xFF, 0xF0, 0x00,
  0x0F, 0x83, 0xFF, 0xE0, 0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x07,
  0xFF, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x38, 0x80, 0x0F, 0x18, 0x03, 0xF8, 0x00, 0x7E,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x0D, 0xFF,
  0xF0, 0x8F, 0xF0, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x77, 0xFC, 0x01, 0xFF, 0xFF,
  0xC4, 0x1F, 0xE0, 0x3E, 0x0F, 0xFE, 0x80, 0xFE, 0x07, 0x80, 0x3F, 0xE8,
  0x0F, 0xF0, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0x06, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x8C, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x8C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0xC0,
  0x00, 0x0F, 0x80, 0x0C, 0x0C, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x60, 0x00,
  0x07, 0xC0, 0xE0, 0x06, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x30, 0x00, 0x07,
  0xC7, 0xE0, 0x01, 0x80, 0x20, 0x7C, 0xFE, 0x00, 0x0E, 0x06, 0x07, 0xBF,
  0xF0, 0x00, 0x3F, 0x80, 0x78, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x83, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x81, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0xC0, 0x00, 0xF0, 0x0C, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0xC0, 0x0F, 0xE0, 0x07, 0xFC, 0x18, 0x00, 0xFF, 0x00, 0xFF, 0xE1, 0x00,
  0x07, 0xF9, 0x09, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0C,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0E, 0x1F, 0xFF, 0xF0, 0x01, 0x80, 0x3F,
  0xFE, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x06, 0x00, 0x01, 0xF8, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x70, 0x00, 0x0F,
  0xFE, 0x07, 0x00, 0x01, 0xFF, 0xF0, 0x70, 0x60, 0x7F, 0xFF, 0x8F, 0x03,
  0x3F, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF, 0xC0, 0x4F, 0x00, 0xFF, 0xF0, 0x06,
  0xF8, 0x07, 0xFC, 0x00, 0x2F, 0x80, 0x3F, 0x00, 0x02, 0x7C, 0x01, 0xC0,
  0x00, 0x27, 0xC0, 0x00, 0x00, 0x02, 0x7E, 0x00, 0x00, 0x00, 0x27, 0xF0,
  0x00, 0x00, 0x06, 0x3F, 0x80, 0x00, 0x00, 0x63, 0xFE, 0x00, 0x00, 0x0C,
  0x1F, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x7F, 0xFE, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0x1C, 0x00, 0x0F, 0xFF, 0x0B,
  0x00, 0x00, 0x7F, 0xFF, 0x40, 0x00, 0x47, 0xFF, 0xD8, 0x00, 0x30, 0x3F,
  0xE3, 0x00, 0x0E, 0x03, 0xF8, 0x60, 0x03, 0xC0, 0x1E, 0x0C, 0x00, 0xFC,
  0x00, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x03, 0x00,
  0x7F, 0xC0, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x01, 0x82, 0x7F, 0xC0, 0x00,
  0x0F, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x03, 0xFF, 0x01, 0xC0, 0x01, 0xFF,
  0xF0, 0x70, 0x00, 0x23, 0xFF, 0x18, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x1C, 0x00, 0x1F, 0xFC, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x00,
  0x79, 0xC0, 0x01, 0xC0, 0x38, 0x10, 0x01, 0xE0, 0x1C, 0x06, 0x01, 0xF0,
  0x0F, 0x01, 0x81, 0xF8, 0x07, 0xC0, 0x41, 0xFE, 0x01, 0xF0, 0x30, 0x7F,
  0x80, 0xFC, 0x08, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x00,
  0x7E, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x0F, 0xF8,
  0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x0F,
  0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x78, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x07,
  0xE0, 0x01, 0x80, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xFF,
  0x02, 0x7E, 0x08, 0x3F, 0xF3, 0x9F, 0xD8, 0x07, 0xFF, 0xC7, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xC6, 0x3F, 0xC0, 0x1F, 0xFF,
  0xF9, 0x07, 0xF0, 0x0F, 0x83, 0xFF, 0xC0, 0xFE, 0x07, 0x80, 0x3F, 0xE0,
  0x3F, 0x81, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0xE0, 0x00, 0xFE, 0x01, 0xFE,
  0x30, 0x00, 0x1F, 0xC0, 0x3F, 0x8C, 0x00, 0x03, 0xF0, 0x07, 0x83, 0x00,
  0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x00, 0x1F, 0x00, 0x60, 0x30, 0x00, 0x07,
  0xC0, 0x38, 0x04, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x20, 0x00, 0x1E, 0x03, 0xE0, 0x04, 0x01, 0x87, 0x00, 0xFC, 0x00,
  0xC1, 0x81, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xE0, 0x0F, 0xF0, 0x00, 0x00,
  0x30, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x3C, 0x03, 0xFF, 0xF8, 0x00, 0x0E, 0x01, 0x87, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x30, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x0F, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE1, 0xF8, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x31, 0x90, 0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x0E, 0x03, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x1F, 0xE0, 0x7C, 0x03, 0xFE, 0x0C, 0x00,
  0xFE, 0x07, 0x00, 0x1F, 0xE0, 0xC0, 0x0F, 0xE0, 0xE0, 0x00, 0xFE, 0x1C,
  0x00, 0x7F, 0x0E, 0x00, 0x07, 0xF1, 0xE0, 0x07, 0xF8, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x3F, 0xCC, 0x00, 0x03, 0xF3, 0xE0, 0x01, 0xF0, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xF3, 0xF8, 0x01, 0x80, 0x40,
  0x00, 0x1F, 0x3F, 0x80, 0x38, 0x06, 0x00, 0x01, 0xE1, 0xFC, 0x07, 0x80,
  0x20, 0x00, 0x1E, 0x1F, 0xE0, 0x78, 0x03, 0x00, 0x21, 0xE0, 0xFE, 0x0F,
  0xC0, 0x1C, 0x0C, 0x1C, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xC0, 0x7F,
  0x0F, 0xF8, 0x00, 0x00, 0x38, 0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x3F, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x3F, 0xE0, 0x00, 0x04,
  0x00, 0x1E, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x01, 0xE0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x03, 0xE0,
  0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x1E, 0x07, 0xFF, 0xE0, 0x01, 0xF0, 0x01,
  0xC0, 0xC3, 0xFF, 0x00, 0x3F, 0x80, 0x18, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x30, 0x00, 0x07, 0xFF, 0xFB,
  0xFF, 0x86, 0x00, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0x84, 0x3F, 0xFE, 0x03, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xE3, 0xF9, 0xFF, 0x1F, 0xF1, 0xE0,
  0x1F, 0xCC, 0xFC, 0x70, 0x03, 0xFA, 0x0C, 0x18, 0x00, 0x7E, 0x80, 0x06,
  0x00, 0x0F, 0xC0, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x40, 0x00, 0xFC, 0x00,
  0x10, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x80, 0x01, 0xFF,
  0xF0, 0x30, 0x00, 0xFF, 0xFC, 0x06, 0x00, 0x7F, 0xFE, 0x00, 0xF7, 0x3F,
  0xFF, 0x80, 0x06, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x7F, 0x00, 0x00, 0x00, 0x4F, 0xE0,
  0x00, 0x7C, 0x33, 0xFC, 0x00, 0x3F, 0x88, 0x7F, 0xC6, 0x0F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x8F, 0xE0,
  0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x98, 0x7F,
  0x01, 0xFF, 0xFF, 0xC8, 0x1F, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0xF0,
  0x03, 0xFC, 0x03, 0xF8, 0x70, 0x00, 0xFE, 0x01, 0xFC, 0x70, 0x00, 0x3F,
  0x80, 0xFE, 0x30, 0x00, 0x1F, 0xC0, 0x7F, 0x98, 0x00, 0x07, 0xE0, 0x1F,
  0xEC, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xE3, 0x00,
  0x00, 0x7C, 0x00, 0xC0, 0x80, 0x00, 0x3C, 0x00, 0xC0, 0x60, 0x00, 0x1E,
  0x01, 0xE0, 0x18, 0x00, 0x0F, 0x01, 0xF0, 0x06, 0x01, 0x87, 0x81, 0xF8,
  0x01, 0xC7, 0x03, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x7F, 0x00, 0x00,
  0x01, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x01, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x01, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0x03, 0xF8, 0x00, 0x3F, 0xF3, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7E,
  0x00, 0x33, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0xF0, 0x00,
  0xFE, 0x01, 0xC0, 0x00, 0xFC, 0x03, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x01,
  0xF8, 0x0C, 0x00, 0x03, 0xF0, 0x18, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x0F,
  0x80, 0x60, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x87, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x3D, 0xFF, 0xF0,
  0x00, 0x72, 0x3F, 0xF0, 0x00, 0xE0, 0x1F, 0xF0, 0x03, 0x80, 0x1F, 0xF0,
  0x06, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x78,
  0x78, 0x1C, 0x0F, 0x0E, 0x01, 0xE7, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0xF8, 0xF8, 0x7C, 0x3C, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0x7F, 0xC0, 0x19, 0xFF, 0x81, 0x83, 0xF8, 0x1C, 0x07, 0x81, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE4, 0xFF, 0xFF, 0xC3, 0xFC,
  0xFE, 0x0F, 0xC7, 0xE0, 0x38, 0x1E, 0x00, 0x80, 0x30, 0x00, 0xF8, 0x08,
  0x18, 0x00, 0x47, 0x80, 0x04, 0xF0, 0x00, 0x2F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x30, 0x1F, 0x07,
  0x01, 0xF0, 0xF8, 0x1F, 0x3F, 0x81, 0xFD, 0xFC, 0x1F, 0x0F, 0xE1, 0xF0,
  0x7E, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1,
  0xF0, 0x1E, 0x1F, 0x01, 0xC1, 0xF0, 0x18, 0x3F, 0xC3, 0x07, 0xFF, 0x60,
  0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xF8, 0x06, 0xF8, 0x0C, 0x7C, 0x1C,
  0x7C, 0x38, 0x7E, 0x38, 0x3E, 0x78, 0x38, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xF2, 0x0F,
  0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x02, 0x7F, 0x83, 0xE0,
  0xFE, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xE0, 0x0E, 0x1F, 0x00,
  0x70, 0xF8, 0x03, 0x87, 0xC0, 0x38, 0x3E, 0x01, 0xC1, 0xF8, 0x0C, 0x1F,
  0xF0, 0x61, 0xFF, 0xC6, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x01, 0xF8, 0x06, 0xF8,
  0x0C, 0xFC, 0x1C, 0x7C, 0x38, 0x7C, 0x38, 0x3E, 0x78, 0x3E, 0x78, 0x3F,
  0x78, 0x1E, 0x78, 0x38, 0xF9, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xF2, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x0F, 0x04, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0x3F, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xFF, 0x9F, 0xFF,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x01, 0x3F, 0xE0, 0x18, 0xFF, 0xC3, 0x83, 0xFC, 0x1C, 0x07, 0xC1, 0xE0,
  0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x80, 0x38, 0x7C, 0x03, 0xC3,
  0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x83,
  0xFE, 0x7E, 0x0F, 0xC3, 0xF0, 0x78, 0x0F, 0x81, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x80, 0x38, 0x3C,
  0x03, 0x81, 0xF0, 0x38, 0x07, 0xC3, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x83, 0xC0, 0x04, 0x78, 0x00, 0x6F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x20, 0x1F, 0x06, 0x01, 0xF0, 0xE0, 0x1F, 0x3F, 0x01, 0xFF, 0xF8,
  0x1F, 0x1F, 0xC1, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F,
  0x01, 0xE1, 0xF0, 0x1E, 0x3F, 0x11, 0xC7, 0xFE, 0x3C, 0x3F, 0xC3, 0x80,
  0xF8, 0x30, 0x07, 0x06, 0x00, 0x20, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x07, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x07, 0xF8,
  0xFF, 0xC9, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0xA1, 0xFE, 0x0F, 0xC0, 0xFC, 0x03, 0x80, 0x10, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x06,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xE4,
  0x03, 0x88, 0x0E, 0x08, 0x38, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x88,
  0x1C, 0x10, 0xE0, 0x27, 0x8C, 0xBC, 0x71, 0xF3, 0xC7, 0xDF, 0x1F, 0xFC,
  0x7F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x41, 0xFD, 0x9F, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x3C, 0x03, 0x88, 0x1C, 0x11, 0xE0, 0x27, 0x00, 0xBC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x23, 0xFD, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x18,
  0x00, 0x20, 0x18, 0x02, 0x00, 0x80, 0x0E, 0x03, 0xC0, 0xE0, 0x0F, 0x83,
  0xF0, 0xF8, 0x07, 0xE3, 0xFC, 0xFE, 0x07, 0xFB, 0xFE, 0xFF, 0xE2, 0xFE,
  0x3F, 0xCF, 0xE2, 0x3E, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F,
  0x83, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x01,
  0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0,
  0x3E, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C,
  0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x07, 0xC0, 0xFE, 0x3F, 0xC3, 0xE4, 0xFF, 0x9F, 0xE1,
  0xFC, 0x1F, 0x07, 0xC0, 0xFE, 0x07, 0x01, 0xE0, 0x3E, 0x03, 0x00, 0x60,
  0x0F, 0x00, 0x80, 0x20, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x78, 0x1C, 0x01, 0xF8, 0x7C, 0x07, 0xF1, 0xFF, 0x0F, 0xFD, 0xFF, 0x27,
  0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3E, 0x4F, 0xF0, 0x7F,
  0x07, 0xC0, 0xFE, 0x0F, 0x00, 0xF8, 0x0C, 0x00, 0xF0, 0x08, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x3E, 0x7F,
  0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x83, 0xE1, 0xFC, 0x3E, 0x0F, 0xC3, 0xE0,
  0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x1E, 0x3E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1C, 0x3E, 0x03, 0xC7,
  0xF0, 0x38, 0xFF, 0x83, 0x07, 0xFE, 0x60, 0x1F, 0xF8, 0x00, 0x7F, 0x00,
  0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x04,
  0x07, 0xF0, 0x78, 0x1F, 0xC3, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0xFF, 0x80,
  0xF8, 0x7F, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x07,
  0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xC3, 0xF8, 0x0F, 0x1F,
  0xE0, 0x38, 0xFF, 0xE0, 0xC3, 0xFF, 0xE6, 0x08, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0D, 0xFF,
  0x03, 0x1F, 0xF8, 0xE0, 0xFE, 0x38, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0xE0, 0xF8,
  0xFE, 0x3F, 0x0F, 0xF9, 0xE0, 0xFE, 0x3C, 0x0F, 0x87, 0x80, 0xE0, 0xF0,
  0x10, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x1C, 0x0C, 0x3E, 0x0C, 0x3F, 0x1E, 0x7F, 0x3E, 0xFF, 0xFF,
  0x9F, 0x9F, 0x0F, 0x9E, 0x0F, 0x8C, 0x0F, 0x88, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x88, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x01, 0x00, 0xC0, 0x70, 0x18, 0x1F,
  0x83, 0x07, 0xFF, 0xC3, 0x7F, 0xF8, 0xC3, 0xFE, 0x30, 0x1F, 0x86, 0x00,
  0x61, 0xE0, 0x08, 0x3E, 0x02, 0x07, 0xE0, 0xE0, 0x7E, 0x3E, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x0F, 0x8F, 0xE1, 0xE0, 0xFC, 0x18, 0x0F, 0x82, 0x00,
  0xF0, 0xC0, 0x1C, 0x3E, 0x03, 0x0F, 0xF8, 0x43, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC2, 0x3F, 0xA7, 0xFF, 0x07, 0xF0, 0x0F,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x80, 0x38, 0x01, 0x80, 0xF8, 0x07,
  0x81, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x8F, 0xF0, 0xFF, 0x27, 0xE0, 0xFC,
  0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF8, 0xFE, 0x4F, 0xFE, 0x7F, 0x03, 0xF8,
  0xFC, 0x03, 0xE0, 0xF8, 0x03, 0x80, 0xE0, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x08, 0x0E, 0x00, 0xE0, 0x7C, 0x07, 0xC1,
  0xF8, 0x7F, 0x87, 0xE3, 0xFF, 0x1F, 0xF0, 0xFC, 0x3F, 0x81, 0xF8, 0xFE,
  0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xC0, 0x7C, 0x07, 0x01, 0xF0,
  0x18, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x7E,
  0x0C, 0x01, 0xFC, 0x60, 0x0F, 0xFD, 0x00, 0x4F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x03,
  0x00, 0x30, 0x7F, 0x03, 0xC0, 0x70, 0x7F, 0x07, 0xE1, 0xF8, 0x7F, 0x8F,
  0xE3, 0xFC, 0x3F, 0xB7, 0xFC, 0xFC, 0x1F, 0xE3, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x81,
  0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x81,
  0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x81,
  0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x1C, 0x0F, 0x81,
  0xF8, 0x38, 0x0F, 0x83, 0xFC, 0x30, 0x1F, 0xC7, 0xFF, 0x60, 0x3F, 0xE0,
  0xFF, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x0C, 0x02, 0x03, 0xC1, 0xC1, 0xF8,
  0x70, 0x7F, 0x3E, 0x3F, 0xDF, 0x89, 0xFB, 0xF0, 0x7E, 0xF8, 0x1F, 0x1C,
  0x07, 0xC2, 0x01, 0xF1, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE6, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x73, 0xE0, 0x18, 0x30, 0x04, 0x04, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x38, 0x18, 0x1E, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x10, 0x7F, 0x01, 0x83, 0xFC, 0x1E, 0x0F, 0xE3, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0xFC, 0x87, 0x0F,
  0xF8, 0x78, 0x3F, 0x83, 0x80, 0x7C, 0x18, 0x01, 0xC1, 0x80, 0x04, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x08, 0x7E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x20, 0xC1, 0x83, 0xF4,
  0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x27, 0xF0, 0xC7, 0xE3,
  0x07, 0xC6, 0x0F, 0x98, 0x1F, 0x30, 0x1E, 0x60, 0x3C, 0xC0, 0x7B, 0x80,
  0xF6, 0x01, 0xEC, 0x03, 0xCC, 0x07, 0x18, 0x0E, 0x30, 0x38, 0x20, 0x60,
  0x21, 0x80, 0x3C, 0x00, 0x00, 0x18, 0x07, 0xC0, 0x70, 0x07, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x01, 0xF0,
  0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80,
  0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 37, 12, 1, -36 },
  { 48, 18, 14, 20, 1, -36 },
  { 80, 22, 28, 26, 2, -32 },
  { 157, 17, 40, 21, 2, -38 },
  { 242, 33, 35, 36, 1, -35 },
  { 387, 25, 31, 29, 2, -31 },
  { 484, 8, 14, 10, 1, -36 },
  { 498, 11, 40, 12, 1, -39 },
  { 553, 11, 40, 12, 1, -39 },
  { 608, 17, 20, 18, 0, -38 },
  { 651, 16, 17, 20, 2, -25 },
  { 685, 8, 14, 9, 0, -8 },
  { 699, 14, 10, 15, 1, -20 },
  { 717, 8, 9, 10, 1, -8 },
  { 726, 24, 39, 26, 1, -37 },
  { 843, 22, 35, 24, 1, -35 },
  { 940, 14, 34, 16, 1, -34 },
  { 1000, 21, 34, 22, 1, -34 },
  { 1090, 22, 34, 23, 1, -34 },
  { 1184, 22, 34, 23, 0, -34 },
  { 1278, 22, 35, 23, 1, -35 },
  { 1375, 21, 35, 23, 1, -35 },
  { 1467, 20, 34, 21, 1, -34 },
  { 1552, 21, 35, 23, 1, -35 },
  { 1644, 21, 35, 23, 1, -35 },
  { 1736, 8, 25, 10, 1, -24 },
  { 1761, 9, 30, 9, 0, -24 },
  { 1795, 14, 18, 14, 0, -23 },
  { 1827, 17, 12, 19, 1, -21 },
  { 1853, 14, 18, 14, 0, -23 },
  { 1885, 19, 37, 23, 2, -36 },
  { 1973, 29, 30, 30, 1, -23 },
  { 2082, 39, 37, 41, 1, -36 },
  { 2263, 43, 37, 45, 0, -36 },
  { 2462, 32, 37, 34, 1, -36 },
  { 2610, 38, 39, 41, 1, -37 },
  { 2796, 33, 37, 35, 1, -36 },
  { 2949, 36, 42, 38, 1, -36 },
  { 3138, 36, 37, 39, 1, -36 },
  { 3305, 35, 46, 37, 1, -39 },
  { 3507, 32, 42, 34, 1, -36 },
  { 3675, 33, 48, 36, 1, -36 },
  { 3873, 39, 37, 41, 1, -36 },
  { 4054, 27, 36, 29, 1, -35 },
  { 4176, 53, 38, 55, 1, -35 },
  { 4428, 42, 36, 44, 1, -35 },
  { 4617, 36, 37, 38, 1, -36 },
  { 4784, 43, 43, 45, 1, -35 },
  { 5016, 38, 39, 40, 1, -36 },
  { 5202, 44, 37, 47, 1, -36 },
  { 5406, 36, 37, 38, 1, -36 },
  { 5573, 35, 36, 37, 1, -36 },
  { 5731, 34, 38, 36, 1, -35 },
  { 5893, 42, 37, 44, 1, -36 },
  { 6088, 52, 37, 54, 1, -36 },
  { 6329, 34, 38, 36, 1, -37 },
  { 6491, 41, 45, 43, 1, -37 },
  { 6722, 31, 42, 33, 1, -36 },
  { 6885, 7, 39, 9, 1, -37 },
  { 6920, 30, 35, 5, -9, -33 },
  { 7052, 7, 39, 9, 1, -37 },
  { 7087, 18, 13, 21, 1, -35 },
  { 7117, 23, 4, 23, 0, 5 },
  { 7129, 8, 9, 25, 8, -35 },
  { 7138, 21, 27, 23, 1, -26 },
  { 7209, 20, 36, 22, 1, -34 },
  { 7299, 16, 26, 18, 1, -25 },
  { 7351, 21, 36, 23, 1, -35 },
  { 7446, 16, 26, 18, 1, -25 },
  { 7498, 15, 45, 12, 0, -37 },
  { 7583, 21, 37, 23, 1, -26 },
  { 7681, 20, 44, 22, 1, -35 },
  { 7791, 12, 36, 14, 1, -35 },
  { 7845, 15, 44, 12, -3, -35 },
  { 7928, 14, 36, 16, 1, -35 },
  { 7991, 14, 36, 14, 1, -35 },
  { 8054, 33, 27, 35, 1, -26 },
  { 8166, 23, 27, 25, 1, -26 },
  { 8244, 20, 27, 21, 0, -26 },
  { 8312, 22, 40, 23, 0, -30 },
  { 8422, 19, 36, 22, 1, -26 },
  { 8508, 16, 27, 18, 1, -26 },
  { 8562, 19, 32, 21, 1, -31 },
  { 8638, 13, 33, 15, 1, -32 },
  { 8692, 23, 27, 25, 1, -26 },
  { 8770, 22, 29, 23, -1, -28 },
  { 8850, 32, 30, 34, 1, -29 },
  { 8970, 18, 36, 20, 1, -26 },
  { 9051, 21, 39, 23, 1, -30 },
  { 9154, 15, 35, 17, 1, -26 },
  { 9220, 13, 40, 17, 1, -39 },
  { 9285, 3, 41, 8, 2, -39 },
  { 9301, 13, 40, 17, 1, -39 },
  { 9366, 16, 4, 18, 1, -17 },
};

const GFXfont UnifrakturMaguntia_Regular50pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular50pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular50pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR50PT7B_H_
