#ifndef _UNIFRAKTURMAGUNTIA_REGULAR40PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x20, 0xE7, 0xF7, 0xEF, 0x9F, 0x1E, 0x38, 0x70, 0xE1, 0xC1,
  0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x00, 0x00, 0x00, 0x08, 0x38, 0xF9,
  0xF9, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x40, 0x83, 0x87, 0x1F, 0x3F, 0xFC,
  0x7C, 0xF0, 0xF1, 0xC1, 0x86, 0x06, 0x18, 0x10, 0x40, 0x43, 0x02, 0x00,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x83, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x01, 0xF0, 0x1C,
  0x30, 0xE0, 0x63, 0x01, 0x9C, 0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x81, 0x9F,
  0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xD8, 0x1F, 0xF0, 0x3F, 0xC0, 0x76, 0x01, 0xD8, 0x07, 0x60, 0x18,
  0xC0, 0xC1, 0xCF, 0x01, 0xF0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x0F, 0x00, 0x00, 0xCE, 0x60, 0x00, 0x67, 0x1C, 0x00, 0x11, 0xC7, 0x80,
  0x0C, 0xF1, 0xE0, 0x06, 0x3C, 0x78, 0x03, 0x0F, 0x1E, 0x01, 0x83, 0xC7,
  0x80, 0xC0, 0xF1, 0xE0, 0x60, 0x3C, 0x78, 0x30, 0x07, 0x1E, 0x0C, 0x01,
  0xC7, 0x06, 0x00, 0x39, 0x83, 0x00, 0x03, 0xC1, 0x87, 0x80, 0x00, 0xC7,
  0x30, 0x00, 0x63, 0x8E, 0x00, 0x30, 0xE3, 0xC0, 0x08, 0x78, 0xF0, 0x06,
  0x1E, 0x3C, 0x03, 0x07, 0x8F, 0x01, 0x81, 0xE3, 0xC0, 0xC0, 0x78, 0xF0,
  0x60, 0x1E, 0x3C, 0x30, 0x03, 0x8F, 0x18, 0x00, 0xE3, 0x86, 0x00, 0x1C,
  0xC3, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0xE0,
  0x00, 0xC3, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1E,
  0x30, 0x00, 0xF3, 0x00, 0x07, 0xB0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0xFE,
  0x0F, 0xC1, 0xC1, 0xFE, 0x0E, 0x1F, 0xF8, 0x21, 0xE7, 0xC3, 0x0E, 0x3F,
  0x10, 0x71, 0xF8, 0x87, 0x87, 0xEC, 0x3C, 0x3F, 0x41, 0xE0, 0xFC, 0x07,
  0x83, 0xF0, 0x3C, 0x1F, 0xCD, 0xF0, 0x7F, 0xC7, 0xC2, 0xFC, 0x0F, 0xE3,
  0xC0, 0x00, 0xC7, 0x3F, 0x7C, 0xF1, 0x86, 0x10, 0x42, 0x00, 0x00, 0x07,
  0x0C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70,
  0x70, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x03, 0xE0, 0x30, 0x18, 0x1C, 0x1C,
  0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0C, 0x1C, 0x18,
  0x18, 0x30, 0xE0, 0x02, 0x00, 0x10, 0x01, 0xE0, 0x3F, 0x4F, 0x37, 0xB9,
  0x3D, 0xEB, 0xC9, 0xFA, 0x47, 0x13, 0xD7, 0x9E, 0x9F, 0xE6, 0xF1, 0x7C,
  0x07, 0xC0, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x71, 0xF7, 0xF3, 0xC3, 0x83,
  0x04, 0x18, 0x20, 0x80, 0x00, 0x63, 0xFC, 0xFF, 0x18, 0x00, 0x00, 0xFF,
  0x1F, 0xE7, 0xE0, 0x20, 0xC7, 0xBF, 0x70, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0x18, 0x07, 0x0E, 0x03, 0x83, 0x83, 0xC1, 0xE3,
  0xE0, 0xF1, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0xF9,
  0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C, 0x0E, 0x0C, 0x03, 0x8C, 0x00, 0x7C,
  0x00, 0x01, 0x80, 0x38, 0x07, 0x80, 0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x88,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x81, 0xFC, 0x7F, 0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x70, 0x7E, 0x60, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x01, 0x06, 0x01, 0x0C, 0x01,
  0x08, 0x01, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF0, 0x0F, 0xFE, 0x0C, 0x3F, 0x8C, 0x07, 0xC4, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF6, 0x00, 0xFF, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF8, 0x0E, 0x3C, 0x0E, 0x0F, 0x0E, 0x01, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x17, 0x80, 0x09, 0xE0, 0x06, 0x78, 0x01, 0x1E, 0x00, 0x87,
  0x80, 0x61, 0xE0, 0x10, 0x78, 0x08, 0x1E, 0x06, 0x07, 0x81, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F,
  0xF8, 0x30, 0x06, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x13, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF9, 0xE0, 0xFC, 0xC0, 0x3F, 0x40,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF4, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1D, 0xE0, 0x1E, 0xF8, 0x0E, 0x3C, 0x0E, 0x0F, 0x0E, 0x01, 0xFC,
  0x00, 0x01, 0xF0, 0x03, 0x1E, 0x03, 0x07, 0x83, 0x83, 0xC3, 0xC1, 0xF1,
  0xC0, 0xF9, 0xE0, 0x38, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x3C,
  0x1F, 0x3F, 0x8F, 0xA3, 0xE7, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8,
  0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x38, 0xF0, 0x1C, 0x3C, 0x1C, 0x0E, 0x0C, 0x03, 0x8C, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xC0, 0x06, 0x80, 0x04, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x0E, 0x0C, 0x0E,
  0x03, 0x0E, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x39, 0xC0, 0x1C, 0xF0, 0x0C,
  0x7C, 0x0E, 0x3F, 0x86, 0x0F, 0xF6, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x6F, 0xF8, 0x61, 0xFC, 0x70, 0x3F, 0x70, 0x0F, 0xB8, 0x03, 0xDC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x0E, 0x60, 0x06,
  0x38, 0x07, 0x06, 0x06, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x06, 0x38, 0x06,
  0x0E, 0x07, 0x07, 0x87, 0x81, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3E,
  0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC1,
  0xF9, 0xE0, 0xFC, 0xF8, 0xBE, 0x3F, 0xDF, 0x07, 0x8F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE3, 0x80, 0xF3, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x38,
  0x3C, 0x18, 0x0F, 0x18, 0x01, 0xF8, 0x00, 0x20, 0xC7, 0xBF, 0x70, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x83, 0x1E, 0xFD, 0xC2, 0x00, 0x10, 0x30,
  0xF3, 0xF3, 0x83, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0E, 0x3E,
  0xFE, 0x78, 0x70, 0x60, 0x83, 0x04, 0x10, 0x00, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xF0, 0x3C, 0x1F, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xC1, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x00, 0x07, 0xF0, 0x70, 0x71, 0xC0, 0x73, 0x00, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x30, 0x3E, 0x01, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x18, 0x00, 0x38,
  0x10, 0x70, 0x20, 0x70, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x01, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x0E, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0x03, 0x80, 0x38, 0x01, 0x80, 0xE0, 0x01, 0x83,
  0x80, 0x01, 0x86, 0x07, 0xFB, 0x1C, 0x19, 0xE7, 0x30, 0x73, 0xC6, 0xE1,
  0xC7, 0x8D, 0xC7, 0x0E, 0x1B, 0x9E, 0x1C, 0x76, 0x3C, 0x78, 0xCC, 0x70,
  0xF1, 0x98, 0xE3, 0xC6, 0x31, 0xCF, 0x9C, 0x73, 0xF7, 0x73, 0x63, 0xCF,
  0x8C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x06,
  0x00, 0xE0, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x30, 0x3F, 0xFC, 0x01, 0xC0, 0xFF, 0xFC, 0x0F, 0x02, 0x03,
  0xF8, 0x7E, 0x08, 0x03, 0xF9, 0xFC, 0x30, 0x03, 0xF0, 0xF8, 0x60, 0x03,
  0xF1, 0xF0, 0x80, 0x07, 0xE3, 0xE1, 0x80, 0x07, 0xC7, 0xC3, 0x00, 0x0F,
  0x8F, 0x87, 0x00, 0x1E, 0x1F, 0x0F, 0xE0, 0x3C, 0x3E, 0x0F, 0xE0, 0x78,
  0x7C, 0x0F, 0xE0, 0xE0, 0xF8, 0x0F, 0xC3, 0x81, 0xF0, 0x03, 0x87, 0x03,
  0xE0, 0x03, 0x1C, 0x07, 0xC0, 0x04, 0x70, 0x0F, 0x80, 0x10, 0xC0, 0x1F,
  0x00, 0x02, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0x37, 0xFC,
  0x01, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0xFF,
  0x00, 0x3F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xE4, 0x3E, 0x03, 0xE1, 0xFF,
  0x07, 0xE0, 0xF0, 0x0F, 0xE0, 0x7C, 0x1C, 0x00, 0xFC, 0x0F, 0xC3, 0x00,
  0x1F, 0x81, 0xF8, 0x60, 0x01, 0xF0, 0x1F, 0x88, 0x00, 0x3E, 0x03, 0xE9,
  0x00, 0x03, 0xC0, 0x30, 0x30, 0x00, 0x78, 0x1C, 0x06, 0x00, 0x0F, 0x0F,
  0xE0, 0x60, 0x01, 0xC7, 0xFE, 0x0E, 0x04, 0x33, 0xFF, 0xE0, 0x7F, 0x0E,
  0x01, 0xFE, 0x00, 0x01, 0x80, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0xFC, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x7F, 0xE0, 0x00, 0x70, 0x13, 0xFE, 0x00,
  0x1C, 0x00, 0x1F, 0xE0, 0x03, 0x00, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x1F,
  0xF8, 0x30, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x30, 0x00, 0xE3, 0x1F, 0x00, 0xF0,
  0x4F, 0xFC, 0x38, 0x0F, 0xFE, 0x1C, 0x06, 0x7E, 0x0F, 0x03, 0x03, 0x03,
  0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7F, 0x80, 0x3E, 0x0F,
  0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xE0,
  0x0F, 0xE0, 0x70, 0x01, 0xFC, 0x18, 0x00, 0x3F, 0x88, 0x00, 0x0F, 0xF4,
  0x00, 0x01, 0xFF, 0x00, 0x20, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xF8, 0x11, 0xFF, 0x07, 0x80, 0xE0, 0xFE, 0x1C, 0x06, 0x01, 0xFC,
  0xE0, 0x38, 0x03, 0xF3, 0x00, 0xF0, 0x03, 0xEC, 0x07, 0xC0, 0x0F, 0xB0,
  0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xD0, 0x03, 0xF8, 0x07, 0x60, 0x07, 0xE0, 0x1C, 0xE0, 0x0F,
  0x80, 0x30, 0xFE, 0x1C, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x0F, 0x40, 0x01, 0x00, 0xFF, 0x80, 0x0C,
  0x07, 0xFF, 0x00, 0x20, 0x7F, 0xFF, 0x01, 0x03, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x30, 0x00, 0xE3, 0x1F, 0x00, 0xF0, 0x4F,
  0xFC, 0x38, 0x0F, 0xFE, 0x1C, 0x06, 0x3E, 0x0F, 0x03, 0x03, 0x03, 0xC3,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x8F, 0xC1, 0xC3, 0xE1, 0xF8, 0xFD, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xF7,
  0xEF, 0xC1, 0xFE, 0x73, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xE0, 0x0F,
  0xE0, 0x70, 0x01, 0xFC, 0x18, 0x00, 0x3F, 0x88, 0x00, 0x0F, 0xF4, 0x00,
  0x01, 0xFF, 0x00, 0x20, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF3, 0xE0, 0x3F, 0xFE, 0x78,
  0x00, 0x7F, 0xC7, 0x00, 0x11, 0xF0, 0x60, 0x01, 0x0E, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0xC0, 0x0F, 0x80, 0x8C,
  0x00, 0xFC, 0x0C, 0x40, 0x0F, 0xE1, 0xE6, 0x00, 0x7E, 0x3F, 0x20, 0x07,
  0xF7, 0xF1, 0x80, 0x3F, 0xDE, 0x0F, 0x7B, 0xF8, 0xC0, 0x18, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x0C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x30, 0x08, 0x00, 0x0E, 0x70, 0xE0,
  0x00, 0xE0, 0x4F, 0x80, 0x1E, 0x02, 0xFE, 0x00, 0xE0, 0x13, 0xF8, 0x0E,
  0x03, 0x0F, 0xE0, 0xF0, 0x30, 0x3F, 0x87, 0x87, 0x00, 0xF8, 0x7C, 0x78,
  0x01, 0x83, 0xC3, 0xC0, 0x10, 0x1E, 0x1F, 0x03, 0x01, 0xF0, 0xF8, 0x3F,
  0x0F, 0x87, 0xE7, 0xFC, 0x7C, 0x1F, 0xCF, 0xF3, 0xE0, 0xFE, 0x0F, 0xDF,
  0x83, 0xF0, 0x7E, 0xFC, 0x0F, 0xC1, 0xF7, 0xE0, 0x3F, 0x07, 0xDF, 0x01,
  0xF8, 0x3E, 0xF8, 0x07, 0xC1, 0xF7, 0xE0, 0x3C, 0x0F, 0x1F, 0x00, 0xE0,
  0x78, 0xFC, 0x0E, 0x03, 0xC3, 0xE0, 0xC0, 0x1C, 0x0F, 0x8C, 0x01, 0xC0,
  0x3E, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x0C, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x33, 0xF8, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x30, 0x1F, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x80,
  0x18, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0xC7, 0xFE,
  0x00, 0x7E, 0x63, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x0C, 0x07, 0x00,
  0xF0, 0xF8, 0x38, 0x07, 0x8F, 0xE1, 0x80, 0x78, 0xFF, 0x88, 0x03, 0xC0,
  0xFF, 0x80, 0x1C, 0x03, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x03, 0xC1, 0xFE, 0x03, 0x80, 0x3F, 0xC9, 0x80, 0x0F, 0xF8,
  0xC0, 0x03, 0xF0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38,
  0x1C, 0x00, 0x3C, 0x06, 0x00, 0x1E, 0x03, 0x00, 0x1F, 0x00, 0xC0, 0x0F,
  0x80, 0x30, 0x07, 0xE0, 0x0F, 0x19, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x9F,
  0xC0, 0x03, 0x9F, 0xF0, 0x01, 0xDB, 0xFC, 0x00, 0xC0, 0x7F, 0x00, 0x60,
  0x1F, 0xC0, 0x60, 0x07, 0xF8, 0x60, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0x07, 0xF8, 0x03, 0x80, 0x7F, 0xD8, 0x60, 0x03, 0xFE, 0x18, 0x00, 0x3F,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x01, 0x80,
  0x01, 0xC0, 0x10, 0x00, 0x78, 0x03, 0x00, 0x0F, 0x00, 0x20, 0x01, 0xF0,
  0x03, 0x00, 0x3E, 0x00, 0x38, 0x67, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x0F, 0xE0, 0x00, 0xC3, 0xFE, 0x00,
  0x18, 0xDF, 0xE0, 0x06, 0x00, 0xFE, 0x00, 0xC0, 0x0F, 0xE0, 0x30, 0x00,
  0xFF, 0x0C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x80, 0x1C, 0x1F, 0x03, 0x00, 0x78, 0x7F, 0x83, 0x00, 0xF1, 0xFF,
  0x87, 0x03, 0xE6, 0x3F, 0x86, 0x07, 0xC8, 0x1F, 0x0C, 0x0F, 0xA0, 0x3F,
  0x18, 0x1F, 0x40, 0x3E, 0x30, 0x3F, 0x80, 0x7F, 0x60, 0x3F, 0x00, 0x7C,
  0xC0, 0x7F, 0x00, 0x61, 0x00, 0xFE, 0x01, 0x06, 0x00, 0xFE, 0x0E, 0x10,
  0x00, 0xFC, 0x7E, 0x40, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xF8, 0x0F,
  0x83, 0x81, 0xF0, 0x3F, 0x86, 0x03, 0xF0, 0xFF, 0x08, 0x07, 0xE0, 0x3F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x38, 0x1E, 0x03, 0x80, 0x78, 0x3C,
  0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0xC0, 0x0F,
  0x7E, 0x00, 0x7B, 0xF8, 0x03, 0xCF, 0xC0, 0x3C, 0x7F, 0x01, 0xE1, 0xF9,
  0x3E, 0x0F, 0xD7, 0xC0, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0x0F, 0xFC, 0x30, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x81,
  0xF0, 0x03, 0xFF, 0x0F, 0xF0, 0xFE, 0x01, 0xFF, 0xF7, 0xFE, 0x6F, 0xC0,
  0xFF, 0xFF, 0x1F, 0xF0, 0xF8, 0x70, 0x3F, 0x83, 0xF8, 0x3E, 0x10, 0x07,
  0xF0, 0x7E, 0x0F, 0xCC, 0x00, 0xFC, 0x0F, 0x81, 0xF2, 0x00, 0x1F, 0x83,
  0xE0, 0x7C, 0x80, 0x03, 0xE0, 0x7C, 0x1F, 0xA0, 0x00, 0xFC, 0x1F, 0x07,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0xF3, 0x00, 0x07, 0xC0, 0xF0, 0x10, 0x40,
  0x00, 0xF0, 0x3C, 0x18, 0x1F, 0xF0, 0x3C, 0x0F, 0x04, 0x03, 0xFE, 0x0F,
  0x03, 0xC3, 0x00, 0x7F, 0x83, 0xC0, 0xE1, 0xC0, 0x00, 0x20, 0xE0, 0x38,
  0xF0, 0x00, 0x08, 0x38, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x03, 0x9F, 0x00,
  0x00, 0x03, 0x00, 0xC7, 0xC0, 0x00, 0x00, 0xC0, 0x31, 0xF0, 0x00, 0x00,
  0x60, 0x08, 0x7E, 0x00, 0x78, 0x13, 0x86, 0x0F, 0x80, 0x7F, 0x0D, 0xF1,
  0x03, 0xF1, 0x3F, 0xE2, 0xFF, 0x80, 0x7F, 0xC9, 0xFF, 0x7F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x97, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x70, 0x00,
  0x40, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xE0, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xC3, 0xFE, 0x07, 0xFF,
  0xF2, 0x1F, 0x87, 0x03, 0xFA, 0x07, 0xC2, 0x00, 0xFF, 0x03, 0xE3, 0x00,
  0x3F, 0x80, 0xF9, 0x00, 0x0F, 0xC0, 0x7C, 0x80, 0x03, 0xE0, 0x3F, 0x40,
  0x00, 0xF8, 0x1F, 0xE0, 0x00, 0x7C, 0x07, 0x18, 0x00, 0x3E, 0x03, 0x04,
  0x18, 0x0F, 0x03, 0x03, 0xFF, 0x07, 0x83, 0x00, 0xFF, 0x83, 0xC1, 0x80,
  0x1F, 0xC1, 0xE1, 0xC0, 0x00, 0x20, 0xE1, 0xE0, 0x00, 0x10, 0x70, 0xF0,
  0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x0C, 0x3E,
  0x00, 0x00, 0x0C, 0x1F, 0x80, 0x1F, 0x06, 0x07, 0xC0, 0x3F, 0x86, 0x03,
  0xF1, 0x3F, 0xE2, 0x00, 0xFF, 0xA3, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x30, 0x7F, 0xF0, 0x0C, 0x00, 0xFF, 0x81, 0x80,
  0x03, 0xF8, 0x30, 0x00, 0x1F, 0xC7, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3E, 0xFE, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x1F, 0x7F,
  0xE0, 0x00, 0xF3, 0xFF, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0xF0, 0x3F, 0x80,
  0x06, 0x00, 0xF8, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0x60,
  0xF4, 0x00, 0x0C, 0x1F, 0x80, 0x00, 0xC7, 0xFE, 0x00, 0x08, 0xFF, 0xF0,
  0x01, 0x00, 0xFF, 0xC0, 0x20, 0x03, 0xFF, 0x1C, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x40, 0x07,
  0xFF, 0x00, 0x70, 0x03, 0xFF, 0xE0, 0x78, 0x01, 0xFF, 0xFC, 0x7F, 0x00,
  0xE0, 0x3F, 0xEF, 0xC0, 0x30, 0x07, 0xE1, 0xF8, 0x08, 0x00, 0xFC, 0x7F,
  0x02, 0x00, 0x3F, 0x0F, 0xF0, 0x80, 0x07, 0xC1, 0xFE, 0x20, 0x01, 0xF0,
  0x3F, 0xC8, 0x00, 0x7C, 0x07, 0xF3, 0x00, 0x1F, 0x00, 0xFE, 0x40, 0x07,
  0xC0, 0x1F, 0x88, 0x09, 0xF0, 0x03, 0xE1, 0xFC, 0x3C, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x03, 0xC0, 0x01,
  0x00, 0x03, 0xF0, 0x00, 0x80, 0x01, 0xFE, 0x00, 0x20, 0x01, 0xFF, 0xE0,
  0x10, 0x00, 0xFF, 0xFE, 0x18, 0x00, 0x20, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x06, 0x7F, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0C, 0x1F, 0xFC, 0x00, 0xC0,
  0x0F, 0xF8, 0x0E, 0x00, 0x0F, 0xE0, 0x70, 0x00, 0x1F, 0xC1, 0xC0, 0x00,
  0x3F, 0x0F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x01,
  0xE1, 0xFE, 0x00, 0x07, 0x87, 0xFE, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x3C,
  0x1F, 0xF8, 0x00, 0xF0, 0x0F, 0xE0, 0x01, 0x80, 0x0F, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x3D, 0x00, 0x73, 0x01, 0xF8,
  0x03, 0xEC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xF1, 0x9F, 0x84, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xF8, 0xFF, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x3F, 0xC1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xF8, 0x87, 0xE0, 0xF0, 0x7F,
  0xA0, 0xFC, 0x18, 0x03, 0xFC, 0x0F, 0xC7, 0x00, 0x3F, 0x81, 0xF8, 0xC0,
  0x03, 0xF0, 0x3F, 0x18, 0x00, 0x3E, 0x03, 0xFB, 0x00, 0x07, 0xC0, 0x3C,
  0x60, 0x00, 0x78, 0x03, 0x0C, 0x00, 0x0F, 0x01, 0x81, 0x80, 0x01, 0xE0,
  0x40, 0x18, 0x00, 0x1C, 0x38, 0x01, 0x80, 0x03, 0x9F, 0x80, 0x18, 0x30,
  0x77, 0xF8, 0x00, 0xF8, 0x0E, 0x3F, 0x00, 0x00, 0x01, 0xC3, 0xF0, 0x00,
  0x00, 0x38, 0x7E, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0xF8,
  0x00, 0x00, 0x30, 0x1F, 0x80, 0x3E, 0x04, 0x03, 0xF0, 0x0F, 0xE1, 0x80,
  0x7F, 0x03, 0xFE, 0x60, 0x07, 0xE4, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x20, 0x0F,
  0xFF, 0xEE, 0x01, 0x9F, 0xFF, 0xC0, 0x60, 0x1F, 0xF8, 0x0C, 0x00, 0x7E,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0xF0, 0xE0, 0x01, 0xFF, 0x8E, 0x18, 0x7F,
  0xFC, 0xE0, 0xFF, 0xFC, 0x6E, 0x07, 0xFE, 0x02, 0xF0, 0x3F, 0xC0, 0x1F,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x17, 0x80, 0x00, 0x01, 0x7C, 0x00,
  0x00, 0x17, 0xE0, 0x00, 0x02, 0x3F, 0x80, 0x00, 0x63, 0xFE, 0x00, 0x1C,
  0x1F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0x81, 0xFF, 0x80, 0x60, 0x07, 0xFE, 0x04,
  0x00, 0x1F, 0xF1, 0xC0, 0x0E, 0x7F, 0xE8, 0x01, 0x83, 0xFC, 0x80, 0x38,
  0x0F, 0x08, 0x03, 0xC0, 0x00, 0x80, 0x7E, 0x00, 0x04, 0x03, 0xF0, 0x00,
  0x40, 0x3F, 0xC0, 0x03, 0x05, 0xFE, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x1F, 0x00, 0x0F, 0x80, 0xE0,
  0x03, 0xFC, 0x1C, 0x00, 0x7F, 0xE1, 0x80, 0x00, 0xFF, 0x20, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x07, 0xFC,
  0x30, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x80,
  0xE2, 0x00, 0x30, 0x38, 0x20, 0x1C, 0x0E, 0x04, 0x0F, 0x03, 0xC0, 0x87,
  0xE0, 0x78, 0x21, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F,
  0x80, 0x3E, 0x03, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0xF8, 0x07, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0x01, 0xF0, 0x01, 0xC0, 0x3E, 0x00, 0x30, 0x07, 0xC0, 0x0C, 0x00, 0xF8,
  0x03, 0x00, 0x1F, 0x00, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xE0,
  0x1F, 0x83, 0xFF, 0x05, 0xF0, 0x8F, 0xFB, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x07, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x03, 0x80, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFF,
  0xF1, 0xFF, 0x00, 0xFF, 0xFE, 0x87, 0xE0, 0x7C, 0x7F, 0xA0, 0xF8, 0x1C,
  0x03, 0xF8, 0x3F, 0x0C, 0x00, 0x7E, 0x07, 0xC3, 0x00, 0x1F, 0x81, 0xFC,
  0x80, 0x03, 0xE0, 0x3C, 0x20, 0x00, 0xF8, 0x04, 0x08, 0x00, 0x1E, 0x03,
  0x03, 0x00, 0x07, 0x81, 0x80, 0x40, 0x01, 0xC0, 0xF0, 0x18, 0x00, 0x70,
  0x3C, 0x03, 0x03, 0x1C, 0x0F, 0x80, 0x3F, 0x0E, 0x03, 0xF0, 0x00, 0x03,
  0x00, 0xFE, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x60, 0x03, 0xF0, 0x00,
  0x30, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x03, 0xC0,
  0x7F, 0xF0, 0x00, 0x70, 0x33, 0xFE, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x0C,
  0x00, 0x07, 0xFC, 0x02, 0x00, 0x00, 0xFF, 0xC3, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x0E, 0x0F, 0xE0, 0x03, 0xFF, 0x8F, 0x9B,
  0xFC, 0x07, 0xFF, 0xE8, 0x70, 0x7E, 0x07, 0xFF, 0xFC, 0x18, 0x1F, 0x83,
  0x80, 0xFE, 0x18, 0x07, 0xC3, 0x80, 0x3F, 0x0C, 0x03, 0xF1, 0x80, 0x0F,
  0xCE, 0x00, 0xF8, 0xC0, 0x03, 0xE7, 0x80, 0x7F, 0x40, 0x01, 0xF3, 0xC0,
  0x1E, 0x20, 0x00, 0x79, 0xF0, 0x04, 0x18, 0x00, 0x3C, 0xF8, 0x06, 0x04,
  0x00, 0x1E, 0x7E, 0x07, 0x03, 0x00, 0x0E, 0x3F, 0x87, 0x80, 0x80, 0xC7,
  0x0F, 0xC3, 0xE0, 0x3F, 0x83, 0x03, 0xE1, 0xF8, 0x01, 0x03, 0x81, 0xF0,
  0xFF, 0x00, 0x01, 0x80, 0x78, 0x3F, 0x80, 0x01, 0x80, 0x3C, 0x0F, 0xE0,
  0x00, 0x80, 0x0E, 0x03, 0xF0, 0x06, 0x80, 0x07, 0x00, 0xF8, 0x1F, 0xC0,
  0x03, 0x00, 0x3C, 0x1F, 0xF0, 0x01, 0xC0, 0x1C, 0x33, 0xFC, 0x01, 0xF0,
  0x06, 0x00, 0x7F, 0x01, 0xFC, 0x06, 0x00, 0x1F, 0xE1, 0xFF, 0x02, 0x00,
  0x07, 0xFF, 0x1F, 0xE6, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xC4, 0x7F, 0xF0, 0x7F, 0x9F, 0xFF, 0x1F, 0xE7, 0xFF, 0xE3,
  0xFC, 0xE0, 0x3E, 0x4F, 0x38, 0x03, 0xD0, 0x06, 0x00, 0x7E, 0x00, 0xC0,
  0x07, 0xC0, 0x18, 0x00, 0xF0, 0x01, 0x00, 0x1E, 0x00, 0x20, 0x03, 0xC0,
  0x06, 0x00, 0xFF, 0xF0, 0x60, 0x3F, 0xFC, 0x03, 0xF7, 0xFF, 0x00, 0x01,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x02,
  0xF8, 0x00, 0x70, 0x5F, 0x80, 0x1F, 0x91, 0xFC, 0x43, 0xFE, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF,
  0x1F, 0xF0, 0x3F, 0xFF, 0xA1, 0xF8, 0x78, 0x3F, 0xE0, 0xFC, 0x60, 0x0F,
  0xE0, 0xFC, 0xC0, 0x07, 0xE0, 0x7C, 0xC0, 0x07, 0xE0, 0x7E, 0x80, 0x03,
  0xE0, 0x7E, 0x80, 0x03, 0xE0, 0x3F, 0x80, 0x01, 0xE0, 0x1C, 0xC0, 0x01,
  0xE0, 0x30, 0x40, 0x01, 0xC0, 0x70, 0x60, 0x01, 0xC0, 0xE0, 0x30, 0x31,
  0xC1, 0xF0, 0x0F, 0x81, 0x81, 0xF0, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x03,
  0x01, 0xF8, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x06, 0x00, 0xFC, 0x00, 0x0C,
  0x00, 0xFE, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x3E,
  0x08, 0x3E, 0x00, 0x7F, 0x30, 0x3E, 0x00, 0xFF, 0xF0, 0x3E, 0x01, 0x1F,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x3C, 0x01, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x20,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xE0, 0x3F, 0x80, 0xE0,
  0x07, 0xC0, 0x60, 0x01, 0xF0, 0x20, 0x00, 0xF8, 0x30, 0x00, 0x3C, 0x08,
  0x00, 0x3C, 0x04, 0x00, 0x1E, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00,
  0x3C, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x07, 0x3F, 0xC0, 0x03, 0xBF, 0xF0, 0x01, 0x93, 0xFC,
  0x00, 0xC0, 0x7F, 0x00, 0xC0, 0x1F, 0xC0, 0xC0, 0x07, 0xF9, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF9, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0xFE, 0x03, 0x9E, 0x0E, 0x1C, 0x38, 0x1C, 0x60, 0x0D, 0x80, 0x0E,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x73, 0xC7,
  0x8E, 0x1C, 0x30, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x80, 0xC7, 0xF0, 0xE1, 0xF0, 0x60, 0x78, 0x70, 0x3C, 0x38,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xE0, 0xF1,
  0xF0, 0x78, 0x7C, 0x3C, 0x3F, 0x3E, 0xCF, 0xEF, 0xC3, 0xE7, 0xC0, 0xC1,
  0xE0, 0x40, 0x20, 0x00, 0x40, 0x03, 0x80, 0x8E, 0x00, 0x5C, 0x00, 0x5C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x10, 0x3C, 0x38, 0x3C,
  0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C,
  0x0C, 0x3F, 0x18, 0x7F, 0xB0, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x01,
  0x00, 0x01, 0xC0, 0x7C, 0x1B, 0xE3, 0x1E, 0x31, 0xF7, 0x0F, 0x70, 0x8F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x03, 0xFF, 0x1F, 0xC0, 0x70, 0x02, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x02, 0x7E, 0x3C, 0x3F, 0x3C,
  0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x3C,
  0x07, 0x3C, 0x07, 0x3C, 0x06, 0x3C, 0x06, 0x7F, 0x0C, 0x3F, 0xC8, 0x0F,
  0xF0, 0x03, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x01, 0xC0, 0x3E, 0x06, 0xF8,
  0x63, 0xC3, 0x1E, 0x38, 0x79, 0xC3, 0xDE, 0x1F, 0xF0, 0xC7, 0xB8, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFF,
  0x87, 0xF0, 0x0E, 0x00, 0x20, 0x00, 0x0E, 0x01, 0xFF, 0x1F, 0xE1, 0xFC,
  0x10, 0x82, 0x00, 0x20, 0x01, 0x00, 0x3C, 0x07, 0xFC, 0xBE, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x5F, 0xC0, 0xC7, 0xF0,
  0xE1, 0xF8, 0xE0, 0x38, 0x70, 0x0C, 0x78, 0x0E, 0x3C, 0x07, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x7C, 0x78, 0x3E, 0x1E,
  0x1F, 0x0F, 0x9F, 0x83, 0xE3, 0xE1, 0xC0, 0xF0, 0x80, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x20, 0x0E, 0x38, 0x0E, 0x1E, 0x06, 0x07, 0x86, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x8E, 0x00, 0x5C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x30, 0x3C, 0x70, 0x3D, 0xF8, 0x3E,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C,
  0x0E, 0x3C, 0x9C, 0x7F, 0x1C, 0x3E, 0x18, 0x0C, 0x30, 0x04, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C,
  0x0F, 0x0F, 0x87, 0xC1, 0xC0, 0x80, 0x00, 0x40, 0x30, 0x1C, 0x1F, 0x9F,
  0xEB, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x8F, 0x87, 0xC1, 0xC0, 0x40, 0x03, 0x80, 0xF8, 0x1E,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x01, 0xF0, 0x7F, 0x17,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7A, 0x0E, 0x43, 0x87, 0xC0, 0x00, 0x00, 0xE0, 0x62,
  0x18, 0x27, 0x13, 0xEE, 0x79, 0xCF, 0xF9, 0xFC, 0x3E, 0x07, 0xC1, 0xFF,
  0xFF, 0xF3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0x4F, 0xF0, 0x3C, 0x03, 0x00,
  0x20, 0x00, 0xE0, 0x62, 0x38, 0x27, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE2, 0x3F, 0x8F,
  0xF0, 0x3C, 0x03, 0x00, 0x20, 0x20, 0x30, 0x10, 0x0E, 0x0E, 0x0E, 0x07,
  0xC7, 0xC7, 0xC1, 0xFB, 0xFB, 0xFC, 0xBF, 0x3F, 0x3F, 0x87, 0x87, 0x87,
  0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0x1E, 0x1E, 0x1E, 0x07, 0x87,
  0x87, 0x81, 0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0x1E, 0x1E, 0x1E, 0x07,
  0x87, 0x87, 0x81, 0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0x1E, 0x1F, 0x1F,
  0x0F, 0xCF, 0xC3, 0xD3, 0xF1, 0xF8, 0xF8, 0x78, 0x38, 0x3E, 0x0C, 0x0C,
  0x07, 0x02, 0x01, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x04, 0x03, 0x83, 0x81,
  0xF1, 0xF8, 0xFF, 0xBF, 0xAF, 0xC7, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0xC7, 0xD7, 0xE0, 0xF8,
  0x78, 0x3E, 0x0C, 0x07, 0x02, 0x00, 0x40, 0x00, 0x70, 0x01, 0xF0, 0x3F,
  0xF0, 0x78, 0xF8, 0x78, 0xFC, 0x78, 0x7C, 0x78, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1F, 0x7C, 0x0F, 0x7C, 0x0E, 0x7C, 0x0E, 0x7C, 0x0C, 0x7C,
  0x1C, 0x7E, 0x18, 0xFF, 0xB0, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x83,
  0xE1, 0xE1, 0xF9, 0xF0, 0x7F, 0xFC, 0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0x83,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0x9F, 0x81, 0x9F, 0xF1, 0xCF, 0xFC, 0x84, 0x7F, 0x80,
  0x3F, 0x80, 0x1D, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0xBF, 0x83, 0x3F, 0xCC, 0x1F, 0x38, 0x1E,
  0x70, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0xBC,
  0x0F, 0x7C, 0x1E, 0x7C, 0x3C, 0xFC, 0xF8, 0xFE, 0xF0, 0xF1, 0xE0, 0xC3,
  0xC1, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x00, 0x01, 0x81, 0x1F, 0x18, 0xF9, 0xEF, 0xFF,
  0x1F, 0x7C, 0x79, 0xC3, 0xCC, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x41, 0xFE, 0x1F, 0xE0, 0x1E,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x00, 0x20,
  0x20, 0x20, 0xE0, 0x43, 0xF1, 0x8F, 0xFE, 0x23, 0xFC, 0x81, 0xE3, 0x00,
  0x87, 0x03, 0x0F, 0x0E, 0x1F, 0x3E, 0x1F, 0xFE, 0x1E, 0x7E, 0x38, 0x3C,
  0x20, 0x38, 0x80, 0x73, 0xC0, 0xCF, 0xE1, 0x1F, 0xFC, 0x07, 0xF0, 0x03,
  0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3F, 0xF7, 0xFE, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xF0, 0x1F, 0xA3, 0xFC, 0x07, 0x80, 0x30, 0x01, 0x00, 0x00, 0x04,
  0x0C, 0x03, 0x07, 0xC0, 0xE1, 0xF0, 0x7C, 0xFE, 0x3F, 0x87, 0x87, 0xC1,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x0F, 0xCF, 0xD7, 0xFC, 0xF8, 0x3E, 0x3E, 0x03, 0x07, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x18, 0x02, 0x0C, 0x03, 0x0F, 0x07, 0xC7, 0xC7,
  0xF3, 0xFC, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F, 0x1F, 0x07, 0xC7, 0x81, 0xE1,
  0xC0, 0xF0, 0xE0, 0x78, 0x70, 0x3C, 0x18, 0x1E, 0x1C, 0x0E, 0x0C, 0x07,
  0x06, 0x07, 0x07, 0xC3, 0x03, 0xF3, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xF8, 0x18, 0x04, 0x3F, 0x0F, 0x07, 0x07, 0xE7,
  0xE3, 0xE0, 0xFB, 0xFF, 0xFC, 0x1F, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1,
  0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0x83, 0xC0,
  0xE1, 0xE0, 0xF0, 0x38, 0x78, 0x3C, 0x0E, 0x1E, 0x0F, 0x03, 0x87, 0x83,
  0xC1, 0xC1, 0xE0, 0xF0, 0x60, 0x78, 0x7E, 0x10, 0x3F, 0x3F, 0xE8, 0x0F,
  0xC1, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0x30, 0x03, 0x80, 0x04, 0x00, 0x40,
  0x00, 0x18, 0x10, 0x70, 0xC3, 0xE3, 0x8F, 0xDE, 0x5F, 0xFC, 0x3C, 0xE0,
  0xF3, 0x03, 0xC4, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xB0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0x43, 0x02, 0x04, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x81, 0xC3, 0x0F,
  0x03, 0xFC, 0x01, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1C, 0x02,
  0x0F, 0x81, 0x87, 0xE3, 0xC1, 0xFB, 0xF0, 0x7E, 0x7C, 0x1E, 0x1F, 0x0F,
  0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xF1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE3, 0xE4,
  0xE3, 0xFC, 0x70, 0x7C, 0x30, 0x0C, 0x30, 0x04, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x04, 0x01,
  0xE0, 0x7E, 0x1F, 0xC4, 0x78, 0x07, 0x00, 0xC0, 0x38, 0x04, 0x01, 0x04,
  0xF3, 0x3F, 0x8B, 0xF8, 0x1F, 0x87, 0xF9, 0x9F, 0x21, 0xEC, 0x3D, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC0, 0xC8, 0x30, 0x84, 0x0F,
  0x00, 0x00, 0xE0, 0x70, 0x18, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xF0,
  0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x0E, 0x03, 0xE0, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x1C,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
};

const GFXglyph UnifrakturMaguntia_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 30, 9, 1, -29 },
  { 28, 14, 11, 16, 1, -29 },
  { 48, 18, 23, 21, 1, -26 },
  { 100, 14, 32, 17, 1, -30 },
  { 156, 26, 28, 29, 1, -28 },
  { 247, 21, 25, 23, 1, -25 },
  { 313, 6, 11, 8, 1, -29 },
  { 322, 8, 33, 10, 1, -32 },
  { 355, 8, 32, 10, 1, -31 },
  { 387, 13, 16, 14, 0, -30 },
  { 413, 14, 14, 16, 1, -20 },
  { 438, 7, 11, 7, 0, -6 },
  { 448, 11, 8, 12, 1, -16 },
  { 459, 6, 7, 8, 1, -6 },
  { 465, 19, 32, 21, 1, -30 },
  { 541, 17, 28, 19, 1, -28 },
  { 601, 12, 27, 13, 0, -27 },
  { 642, 16, 27, 18, 1, -27 },
  { 696, 17, 28, 19, 1, -28 },
  { 756, 18, 27, 18, 0, -27 },
  { 817, 17, 28, 19, 1, -28 },
  { 877, 17, 28, 18, 1, -28 },
  { 937, 16, 27, 17, 1, -27 },
  { 991, 17, 28, 19, 1, -28 },
  { 1051, 17, 28, 18, 1, -28 },
  { 1111, 6, 20, 8, 1, -19 },
  { 1126, 7, 24, 7, 0, -19 },
  { 1147, 11, 15, 12, 0, -19 },
  { 1168, 14, 8, 15, 1, -16 },
  { 1182, 11, 15, 12, 0, -19 },
  { 1203, 15, 30, 18, 1, -29 },
  { 1260, 23, 23, 24, 1, -18 },
  { 1327, 31, 30, 33, 1, -29 },
  { 1444, 35, 30, 36, 0, -29 },
  { 1576, 26, 30, 27, 1, -29 },
  { 1674, 30, 31, 32, 1, -29 },
  { 1791, 26, 29, 28, 1, -29 },
  { 1886, 28, 35, 30, 1, -30 },
  { 2009, 29, 30, 31, 1, -29 },
  { 2118, 29, 36, 29, 0, -31 },
  { 2249, 25, 33, 27, 1, -29 },
  { 2353, 27, 38, 28, 1, -29 },
  { 2482, 31, 29, 32, 1, -28 },
  { 2595, 21, 29, 23, 1, -28 },
  { 2672, 42, 30, 44, 1, -28 },
  { 2830, 33, 29, 35, 1, -28 },
  { 2950, 28, 30, 30, 1, -29 },
  { 3055, 34, 35, 36, 1, -28 },
  { 3204, 30, 32, 32, 1, -29 },
  { 3324, 35, 30, 37, 1, -29 },
  { 3456, 28, 29, 30, 1, -29 },
  { 3558, 28, 28, 30, 1, -28 },
  { 3656, 27, 30, 29, 1, -28 },
  { 3758, 34, 30, 35, 1, -29 },
  { 3886, 41, 30, 43, 1, -29 },
  { 4040, 27, 30, 29, 1, -29 },
  { 4142, 32, 35, 34, 1, -29 },
  { 4282, 25, 34, 27, 1, -29 },
  { 4389, 5, 32, 7, 1, -30 },
  { 4409, 25, 28, 4, -8, -26 },
  { 4497, 5, 32, 7, 1, -30 },
  { 4517, 15, 11, 17, 1, -28 },
  { 4538, 19, 3, 18, 0, 4 },
  { 4546, 6, 7, 20, 6, -28 },
  { 4552, 17, 22, 18, 1, -21 },
  { 4599, 16, 29, 18, 1, -28 },
  { 4657, 12, 21, 14, 1, -20 },
  { 4689, 16, 29, 18, 1, -28 },
  { 4747, 13, 21, 14, 1, -20 },
  { 4782, 12, 35, 10, 0, -28 },
  { 4835, 17, 29, 19, 1, -21 },
  { 4897, 16, 35, 18, 1, -28 },
  { 4967, 9, 29, 11, 1, -28 },
  { 5000, 11, 35, 10, -2, -28 },
  { 5049, 11, 29, 13, 1, -28 },
  { 5089, 11, 29, 11, 1, -28 },
  { 5129, 26, 22, 28, 1, -21 },
  { 5201, 18, 22, 20, 1, -21 },
  { 5251, 16, 21, 17, 0, -20 },
  { 5293, 17, 32, 18, 0, -24 },
  { 5361, 15, 29, 17, 1, -21 },
  { 5416, 13, 22, 15, 1, -21 },
  { 5452, 15, 26, 17, 1, -25 },
  { 5501, 12, 27, 12, 0, -26 },
  { 5542, 18, 22, 20, 1, -21 },
  { 5592, 17, 24, 18, 0, -23 },
  { 5643, 26, 25, 28, 1, -24 },
  { 5725, 14, 29, 16, 1, -21 },
  { 5776, 17, 31, 19, 1, -24 },
  { 5842, 11, 28, 13, 1, -21 },
  { 5881, 11, 32, 13, 1, -31 },
  { 5925, 2, 33, 6, 2, -31 },
  { 5934, 11, 32, 13, 1, -31 },
  { 5978, 13, 3, 15, 1, -13 },
};

const GFXfont UnifrakturMaguntia_Regular40pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular40pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular40pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR40PT7B_H_
