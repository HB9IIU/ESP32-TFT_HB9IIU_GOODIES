#ifndef _UNIFRAKTURMAGUNTIA_REGULAR38PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x71, 0xF7, 0xF7, 0xCF, 0x9E, 0x1C, 0x38, 0x70, 0xE1, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x00, 0x02, 0x0C, 0x3C, 0xFC, 0x70,
  0x40, 0x00, 0x20, 0x21, 0x83, 0x1E, 0x3D, 0xFB, 0xF3, 0xC7, 0x8C, 0x1C,
  0x60, 0xC2, 0x06, 0x10, 0x21, 0x02, 0x00, 0x03, 0x0E, 0x03, 0x86, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x06, 0x1C, 0x07, 0x0C, 0x03, 0x86, 0x01, 0xC7, 0x0E, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFC, 0x18, 0x70, 0x0C, 0x38, 0x0E, 0x18, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7C,
  0x0C, 0x30, 0xC0, 0xC6, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xF8, 0x27,
  0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xD0, 0x7E, 0xC0,
  0xFE, 0x03, 0xF0, 0x1D, 0x80, 0xEC, 0x07, 0x20, 0x31, 0xC3, 0x03, 0xF0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x1E, 0x00, 0x01, 0x19, 0xC0,
  0x01, 0xDC, 0x60, 0x00, 0x8E, 0x38, 0x00, 0xCF, 0x1C, 0x00, 0xC7, 0x8F,
  0x00, 0xC3, 0xC7, 0x80, 0xC1, 0xE3, 0xC0, 0xC0, 0xF1, 0xE0, 0xC0, 0x78,
  0xE0, 0x40, 0x1C, 0x70, 0x40, 0x0E, 0x30, 0x60, 0x03, 0x38, 0x60, 0x00,
  0xF0, 0x61, 0xE0, 0x00, 0x63, 0x98, 0x00, 0x63, 0x8E, 0x00, 0x61, 0xC7,
  0x00, 0x20, 0xE3, 0xC0, 0x30, 0xF1, 0xE0, 0x30, 0x78, 0xF0, 0x30, 0x3C,
  0x78, 0x30, 0x0E, 0x3C, 0x30, 0x07, 0x1C, 0x30, 0x03, 0x8E, 0x10, 0x00,
  0xE6, 0x10, 0x00, 0x1E, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x31,
  0x80, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F,
  0x18, 0x00, 0xFB, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x7F, 0x07, 0xC1, 0xC1,
  0xFE, 0x0C, 0x3B, 0xE0, 0x87, 0x1F, 0x08, 0x71, 0xF1, 0x0F, 0x1F, 0x90,
  0xF0, 0xFA, 0x0F, 0x0F, 0xE0, 0xF8, 0x7E, 0x07, 0x83, 0xF3, 0x7C, 0x3F,
  0xE3, 0xC3, 0xFC, 0x0F, 0xC7, 0x80, 0x20, 0xC7, 0xBF, 0x38, 0x61, 0x84,
  0x10, 0x80, 0x03, 0x0C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x70, 0x70, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x07, 0xC0, 0x20, 0x30,
  0x18, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x18, 0x10, 0x30, 0xC0, 0x00, 0x00, 0x10, 0x03, 0xC0, 0x3F, 0x8F, 0x77,
  0xB9, 0x79, 0xEB, 0xC0, 0xE2, 0x7B, 0xF3, 0x97, 0xBD, 0x9C, 0x2E, 0x90,
  0xF8, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x83, 0xFF, 0xE0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x10, 0xC7, 0xBF, 0x3C, 0x71, 0x86, 0x10, 0x42, 0x00,
  0x03, 0xC7, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x00, 0x20, 0xC7,
  0xBF, 0x70, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xC0, 0x0E, 0x70, 0x1C, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x3C, 0x1C, 0x38,
  0x0C, 0x70, 0x03, 0xC0, 0x01, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x1F, 0x03,
  0xF0, 0x4F, 0x08, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0xC7, 0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0x87, 0xE6, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x04, 0x18, 0x08, 0x60, 0x11, 0x00, 0x23, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xF8,
  0x30, 0xFC, 0x40, 0x7E, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1C, 0x70, 0x18, 0x38, 0x30, 0x0F, 0xC0,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0B,
  0xC0, 0x09, 0xE0, 0x0C, 0xF0, 0x04, 0x78, 0x04, 0x3C, 0x06, 0x1E, 0x02,
  0x0F, 0x02, 0x07, 0x81, 0x03, 0xC1, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x3E, 0x3C,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x27, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE,
  0x70, 0x7F, 0x60, 0x1F, 0x40, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0C, 0x78, 0x18, 0x38, 0x30,
  0x0F, 0xC0, 0x03, 0xE0, 0x0E, 0x78, 0x0C, 0x3C, 0x18, 0x3C, 0x38, 0x3E,
  0x38, 0x1E, 0x78, 0x1C, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF9, 0xF0,
  0xFB, 0xFC, 0xFE, 0x3C, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x38, 0x1C, 0x3C, 0x38, 0x0C, 0x30, 0x07, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF6, 0x00, 0x68, 0x00, 0xD0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x0C,
  0x30, 0x38, 0x18, 0x70, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0x78,
  0x0E, 0x7C, 0x0C, 0x7F, 0x18, 0x3F, 0xB0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x19, 0xFC, 0x30, 0x7E, 0x60, 0x3E, 0xE0, 0x1E, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x38,
  0x38, 0x0F, 0xE0, 0x07, 0xC0, 0x0C, 0x70, 0x18, 0x38, 0x38, 0x38, 0x70,
  0x3C, 0x70, 0x3C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0x78, 0x5E, 0x3F, 0x9E, 0x1F,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x70, 0x3C, 0xF0, 0x3C, 0xF8,
  0x38, 0x78, 0x30, 0x78, 0x70, 0x3C, 0x60, 0x0F, 0x80, 0x20, 0xCF, 0xBF,
  0x70, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0xC7, 0xBF, 0x70, 0x80, 0x00,
  0x10, 0x31, 0xF3, 0xF3, 0x82, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x06,
  0x1E, 0x7E, 0x3C, 0x38, 0x60, 0xC1, 0x02, 0x08, 0x00, 0x00, 0x40, 0x60,
  0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x7C, 0x1F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x00,
  0x0F, 0xE0, 0x70, 0xF1, 0x80, 0xF3, 0x01, 0xEE, 0x01, 0xDF, 0x03, 0xFE,
  0x07, 0xBC, 0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x18, 0x10, 0x38, 0x20, 0x38, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x60, 0x01, 0xE0, 0x07, 0xE0, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0E, 0x0E, 0x00, 0xE0,
  0x0C, 0x07, 0x00, 0x18, 0x38, 0x00, 0x31, 0xC0, 0xFE, 0xC6, 0x0E, 0xF3,
  0xB8, 0x73, 0xC6, 0xE3, 0x8F, 0x1B, 0x0E, 0x3C, 0x6C, 0x70, 0xE3, 0xB1,
  0xC7, 0x8C, 0xCF, 0x1E, 0x33, 0x3C, 0xF1, 0x8C, 0xF7, 0xC6, 0x39, 0xFF,
  0x37, 0x63, 0x8F, 0x19, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x30,
  0x07, 0x03, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x7F, 0xE0,
  0x07, 0x07, 0xFF, 0x80, 0xF0, 0x40, 0xFE, 0x1F, 0x84, 0x01, 0xF9, 0xFC,
  0x60, 0x0F, 0xC7, 0xC2, 0x00, 0x3F, 0x1E, 0x10, 0x00, 0xF8, 0xF0, 0x80,
  0x07, 0xC7, 0x86, 0x00, 0x3E, 0x3C, 0x3C, 0x01, 0xE1, 0xE1, 0xFC, 0x0F,
  0x0F, 0x07, 0xF0, 0x78, 0x78, 0x1F, 0x83, 0x83, 0xC0, 0x3E, 0x38, 0x1E,
  0x00, 0x61, 0x80, 0xF0, 0x03, 0x18, 0x07, 0x80, 0x11, 0x80, 0x3C, 0x00,
  0x08, 0x01, 0xE0, 0x00, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xFC,
  0x03, 0xC0, 0x3F, 0xF0, 0x3F, 0x02, 0x3F, 0xC6, 0xFF, 0x00, 0x7F, 0xE7,
  0xF0, 0x01, 0xFE, 0x1F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xC7, 0xFC,
  0x03, 0xFF, 0xF2, 0x3F, 0x03, 0xF3, 0xFA, 0x0F, 0x83, 0xC0, 0x7F, 0x07,
  0xE1, 0xC0, 0x1F, 0x81, 0xF0, 0xC0, 0x07, 0xC0, 0xF8, 0x60, 0x03, 0xE0,
  0x7F, 0x20, 0x00, 0xF0, 0x1F, 0x10, 0x00, 0x78, 0x06, 0x0C, 0x00, 0x3C,
  0x0C, 0x06, 0x00, 0x1C, 0x3F, 0x81, 0x80, 0x0E, 0x7F, 0xF0, 0x60, 0xC6,
  0x7F, 0xFC, 0x1F, 0x87, 0x00, 0xFE, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x03,
  0x00, 0x07, 0xC0, 0x02, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x78, 0x0F, 0xF8, 0x00, 0x38, 0x0F, 0xFE, 0x00, 0x1C, 0x00,
  0x7F, 0x80, 0x0C, 0x00, 0x1F, 0xE0, 0x0C, 0x00, 0x07, 0xFC, 0x0C, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x03, 0xF8, 0x70, 0x0F, 0x08, 0xFD, 0x0E, 0x07, 0xFF,
  0x1C, 0x06, 0xFE, 0x3C, 0x18, 0x18, 0x38, 0x30, 0x00, 0x78, 0x70, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xFC, 0x00, 0xF8, 0xFE, 0x00,
  0xF8, 0x7F, 0x00, 0xF8, 0x7F, 0x80, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x01, 0xE0,
  0x3F, 0x01, 0xC0, 0x3F, 0x83, 0x80, 0x1F, 0xC6, 0x00, 0x0F, 0xE8, 0x00,
  0x07, 0xF8, 0x01, 0x03, 0xFF, 0x1E, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x7F, 0xC1, 0xE0, 0x30,
  0xFF, 0x0E, 0x03, 0x01, 0xF8, 0xE0, 0x30, 0x07, 0xE6, 0x03, 0xC0, 0x1F,
  0x30, 0x1F, 0x00, 0x7D, 0x80, 0xFC, 0x01, 0xE8, 0x07, 0xF0, 0x07, 0x40,
  0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xE8, 0x03, 0xF8, 0x07, 0x20, 0x0F,
  0xC0, 0x38, 0xC2, 0x3E, 0x01, 0x81, 0xE0, 0xE0, 0x0C, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x62, 0x00, 0x10, 0x0F, 0xE0, 0x01, 0x00,
  0xFF, 0xC0, 0x18, 0x1F, 0xFF, 0x81, 0x81, 0x87, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x01, 0xFC, 0x38, 0x03, 0x82, 0x3F, 0x41, 0xC0, 0xFF, 0xE1, 0xC0,
  0x6F, 0xE1, 0xE0, 0xC0, 0xC0, 0xE0, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3F, 0x0E, 0x1F, 0x1F, 0xCF, 0xDF,
  0x87, 0xFF, 0xF7, 0xC1, 0xFD, 0xFB, 0xE0, 0xFF, 0x39, 0xF0, 0x3F, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x3C,
  0x03, 0xF0, 0x1C, 0x01, 0xFC, 0x18, 0x00, 0x7F, 0x18, 0x00, 0x1F, 0xD0,
  0x00, 0x07, 0xF8, 0x01, 0x01, 0xFF, 0xCF, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF6, 0x78, 0x0F, 0xFF, 0x9C, 0x00,
  0x3F, 0xC3, 0x00, 0x19, 0xF0, 0xE0, 0x06, 0x1C, 0x18, 0x01, 0xC0, 0x03,
  0x00, 0x38, 0x00, 0x60, 0x0F, 0x81, 0x0C, 0x01, 0xF8, 0x39, 0x80, 0x1F,
  0x8F, 0x90, 0x03, 0xF1, 0xFB, 0x00, 0x3F, 0x7E, 0x30, 0x07, 0xF3, 0x83,
  0x06, 0x7E, 0x30, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1C,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x18, 0x00, 0x60, 0xCF,
  0x00, 0x38, 0x0B, 0xF0, 0x0F, 0x01, 0xBF, 0x81, 0xC0, 0x43, 0xF8, 0x78,
  0x30, 0x3F, 0x8E, 0x0E, 0x03, 0xE3, 0xC3, 0x80, 0x38, 0x78, 0xF8, 0x0C,
  0x0F, 0x1F, 0x03, 0x03, 0xE3, 0xF0, 0xFC, 0x7C, 0x3E, 0x7F, 0xCF, 0x87,
  0xE1, 0xFD, 0xF0, 0x7E, 0x0F, 0xBE, 0x07, 0xE0, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFC, 0x0F, 0xC3, 0xEF, 0x80, 0xF8, 0x3D, 0xF0, 0x1F, 0x07, 0xBF, 0x01,
  0xC0, 0xF3, 0xE0, 0x30, 0x1C, 0x7E, 0x0C, 0x07, 0x87, 0xE2, 0x00, 0xE0,
  0x7C, 0x00, 0x3C, 0x07, 0xE0, 0x06, 0x00, 0x3E, 0x01, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0xFE, 0x00, 0x01, 0x07,
  0xF0, 0x00, 0x40, 0x7C, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x01, 0x00, 0x1E, 0x00, 0x60, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F,
  0xE0, 0x0F, 0xC7, 0xFE, 0x00, 0xFD, 0x8F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01,
  0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0x80, 0xF8, 0xF0,
  0x70, 0x1F, 0x3F, 0x04, 0x03, 0xCF, 0xF1, 0x80, 0x78, 0x3F, 0xE0, 0x0E,
  0x03, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1C, 0x1F, 0xE0,
  0x38, 0x07, 0xFA, 0x30, 0x03, 0xFC, 0x70, 0x00, 0xF8, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x30, 0x01, 0xE0,
  0x30, 0x03, 0xE0, 0x18, 0x03, 0xF0, 0x0E, 0x09, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x04, 0x00, 0x1E,
  0x3F, 0x80, 0x0E, 0x7F, 0xC0, 0x0E, 0x9F, 0xE0, 0x0C, 0x07, 0xF0, 0x18,
  0x03, 0xF8, 0x10, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0x83, 0xFC,
  0x03, 0x80, 0x7F, 0xA1, 0x80, 0x1F, 0xE1, 0x80, 0x07, 0xE0, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x70, 0x18, 0x00, 0x78, 0x04, 0x00,
  0x3C, 0x03, 0x00, 0x1E, 0x00, 0xC0, 0x0F, 0x80, 0x30, 0x27, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x61, 0xFC, 0x00, 0x33, 0xFF, 0x00,
  0x31, 0x1F, 0xC0, 0x18, 0x07, 0xF0, 0x18, 0x01, 0xFE, 0x18, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0xE0, 0xF0, 0x30, 0x07, 0x0F, 0xF0, 0xE0, 0x1C, 0x7F, 0xE1, 0x80, 0xF3,
  0x1F, 0xC6, 0x03, 0xC8, 0x1F, 0x1C, 0x0F, 0x20, 0x7C, 0x30, 0x3F, 0x00,
  0xF8, 0xC0, 0xFC, 0x03, 0xF3, 0x03, 0xF8, 0x07, 0x98, 0x07, 0xE0, 0x08,
  0x60, 0x1F, 0xC0, 0xC3, 0x00, 0x3F, 0x0F, 0x10, 0x00, 0xFE, 0xFE, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x0F, 0x80, 0x78, 0x38, 0x3F, 0x03, 0xF0, 0x60, 0x7C, 0x1F, 0xE3,
  0x01, 0xF8, 0x0F, 0xD8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00,
  0x1E, 0x00, 0x40, 0x00, 0x20, 0x00, 0x78, 0x00, 0x38, 0x78, 0x0E, 0x03,
  0xC1, 0xC0, 0x1E, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x7C, 0x00, 0xF7, 0xC0,
  0x0F, 0x7E, 0x00, 0xF7, 0xE0, 0x0E, 0x3F, 0x00, 0xE3, 0xF0, 0x1C, 0x1F,
  0xB7, 0x81, 0xF8, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x10, 0xFF, 0x02, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x01, 0x00, 0x0F, 0xF8, 0x3F, 0x07,
  0xE0, 0x1F, 0xFC, 0x7F, 0x8F, 0xF0, 0x3F, 0xFE, 0xDF, 0xD0, 0xF8, 0x70,
  0xFF, 0x07, 0xE0, 0xF8, 0x40, 0x3F, 0x83, 0xE0, 0x78, 0xC0, 0x0F, 0x83,
  0xF0, 0x7C, 0x80, 0x0F, 0xC1, 0xF0, 0x7C, 0x80, 0x07, 0xC1, 0xF0, 0x7E,
  0x80, 0x03, 0xC0, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0xF0, 0x38, 0x80, 0x03,
  0xE0, 0xF0, 0x30, 0x43, 0x81, 0xE0, 0xF0, 0x60, 0x7F, 0xC1, 0xE0, 0x70,
  0xC0, 0x3F, 0xC1, 0xE0, 0x70, 0xC0, 0x0E, 0x41, 0xC0, 0x71, 0xC0, 0x00,
  0x41, 0xC0, 0x73, 0xC0, 0x00, 0x01, 0xC0, 0x63, 0xC0, 0x00, 0x01, 0x80,
  0x63, 0xC0, 0x00, 0x01, 0x80, 0xE3, 0xC0, 0x00, 0x01, 0x00, 0xC3, 0xE0,
  0x07, 0x03, 0x00, 0x83, 0xE0, 0x1F, 0x82, 0xF8, 0x83, 0xF0, 0x3F, 0xC5,
  0xFD, 0x01, 0xFF, 0x67, 0xFD, 0xFE, 0x01, 0xFE, 0x03, 0xFA, 0xFE, 0x00,
  0xF8, 0x03, 0xF0, 0x3C, 0x00, 0x70, 0x00, 0x80, 0x10, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0x31, 0xF0, 0x70, 0x7F, 0x60, 0xF8,
  0x40, 0x1F, 0xC0, 0xF8, 0x80, 0x0F, 0xC0, 0xF8, 0x80, 0x07, 0xC0, 0xF8,
  0x80, 0x07, 0xC0, 0x7E, 0x80, 0x03, 0xE0, 0x7C, 0x80, 0x03, 0xE0, 0x30,
  0xC0, 0x01, 0xE0, 0x20, 0x63, 0x81, 0xE0, 0x40, 0x7F, 0xC1, 0xE0, 0xC0,
  0x3F, 0xC1, 0xE1, 0x80, 0x06, 0x61, 0xC3, 0x80, 0x00, 0x41, 0xC3, 0x80,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x01, 0x87, 0xC0,
  0x00, 0x01, 0x07, 0xC0, 0x07, 0x83, 0x07, 0xE0, 0x1F, 0xC2, 0x03, 0xF0,
  0x3F, 0xC4, 0x03, 0xFF, 0x47, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x39, 0xFF,
  0xC0, 0x18, 0x07, 0xFC, 0x0E, 0x00, 0x3F, 0xC3, 0x80, 0x01, 0xFC, 0x70,
  0x00, 0x1F, 0x9E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7F, 0x00, 0x01,
  0xE7, 0xF8, 0x00, 0x3C, 0xFF, 0xC0, 0x03, 0x8F, 0xFC, 0x00, 0x70, 0x7F,
  0x80, 0x0E, 0x03, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x01, 0x80, 0x06,
  0x02, 0x20, 0x00, 0xC1, 0xF0, 0x00, 0x10, 0x7F, 0x80, 0x06, 0x3F, 0xF8,
  0x00, 0x80, 0x7F, 0xC0, 0x20, 0x07, 0xFE, 0x18, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x0F,
  0xF8, 0x03, 0x00, 0x3F, 0xFC, 0x0F, 0x00, 0x7F, 0xFE, 0x3F, 0x00, 0x60,
  0x7F, 0xFF, 0x80, 0xC0, 0x3F, 0x9F, 0xC0, 0x80, 0x1F, 0x8F, 0xE0, 0x80,
  0x0F, 0x87, 0xF0, 0x80, 0x0F, 0x87, 0xF8, 0x80, 0x0F, 0x83, 0xFC, 0x80,
  0x0F, 0x80, 0xFE, 0x80, 0x07, 0x80, 0x7E, 0x40, 0x07, 0x80, 0x3F, 0x30,
  0x47, 0x80, 0x1F, 0x0F, 0x87, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x06, 0x00, 0x07, 0x80, 0x06, 0x00,
  0x07, 0x80, 0x06, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x3F, 0x80, 0x08, 0x00,
  0x7F, 0xE0, 0x08, 0x00, 0xFF, 0xF8, 0x30, 0x01, 0x83, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0x7F, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x39, 0xFF,
  0xC0, 0x06, 0x00, 0xFF, 0x00, 0xE0, 0x03, 0xFC, 0x0E, 0x00, 0x07, 0xE0,
  0x70, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xFC,
  0x00, 0x07, 0x87, 0xF8, 0x00, 0x3C, 0x3F, 0xF0, 0x00, 0xE0, 0xFF, 0xC0,
  0x07, 0x01, 0xFE, 0x00, 0x38, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x08, 0x80, 0x23, 0x01, 0xF0, 0x07, 0xD0, 0x3F,
  0xE0, 0x7F, 0x83, 0xFF, 0x84, 0xFC, 0x41, 0xFF, 0x03, 0xF6, 0x07, 0xFE,
  0x1F, 0xE0, 0x0F, 0xFF, 0x3E, 0x00, 0x1F, 0xF0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x00,
  0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFC, 0x47,
  0xE0, 0x78, 0x7F, 0xA0, 0xF8, 0x18, 0x07, 0xF8, 0x3F, 0x0C, 0x00, 0xFE,
  0x07, 0xC3, 0x00, 0x1F, 0x81, 0xF8, 0xC0, 0x03, 0xE0, 0x3F, 0x20, 0x00,
  0x78, 0x07, 0x88, 0x00, 0x1E, 0x01, 0x83, 0x00, 0x07, 0x81, 0x80, 0xC0,
  0x00, 0xE0, 0xC0, 0x18, 0x00, 0x38, 0xF0, 0x03, 0x01, 0x0E, 0x7E, 0x00,
  0x7B, 0x83, 0xBF, 0x80, 0x01, 0x00, 0xE3, 0xF0, 0x00, 0x00, 0x38, 0x7C,
  0x00, 0x00, 0x0C, 0x1F, 0x00, 0x00, 0x03, 0x07, 0xE0, 0x00, 0x01, 0x80,
  0xF8, 0x01, 0xE0, 0x60, 0x3E, 0x00, 0xFC, 0x10, 0x0F, 0xC0, 0x7F, 0x88,
  0x03, 0xFA, 0x27, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC3, 0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x7F, 0xE0,
  0x18, 0x01, 0xF8, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x03, 0xF8, 0x70, 0x01, 0xFF, 0x8E,
  0x10, 0xFF, 0xF9, 0xC1, 0xFF, 0xE1, 0xB8, 0x1F, 0xF0, 0x17, 0x81, 0xF8,
  0x02, 0xF0, 0x1C, 0x00, 0x3F, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x01, 0x3E,
  0x00, 0x00, 0x27, 0xF0, 0x00, 0x0C, 0x7F, 0x00, 0x07, 0x07, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1C, 0x1F, 0xF8, 0x06, 0x00, 0x7F, 0xC1, 0x80, 0x07, 0xFC, 0xE0,
  0x03, 0x3F, 0xE4, 0x01, 0xC1, 0xF8, 0x80, 0x78, 0x1E, 0x10, 0x0F, 0x00,
  0x02, 0x01, 0xF0, 0x00, 0x20, 0x3F, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x31,
  0x3F, 0x80, 0x01, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x7E, 0x07, 0x00, 0x3F, 0xE1, 0xC0, 0x0D, 0xFE,
  0x60, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0C,
  0x00, 0xFF, 0x86, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xB8, 0x01, 0x83, 0x84, 0x03, 0x83, 0x82, 0x07, 0x83,
  0xC1, 0x0F, 0xC1, 0xE1, 0x87, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF0,
  0x3F, 0x00, 0x78, 0x1F, 0xC0, 0x3C, 0x07, 0xF0, 0x1E, 0x01, 0xF8, 0x0F,
  0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0x80,
  0xF8, 0x01, 0x80, 0x7C, 0x01, 0x80, 0x3E, 0x01, 0x80, 0x1F, 0x01, 0x80,
  0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xFC, 0x07, 0xE1, 0xFF, 0x05, 0xF1, 0x1F,
  0xC4, 0xFD, 0x07, 0xFC, 0x7F, 0x01, 0xFE, 0x1F, 0x00, 0x7C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0xFC, 0x3F, 0xC0, 0x3F, 0xFE, 0x63, 0xE0, 0x7E, 0xFF,
  0x43, 0xF0, 0x70, 0x1F, 0xC1, 0xF0, 0xC0, 0x0F, 0xC1, 0xF8, 0xC0, 0x07,
  0xC0, 0xFC, 0x80, 0x07, 0xC0, 0x70, 0x80, 0x03, 0xC0, 0x20, 0x80, 0x03,
  0xC0, 0x40, 0xC0, 0x03, 0xC0, 0xC0, 0x40, 0x03, 0x81, 0xC0, 0x60, 0x23,
  0x81, 0xE0, 0x30, 0x43, 0x83, 0xF0, 0x0F, 0x83, 0x01, 0xF8, 0x00, 0x06,
  0x01, 0xFC, 0x00, 0x04, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x1C, 0x0D, 0xFF,
  0x00, 0x18, 0x10, 0x7F, 0x80, 0x18, 0x00, 0x3F, 0xE0, 0x30, 0x00, 0x0F,
  0xF8, 0x60, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x30, 0x3F, 0x00, 0x1F, 0xF8, 0xF1, 0xFF, 0x00,
  0xFF, 0xFB, 0x14, 0x3F, 0x03, 0xFF, 0xFC, 0x10, 0x3F, 0x07, 0x83, 0xF8,
  0x60, 0x3E, 0x1C, 0x01, 0xF0, 0xC0, 0x7E, 0x30, 0x03, 0xF3, 0x80, 0x7C,
  0x60, 0x03, 0xE7, 0x00, 0xFC, 0x80, 0x03, 0xCF, 0x00, 0xF5, 0x00, 0x07,
  0x9E, 0x00, 0xC3, 0x00, 0x0F, 0x3E, 0x03, 0x02, 0x00, 0x1E, 0x7E, 0x0E,
  0x06, 0x00, 0x38, 0xFC, 0x3E, 0x06, 0x0C, 0x70, 0xFC, 0x7E, 0x03, 0xE0,
  0xC0, 0xF8, 0xFE, 0x00, 0x03, 0x01, 0xF0, 0xFE, 0x00, 0x06, 0x01, 0xE1,
  0xFC, 0x00, 0x18, 0x03, 0xC1, 0xFC, 0x00, 0x20, 0x07, 0x00, 0xF8, 0x1F,
  0x80, 0x06, 0x00, 0xF0, 0x7F, 0x80, 0x1C, 0x01, 0xC1, 0xFF, 0x80, 0x3C,
  0x01, 0x8C, 0x3F, 0x80, 0xFC, 0x02, 0x00, 0x3F, 0x83, 0xFE, 0x08, 0x00,
  0x3F, 0xF9, 0xFE, 0x20, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x06, 0x01, 0xFF, 0x83, 0xF8, 0xFF, 0xF1, 0xFE, 0x7F, 0xFC, 0x7F, 0x1C,
  0x0F, 0x97, 0xCE, 0x01, 0xE8, 0x43, 0x00, 0x3E, 0x00, 0xC0, 0x0F, 0x80,
  0x30, 0x03, 0xC0, 0x04, 0x00, 0xF0, 0x01, 0x00, 0x3C, 0x00, 0x60, 0x0F,
  0xFE, 0x0C, 0x27, 0xFF, 0x00, 0xF3, 0xFF, 0x80, 0x01, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x05, 0xF0, 0x00, 0x41, 0x7E, 0x00, 0x7C, 0xCF,
  0xC4, 0x1F, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xC1, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0x00, 0x7F, 0xF0, 0xFF, 0x81, 0xFF, 0xFB, 0x1F, 0x07, 0xEF, 0xF4,
  0x1F, 0x0C, 0x03, 0xF8, 0x3E, 0x30, 0x03, 0xF0, 0x7E, 0x60, 0x03, 0xE0,
  0x7C, 0x80, 0x07, 0xC0, 0xFD, 0x00, 0x07, 0x80, 0xFE, 0x00, 0x0F, 0x00,
  0xC6, 0x00, 0x1E, 0x03, 0x04, 0x00, 0x38, 0x1C, 0x0C, 0x04, 0x70, 0x78,
  0x0E, 0x30, 0xE0, 0xF0, 0x03, 0x81, 0x83, 0xF0, 0x00, 0x07, 0x07, 0xE0,
  0x00, 0x0C, 0x07, 0xE0, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x60, 0x0F, 0xC0,
  0x01, 0x80, 0x1F, 0x80, 0x02, 0x00, 0x1F, 0x80, 0x0F, 0x04, 0x3F, 0x00,
  0x3F, 0x10, 0x7E, 0x00, 0xFF, 0xE0, 0x7C, 0x02, 0x7F, 0x80, 0xF0, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x20, 0x00, 0x0F, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x20, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x1C,
  0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x78, 0x1F, 0xC0, 0xC0, 0x0F, 0x83, 0x00, 0x0F, 0x06,
  0x00, 0x1F, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x78, 0x10, 0x00, 0xF0, 0x18,
  0x01, 0xC0, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x63, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x8F, 0x00, 0x07, 0x7F, 0x80, 0x0D, 0xFF, 0x80, 0x18, 0x7F, 0x00, 0x60,
  0x3F, 0x00, 0x80, 0x3F, 0x82, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFC, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xFC, 0x02, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xF3, 0x83, 0x07, 0x18, 0x0E,
  0xC0, 0x1A, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3,
  0xC7, 0x1E, 0x18, 0x20, 0x40, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07,
  0xE0, 0x0B, 0xF8, 0x19, 0xFC, 0x30, 0x78, 0x70, 0x78, 0x70, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78, 0x78,
  0x78, 0x7C, 0x79, 0x3F, 0xFE, 0x3E, 0x3C, 0x1C, 0x3C, 0x08, 0x08, 0x03,
  0xC1, 0x1C, 0x02, 0x70, 0x02, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x08, 0x3C, 0x70, 0x79, 0xF0, 0xFD, 0xF1, 0xE3, 0xE3, 0xC3, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x71, 0xE0,
  0xE3, 0xC1, 0x87, 0xC2, 0x1F, 0xC8, 0x0F, 0xE0, 0x07, 0x80, 0x06, 0x00,
  0x04, 0x00, 0x03, 0x80, 0xFC, 0x13, 0xC3, 0x1E, 0x71, 0xE7, 0x0C, 0xF0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3F, 0xF1, 0xF8, 0x0F, 0x00, 0x40, 0x70, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x04, 0x7C, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E,
  0x3C, 0x0C, 0x7E, 0x08, 0x7F, 0x98, 0x0F, 0xF0, 0x07, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0xFC, 0x13, 0xC3, 0x1C, 0x71, 0xE7, 0x1E, 0xF0,
  0xFE, 0x0E, 0xF3, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3F, 0xF1, 0xFC, 0x0F, 0x00, 0x40, 0x00, 0x03, 0xF4, 0x7F,
  0x8F, 0xE1, 0x18, 0x40, 0x08, 0x01, 0x80, 0x38, 0x0F, 0xFA, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x07, 0xE0, 0x09, 0xFC, 0x18, 0xFE, 0x30, 0x7C, 0x70, 0x18, 0x70, 0x18,
  0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x7C,
  0x78, 0x3C, 0x7C, 0x3C, 0x3E, 0x7E, 0x1F, 0x9E, 0x1C, 0x1E, 0x10, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x30, 0x1C, 0x70, 0x18, 0x78, 0x30, 0x3C, 0x60,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC2, 0x38, 0x04, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x60, 0x79, 0xE0, 0xFF, 0xE1, 0xE7,
  0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1E, 0x8E, 0x7F,
  0x18, 0x7C, 0x60, 0x70, 0xC0, 0x43, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0E, 0x07, 0xC1, 0xE0, 0x38, 0x08,
  0x00, 0x01, 0x00, 0x60, 0x3C, 0x0F, 0x87, 0xF2, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE8, 0x7E,
  0x0F, 0x01, 0xC0, 0x20, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x0E, 0x01, 0xE0, 0x7F, 0x17, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x1F, 0x03, 0x90, 0x62,
  0x18, 0x3C, 0x00, 0x00, 0x00, 0x7A, 0x18, 0x26, 0x25, 0xCC, 0x7B, 0x8F,
  0x71, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x5E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF4,
  0x7F, 0x01, 0xE0, 0x18, 0x02, 0x00, 0x00, 0x00, 0xF8, 0xE1, 0x70, 0x5C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFA,
  0x7F, 0x03, 0x80, 0x60, 0x10, 0x20, 0x20, 0x20, 0x1C, 0x1C, 0x38, 0x1F,
  0x1F, 0x3E, 0x0F, 0x9F, 0xBF, 0xCB, 0xF3, 0xE7, 0xF0, 0xF1, 0xE1, 0xE0,
  0x78, 0x70, 0xF0, 0x3C, 0x38, 0x78, 0x1E, 0x1C, 0x3C, 0x0F, 0x0E, 0x1E,
  0x07, 0x87, 0x0F, 0x03, 0xC3, 0x87, 0x81, 0xE1, 0xC3, 0xC0, 0xF0, 0xE1,
  0xE0, 0x78, 0x70, 0xF0, 0x7C, 0x7C, 0x78, 0x3E, 0x3E, 0x1E, 0xBF, 0xBF,
  0x8F, 0x87, 0x07, 0x07, 0xC1, 0x01, 0x01, 0xC0, 0x80, 0x80, 0x40, 0x30,
  0x30, 0x3C, 0x3C, 0x1F, 0x3F, 0x1F, 0xAF, 0xE3, 0xE3, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83,
  0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3D, 0x7F, 0x1F, 0x8E,
  0x07, 0x82, 0x03, 0x81, 0x00, 0x40, 0x00, 0x60, 0x07, 0xC1, 0xF7, 0xC3,
  0xCF, 0xC7, 0x8F, 0x8F, 0x0F, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x1F, 0x8C, 0x7F, 0x90,
  0x1F, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0F, 0x81, 0x03, 0xE1, 0xC1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1E, 0x3E, 0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x06, 0x3F, 0x07, 0x3F, 0xC3,
  0x1F, 0xFB, 0x09, 0xFF, 0x00, 0x7F, 0x00, 0x3B, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x38, 0x01, 0xF8, 0x0B, 0xF8, 0x47,
  0xF3, 0x07, 0x9C, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x07, 0xB8, 0x1E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xBE, 0x1E, 0x7C, 0x79, 0xFF, 0xE3, 0xE7, 0x87,
  0x1E, 0x10, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x08, 0x00, 0x03, 0x04, 0x78, 0xE7, 0xDE, 0xBF, 0xF3, 0xEF,
  0x1C, 0x61, 0xC4, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0x80, 0x02, 0x04, 0x04, 0x1C, 0x10, 0xF8, 0xC7,
  0xFF, 0x63, 0xF9, 0x03, 0x8C, 0x04, 0x38, 0x10, 0xF0, 0xE3, 0xEF, 0xC7,
  0xFF, 0x8E, 0x1E, 0x10, 0x38, 0x80, 0xE3, 0x01, 0x1F, 0x0C, 0xFF, 0xE0,
  0xFF, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x10, 0x06, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x83, 0xFF, 0x7F, 0xE3, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF6,
  0x7F, 0x01, 0xE0, 0x18, 0x01, 0x00, 0x00, 0x08, 0x18, 0x04, 0x1E, 0x07,
  0x0F, 0x87, 0xCB, 0xC7, 0xF1, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x38, 0x1C,
  0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x3C, 0x3E, 0x7E, 0xBF, 0xEF, 0x83, 0xC3, 0xC0, 0xC0,
  0xC0, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x60, 0x10, 0x60, 0x38, 0xF0,
  0x78, 0xF9, 0xFC, 0xFE, 0x3E, 0x7C, 0x1E, 0x7E, 0x1F, 0x3E, 0x0F, 0x1E,
  0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x07, 0x0C, 0x0E, 0x0C, 0x0E, 0x0C,
  0x0C, 0x1E, 0x1C, 0x1F, 0x90, 0x3F, 0xE0, 0x07, 0xC0, 0x01, 0xC0, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x10,
  0x18, 0xFC, 0x3C, 0x38, 0x7C, 0x7C, 0xFC, 0x3E, 0xBF, 0x3E, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1E, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x1E, 0x1E,
  0x07, 0x1E, 0x1E, 0x07, 0x1E, 0x1E, 0x07, 0x1E, 0x1E, 0x07, 0x1E, 0x1E,
  0x0E, 0x1E, 0x1E, 0x0C, 0x1E, 0x1F, 0x08, 0x3E, 0x3F, 0xD0, 0x3F, 0x0F,
  0xE0, 0x1E, 0x03, 0xC0, 0x0C, 0x01, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x20,
  0xE1, 0x8F, 0x9C, 0x7D, 0xF5, 0xF7, 0x87, 0x38, 0x38, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xE4,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0x8E, 0x08, 0x20, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x60, 0xE1, 0xCF, 0x83, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xE0, 0x10, 0xF8, 0x30, 0xFC, 0x78, 0x7D, 0xFC, 0x3E, 0x7C,
  0x1C, 0x3E, 0x1C, 0x1E, 0x1C, 0x1F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1E, 0x0E, 0x3E, 0x0E, 0x3E, 0x8C,
  0x7F, 0x1C, 0x1E, 0x18, 0x0C, 0x10, 0x04, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x01, 0xC0, 0x7C,
  0x1F, 0xC4, 0xF8, 0x0F, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x0C, 0xF6, 0x3F,
  0x8B, 0xF8, 0x1F, 0x85, 0xF1, 0x1E, 0x61, 0xE8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xB0, 0x76, 0x0C, 0x41, 0x84, 0x60, 0x70, 0x00, 0x00, 0x80,
  0xF0, 0x60, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0x83, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x03, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x18, 0x1C, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 28, 9, 1, -27 },
  { 26, 13, 10, 15, 1, -27 },
  { 43, 17, 21, 20, 1, -24 },
  { 88, 13, 31, 16, 1, -29 },
  { 139, 25, 27, 27, 1, -27 },
  { 224, 20, 23, 22, 1, -23 },
  { 282, 6, 10, 8, 1, -27 },
  { 290, 8, 31, 9, 1, -30 },
  { 321, 8, 31, 9, 1, -30 },
  { 352, 13, 15, 13, 0, -28 },
  { 377, 13, 13, 15, 1, -19 },
  { 399, 6, 11, 7, 0, -6 },
  { 408, 11, 7, 11, 1, -15 },
  { 418, 6, 7, 8, 1, -6 },
  { 424, 18, 30, 20, 1, -28 },
  { 492, 16, 26, 18, 1, -26 },
  { 544, 12, 26, 12, 0, -26 },
  { 583, 15, 26, 17, 1, -26 },
  { 632, 16, 26, 18, 1, -26 },
  { 684, 17, 26, 17, 0, -26 },
  { 740, 16, 27, 18, 1, -27 },
  { 794, 16, 27, 17, 1, -27 },
  { 848, 15, 26, 16, 1, -26 },
  { 897, 16, 27, 18, 1, -27 },
  { 951, 16, 27, 17, 1, -27 },
  { 1005, 6, 19, 8, 1, -18 },
  { 1020, 7, 23, 7, 0, -18 },
  { 1041, 10, 14, 11, 0, -18 },
  { 1059, 13, 9, 15, 1, -16 },
  { 1074, 10, 14, 11, 0, -18 },
  { 1092, 15, 28, 17, 1, -27 },
  { 1145, 22, 22, 23, 1, -17 },
  { 1206, 29, 28, 31, 1, -27 },
  { 1308, 33, 29, 34, 0, -28 },
  { 1428, 24, 28, 26, 1, -28 },
  { 1512, 29, 29, 31, 1, -28 },
  { 1618, 25, 28, 27, 1, -28 },
  { 1706, 27, 33, 29, 1, -28 },
  { 1818, 27, 28, 29, 1, -27 },
  { 1913, 27, 34, 28, 0, -29 },
  { 2028, 24, 32, 26, 1, -27 },
  { 2124, 25, 37, 27, 1, -27 },
  { 2240, 30, 28, 31, 0, -27 },
  { 2345, 20, 28, 22, 1, -27 },
  { 2415, 40, 29, 42, 1, -27 },
  { 2560, 32, 28, 34, 1, -27 },
  { 2672, 27, 28, 29, 1, -27 },
  { 2767, 32, 33, 34, 1, -27 },
  { 2899, 29, 30, 30, 1, -27 },
  { 3008, 34, 28, 35, 1, -27 },
  { 3127, 27, 27, 29, 1, -27 },
  { 3219, 27, 27, 28, 1, -27 },
  { 3311, 25, 29, 27, 1, -27 },
  { 3402, 32, 29, 34, 1, -28 },
  { 3518, 39, 28, 41, 1, -27 },
  { 3655, 26, 29, 27, 1, -28 },
  { 3750, 31, 34, 33, 1, -28 },
  { 3882, 23, 32, 25, 1, -27 },
  { 3974, 5, 30, 7, 1, -28 },
  { 3993, 23, 27, 4, -7, -25 },
  { 4071, 5, 30, 7, 1, -28 },
  { 4090, 14, 10, 16, 1, -27 },
  { 4108, 18, 3, 17, 0, 4 },
  { 4115, 6, 7, 19, 6, -27 },
  { 4121, 16, 21, 18, 1, -20 },
  { 4163, 15, 27, 17, 1, -26 },
  { 4214, 12, 20, 13, 1, -19 },
  { 4244, 16, 27, 17, 1, -26 },
  { 4298, 12, 20, 14, 1, -19 },
  { 4328, 11, 33, 9, 0, -27 },
  { 4374, 16, 28, 18, 1, -20 },
  { 4430, 15, 34, 17, 1, -27 },
  { 4494, 10, 27, 10, 0, -26 },
  { 4528, 11, 34, 9, -2, -27 },
  { 4575, 11, 28, 12, 1, -27 },
  { 4614, 10, 28, 10, 1, -27 },
  { 4649, 25, 21, 27, 1, -20 },
  { 4715, 17, 20, 19, 1, -19 },
  { 4758, 15, 20, 16, 0, -19 },
  { 4796, 17, 31, 17, 0, -23 },
  { 4862, 14, 28, 16, 1, -20 },
  { 4911, 12, 21, 14, 1, -20 },
  { 4943, 14, 25, 16, 1, -24 },
  { 4987, 11, 25, 12, 0, -24 },
  { 5022, 17, 21, 19, 1, -20 },
  { 5067, 16, 23, 17, 0, -22 },
  { 5113, 24, 23, 26, 1, -22 },
  { 5182, 13, 28, 15, 1, -20 },
  { 5228, 16, 30, 18, 1, -23 },
  { 5288, 11, 27, 13, 1, -20 },
  { 5326, 10, 31, 13, 1, -30 },
  { 5365, 2, 32, 6, 2, -30 },
  { 5373, 10, 31, 13, 1, -30 },
  { 5412, 12, 3, 14, 1, -13 },
};

const GFXfont UnifrakturMaguntia_Regular38pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular38pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular38pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR38PT7B_H_
