#ifndef _UNIFRAKTURMAGUNTIA_REGULAR32PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0x20, 0xCF, 0xBE, 0x79, 0xC7, 0x1C, 0x30, 0xC2, 0x08, 0x20, 0x82,
  0x00, 0x00, 0x02, 0x0C, 0xF9, 0xC2, 0x00, 0x20, 0x8C, 0x33, 0xEF, 0xBC,
  0xF3, 0x8E, 0x61, 0x8C, 0x31, 0x04, 0x41, 0x00, 0x0E, 0x30, 0x38, 0xC0,
  0xE7, 0x03, 0x9C, 0x0C, 0x71, 0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x0C, 0x60,
  0x71, 0x81, 0xC6, 0x07, 0x38, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x06, 0x30,
  0x18, 0xC0, 0xE3, 0x03, 0x9C, 0x00, 0x04, 0x00, 0x80, 0x10, 0x07, 0x83,
  0x08, 0xC1, 0x98, 0x3B, 0x07, 0x70, 0xEF, 0x09, 0xF8, 0x1F, 0x81, 0xFC,
  0x1F, 0x80, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0x01, 0xA0, 0x63, 0x18, 0x3E,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x11, 0xE0, 0x00, 0xDD, 0x80,
  0x08, 0xC6, 0x00, 0xCE, 0x38, 0x0C, 0x71, 0xC0, 0xC3, 0x8E, 0x0C, 0x1C,
  0x70, 0x40, 0xE3, 0x84, 0x03, 0x18, 0x40, 0x1D, 0x86, 0x00, 0x78, 0x63,
  0x80, 0x06, 0x76, 0x00, 0x63, 0x18, 0x02, 0x38, 0xC0, 0x21, 0xC7, 0x02,
  0x0E, 0x38, 0x20, 0x71, 0xC3, 0x03, 0x8E, 0x30, 0x1C, 0x73, 0x00, 0x63,
  0x30, 0x03, 0xB1, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x06, 0x60, 0x0C, 0x60,
  0x0C, 0x70, 0x1E, 0x60, 0x1E, 0x60, 0x0E, 0xC0, 0x0F, 0x80, 0x0F, 0x1F,
  0x1F, 0x0E, 0x3F, 0x86, 0x77, 0x84, 0xE3, 0xC4, 0xE3, 0xC8, 0xE1, 0xE8,
  0xE1, 0xF0, 0xF0, 0xF0, 0x70, 0xF9, 0x78, 0x7F, 0x1F, 0x9C, 0x43, 0x3C,
  0xF3, 0x18, 0x84, 0x40, 0x06, 0x08, 0x18, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x02, 0x60, 0x10, 0x18, 0x0C, 0x0C, 0x0C,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x04, 0x01, 0x80, 0xFC,
  0x72, 0x77, 0x5C, 0xFF, 0x97, 0x93, 0xAE, 0xE5, 0xC5, 0xE4, 0x78, 0x02,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x21, 0x9F, 0xF3, 0x88, 0x44, 0x20, 0x00,
  0x9F, 0x9F, 0xC0, 0x00, 0x63, 0xF3, 0xF0, 0x20, 0xC7, 0x8F, 0x10, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0x80,
  0x63, 0x03, 0x8E, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0x79, 0xC1, 0xC7, 0x07, 0x0E, 0x38, 0x18, 0xC0, 0x3E,
  0x00, 0x06, 0x01, 0x80, 0xE0, 0x78, 0x3E, 0x17, 0x88, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1F, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0x0F, 0x98, 0x1E,
  0x40, 0x79, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x41, 0x01, 0x08, 0x04, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x0F, 0xC0, 0xC3, 0xC2, 0x07, 0x90,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0xC0,
  0xFF, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x70, 0x1D,
  0xC0, 0x77, 0x01, 0x9E, 0x0C, 0x38, 0x60, 0x3F, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x17, 0x80, 0xDE, 0x02, 0x78, 0x11,
  0xE0, 0xC7, 0x82, 0x1E, 0x10, 0x78, 0xC1, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x1F, 0xF0,
  0x30, 0x71, 0xFF, 0x0F, 0xF0, 0x7E, 0x02, 0x00, 0x10, 0x00, 0x80, 0x09,
  0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0xC1, 0xF4, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x6F, 0x06, 0x38, 0x60,
  0x7E, 0x00, 0x07, 0x80, 0xC7, 0x06, 0x3C, 0x60, 0xE7, 0x07, 0x38, 0x39,
  0xC0, 0x1E, 0x00, 0xF1, 0x87, 0xBF, 0x3E, 0x3D, 0xF0, 0xEF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x06,
  0x0C, 0x60, 0x3E, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0xC0, 0x24, 0x01,
  0x40, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x0C, 0x08, 0xC0, 0x6E, 0x03,
  0x70, 0x1B, 0xC0, 0xDF, 0x06, 0x7E, 0x63, 0xFC, 0x0F, 0xF0, 0x3F, 0xC3,
  0x3F, 0x30, 0x7B, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x6E, 0x03, 0x38, 0x70, 0x7E, 0x00, 0x0F, 0x00, 0xCE, 0x0C, 0x38, 0xE1,
  0xCE, 0x0F, 0x70, 0x7B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0x3F,
  0xE1, 0xF7, 0x17, 0x9F, 0x3C, 0x71, 0xC0, 0x0E, 0x00, 0x73, 0x03, 0xBC,
  0x39, 0xE1, 0xC7, 0x0C, 0x18, 0xC0, 0x7C, 0x00, 0x10, 0xC7, 0x8C, 0x20,
  0x00, 0x00, 0x00, 0x02, 0x0C, 0x78, 0xF1, 0x00, 0x10, 0xC7, 0x8C, 0x20,
  0x00, 0x00, 0x00, 0x02, 0x0C, 0x7B, 0xE3, 0x84, 0x10, 0x82, 0x00, 0x01,
  0x81, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0,
  0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0xE0, 0x78, 0x3E, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x00, 0x1F, 0x87, 0x0E, 0x40, 0xEC, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0xF0,
  0x1F, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xC0, 0x30, 0x03, 0x04, 0x30, 0x41,
  0x8C, 0x0F, 0x80, 0x00, 0x02, 0x00, 0x30, 0x0F, 0x80, 0x70, 0x02, 0x00,
  0x03, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30, 0xC0, 0x04, 0x60, 0x01, 0x98,
  0x3F, 0x6C, 0x3B, 0x9B, 0x1C, 0xE6, 0xC6, 0x39, 0xB3, 0x8C, 0x6C, 0xE7,
  0x13, 0x71, 0xCC, 0xCC, 0xF6, 0x33, 0xDF, 0x36, 0x00, 0x0D, 0x80, 0x06,
  0x30, 0x03, 0x07, 0x03, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x02, 0x1F, 0xF0,
  0x0C, 0x3F, 0xF8, 0x3C, 0x40, 0xFC, 0xFC, 0xC0, 0x7C, 0x78, 0x80, 0x3E,
  0x78, 0x80, 0x3E, 0x78, 0x80, 0x1E, 0x78, 0xC0, 0x1E, 0x78, 0xF0, 0x1C,
  0x78, 0x7C, 0x1C, 0x78, 0x3E, 0x18, 0x78, 0x1E, 0x38, 0x78, 0x06, 0x30,
  0x78, 0x04, 0x60, 0x78, 0x00, 0xC0, 0x78, 0x01, 0x00, 0x78, 0x03, 0xC0,
  0x78, 0x07, 0xE0, 0x78, 0x1F, 0xF0, 0xFC, 0x01, 0xFF, 0x3F, 0x00, 0xFE,
  0x3E, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3C, 0x01, 0xFF,
  0x8F, 0xF0, 0x3F, 0xFC, 0x8F, 0x07, 0x87, 0xF0, 0xF8, 0x60, 0x1F, 0x07,
  0x86, 0x01, 0xF0, 0x78, 0xC0, 0x0F, 0x07, 0xEC, 0x00, 0xF0, 0x3C, 0x40,
  0x07, 0x03, 0x04, 0x00, 0x70, 0xF0, 0x60, 0x06, 0x3F, 0xC3, 0x04, 0xEF,
  0xFE, 0x0F, 0x8C, 0x07, 0xE0, 0x00, 0x80, 0x1F, 0x00, 0x10, 0x00, 0xF0,
  0x06, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x06, 0x05, 0xFC,
  0x00, 0xE0, 0x07, 0xE0, 0x0C, 0x00, 0x3F, 0x81, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0x00, 0xC2, 0x7D,
  0x18, 0x1F, 0xF3, 0x83, 0x3C, 0x78, 0x40, 0x87, 0x1C, 0x00, 0x71, 0xC0,
  0x0F, 0x3E, 0x00, 0xF3, 0xF0, 0x0F, 0x1F, 0x80, 0xF0, 0xFC, 0x0F, 0x0F,
  0xE0, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x7C,
  0x0E, 0x03, 0xE0, 0xC0, 0x1F, 0x10, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x30,
  0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x3F, 0x1F, 0xF0, 0x78, 0x21, 0xF8, 0xE0, 0x60, 0xFC, 0xC0,
  0xC0, 0x3C, 0xC1, 0xE0, 0x1E, 0x81, 0xF0, 0x0E, 0x81, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0x80, 0xFC, 0x07, 0x40, 0x7E, 0x03, 0x60, 0x1E, 0x03, 0x1F,
  0x1E, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x08, 0x02, 0x01, 0x10, 0x06, 0x07,
  0xE0, 0x04, 0x1F, 0xF8, 0x08, 0x37, 0xFE, 0x10, 0x40, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC3, 0x00, 0x61, 0x3E, 0x86, 0x07,
  0xFC, 0x70, 0x67, 0x87, 0x04, 0x08, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1E,
  0x7C, 0x00, 0xF3, 0xF1, 0xC7, 0x8F, 0xDF, 0xFC, 0x3F, 0xFD, 0xE1, 0xFD,
  0xCF, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0E, 0x01, 0xF0, 0x60, 0x07, 0xC4, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x03,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xA7, 0x81, 0xFF, 0x8C, 0x00, 0x7E, 0x30,
  0x02, 0x38, 0x60, 0x08, 0x00, 0x80, 0x30, 0x01, 0x00, 0x70, 0x02, 0x01,
  0xF0, 0x64, 0x01, 0xF1, 0xE4, 0x03, 0xF7, 0xCC, 0x03, 0xFF, 0x84, 0x37,
  0xE6, 0x07, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x38, 0x0F,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x06, 0x00, 0x1C, 0x18, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x80, 0x0C, 0x23, 0x80, 0x70, 0x3F, 0x80,
  0xC0, 0x4F, 0x83, 0x83, 0x0F, 0x8F, 0x0C, 0x0F, 0x9C, 0x70, 0x0C, 0x38,
  0xE0, 0x20, 0xF1, 0xE0, 0xE1, 0xE3, 0xE7, 0xF3, 0xC7, 0xDF, 0xE7, 0x87,
  0xC3, 0xEF, 0x07, 0xC3, 0xDE, 0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x0F,
  0x0F, 0x78, 0x1C, 0x1C, 0xF8, 0x38, 0x38, 0xF0, 0x40, 0x70, 0xF1, 0x01,
  0xC0, 0xF0, 0x03, 0x00, 0xF8, 0x0C, 0x00, 0x7E, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x0B, 0xF0, 0x00, 0x61, 0xF8, 0x01, 0x81, 0xC0, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x80, 0x1E, 0x01, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x3F, 0x80, 0x7D,
  0x9F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0xF3, 0xC3, 0x81,
  0xCF, 0xC2, 0x03, 0xAF, 0xC8, 0x06, 0x07, 0xE0, 0x1C, 0x07, 0x80, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0x87, 0xF0, 0x30, 0x1F,
  0xF6, 0x00, 0xFC, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x0F, 0x03, 0x00, 0xF0, 0x18, 0x2F, 0x80, 0x7C, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x1C, 0x00, 0xE7, 0xF0, 0x06, 0xFF, 0x80, 0x60, 0xFC, 0x0C,
  0x07, 0xE1, 0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x70, 0xFE, 0x06, 0x01, 0xFF, 0x30, 0x07, 0xE1,
  0x00, 0x06, 0x08, 0x00, 0x60, 0x40, 0x07, 0x02, 0x00, 0x38, 0x18, 0x03,
  0xC0, 0x40, 0x1E, 0x01, 0x82, 0xF8, 0x03, 0xE3, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x73, 0xF8, 0x03, 0x3F, 0xE0, 0x18, 0x1F, 0x81, 0x80, 0x7E, 0x18,
  0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x38, 0xFC, 0x30, 0x1C, 0xFF,
  0x08, 0x1C, 0xC7, 0xC6, 0x0E, 0x41, 0xE3, 0x07, 0xA0, 0xF9, 0x83, 0xD0,
  0x3E, 0xC1, 0xF8, 0x1E, 0x60, 0x7C, 0x06, 0x20, 0x3F, 0x04, 0x20, 0x0F,
  0x8F, 0x20, 0x07, 0xEF, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1C, 0x3C, 0x07, 0x0E, 0x1F, 0x0F, 0xC2, 0x07, 0x87, 0xF2, 0x03, 0xE8,
  0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x9E, 0x07, 0x03, 0x87, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x1C,
  0xF8, 0x0E, 0x7C, 0x07, 0x3F, 0x03, 0x8F, 0xA7, 0x83, 0xCF, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x1F,
  0xC0, 0x1F, 0xF0, 0x30, 0xFF, 0x70, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE1, 0xF0, 0xF8, 0x0F, 0xFC, 0xFE, 0x7F, 0x07, 0xFF, 0xC7, 0xE1,
  0xE1, 0x03, 0xF0, 0xF8, 0x78, 0x80, 0x7C, 0x1E, 0x1F, 0x20, 0x0F, 0x87,
  0x83, 0xC8, 0x01, 0xE0, 0xF0, 0xFA, 0x00, 0x78, 0x3C, 0x3C, 0x80, 0x0F,
  0x0F, 0x06, 0x20, 0x03, 0xC3, 0xC3, 0x07, 0xF0, 0xF0, 0xF1, 0x80, 0xFE,
  0x1C, 0x18, 0xE0, 0x08, 0x86, 0x06, 0x30, 0x00, 0x41, 0x81, 0x9C, 0x00,
  0x00, 0x60, 0x67, 0x00, 0x00, 0x30, 0x31, 0xE0, 0x00, 0x0C, 0x0C, 0x78,
  0x03, 0x82, 0x42, 0x1E, 0x03, 0xF1, 0x78, 0x87, 0xC9, 0xFE, 0xFF, 0xC0,
  0xFF, 0x0F, 0xEF, 0xE0, 0x1F, 0x01, 0xF4, 0x70, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0x80, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x8F, 0x8C, 0x0F, 0xE0, 0xF1, 0x00,
  0xFC, 0x1E, 0x20, 0x0F, 0x83, 0xE4, 0x00, 0xF0, 0x3E, 0x80, 0x0F, 0x07,
  0x90, 0x01, 0xE0, 0x43, 0x00, 0x3C, 0x10, 0x3F, 0x87, 0x86, 0x03, 0xF8,
  0x71, 0x80, 0x01, 0x0C, 0x30, 0x00, 0x41, 0x8E, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x0C, 0x3C, 0x00, 0x01, 0x87, 0x80, 0x38, 0x20, 0xF0, 0x1F, 0x88,
  0x1F, 0x25, 0xFB, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x01, 0xF0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF0, 0x0C, 0x1F, 0xE0, 0xC0, 0x1F, 0xC6, 0x00, 0x1F, 0x38, 0x00,
  0x3E, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xDF, 0xE0, 0x07,
  0x3F, 0xC0, 0x1C, 0x3F, 0x00, 0x70, 0x3C, 0x00, 0xC0, 0x20, 0x02, 0x01,
  0x00, 0x18, 0xF8, 0x00, 0x47, 0xF0, 0x01, 0x2F, 0xF0, 0x08, 0x0F, 0xF0,
  0x40, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xC0, 0x1F, 0xF8, 0x38, 0x03, 0xDF, 0xCF, 0xC0, 0x60,
  0x7F, 0x7C, 0x04, 0x03, 0xE7, 0xE0, 0xC0, 0x1E, 0x3F, 0x0C, 0x01, 0xE1,
  0xF8, 0x40, 0x1E, 0x0F, 0xC4, 0x01, 0xE0, 0x7E, 0x40, 0x1E, 0x03, 0xE3,
  0x04, 0xE0, 0x1F, 0x0F, 0x8E, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xE0, 0x04,
  0x00, 0x7F, 0x00, 0x80, 0x0F, 0xFC, 0x08, 0x01, 0x9F, 0xFB, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0C,
  0x1F, 0xE0, 0x30, 0x07, 0xF0, 0x60, 0x01, 0xF0, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x3C, 0xFE, 0x00, 0x3C, 0x7F, 0x80, 0x1C, 0x3F,
  0xC0, 0x1C, 0x1F, 0xC0, 0x1C, 0x03, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x18, 0x3E, 0x03, 0xD0, 0x7F, 0x07, 0xF0, 0xBF, 0xC9, 0xF1, 0x0F,
  0xF0, 0xFE, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xF8, 0xFF,
  0x07, 0xFF, 0xD0, 0xF0, 0x60, 0xFD, 0x0F, 0x8C, 0x03, 0xE0, 0x78, 0x80,
  0x1E, 0x07, 0xC8, 0x00, 0xF0, 0x3E, 0x80, 0x0F, 0x01, 0x88, 0x00, 0x70,
  0x30, 0x80, 0x07, 0x0C, 0x04, 0x00, 0x71, 0x80, 0x60, 0x47, 0x7C, 0x01,
  0xF8, 0x73, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x06,
  0x1F, 0x00, 0x00, 0x40, 0xF0, 0x0F, 0x0C, 0x0F, 0x81, 0xF8, 0x80, 0xF8,
  0x3F, 0xD0, 0x07, 0xF0, 0x7E, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x81, 0x9F,
  0xFC, 0x08, 0x0F, 0xE0, 0x40, 0x0F, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x03, 0xC3, 0x00, 0x3F, 0xCC, 0x23, 0xFF, 0xB0, 0xFF, 0xE2, 0xE1,
  0xFE, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x78, 0x00,
  0x05, 0xF0, 0x00, 0x33, 0xF0, 0x03, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x07,
  0x07, 0xF8, 0x10, 0x07, 0xF8, 0x80, 0x27, 0xFE, 0x01, 0x8F, 0xC8, 0x0E,
  0x0E, 0x20, 0x78, 0x00, 0x81, 0xF8, 0x01, 0x03, 0xF0, 0x02, 0x17, 0xE0,
  0x05, 0x8F, 0x80, 0x00, 0x1F, 0x00, 0x10, 0x3C, 0x01, 0xE0, 0xE0, 0x1F,
  0xC3, 0x00, 0x9F, 0x90, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x0E, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x30, 0xC2, 0x07,
  0x0E, 0x10, 0xF0, 0x70, 0x8F, 0x87, 0x88, 0x3C, 0x3E, 0x01, 0xE1, 0xF8,
  0x0F, 0x07, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x70, 0x3C, 0x03, 0x01, 0xE0, 0x10, 0x0F, 0x01, 0x00,
  0x78, 0x1C, 0x03, 0xC3, 0xF0, 0x3E, 0x3F, 0xC2, 0xF0, 0x1F, 0xE7, 0xF0,
  0x7E, 0x1F, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x70, 0x03, 0xFE, 0x3F, 0x80, 0xFF, 0xE8, 0xF8, 0x38, 0x7F, 0x0F, 0x0C,
  0x07, 0xE1, 0xF1, 0x00, 0x7C, 0x1F, 0x20, 0x07, 0x83, 0xC4, 0x00, 0xF0,
  0x30, 0x80, 0x0E, 0x0C, 0x10, 0x01, 0xC1, 0x81, 0x00, 0x30, 0x70, 0x10,
  0xC6, 0x0F, 0x00, 0xE1, 0x81, 0xF0, 0x00, 0x20, 0x3F, 0x00, 0x08, 0x03,
  0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC1, 0xFE, 0x00, 0x70, 0x6F,
  0xF0, 0x06, 0x00, 0x7F, 0x01, 0x80, 0x07, 0xF0, 0x20, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0x83, 0xC0, 0x0F,
  0xF9, 0xE7, 0xF8, 0x0F, 0xFE, 0x9C, 0x3E, 0x0F, 0xFF, 0x84, 0x0F, 0x0E,
  0x07, 0xC6, 0x07, 0xC6, 0x01, 0xF3, 0x01, 0xE2, 0x00, 0x79, 0x80, 0xF9,
  0x00, 0x3D, 0xE0, 0x3A, 0x80, 0x0E, 0xF8, 0x08, 0x40, 0x07, 0x3C, 0x18,
  0x10, 0x03, 0x1F, 0x0E, 0x0C, 0x11, 0x8F, 0x8F, 0x81, 0xF1, 0x83, 0xC7,
  0xE0, 0x00, 0xC0, 0xF1, 0xF8, 0x00, 0x40, 0x70, 0x7C, 0x00, 0x40, 0x38,
  0x1E, 0x03, 0xC0, 0x0C, 0x07, 0x07, 0xF0, 0x0E, 0x01, 0x87, 0xFC, 0x07,
  0x80, 0x84, 0x3F, 0x07, 0xE0, 0x40, 0x0F, 0xCF, 0xF8, 0x40, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x81, 0xFF, 0x0F, 0xDF, 0xFC, 0xFE, 0xF7, 0xE7, 0xEE, 0x07, 0xA6, 0x60,
  0x3E, 0x02, 0x00, 0xF0, 0x10, 0x07, 0x80, 0x80, 0x3C, 0x02, 0x01, 0xFF,
  0x18, 0x1F, 0xF0, 0x3D, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x02, 0xF0, 0x07, 0x17, 0xC0,
  0x7D, 0x9F, 0x33, 0xF8, 0xFF, 0x3F, 0xC3, 0xF0, 0x3C, 0x0F, 0x00, 0x07,
  0xC0, 0xF8, 0x07, 0xFC, 0x7F, 0x07, 0xFF, 0xA3, 0xE1, 0xC3, 0xF8, 0x78,
  0xC0, 0x7E, 0x1F, 0x20, 0x0F, 0x83, 0xC8, 0x01, 0xE0, 0xFA, 0x00, 0x78,
  0x1F, 0x80, 0x0E, 0x02, 0x20, 0x03, 0x83, 0x04, 0x00, 0xC1, 0xC0, 0x86,
  0x30, 0xF0, 0x1E, 0x1C, 0x3C, 0x00, 0x06, 0x0F, 0x80, 0x01, 0x03, 0xF0,
  0x00, 0xC0, 0x7C, 0x00, 0x20, 0x1F, 0x00, 0x10, 0x03, 0xE0, 0x0E, 0x08,
  0xF8, 0x07, 0xEC, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0x1F, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x10, 0x00, 0x38, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1C, 0x0F, 0x80, 0xC0, 0x1E, 0x04, 0x00, 0xF0, 0x20, 0x03,
  0x81, 0x00, 0x1C, 0x08, 0x01, 0xC0, 0x20, 0x0C, 0x00, 0xE0, 0xC0, 0x00,
  0x1E, 0x00, 0x07, 0xFC, 0x00, 0x4F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE1, 0xE0,
  0x03, 0x3F, 0x80, 0x3A, 0x7E, 0x01, 0x80, 0xF8, 0x08, 0x03, 0xF0, 0x80,
  0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xFF, 0x04, 0x00, 0x80, 0x38,
  0x0F, 0x81, 0xF0, 0x77, 0x1C, 0x36, 0x03, 0x80, 0x30, 0x04, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE7, 0x1C, 0x61, 0x04, 0x02, 0x00, 0x38, 0x03, 0xF0, 0x27,
  0xE2, 0x1E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xE1, 0xCF, 0x0E, 0x3E, 0xFC, 0xFB, 0xC3, 0x0C, 0x10, 0x20, 0x07, 0x04,
  0xC0, 0x2E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE1, 0x07, 0x38, 0x3B,
  0xE1, 0xE7, 0x8E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xC7, 0x06,
  0x38, 0x73, 0xC3, 0x1F, 0x11, 0xFF, 0x01, 0xF0, 0x03, 0x00, 0x10, 0x00,
  0x07, 0x07, 0xC2, 0x79, 0x8E, 0x63, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x23, 0xF4, 0x78, 0x08, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07,
  0xF2, 0xC7, 0x8E, 0x1E, 0x70, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06,
  0x38, 0x33, 0xC1, 0x9F, 0x09, 0x7E, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x07, 0xC2, 0x71, 0x8E, 0x63, 0xB8, 0xFE, 0x13, 0xB8, 0xF0, 0x38,
  0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x23, 0xF4, 0x70, 0x08, 0x00, 0x00, 0x0F,
  0x47, 0xE7, 0xE2, 0x01, 0x00, 0x80, 0x60, 0xFF, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00, 0x10, 0x01, 0xC0,
  0x1F, 0x81, 0x3F, 0x10, 0x71, 0x81, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCF, 0x0E, 0x38, 0x79, 0xE3, 0xC7, 0xEE, 0x38, 0x71, 0x03,
  0x80, 0x1C, 0x00, 0xE6, 0x06, 0x38, 0x60, 0xE6, 0x00, 0xC0, 0x07, 0x84,
  0xE0, 0x2E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE2, 0x07, 0x78, 0x3F,
  0xE1, 0xCF, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xE7, 0x0E,
  0x38, 0x71, 0xC3, 0x9E, 0x1C, 0xF4, 0xCF, 0xC4, 0x0C, 0x60, 0x46, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x18,
  0x00, 0x00, 0x30, 0x38, 0x7E, 0xBC, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1F, 0x1E, 0x0E, 0x04, 0x07, 0x07, 0x83, 0xC0, 0xC0,
  0x00, 0x00, 0x20, 0x18, 0x1F, 0x1F, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x07,
  0x83, 0x23, 0x1E, 0x00, 0x07, 0xC6, 0x26, 0x6F, 0x77, 0xB9, 0xF0, 0xE0,
  0xFE, 0xFF, 0x9C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x4F, 0xC3, 0xC0, 0x60, 0x20, 0x07, 0xCC, 0x26, 0x0F, 0x07, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x4F, 0xCB, 0xC0, 0x60, 0x20, 0x00, 0x02, 0x03, 0x87,
  0x18, 0x1E, 0x79, 0xF1, 0xF5, 0xF7, 0xE3, 0xC7, 0x1E, 0x1C, 0x38, 0xF0,
  0xE1, 0xC7, 0x87, 0x0E, 0x3C, 0x38, 0x71, 0xE1, 0xC3, 0x8F, 0x0E, 0x1C,
  0x78, 0x70, 0xE3, 0xC3, 0x87, 0x1E, 0x1E, 0x38, 0xF1, 0xF3, 0xE3, 0xE7,
  0x0E, 0x1E, 0x18, 0x20, 0x60, 0x81, 0x00, 0x00, 0x20, 0xC1, 0xC7, 0x8F,
  0xBF, 0xAF, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x71, 0xF1, 0xF3, 0x87, 0x84, 0x0E,
  0x10, 0x10, 0x01, 0x80, 0x7E, 0x1C, 0xF0, 0xE3, 0xC7, 0x1F, 0x38, 0x79,
  0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xF0, 0xCF, 0xC4, 0x3F,
  0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x3E,
  0x18, 0x78, 0xE1, 0xFF, 0xC3, 0xC7, 0x87, 0x1E, 0x1C, 0x3C, 0x70, 0xF1,
  0xC1, 0xC7, 0x07, 0x1C, 0x18, 0x70, 0x67, 0xC3, 0x3F, 0x8C, 0xFF, 0xC0,
  0x7E, 0x01, 0xF0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x0F, 0xC1, 0x9F, 0x98, 0x78,
  0xC3, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x87, 0x3C,
  0x38, 0xFF, 0xC3, 0xCE, 0x0C, 0x70, 0x83, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x61, 0x9C, 0x6F, 0xBE, 0xFF, 0x39, 0x8E,
  0x43, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x39, 0x1F, 0x81, 0xE0,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x4C, 0x00, 0x20, 0x02, 0x0C, 0x11, 0xFE,
  0x6F, 0xE4, 0x3C, 0xC0, 0x8E, 0x10, 0xF3, 0x8F, 0xFC, 0x79, 0xE3, 0x0E,
  0x20, 0x67, 0x04, 0xFC, 0x87, 0xF0, 0x1E, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x01, 0x01, 0x81, 0x81, 0xC1, 0xFD, 0xFF, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x9F, 0x87, 0xC0, 0xC0, 0x40, 0x00,
  0x21, 0x80, 0x87, 0x07, 0x3E, 0x3E, 0xB8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7,
  0xFF, 0xC7, 0x9E, 0x0C, 0x38, 0x00, 0x00, 0x20, 0x01, 0x01, 0x0E, 0x0E,
  0x38, 0x78, 0xF6, 0xF3, 0xE1, 0xE7, 0x87, 0x8F, 0x0E, 0x1C, 0x3C, 0x70,
  0xF0, 0xC1, 0x82, 0x0E, 0x18, 0x38, 0x60, 0xC1, 0xC2, 0x0F, 0xD0, 0x0F,
  0x80, 0x1C, 0x00, 0x20, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0x04, 0x08, 0xF8, 0xF1, 0xC7, 0x9F, 0x7E, 0x3E, 0x79, 0xE3, 0x87,
  0x0F, 0x38, 0x70, 0x73, 0x87, 0x07, 0x38, 0x70, 0x73, 0x87, 0x07, 0x38,
  0x70, 0x73, 0x87, 0x06, 0x38, 0x78, 0x43, 0xC7, 0xC8, 0x7C, 0xFF, 0x03,
  0xE1, 0xE0, 0x18, 0x06, 0x01, 0x00, 0x40, 0x20, 0x07, 0x19, 0xF7, 0x3F,
  0xF1, 0xCE, 0x39, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3D, 0x0F, 0xC3, 0xF0, 0x8C, 0x10, 0x82, 0x00, 0x40, 0x04, 0x18,
  0x47, 0x87, 0xE0, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0xE1, 0x8F, 0x9E,
  0x3F, 0xF8, 0xE3, 0xC7, 0x0F, 0x38, 0x79, 0xC1, 0xCE, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x7F, 0x31, 0xE3, 0x06, 0x10, 0x11,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x1C, 0x1F, 0x1F, 0x81, 0xC0,
  0xE0, 0x60, 0x60, 0x63, 0x7E, 0x7F, 0x07, 0xC5, 0xE4, 0x7A, 0x3F, 0x0F,
  0x07, 0x83, 0xC1, 0xA0, 0xD8, 0x44, 0x61, 0xC0, 0x03, 0x0C, 0x1C, 0x18,
  0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x18, 0x30, 0xE0, 0x60, 0x30, 0x18,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC0, 0x70, 0x38, 0x18, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x18, 0x0C, 0x07, 0x06, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x3C, 0x1C, 0x1C,
  0x18, 0x30, 0x60, 0x80, 0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 11, 9, 13, 1, -23 },
  { 32, 14, 19, 16, 1, -21 },
  { 66, 11, 25, 13, 1, -24 },
  { 101, 21, 23, 23, 1, -23 },
  { 162, 16, 20, 18, 1, -20 },
  { 202, 5, 9, 6, 1, -23 },
  { 208, 8, 26, 8, 0, -25 },
  { 234, 8, 26, 8, 0, -25 },
  { 260, 11, 12, 11, 0, -24 },
  { 277, 11, 11, 13, 1, -16 },
  { 293, 5, 9, 6, 0, -5 },
  { 299, 9, 7, 10, 1, -13 },
  { 307, 6, 5, 6, 0, -5 },
  { 311, 15, 25, 17, 1, -24 },
  { 358, 14, 22, 15, 1, -22 },
  { 397, 10, 22, 10, 0, -22 },
  { 425, 14, 21, 14, 0, -21 },
  { 462, 14, 22, 15, 0, -22 },
  { 501, 14, 22, 15, 0, -22 },
  { 540, 13, 23, 15, 1, -23 },
  { 578, 13, 23, 15, 1, -23 },
  { 616, 13, 22, 14, 0, -22 },
  { 652, 13, 23, 15, 1, -23 },
  { 690, 13, 23, 15, 1, -23 },
  { 728, 6, 15, 6, 0, -15 },
  { 740, 6, 19, 5, 0, -15 },
  { 755, 9, 12, 9, 0, -15 },
  { 769, 11, 7, 12, 1, -13 },
  { 779, 9, 12, 9, 0, -15 },
  { 793, 12, 23, 15, 1, -23 },
  { 828, 18, 19, 19, 1, -15 },
  { 871, 24, 24, 26, 1, -23 },
  { 943, 28, 24, 29, 0, -23 },
  { 1027, 20, 23, 22, 1, -23 },
  { 1085, 24, 24, 26, 1, -23 },
  { 1157, 21, 23, 22, 1, -23 },
  { 1218, 23, 28, 24, 1, -24 },
  { 1299, 23, 24, 25, 1, -23 },
  { 1368, 23, 29, 23, 0, -25 },
  { 1452, 20, 27, 22, 1, -23 },
  { 1520, 21, 31, 23, 1, -23 },
  { 1602, 25, 24, 26, 0, -23 },
  { 1677, 17, 24, 18, 1, -23 },
  { 1728, 34, 24, 35, 1, -22 },
  { 1830, 27, 24, 28, 1, -23 },
  { 1911, 22, 24, 24, 1, -23 },
  { 1977, 28, 28, 29, 0, -23 },
  { 2075, 24, 25, 26, 1, -23 },
  { 2150, 28, 24, 30, 1, -23 },
  { 2234, 22, 23, 24, 1, -23 },
  { 2298, 22, 22, 24, 1, -22 },
  { 2359, 21, 24, 23, 1, -22 },
  { 2422, 27, 24, 28, 1, -23 },
  { 2503, 33, 24, 35, 1, -23 },
  { 2602, 21, 23, 23, 1, -23 },
  { 2663, 26, 28, 27, 1, -23 },
  { 2754, 21, 28, 21, 0, -23 },
  { 2828, 4, 26, 6, 1, -24 },
  { 2841, 20, 23, 3, -6, -21 },
  { 2899, 4, 26, 6, 1, -24 },
  { 2912, 11, 10, 13, 1, -23 },
  { 2926, 15, 2, 15, 0, 4 },
  { 2930, 5, 6, 16, 5, -22 },
  { 2934, 13, 17, 15, 1, -16 },
  { 2962, 13, 23, 14, 1, -22 },
  { 3000, 10, 17, 11, 1, -16 },
  { 3022, 13, 23, 15, 1, -22 },
  { 3060, 10, 17, 12, 1, -16 },
  { 3082, 9, 29, 8, 0, -24 },
  { 3115, 13, 24, 15, 1, -17 },
  { 3154, 13, 28, 14, 1, -22 },
  { 3200, 8, 23, 9, 0, -22 },
  { 3223, 9, 29, 8, -2, -23 },
  { 3256, 9, 23, 10, 1, -22 },
  { 3282, 9, 23, 9, 1, -22 },
  { 3308, 21, 18, 23, 1, -17 },
  { 3356, 14, 17, 16, 1, -16 },
  { 3386, 13, 17, 13, 0, -16 },
  { 3414, 14, 25, 14, 0, -19 },
  { 3458, 13, 24, 14, 0, -17 },
  { 3497, 10, 17, 12, 1, -16 },
  { 3519, 12, 21, 13, 1, -20 },
  { 3551, 9, 21, 10, 0, -20 },
  { 3575, 14, 18, 16, 1, -17 },
  { 3607, 14, 19, 14, 0, -18 },
  { 3641, 20, 20, 22, 1, -19 },
  { 3691, 11, 24, 13, 1, -17 },
  { 3724, 13, 24, 15, 1, -19 },
  { 3763, 9, 22, 11, 1, -16 },
  { 3788, 8, 26, 11, 1, -25 },
  { 3814, 1, 27, 5, 2, -25 },
  { 3818, 8, 26, 11, 1, -25 },
  { 3844, 10, 2, 12, 1, -11 },
};

const GFXfont UnifrakturMaguntia_Regular32pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular32pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular32pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR32PT7B_H_
