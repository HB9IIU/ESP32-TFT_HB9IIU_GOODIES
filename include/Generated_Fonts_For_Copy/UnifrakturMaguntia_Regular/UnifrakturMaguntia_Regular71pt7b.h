#ifndef _UNIFRAKTURMAGUNTIA_REGULAR71PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xF3, 0xFF,
  0xCF, 0xFE, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x1F,
  0x01, 0xFC, 0x3F, 0xF1, 0xFF, 0xC3, 0xF8, 0x0F, 0x00, 0x38, 0x01, 0x80,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x1F,
  0x00, 0x78, 0x3F, 0x80, 0xFC, 0x7F, 0xC3, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F,
  0xE1, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x1E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x10, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x08,
  0x00, 0x40, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xF0,
  0x78, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xE3, 0xFC, 0x01, 0xE1,
  0xFF, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x8E, 0x00, 0x7F, 0xEF, 0x80, 0x1F, 0xF7, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xC7, 0x00, 0x03, 0xC1,
  0xC0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x83, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0xF8,
  0x7C, 0x00, 0x00, 0x03, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0x0E, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x38, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1C, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x0E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x38, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x70,
  0x00, 0x00, 0x07, 0xFE, 0x01, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x8F, 0x80, 0x00, 0x00, 0x70, 0x1E,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0x81, 0xF8,
  0x3F, 0x00, 0x00, 0x1E, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x38, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xE0, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0x80, 0x3F, 0x81,
  0xF8, 0x00, 0x0E, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x38, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x1C, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x70, 0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0x81, 0xF8,
  0x07, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x78, 0x00, 0x00, 0x7C, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x3E, 0x03,
  0x80, 0x00, 0x00, 0x78, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x00,
  0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0x03, 0xFC,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1E, 0x00, 0xF3, 0xFE, 0x00, 0xE0, 0x0F, 0x1F, 0xF8, 0x07,
  0x00, 0xF8, 0x7F, 0xC0, 0x38, 0x0F, 0x83, 0xFF, 0x01, 0x80, 0x7C, 0x0F,
  0xF8, 0x0C, 0x07, 0xE0, 0x7F, 0xC0, 0x60, 0x3F, 0x01, 0xFF, 0x06, 0x01,
  0xF8, 0x0F, 0xFC, 0x30, 0x1F, 0xC0, 0x3F, 0xE3, 0x00, 0xFF, 0x01, 0xFF,
  0x98, 0x07, 0xF8, 0x07, 0xFD, 0x80, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x67, 0xFC, 0x03, 0xFF, 0x8E, 0x3F, 0xF0,
  0x0F, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x18, 0x07, 0x81, 0xF8, 0x7F, 0xDF, 0xF9, 0xFF, 0x0F, 0xE0, 0xFC,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x06, 0x60, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x0E, 0x7E, 0x70, 0xFE, 0x3C, 0x7E, 0x7E, 0x3C, 0x7E, 0x7F, 0x18, 0xFE,
  0x3F, 0x19, 0xFC, 0x3F, 0x9B, 0xFC, 0x3F, 0xFF, 0xFC, 0x20, 0x7E, 0x04,
  0x40, 0x3C, 0x04, 0x3B, 0xFF, 0xFC, 0x3F, 0xDB, 0xFC, 0x7F, 0x99, 0xFC,
  0x7F, 0x18, 0xFE, 0x7E, 0x3C, 0xFE, 0xFE, 0x3C, 0x7E, 0x0E, 0x7E, 0x70,
  0x02, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x04, 0x00, 0x60, 0x07, 0x00, 0xF8,
  0x1F, 0xC7, 0xFE, 0x7F, 0xF1, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x00, 0x01, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x00, 0x04,
  0x00, 0x60, 0x0E, 0x01, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xE3, 0xF8, 0x0F,
  0x00, 0xE0, 0x06, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0x7F, 0xE0, 0x60, 0xFF, 0x02, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x07, 0x80, 0x1F, 0xFC,
  0x3C, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x7F, 0xE7, 0x00, 0x01, 0xFF, 0x9C,
  0x00, 0x03, 0xFE, 0x60, 0x00, 0x0F, 0xF9, 0x80, 0x00, 0x3F, 0xE6, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x1F, 0x00, 0x03, 0x00, 0x78, 0x00,
  0x08, 0x03, 0xC0, 0x00, 0x60, 0x1E, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x06,
  0x07, 0x80, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x78, 0x1F,
  0xFE, 0x01, 0xC0, 0x0F, 0xFE, 0x07, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x0F,
  0xFC, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xE0, 0x00,
  0x0F, 0xF7, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x7F, 0x7F, 0xC0, 0x00, 0xFC, 0x7F, 0x80, 0x01, 0xF8, 0xFF, 0x00, 0x07,
  0xE1, 0xFE, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x78,
  0x03, 0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x0F, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x19, 0xFC, 0x00, 0x00, 0x63, 0xF8, 0x00, 0x00,
  0xC7, 0xF0, 0x00, 0x03, 0x0F, 0xE0, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x18,
  0x3F, 0x80, 0x00, 0x60, 0x7F, 0x00, 0x01, 0xC0, 0xFE, 0x00, 0x03, 0x01,
  0xFC, 0x00, 0x0C, 0x03, 0xF8, 0x00, 0x38, 0x07, 0xF0, 0x00, 0x60, 0x0F,
  0xE0, 0x01, 0x80, 0x1F, 0xC0, 0x07, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0x7F,
  0x00, 0x30, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xFC, 0x01, 0x80, 0x03, 0xF8,
  0x07, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x06, 0x00,
  0x00, 0x60, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x1F, 0xF0, 0x00, 0x1D, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x1F, 0x00, 0x1F, 0xF8, 0x3C,
  0x00, 0x0F, 0xF8, 0x60, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0xE0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x1F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0xFC, 0x7F, 0x80, 0x01,
  0xF8, 0xFF, 0x00, 0x03, 0xE1, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x0F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x1E, 0x07, 0xF0, 0x00,
  0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0xF8,
  0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x7F,
  0x87, 0xFF, 0x81, 0xFE, 0x3F, 0xFF, 0x07, 0xF9, 0xC3, 0xFE, 0x1F, 0xE6,
  0x07, 0xFC, 0x7F, 0xB0, 0x0F, 0xF1, 0xFE, 0xC0, 0x3F, 0xE7, 0xFE, 0x00,
  0x7F, 0x9F, 0xF8, 0x01, 0xFE, 0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F,
  0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1E,
  0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xFC, 0x3C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xF0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x3F, 0x00, 0x00,
  0xF0, 0x7E, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x07,
  0x83, 0xF0, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x7C,
  0x1F, 0xF8, 0x00, 0xF0, 0x3F, 0xFC, 0x03, 0xC0, 0x3F, 0xFC, 0x0F, 0x00,
  0x7F, 0xFE, 0x3C, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0x9F, 0xFF, 0xC0, 0x0E, 0x0F, 0xFF, 0x80, 0x38,
  0x07, 0xFF, 0x80, 0xE0, 0x07, 0xFF, 0x03, 0xC0, 0x03, 0xFF, 0x0F, 0x00,
  0x03, 0xFE, 0x1E, 0x00, 0x03, 0xFE, 0x7C, 0x00, 0x03, 0xFC, 0xF8, 0x00,
  0x03, 0xFB, 0xE0, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF8, 0x1F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF9, 0xFE,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF8, 0xFF, 0x00, 0x5F, 0xE3, 0xFC, 0x03, 0x7F, 0x87, 0xF8, 0x19,
  0xFE, 0x0F, 0xF0, 0xC7, 0xF8, 0x1F, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F,
  0x80, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x0F, 0xF0, 0x7C,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0xC0,
  0x0F, 0xC0, 0xFF, 0x00, 0x3E, 0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x07,
  0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFE, 0x03, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0E, 0x01, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xE3, 0xFC,
  0x1F, 0x00, 0xE0, 0x06, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x06, 0x00, 0xE0, 0x1F, 0x03, 0xF8, 0x7F, 0xEF, 0xFE, 0x3F, 0x80, 0xF0,
  0x0E, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1F, 0x01,
  0xFC, 0x1F, 0xF9, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x38, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x06, 0x00, 0x38, 0x03,
  0xE0, 0x3F, 0x87, 0xFE, 0x3F, 0xF8, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0x83,
  0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x9E, 0x00, 0x07, 0xF3, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xC0, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x04, 0x01, 0xF0, 0x01, 0x80, 0x3E, 0x00, 0x30, 0x07, 0xE0,
  0x0C, 0x00, 0x7C, 0x03, 0x80, 0x07, 0xE0, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x01, 0xF0,
  0x00, 0xF9, 0xF1, 0xE0, 0x7C, 0x00, 0xFF, 0xFC, 0x78, 0x3E, 0x00, 0xF8,
  0xFE, 0x1E, 0x0F, 0x80, 0x7C, 0x3F, 0x83, 0xC7, 0xC0, 0x3F, 0x0F, 0xE0,
  0xF1, 0xF0, 0x1F, 0x83, 0xF0, 0x3C, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x1F,
  0x03, 0xF0, 0x3F, 0x07, 0x8F, 0x81, 0xF8, 0x0F, 0x81, 0xE3, 0xE0, 0xFE,
  0x07, 0xE0, 0x78, 0xF8, 0x3F, 0x01, 0xF8, 0x1E, 0x3E, 0x0F, 0xC0, 0xFE,
  0x0F, 0x0F, 0x87, 0xF0, 0x3F, 0x03, 0xC3, 0xE1, 0xF8, 0x1F, 0xC1, 0xF0,
  0xF8, 0x7E, 0x07, 0xF0, 0x78, 0x3E, 0x1F, 0x83, 0xF8, 0x3C, 0x07, 0x87,
  0xE1, 0xFE, 0x1F, 0x01, 0xE1, 0xFC, 0xFF, 0x9F, 0x80, 0x7C, 0x3F, 0xFF,
  0xFF, 0xC7, 0x9F, 0x07, 0xF8, 0xFF, 0xC1, 0xE3, 0xC0, 0xF8, 0x1F, 0xC0,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x38, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x01,
  0xC0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x06, 0x00, 0x00, 0x7F, 0xF0, 0x3F,
  0xE0, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xE0, 0x00, 0x03, 0xFF,
  0x83, 0xFE, 0x03, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x0C, 0x00, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x30, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0xE0,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x7C, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x78, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xC1, 0x01, 0x03, 0xFF, 0xF8,
  0x39, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x70, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF1,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xCC, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0xB0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xF8, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE1, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x1C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x03,
  0x80, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x30, 0x3E, 0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x01, 0xC0, 0xF8, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x1C, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0x87, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x06, 0x07, 0xFC, 0x00, 0x0F,
  0xC0, 0x18, 0x7F, 0xF9, 0x80, 0xFC, 0x00, 0x4F, 0xFF, 0xFC, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0x01,
  0xC1, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0,
  0x03, 0x80, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x3C, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x08, 0x1F, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x70, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0x00,
  0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE3, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x8E, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x38, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF3, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xEE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xB8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE6, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0x98, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x70, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE1, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0xE0, 0x7F, 0x80, 0x00, 0x78, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x78, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x18, 0x1F, 0xF0, 0x00, 0x0F,
  0xC0, 0x18, 0x7F, 0xFD, 0x80, 0x3F, 0x00, 0x1B, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xE0,
  0x01, 0xC1, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xFE,
  0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFE,
  0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF,
  0x7F, 0xF1, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xFE,
  0x1F, 0x87, 0xFE, 0x00, 0x7F, 0xFE, 0x1C, 0x07, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x08, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0xC3, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x08, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0x81, 0x80, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x30, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0x87, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0x60, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0x8E, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0xE0, 0x00,
  0x0F, 0xFF, 0xBF, 0xFC, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x00, 0x8F, 0xFF, 0x07, 0xC0, 0x0F, 0x00, 0xF1, 0xFF, 0xF0, 0x70, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x04, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x03, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x30, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0x1F, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x27, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x07, 0x3F, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xC7, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x60, 0x7F,
  0xFC, 0x00, 0xFC, 0x00, 0x38, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x0E, 0x00,
  0x7F, 0xFC, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0xFF, 0xC1, 0xFC, 0x01, 0xF0,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xE0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xE0, 0x3F, 0xF9, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x91, 0xFF,
  0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xF3, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xF3, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xEF, 0xFC,
  0x00, 0x1F, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE3, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFC,
  0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x0F, 0x00, 0x0F,
  0xE0, 0x7F, 0xE0, 0x03, 0xC0, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0xF0, 0x00,
  0x3F, 0x80, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xC1, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0x83, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x07,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0xF8, 0x00, 0x1F, 0xC3, 0xFF, 0xC0, 0x1C, 0x00, 0x07, 0xF1,
  0xFF, 0xF8, 0x0E, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0xFE,
  0x21, 0xFF, 0xE1, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0xF8, 0x40, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x0F,
  0xFC, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x87, 0x3F, 0xFF, 0x80, 0x00, 0x3C, 0x30, 0x3F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x10, 0x0F, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x78, 0x00, 0xC7,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0x87, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x71, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0xC0, 0xFF, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x38, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x03, 0xC0,
  0x00, 0x7E, 0x07, 0xFF, 0xFC, 0x03, 0xC0, 0x01, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0x80, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0x00, 0x07, 0xF0, 0xF0,
  0x3F, 0xF8, 0x0F, 0x00, 0x1F, 0xE1, 0x80, 0x3F, 0xF0, 0x1E, 0x00, 0x3F,
  0xC6, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0x7F, 0x8C, 0x00, 0x3F, 0xE0, 0x38,
  0x00, 0xFF, 0x18, 0x00, 0x7F, 0xE0, 0x70, 0x01, 0xFF, 0x20, 0x00, 0xFF,
  0xC0, 0xF0, 0x03, 0xFE, 0x40, 0x00, 0xFF, 0xC1, 0xC0, 0x07, 0xFE, 0x80,
  0x01, 0xFF, 0xE3, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xCF, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFE, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x38,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3F, 0xFC, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xF0, 0x1C, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xF0, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x7F, 0xF1, 0x80, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE6, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x0E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xF0, 0x38, 0x00, 0x1F, 0xF8, 0x19, 0xFF, 0xF0, 0xE0, 0x00, 0x3F, 0xFC,
  0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x07,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xF1, 0xFF, 0x80, 0x00, 0x1F,
  0xC7, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0xF8,
  0x00, 0x07, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x83, 0xFF, 0xC0, 0x00, 0xFC,
  0x07, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xF8,
  0x83, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0x80, 0x3F, 0xFF, 0xC0, 0x0C, 0x00, 0x3F, 0xFF, 0xE1, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x30, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xEC, 0x07, 0xFE, 0x00, 0xFE, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0x81, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x30,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x0C, 0x00, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE1, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x84, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xD8, 0x00, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF3, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x60, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x0C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x70, 0x03, 0xE3, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1C,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0x00, 0x03, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0xC0, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0xC6, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x08,
  0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x7C, 0x00,
  0x1F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0xC0, 0x00, 0x38, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x38, 0xF8,
  0x06, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x06, 0x3F, 0x81, 0x80, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x01, 0x8F, 0xF8, 0x30, 0x01, 0xFF, 0xC3, 0x07,
  0xFF, 0xF0, 0x73, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF1, 0xDF, 0xFF, 0x1C,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x20, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF1, 0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x78, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x1C, 0x07, 0xFE, 0x01, 0xF8,
  0x0F, 0xFF, 0xE3, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x3F, 0xFE, 0xC0, 0x0F,
  0xF8, 0x0F, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x81, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x0C,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x86, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xD8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE3, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x60, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0x80, 0x1C, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0x00, 0x03,
  0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x80,
  0x78, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x00, 0x08, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x38, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x06, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x81, 0xC0, 0x01, 0xFF, 0xE3,
  0x87, 0xFF, 0xF0, 0x70, 0x00, 0x1F, 0xFF, 0xE1, 0x8F, 0xFF, 0x1C, 0x00,
  0x03, 0xFF, 0xF8, 0x20, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF1,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x30, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x06, 0x02, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x1F,
  0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xF0, 0x18, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFC, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x86, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE,
  0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC3, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x0E,
  0x00, 0x30, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x3E, 0x07, 0x83, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x1F, 0xFF,
  0xFF, 0xBF, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF1, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF1, 0x80, 0x00, 0x7C, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x77, 0xFF, 0x80, 0xD0, 0xFF, 0xFF, 0x83, 0x03, 0xFF, 0x06, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x78, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC3, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x30, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x80, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x0E, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x38, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF4, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF3, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x38, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x07, 0x80, 0x02, 0x01, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x18, 0x07,
  0xF7, 0xFF, 0xC0, 0x00, 0x0F, 0xC7, 0x80, 0x1F, 0xC3, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x01,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x06, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x30, 0x00, 0x03, 0xFF, 0x8C, 0x1B, 0xFF, 0xF1, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x83, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0x40, 0x07, 0xFF,
  0xFF, 0xC3, 0xE0, 0x18, 0x07, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0x07, 0xFF,
  0xFF, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xCF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x33, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x06, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xBF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x6F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x0B, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x37, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x19, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x9C,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x6E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF3,
  0x80, 0x00, 0x03, 0x0F, 0xFF, 0xF8, 0xC0, 0x00, 0x03, 0x81, 0xFF, 0xFC,
  0x30, 0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x0C, 0x00, 0x01, 0xF0, 0x03, 0xFE,
  0x03, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x83, 0xBF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0x00, 0x00,
  0x07, 0x7F, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE3, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x7C,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x03, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x03, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x0E, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x0C, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x07, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x0E, 0x7F, 0xC0, 0x40, 0xFF,
  0xFC, 0x3C, 0x7F, 0xE3, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xE3, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x30, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE6,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xC0,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC1, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x38,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x86, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x18, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0x06, 0x07,
  0xC0, 0x07, 0xFC, 0x00, 0x38, 0x01, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xE3, 0xE0, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x07, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0xE3, 0xC6, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x70, 0x3B, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x1F,
  0xFF, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x3C,
  0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0x00, 0x03, 0xFF,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x78, 0x00,
  0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x1F, 0xF8, 0x1C, 0x00, 0x00, 0x1F, 0xF0,
  0xFC, 0x00, 0x07, 0xFE, 0x07, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x00,
  0xFF, 0xE1, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x60,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF0, 0x18, 0x00, 0x00, 0x07,
  0xF1, 0xFF, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xE0,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xC3, 0xFF, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xF0, 0xFF, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x3F,
  0xF8, 0x01, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x0C, 0x00, 0x08, 0x1F, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0x80,
  0x06, 0x07, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x38, 0x07, 0x01, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0x00, 0x60, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x80,
  0x20, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0x20, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFC, 0x7F, 0xFE, 0x0F, 0x80, 0x03,
  0xFE, 0x30, 0xFE, 0x07, 0x80, 0x00, 0xFF, 0x98, 0x1E, 0x07, 0x80, 0x00,
  0x3F, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xEC, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xE1, 0xE7, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xC7, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x7F, 0xE0, 0x00, 0x00, 0x18, 0x01, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0x8F, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xC7, 0xFF,
  0x80, 0x40, 0x3F, 0xF9, 0xC1, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x06, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x02, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x83, 0x8F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE3, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF9, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE3, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF1, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xB0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x18, 0x1F, 0x80,
  0x3F, 0xC0, 0x03, 0x80, 0x38, 0x0F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x06, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x08, 0x3F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xC3, 0xBF, 0xFF, 0x00, 0x00, 0x1C, 0x30, 0x7F, 0xFC, 0x00, 0x01,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x3F, 0x0F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0x7F,
  0xF0, 0x00, 0x31, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xC0, 0x38, 0x1F, 0xFC,
  0x03, 0xC0, 0x3F, 0xC0, 0x3C, 0x00, 0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x1F,
  0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0xCC, 0xFF, 0xE7, 0xFF, 0xC3, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x80, 0x78, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x41, 0xE0, 0x00, 0x06,
  0x3E, 0x00, 0x00, 0x27, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x0F, 0xE0, 0x1C, 0x00, 0xFE,
  0x03, 0xC0, 0x0F, 0xE0, 0x7C, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFF,
  0x00, 0xFE, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0xC0, 0xFE, 0x07, 0xFC, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x07, 0x81, 0xFE,
  0x00, 0xF0, 0x1F, 0xF0, 0x0E, 0x03, 0xFF, 0xC1, 0xC0, 0x7F, 0xFF, 0x38,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0x9F, 0xE0, 0x1C, 0x3F, 0x80, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x3E, 0x07, 0xF8, 0xF8, 0x1F, 0xE7, 0xE0, 0x3F, 0x1F,
  0x00, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x23, 0xFF, 0x80, 0x06, 0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0x80,
  0x7F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xF0, 0x7F, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x7C, 0x1F, 0xC0, 0x03,
  0xC0, 0xFE, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x07, 0x03,
  0xFE, 0x00, 0x78, 0x1F, 0xF8, 0x03, 0x83, 0xFF, 0xF0, 0x18, 0x0F, 0xFF,
  0xE1, 0xC0, 0x0F, 0xFF, 0x9C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0x9F, 0xC0, 0x1C, 0x7F, 0x80, 0xE0, 0xFE, 0x07,
  0x83, 0xFC, 0x3E, 0x07, 0xF0, 0xF8, 0x1F, 0xE7, 0xE0, 0x7F, 0x9F, 0x00,
  0xFE, 0x7C, 0x03, 0xFD, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0x3F, 0x00, 0xE0,
  0xFC, 0x1E, 0x03, 0xFB, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x40, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xE7, 0xF8, 0x03, 0x07, 0xC0, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x19, 0xFF, 0xE0, 0x01,
  0x87, 0xFF, 0xE0, 0x1C, 0x1F, 0xFF, 0x01, 0xC0, 0x7F, 0xF0, 0x1E, 0x00,
  0xFF, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x1C,
  0x0F, 0xC0, 0x01, 0xE0, 0xFE, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0xF8, 0x3F,
  0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x83, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0x01, 0xFF, 0x83,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3C, 0x00, 0xFF, 0x01, 0x80, 0x03, 0xF0,
  0x10, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0x80, 0xFE, 0x00, 0x78, 0x03, 0xF0, 0x03, 0x80,
  0x0F, 0xC0, 0x78, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x80, 0x7C, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x10, 0xFC, 0x00,
  0x00, 0xCF, 0xC0, 0x00, 0x02, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x20, 0x01, 0xFE, 0x07,
  0x80, 0x07, 0xF0, 0x7C, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x1F,
  0xC0, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03,
  0xFC, 0x01, 0xF8, 0x1F, 0xE3, 0x0F, 0x81, 0xFF, 0xB0, 0x7C, 0x1F, 0xFF,
  0x03, 0xC0, 0x3F, 0xF0, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x01, 0xF0, 0x1E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCC, 0xFF, 0x86, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x60, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x6F, 0xF8, 0x06, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xD0, 0x00, 0xFC, 0xC0, 0x07, 0xC3, 0x00, 0x7C, 0x08, 0x03, 0xC0,
  0x20, 0x7C, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x80, 0x7C, 0x06, 0x07, 0xC0, 0x10, 0x7C,
  0x00, 0x47, 0xE0, 0xC3, 0x3E, 0x1E, 0x0F, 0xF1, 0xF0, 0x7F, 0x8F, 0x83,
  0xFC, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x10, 0x1F, 0xF9, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x04, 0x03, 0xC0,
  0x60, 0x78, 0x02, 0x0F, 0x80, 0x31, 0xF8, 0x01, 0xBF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x60, 0xFF, 0xCC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x8F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x87, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF9, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x3F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x10, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0xFC,
  0xDF, 0xFC, 0x3F, 0xF0, 0x8F, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF1, 0x3F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xE0, 0x03, 0xFC,
  0x03, 0xC0, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xF7, 0xFC, 0x03, 0xFC, 0x7F,
  0xC0, 0x1F, 0xC3, 0xFE, 0x01, 0xFC, 0x3F, 0xF0, 0x1F, 0xC1, 0xFF, 0x81,
  0xFC, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC1, 0xFC, 0x07, 0xFC, 0x1F, 0xC0,
  0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07,
  0xE1, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x07, 0xC3, 0xFC, 0x00, 0x78, 0x3F,
  0xE0, 0x0F, 0x03, 0xFF, 0x00, 0xE0, 0xFF, 0xFC, 0x1C, 0x07, 0xFF, 0xE3,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x80, 0x3F, 0xE0, 0x03, 0x00, 0x7F, 0xE0, 0x1F,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFC, 0x07, 0xFC,
  0x01, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x0F, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0xFE,
  0x00, 0x7E, 0x0F, 0xFC, 0x00, 0xF8, 0x3F, 0xF8, 0x01, 0xE0, 0xFF, 0xF8,
  0x07, 0x81, 0xFF, 0xFC, 0x0E, 0x07, 0xFF, 0xFE, 0x38, 0x0E, 0xFF, 0xFF,
  0x60, 0x10, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x07, 0xC2, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0C, 0xFF, 0xE0, 0x01, 0xC7, 0xFF, 0xC0, 0x38,
  0x3F, 0xFF, 0x07, 0x81, 0xFF, 0xC0, 0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x3F,
  0x81, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x3F, 0x83, 0xFE, 0x03, 0xF8,
  0x3F, 0xF0, 0x7F, 0x81, 0xFF, 0xCB, 0xF8, 0x0F, 0xFF, 0x3F, 0x80, 0x7F,
  0xE3, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xE0, 0x1F,
  0x80, 0x0C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x3E,
  0x00, 0xC0, 0x7E, 0x03, 0xC1, 0xFE, 0x0F, 0x87, 0xFE, 0x3F, 0x8F, 0xFC,
  0xFF, 0x3F, 0xFF, 0xFF, 0x47, 0xFF, 0xFE, 0x0F, 0xF9, 0xFC, 0x1F, 0xE3,
  0xF0, 0x1F, 0xC3, 0xC0, 0x3F, 0x87, 0x00, 0x7F, 0x06, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x84, 0x01, 0xFF, 0x90, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x07, 0xC0, 0x0C, 0x01, 0xFE, 0x03, 0x80, 0x7F, 0xF0, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0C, 0x7F, 0xFF, 0x83, 0x07, 0xFF, 0xE0, 0xE0, 0x3F,
  0xF8, 0x38, 0x01, 0xFE, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x40, 0x3E,
  0x00, 0x18, 0x07, 0xE0, 0x07, 0x00, 0xFE, 0x01, 0xE0, 0x1F, 0xE0, 0x7E,
  0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE7, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x7E, 0x07, 0xFC, 0x07, 0x80, 0x7F,
  0x80, 0xE0, 0x07, 0xF0, 0x18, 0x00, 0x7E, 0x06, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xE0, 0x7F, 0x00, 0x1C, 0x1F, 0xF8, 0x07, 0x07, 0xFF, 0xE0, 0xC0,
  0xFF, 0xFF, 0x70, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x41, 0xFF, 0x10,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF8, 0x8F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE1, 0x0F, 0xFC, 0x3F, 0xF3, 0x3F,
  0xFE, 0xEF, 0xFE, 0x1F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x18, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0x7F,
  0x81, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF, 0xE0, 0x7F, 0xEC, 0x1F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x1F,
  0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xC0, 0x01,
  0xFE, 0x03, 0x80, 0x03, 0xFF, 0x87, 0x00, 0x03, 0xFF, 0xE6, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x08, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x10, 0x1F, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xC0, 0x1F, 0x00,
  0x1E, 0x07, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC,
  0x07, 0xFB, 0x8F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x38, 0x01, 0xFE,
  0x07, 0xFF, 0x83, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0x30, 0x01, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0xF8,
  0x03, 0x00, 0x3F, 0x01, 0xE0, 0x1F, 0xE0, 0xF8, 0x07, 0xFC, 0x7F, 0x03,
  0xFF, 0x1F, 0xC0, 0xFF, 0xEF, 0xF8, 0x4F, 0xFF, 0xFE, 0x11, 0xFF, 0x3F,
  0x80, 0x7F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF0, 0x03, 0xF8, 0x78, 0x00, 0xFE,
  0x0C, 0x00, 0x3F, 0x82, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x7F, 0xE4, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xE0, 0xFC, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x07, 0x00, 0x3F,
  0x00, 0xF0, 0x1F, 0xC0, 0x0F, 0xBF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x3F,
  0xC0, 0x03, 0x00, 0x7F, 0xE0, 0x0E, 0x00, 0xFF, 0xE0, 0x3E, 0x01, 0xFF,
  0xC1, 0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xBF, 0xFC, 0x01, 0xFF,
  0x87, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0xC0, 0x0F, 0x80, 0x7F, 0x8C, 0x1F, 0x01, 0xFF, 0xF0, 0x3C, 0x07,
  0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x01, 0xE0, 0x01, 0xFC, 0x07, 0x80, 0x01,
  0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x30, 0x30, 0x0E, 0x07, 0x81, 0x81, 0xFF, 0x60, 0x3F, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x37, 0xFC, 0x06,
  0x3F, 0xE0, 0xC1, 0xFE, 0x1C, 0x1F, 0xE1, 0x80, 0xFE, 0x38, 0x0F, 0xF3,
  0x00, 0xFF, 0x70, 0x07, 0xF7, 0x00, 0x7F, 0x60, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xEE, 0x00, 0x3E, 0xE0, 0x03,
  0xEE, 0x00, 0x7C, 0xE0, 0x07, 0xC6, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00,
  0x70, 0x30, 0x0E, 0x01, 0x81, 0xC0, 0x0E, 0x38, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 13, 52, 17, 2, -51 },
  { 86, 24, 20, 29, 2, -51 },
  { 146, 32, 40, 37, 2, -45 },
  { 306, 25, 57, 30, 2, -54 },
  { 485, 47, 49, 51, 2, -50 },
  { 773, 37, 45, 41, 2, -44 },
  { 982, 11, 20, 14, 1, -51 },
  { 1010, 16, 58, 18, 1, -56 },
  { 1126, 16, 58, 18, 1, -56 },
  { 1242, 24, 28, 25, 0, -53 },
  { 1326, 23, 25, 28, 3, -36 },
  { 1398, 12, 20, 13, 0, -11 },
  { 1428, 20, 14, 21, 2, -28 },
  { 1463, 12, 12, 14, 1, -11 },
  { 1481, 34, 56, 37, 2, -53 },
  { 1719, 31, 51, 33, 1, -50 },
  { 1917, 21, 49, 23, 1, -49 },
  { 2046, 30, 48, 32, 1, -48 },
  { 2226, 31, 49, 33, 1, -49 },
  { 2416, 31, 48, 32, 1, -48 },
  { 2602, 31, 49, 33, 1, -49 },
  { 2792, 30, 51, 32, 1, -50 },
  { 2984, 29, 48, 31, 1, -48 },
  { 3158, 31, 50, 33, 1, -50 },
  { 3352, 30, 50, 32, 1, -50 },
  { 3540, 12, 35, 14, 1, -34 },
  { 3593, 13, 43, 12, 0, -34 },
  { 3663, 20, 26, 20, 0, -33 },
  { 3728, 24, 15, 27, 2, -29 },
  { 3773, 20, 26, 20, 0, -33 },
  { 3838, 27, 52, 32, 2, -51 },
  { 4014, 42, 42, 43, 1, -33 },
  { 4235, 54, 53, 58, 2, -51 },
  { 4593, 62, 53, 63, 0, -52 },
  { 5004, 45, 53, 49, 2, -52 },
  { 5303, 54, 55, 58, 2, -52 },
  { 5675, 47, 53, 50, 2, -52 },
  { 5987, 51, 61, 54, 1, -52 },
  { 6376, 51, 53, 55, 2, -51 },
  { 6714, 50, 65, 52, 1, -55 },
  { 7121, 46, 61, 49, 1, -52 },
  { 7472, 48, 70, 50, 1, -52 },
  { 7892, 55, 53, 58, 1, -51 },
  { 8257, 38, 51, 41, 1, -50 },
  { 8500, 75, 54, 79, 2, -50 },
  { 9007, 59, 51, 63, 2, -50 },
  { 9384, 50, 53, 54, 2, -51 },
  { 9716, 61, 62, 63, 1, -50 },
  { 10189, 54, 56, 57, 1, -51 },
  { 10567, 62, 52, 66, 2, -51 },
  { 10970, 50, 52, 54, 2, -51 },
  { 11295, 50, 52, 53, 2, -51 },
  { 11620, 48, 54, 51, 1, -50 },
  { 11944, 59, 54, 63, 2, -52 },
  { 12343, 74, 52, 77, 1, -51 },
  { 12824, 49, 53, 51, 1, -52 },
  { 13149, 57, 63, 61, 2, -52 },
  { 13598, 45, 61, 47, 1, -52 },
  { 13942, 10, 55, 13, 1, -52 },
  { 14011, 43, 49, 8, -13, -46 },
  { 14275, 10, 55, 13, 1, -52 },
  { 14344, 27, 19, 30, 1, -50 },
  { 14409, 34, 5, 32, -1, 8 },
  { 14431, 10, 13, 36, 12, -50 },
  { 14448, 29, 38, 33, 2, -36 },
  { 14586, 28, 51, 32, 2, -49 },
  { 14765, 22, 38, 25, 2, -36 },
  { 14870, 29, 50, 32, 2, -49 },
  { 15052, 22, 37, 26, 2, -36 },
  { 15154, 22, 64, 17, -1, -52 },
  { 15330, 29, 52, 33, 2, -37 },
  { 15519, 29, 62, 31, 1, -50 },
  { 15744, 17, 50, 19, 1, -49 },
  { 15851, 21, 63, 17, -4, -50 },
  { 16017, 21, 52, 23, 1, -50 },
  { 16154, 20, 52, 19, 1, -50 },
  { 16284, 47, 38, 50, 2, -37 },
  { 16508, 32, 38, 36, 2, -36 },
  { 16660, 28, 37, 29, 0, -36 },
  { 16790, 31, 56, 32, 0, -42 },
  { 17007, 28, 52, 31, 1, -37 },
  { 17189, 23, 38, 26, 1, -37 },
  { 17299, 27, 45, 30, 1, -44 },
  { 17451, 19, 47, 22, 1, -45 },
  { 17563, 32, 38, 36, 2, -37 },
  { 17715, 32, 41, 32, -1, -40 },
  { 17879, 45, 44, 49, 2, -42 },
  { 18127, 26, 52, 28, 1, -37 },
  { 18296, 31, 55, 33, 1, -43 },
  { 18510, 20, 50, 24, 2, -37 },
  { 18635, 19, 57, 24, 1, -55 },
  { 18771, 5, 58, 11, 3, -55 },
  { 18808, 19, 57, 24, 1, -55 },
  { 18944, 22, 5, 26, 2, -24 },
};

const GFXfont UnifrakturMaguntia_Regular71pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular71pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular71pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR71PT7B_H_
