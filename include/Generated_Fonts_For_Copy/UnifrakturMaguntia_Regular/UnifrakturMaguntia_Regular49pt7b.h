#ifndef _UNIFRAKTURMAGUNTIA_REGULAR49PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x0E, 0x0F, 0x8F, 0xEF, 0xFB, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xE0, 0xF8,
  0xFE, 0x3E, 0x8E, 0x02, 0x00, 0x00, 0x10, 0x04, 0x0C, 0x06, 0x0F, 0x03,
  0x8F, 0xC7, 0xEF, 0xF3, 0xF9, 0xF8, 0x7C, 0x7C, 0x1E, 0x1C, 0x0E, 0x0E,
  0x07, 0x06, 0x01, 0x03, 0x01, 0x81, 0x00, 0x81, 0x00, 0x40, 0x00, 0x40,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0x80, 0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF0, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x0F, 0x00, 0x3C, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x7F, 0xC0, 0x78, 0x70, 0x70, 0x18, 0x78, 0x0E, 0x38, 0x07,
  0x9C, 0x03, 0xCE, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x79, 0xF8, 0x18, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFD, 0xC0, 0x7E, 0xF0, 0x1F, 0x78, 0x07, 0xFC, 0x03,
  0xDC, 0x00, 0xEE, 0x00, 0x73, 0x00, 0x79, 0x80, 0x38, 0x70, 0x38, 0x1E,
  0x78, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x00, 0x02, 0x0F, 0xF0, 0x00, 0x01, 0x87, 0x3C,
  0x00, 0x01, 0x87, 0x8F, 0x00, 0x01, 0x87, 0x87, 0x80, 0x01, 0xC3, 0xC3,
  0xC0, 0x01, 0xC1, 0xE1, 0xF0, 0x01, 0xC1, 0xF0, 0xF8, 0x00, 0xC0, 0xF8,
  0x7C, 0x00, 0xC0, 0x7C, 0x3E, 0x00, 0xC0, 0x3E, 0x1F, 0x00, 0xC0, 0x1F,
  0x0F, 0x80, 0xC0, 0x07, 0x87, 0xC0, 0xE0, 0x03, 0xC3, 0xC0, 0xE0, 0x01,
  0xE1, 0xE0, 0x60, 0x00, 0x78, 0xF0, 0x60, 0x00, 0x1C, 0xF0, 0x60, 0x00,
  0x0F, 0xF0, 0x60, 0xF8, 0x01, 0xF0, 0x60, 0xFE, 0x00, 0x00, 0x70, 0xE3,
  0x80, 0x00, 0x70, 0xF1, 0xE0, 0x00, 0x70, 0x78, 0x78, 0x00, 0x30, 0x7C,
  0x3C, 0x00, 0x30, 0x3E, 0x1E, 0x00, 0x30, 0x1F, 0x0F, 0x00, 0x30, 0x0F,
  0x87, 0xC0, 0x30, 0x07, 0xC3, 0xE0, 0x38, 0x03, 0xE1, 0xE0, 0x38, 0x01,
  0xF0, 0xF0, 0x18, 0x00, 0xF8, 0x78, 0x18, 0x00, 0x3C, 0x3C, 0x18, 0x00,
  0x1E, 0x3C, 0x18, 0x00, 0x07, 0x1C, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1F, 0x0E,
  0x00, 0x0F, 0x87, 0x00, 0x07, 0xC7, 0x00, 0x03, 0xF7, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF0, 0x3F,
  0xE0, 0x70, 0x3B, 0xF0, 0x38, 0x38, 0xFC, 0x18, 0x3C, 0x7E, 0x0C, 0x3C,
  0x3F, 0x86, 0x1E, 0x0F, 0xC2, 0x0F, 0x07, 0xF3, 0x07, 0xC1, 0xFF, 0x03,
  0xE0, 0xFF, 0x81, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE1, 0x7E, 0x07, 0xF8,
  0xDF, 0x81, 0xFF, 0xCF, 0xE1, 0xFF, 0xC3, 0xFF, 0x9F, 0xC0, 0x7F, 0x07,
  0xC0, 0x10, 0x18, 0x3C, 0x7E, 0xFF, 0x3E, 0x1E, 0x0E, 0x0C, 0x0C, 0x08,
  0x18, 0x10, 0x00, 0x00, 0x40, 0x30, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0xF0, 0x03,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x1B, 0xE8, 0xF9, 0xCF, 0x79, 0x9F, 0x7C, 0xBE, 0x7E, 0xFE, 0x43, 0xE2,
  0x43, 0xC2, 0x7E, 0xFE, 0x7C, 0xBE, 0x79, 0x9F, 0xF9, 0xDF, 0x1B, 0xE8,
  0x07, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x08, 0x1C, 0x3E,
  0x7F, 0x3F, 0x1F, 0x0E, 0x0E, 0x0C, 0x0C, 0x08, 0x08, 0x10, 0x03, 0xFC,
  0x7F, 0xE1, 0xFF, 0x8F, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xFE, 0x1F, 0xF8,
  0xFE, 0x00, 0x00, 0x10, 0x38, 0x7C, 0xFF, 0x7C, 0x38, 0x10, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x01, 0xE0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80,
  0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x1F,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x8F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3C, 0x1F, 0xE7, 0x00, 0xFE, 0x60,
  0x07, 0xF6, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x10, 0x18, 0x01, 0x03, 0x00, 0x10, 0x60,
  0x01, 0x04, 0x00, 0x30, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x06, 0x0F, 0xF0, 0x60, 0x1F, 0xC6, 0x00, 0x7E, 0x20, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFB, 0x80, 0x0F, 0xFE, 0x00, 0x3D, 0xF8, 0x03, 0xEF, 0xC0, 0x1E, 0x7E,
  0x00, 0xF1, 0xF0, 0x07, 0x0F, 0x80, 0x70, 0x1E, 0x06, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x05, 0xF0, 0x00, 0x37, 0xC0, 0x00,
  0x9F, 0x00, 0x04, 0x7C, 0x00, 0x31, 0xF0, 0x00, 0x87, 0xC0, 0x04, 0x1F,
  0x00, 0x30, 0x7C, 0x00, 0x81, 0xF0, 0x04, 0x07, 0xC0, 0x30, 0x1F, 0x00,
  0x80, 0x7C, 0x06, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x18, 0x00, 0x40, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x23, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x7F, 0x8C, 0x00, 0xFC, 0x40, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xDC, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x0F,
  0x7E, 0x00, 0x73, 0xF0, 0x07, 0x0F, 0x80, 0x38, 0x3C, 0x03, 0x00, 0xF0,
  0x30, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x18, 0xF8, 0x07, 0x07, 0xC0,
  0x70, 0x3E, 0x0E, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x01, 0xC7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x3E,
  0x07, 0xC7, 0xF8, 0xFC, 0xFF, 0xCF, 0xD8, 0x7E, 0xFD, 0x03, 0xEF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xE7,
  0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x1E, 0x03, 0x80, 0xF0, 0x70,
  0x07, 0x86, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xC8, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x70,
  0x70, 0x01, 0x83, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00,
  0x1C, 0x7C, 0x00, 0xE3, 0xF0, 0x07, 0x1F, 0xC0, 0x70, 0x7F, 0x87, 0x03,
  0xFF, 0x70, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x77, 0xFE, 0x07, 0x0F, 0xF8, 0x70, 0x3F, 0xC7, 0x00, 0x7F, 0x38,
  0x01, 0xFB, 0xC0, 0x07, 0xDC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x38, 0x00, 0x70, 0xE0,
  0x07, 0x07, 0x80, 0x70, 0x0E, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x71, 0xE0, 0x0E, 0x0F, 0x01, 0xC0, 0x78, 0x1C, 0x07, 0xC3, 0xC0,
  0x7C, 0x7C, 0x07, 0xE7, 0x80, 0x7E, 0x78, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xF7, 0xE0, 0xFF, 0x7E, 0x0B, 0xF3, 0xFB, 0xBF,
  0x1F, 0xF3, 0xF0, 0xFE, 0x3F, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x38, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0,
  0x78, 0x7E, 0x07, 0x03, 0xE0, 0x70, 0x3E, 0x0E, 0x01, 0xF1, 0xC0, 0x07,
  0xF0, 0x00, 0x10, 0x38, 0x3C, 0xFE, 0x7F, 0x38, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x38, 0x7C, 0xFF, 0x7C, 0x38,
  0x10, 0x00, 0x08, 0x0E, 0x07, 0x8F, 0xE3, 0xF8, 0xE0, 0x30, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0E, 0x0F, 0x8F,
  0xE3, 0xF0, 0xF8, 0x38, 0x1C, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00, 0x07,
  0xF8, 0x0F, 0x07, 0x87, 0x00, 0xF3, 0x80, 0x1E, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDE, 0x03, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x02, 0x07, 0x00,
  0x81, 0xE0, 0x60, 0x1C, 0x30, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x7F, 0xCE,
  0x78, 0x1F, 0xF8, 0xE7, 0x83, 0xCF, 0x8E, 0x70, 0x78, 0xF8, 0xEF, 0x0F,
  0x8F, 0x8E, 0xF0, 0xF0, 0xF0, 0xEE, 0x1F, 0x0F, 0x0E, 0xE1, 0xE0, 0xF0,
  0xEE, 0x3E, 0x1E, 0x1C, 0xE3, 0xC1, 0xE1, 0xCE, 0x3C, 0x3E, 0x38, 0xE3,
  0xC7, 0xE7, 0x8E, 0x3C, 0xFC, 0xF0, 0x71, 0xFF, 0xFE, 0x77, 0x0F, 0x1F,
  0x87, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x0F, 0xFF,
  0x00, 0x01, 0xC0, 0x7F, 0xFE, 0x00, 0x1E, 0x03, 0xFF, 0xFC, 0x01, 0xF0,
  0x18, 0x0F, 0xF8, 0x1F, 0xC0, 0xC0, 0x1F, 0xF1, 0xFE, 0x06, 0x00, 0x3F,
  0xC3, 0xF8, 0x10, 0x00, 0x7F, 0x87, 0xE0, 0xC0, 0x00, 0xFE, 0x1F, 0x83,
  0x00, 0x03, 0xF8, 0x7E, 0x0C, 0x00, 0x07, 0xE1, 0xF8, 0x30, 0x00, 0x1F,
  0x87, 0xE0, 0xE0, 0x00, 0x7E, 0x1F, 0x83, 0xC0, 0x01, 0xF8, 0x7E, 0x07,
  0xF0, 0x07, 0xE1, 0xF8, 0x1F, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0xE0, 0x7C,
  0x1F, 0x80, 0x7F, 0x81, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0x01, 0xF8, 0x00,
  0x78, 0x38, 0x07, 0xE0, 0x00, 0xE1, 0xC0, 0x1F, 0x80, 0x03, 0x07, 0x00,
  0x7E, 0x00, 0x08, 0x30, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x07, 0xE0, 0x00,
  0x0C, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x0F,
  0xFF, 0x81, 0xFF, 0x00, 0x43, 0xFF, 0x0D, 0xFF, 0xC0, 0x07, 0xFF, 0xE7,
  0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xCC, 0x3F, 0x80, 0x3F,
  0xFF, 0xF9, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x7F, 0x01, 0xC0, 0x07,
  0xF8, 0x07, 0xE0, 0x70, 0x00, 0x7F, 0x00, 0xFE, 0x0E, 0x00, 0x07, 0xE0,
  0x1F, 0xC1, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x30, 0x00, 0x0F, 0x80, 0x3F,
  0xC6, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0xC0, 0x00, 0x3E, 0x00, 0x70, 0x18,
  0x00, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x00, 0xF8, 0x1F, 0xC0, 0x30, 0x00,
  0x1F, 0x0F, 0xFE, 0x07, 0x00, 0x43, 0xC7, 0xFF, 0xE0, 0x70, 0x18, 0x71,
  0xFF, 0xFE, 0x03, 0xFC, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x01, 0x1F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0x9E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x03, 0x80, 0x01,
  0xE1, 0x87, 0xE0, 0x03, 0xC0, 0xCF, 0xFF, 0x07, 0x80, 0x5F, 0xFE, 0x0F,
  0x00, 0x7F, 0xFC, 0x1F, 0x00, 0xC1, 0xF0, 0x1E, 0x03, 0x80, 0x60, 0x3E,
  0x07, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x7E,
  0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xF0, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x7E,
  0x07, 0xFC, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x1F,
  0xE0, 0x1E, 0x00, 0x1F, 0xE0, 0x1C, 0x00, 0x0F, 0xF0, 0x30, 0x00, 0x07,
  0xFC, 0x60, 0x00, 0x03, 0xFE, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x02, 0x01,
  0xFF, 0xF0, 0x1E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x10, 0xFF, 0xE0, 0x3C, 0x01, 0xC0,
  0xFF, 0xC1, 0xE0, 0x0E, 0x00, 0xFF, 0x07, 0x00, 0x70, 0x01, 0xFE, 0x38,
  0x03, 0xE0, 0x03, 0xF8, 0xE0, 0x0F, 0x80, 0x07, 0xF3, 0x00, 0x7F, 0x00,
  0x0F, 0xCC, 0x01, 0xFE, 0x00, 0x1F, 0xB0, 0x03, 0xFC, 0x00, 0x3E, 0xC0,
  0x0F, 0xF8, 0x00, 0xF9, 0x00, 0x1F, 0xF0, 0x01, 0xE4, 0x00, 0x3F, 0xE0,
  0x07, 0x98, 0x00, 0x7F, 0x80, 0x0E, 0x30, 0x00, 0xFE, 0x00, 0x38, 0x60,
  0x01, 0xF8, 0x00, 0xE0, 0xE0, 0x83, 0xE0, 0x03, 0x80, 0xFE, 0x0F, 0x80,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x18, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x00,
  0x60, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x08, 0x01, 0xFF,
  0xFF, 0x00, 0x40, 0x1C, 0x3F, 0xFF, 0x8E, 0x00, 0x40, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7F, 0x81, 0xC0, 0x00, 0x78, 0x21, 0xF8, 0x00, 0x70, 0x09, 0xFF,
  0xE0, 0x78, 0x07, 0xFF, 0xE0, 0x78, 0x03, 0xFF, 0xE0, 0x7C, 0x03, 0x07,
  0xC0, 0x3C, 0x07, 0x00, 0x40, 0x3E, 0x07, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x03, 0xF1, 0xFE, 0x0F, 0x81, 0xF8, 0x7F, 0x8F, 0xE4, 0xFC, 0x3F,
  0xEF, 0xFE, 0x7E, 0x0F, 0xFF, 0xFE, 0x3F, 0x03, 0xFE, 0x7F, 0x1F, 0x80,
  0xFF, 0x8F, 0x0F, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0xF8, 0x07, 0x80, 0x03,
  0xFC, 0x03, 0x80, 0x00, 0xFF, 0x03, 0x00, 0x00, 0x3F, 0xE3, 0x00, 0x00,
  0x0F, 0xFA, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x04, 0x01, 0xFF, 0xF0, 0x1E,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF1,
  0xF0, 0x00, 0x7F, 0xF8, 0x38, 0x00, 0x13, 0xFE, 0x0E, 0x00, 0x06, 0x1F,
  0x81, 0xC0, 0x01, 0x81, 0xC0, 0x30, 0x00, 0x78, 0x00, 0x06, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x7F, 0x01, 0xC2, 0x00,
  0x0F, 0xE0, 0x3C, 0x60, 0x01, 0xFE, 0x0F, 0xCC, 0x00, 0x1F, 0xE3, 0xFD,
  0x80, 0x03, 0xFE, 0xFF, 0x18, 0x00, 0x3F, 0xFF, 0xC1, 0x80, 0x03, 0xFC,
  0x78, 0x18, 0x04, 0x7F, 0xC6, 0x01, 0xE7, 0xC7, 0xF8, 0x00, 0x07, 0x80,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x60, 0x00, 0x1E, 0x08, 0x1C, 0x00, 0x07, 0x80, 0x8F, 0xC0, 0x01, 0xE0,
  0x0B, 0xFC, 0x00, 0x78, 0x01, 0xBF, 0xC0, 0x1E, 0x00, 0x63, 0xFE, 0x07,
  0xC0, 0x30, 0x3F, 0xE0, 0xF8, 0x0C, 0x03, 0xFE, 0x3E, 0x07, 0x80, 0x3F,
  0x87, 0xC1, 0xE0, 0x01, 0xC0, 0xF8, 0x7C, 0x00, 0x30, 0x3F, 0x0F, 0xC0,
  0x18, 0x07, 0xE1, 0xF8, 0x07, 0x00, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0x87,
  0xF0, 0xFF, 0xC3, 0xF0, 0x7F, 0x3F, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0xDF,
  0xC0, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xF0, 0x3F, 0x7F, 0x01, 0xFE, 0x07,
  0xF7, 0xE0, 0x1F, 0xE0, 0x7E, 0xFE, 0x01, 0xFC, 0x0F, 0xDF, 0xC0, 0x1F,
  0x80, 0xFB, 0xF8, 0x03, 0xF0, 0x1F, 0x3F, 0x80, 0x3E, 0x03, 0xE7, 0xF0,
  0x07, 0x80, 0x7C, 0x7E, 0x00, 0xE0, 0x0F, 0x0F, 0xE0, 0x38, 0x03, 0xE0,
  0xFE, 0x0E, 0x00, 0x78, 0x0F, 0xC1, 0x00, 0x0F, 0x00, 0xFC, 0x40, 0x03,
  0xC0, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0x9F, 0xE0, 0x00, 0x01, 0x83, 0xFF, 0x00, 0x00, 0xC0, 0x7F,
  0x80, 0x00, 0x70, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x00,
  0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF1, 0xE0, 0x1E, 0x00, 0xF8, 0xFE,
  0x07, 0x00, 0x3E, 0x7F, 0xC1, 0x80, 0x0F, 0xBF, 0xF8, 0x40, 0x03, 0xC1,
  0xFF, 0x60, 0x01, 0xF0, 0x3F, 0xF0, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xF8, 0x3F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x07, 0x00,
  0x0F, 0xFF, 0x1C, 0x00, 0x0F, 0xFC, 0x38, 0x00, 0x0F, 0xE0, 0x70, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x0F,
  0xC0, 0x1C, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x7F,
  0x00, 0x0F, 0xBE, 0xFF, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x00, 0x1F, 0x0F,
  0xF0, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x3C, 0xFF, 0xF8, 0x00, 0x72, 0x1F,
  0xF8, 0x00, 0xE0, 0x1F, 0xF8, 0x03, 0x80, 0x1F, 0xF8, 0x06, 0x00, 0x1F,
  0xF8, 0x38, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x3F, 0xF8, 0x00, 0xF0,
  0x07, 0xFE, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x70, 0x00, 0x3F, 0xF0, 0x30,
  0x00, 0x0F, 0xE0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x7C, 0x00,
  0xC0, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x1F, 0x80,
  0x06, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x23, 0xF0, 0x00, 0x3C, 0xF9, 0xFC,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x01, 0xE0, 0x7F,
  0x00, 0x00, 0xE0, 0xFF, 0xC0, 0x00, 0x70, 0xFF, 0xF8, 0x00, 0x30, 0xC7,
  0xFE, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x7F, 0xE0, 0x18, 0x00,
  0x1F, 0xF8, 0x18, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x83, 0xFC,
  0x06, 0x00, 0x3C, 0x1F, 0xF8, 0x1C, 0x00, 0xF0, 0xFF, 0xF0, 0x30, 0x07,
  0xC7, 0x1F, 0xE0, 0xE0, 0x1F, 0x10, 0x3F, 0xC3, 0x80, 0xFC, 0xC0, 0x7F,
  0x06, 0x03, 0xF2, 0x00, 0xFE, 0x18, 0x0F, 0xE8, 0x03, 0xF8, 0x60, 0x1F,
  0xA0, 0x07, 0xF9, 0x80, 0x7F, 0x80, 0x1F, 0xCE, 0x01, 0xFE, 0x00, 0x3E,
  0x38, 0x03, 0xFC, 0x00, 0x60, 0xC0, 0x0F, 0xF0, 0x06, 0x06, 0x00, 0x1F,
  0xE0, 0x78, 0x30, 0x00, 0x7F, 0xC3, 0xF1, 0x80, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0x80, 0x78, 0x1F, 0xC0, 0x1F, 0x81, 0xC0, 0x3F, 0x01, 0xFF, 0x07,
  0x00, 0xFE, 0x0F, 0xFC, 0x18, 0x03, 0xFC, 0x27, 0xFC, 0xC0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE3, 0xF0, 0x00, 0x78, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xCF, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0x7C, 0xFF, 0x00, 0x1E, 0x3F, 0xC0,
  0x0F, 0x87, 0xF8, 0x03, 0xC1, 0xFE, 0x01, 0xF0, 0x3F, 0xDF, 0xF8, 0x07,
  0xF1, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x02, 0xFF, 0xFE, 0x00, 0xC1, 0xFF, 0xC0, 0x60, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xFF, 0x7F,
  0xFD, 0x87, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0x03, 0x80, 0x7F,
  0xC0, 0xFE, 0x03, 0xF0, 0x60, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x84, 0x00,
  0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x88,
  0x00, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x1F,
  0xE8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x0F, 0x8C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x60, 0x60, 0x00, 0x1F, 0x80,
  0xF8, 0x0C, 0x07, 0x0F, 0x01, 0xF8, 0x0F, 0x81, 0x80, 0x3F, 0xF8, 0x0F,
  0x00, 0xF8, 0x38, 0x01, 0xFF, 0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x0F, 0xFC,
  0x0F, 0x00, 0xF0, 0x70, 0x00, 0x20, 0xC0, 0xF0, 0x0F, 0x0F, 0x00, 0x00,
  0x0C, 0x0F, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x3F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x0C,
  0x3F, 0x80, 0x00, 0xC0, 0x18, 0x01, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0x3C,
  0x18, 0x1F, 0xC0, 0x0F, 0xF8, 0x27, 0xE1, 0x01, 0xFE, 0x21, 0xFF, 0xC6,
  0xFF, 0xA0, 0x0F, 0xFF, 0x33, 0xFE, 0xDF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF9, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x23, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0x0C, 0x7F, 0x01, 0xF1, 0xFF, 0xCC, 0x1F, 0xC1, 0xC0, 0x1F, 0xF4,
  0x07, 0xE0, 0xC0, 0x07, 0xFC, 0x03, 0xF8, 0x40, 0x01, 0xFE, 0x01, 0xFC,
  0x60, 0x00, 0x7F, 0x00, 0x7E, 0x20, 0x00, 0x1F, 0xC0, 0x3F, 0x90, 0x00,
  0x07, 0xE0, 0x1F, 0xEC, 0x00, 0x03, 0xF0, 0x07, 0xEE, 0x00, 0x00, 0xF8,
  0x01, 0xC1, 0x00, 0x00, 0x7E, 0x00, 0xC0, 0xC0, 0x00, 0x3F, 0x00, 0xC0,
  0x73, 0xF0, 0x1F, 0x80, 0xC0, 0x1F, 0xFC, 0x07, 0xC0, 0xE0, 0x07, 0xFF,
  0x03, 0xC0, 0xE0, 0x01, 0xFF, 0x81, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0xF0,
  0x78, 0x00, 0x00, 0x20, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x00,
  0x00, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x00,
  0x0E, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x3C, 0x03, 0x01,
  0xF8, 0x00, 0x7F, 0x03, 0x00, 0xFE, 0x00, 0x7F, 0xC1, 0x80, 0x3F, 0x84,
  0x7F, 0xF1, 0x80, 0x1F, 0xFC, 0x67, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x1F,
  0xFE, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x1C, 0x00, 0x07, 0xFE, 0x07, 0x80,
  0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0xC7,
  0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03,
  0xF3, 0xFE, 0x00, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0x07, 0xC7, 0xFF, 0x80,
  0x00, 0x78, 0x7F, 0xF8, 0x00, 0x0F, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x3F,
  0xF0, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x71, 0x00, 0x00,
  0x60, 0x3F, 0x80, 0x00, 0x0C, 0x0F, 0xF8, 0x00, 0x03, 0x07, 0xFF, 0xC0,
  0x00, 0x41, 0xFF, 0xFC, 0x00, 0x18, 0x01, 0xFF, 0xE0, 0x06, 0x00, 0x0F,
  0xFF, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0x00, 0x1F,
  0x07, 0xFC, 0xFF, 0xC0, 0x07, 0x00, 0x7F, 0xE7, 0xF8, 0x03, 0x80, 0x0F,
  0xF1, 0xFF, 0x00, 0xC0, 0x01, 0xFC, 0x3F, 0xE0, 0x30, 0x00, 0x7F, 0x0F,
  0xFC, 0x08, 0x00, 0x0F, 0xC1, 0xFF, 0x82, 0x00, 0x03, 0xF0, 0x3F, 0xF0,
  0x80, 0x00, 0xFC, 0x07, 0xFE, 0x30, 0x00, 0x3F, 0x00, 0xFF, 0xCC, 0x00,
  0x0F, 0xC0, 0x0F, 0xF1, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x20, 0x00, 0x7C,
  0x00, 0x3F, 0x86, 0x03, 0x1F, 0x00, 0x07, 0xE0, 0xFF, 0x87, 0xC0, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x00, 0x0F, 0xF0, 0x00, 0x10,
  0x00, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x02, 0x00, 0x01,
  0xFF, 0xFF, 0x03, 0x00, 0x00, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x9F, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0E,
  0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x1C, 0x00, 0x07, 0xFE,
  0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0xF8, 0x00,
  0x07, 0xC1, 0xFF, 0xE0, 0x00, 0x1E, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x1F,
  0xFE, 0x00, 0x07, 0x80, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x1C, 0x40, 0x07, 0x18, 0x03, 0xF8, 0x00, 0x7C, 0xC0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x6F, 0xFF, 0x0C,
  0x7F, 0x0C, 0x1F, 0xFE, 0x01, 0xFE, 0xC0, 0x3F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xDF, 0xE0, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x03, 0xFF, 0x81,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0xC3, 0xF8, 0x03, 0xFF, 0xFF, 0xC8, 0x1F, 0xC0,
  0x3C, 0x07, 0xFD, 0x81, 0xFE, 0x07, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x60,
  0x00, 0xFF, 0x00, 0xFE, 0x0E, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0xC0, 0x00,
  0x3F, 0x00, 0x7F, 0xCC, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0xC0, 0x00, 0x1F,
  0x80, 0x1F, 0x0C, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0xC0, 0x00, 0x0F, 0x80,
  0x30, 0x06, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x60, 0x00, 0x0F, 0x81, 0x80,
  0x07, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x38, 0x00, 0x07, 0x8F, 0xC0, 0x01,
  0xC0, 0x60, 0x7B, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0x8F, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0xC0, 0x1F,
  0xC0, 0x03, 0xF8, 0x18, 0x01, 0xFC, 0x00, 0x7F, 0xC1, 0x80, 0x1F, 0xE0,
  0x0F, 0xFE, 0x30, 0x00, 0xFF, 0x20, 0x9F, 0xF6, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x02, 0x00, 0x0F,
  0xFF, 0xF0, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x81, 0xFF, 0xFC, 0x00,
  0xC0, 0x07, 0xFF, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x0C, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x1C, 0x00,
  0x07, 0xFF, 0x83, 0x82, 0x03, 0xFF, 0xF8, 0xF0, 0x21, 0xFF, 0xFF, 0x9E,
  0x03, 0xFF, 0xF8, 0x33, 0xC0, 0x7F, 0xFC, 0x03, 0x7C, 0x07, 0xFE, 0x00,
  0x2F, 0x80, 0x7F, 0x80, 0x04, 0xF0, 0x03, 0x80, 0x00, 0xDF, 0x00, 0x00,
  0x00, 0x1B, 0xF0, 0x00, 0x00, 0x03, 0x7F, 0x00, 0x00, 0x00, 0x47, 0xF0,
  0x00, 0x00, 0x18, 0xFF, 0x00, 0x00, 0x07, 0x0F, 0xF8, 0x00, 0x01, 0xC1,
  0xFF, 0xC0, 0x00, 0xF0, 0x1F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x7F, 0xFC, 0x00, 0x70, 0x01, 0xFF,
  0xE0, 0x1C, 0x00, 0x0F, 0xFE, 0x13, 0x00, 0x02, 0xFF, 0xFF, 0xC0, 0x00,
  0xC7, 0xFF, 0x98, 0x00, 0x70, 0x3F, 0xE3, 0x00, 0x1E, 0x03, 0xF0, 0x60,
  0x07, 0xC0, 0x1C, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0x00,
  0x10, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x07, 0xFC,
  0x00, 0x01, 0xC6, 0x7F, 0xC0, 0x00, 0x0F, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x1E, 0x00,
  0x07, 0xFF, 0x83, 0x80, 0x01, 0xBF, 0xF9, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x70, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x02, 0x01, 0xE1, 0x80, 0x07, 0x01, 0xE0, 0x40, 0x0F, 0x01, 0xE0, 0x20,
  0x1F, 0x01, 0xF0, 0x10, 0x3F, 0x80, 0xF8, 0x18, 0x7F, 0x80, 0x7C, 0x08,
  0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xE0,
  0x01, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0xFF,
  0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0, 0x03,
  0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0x07, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0x07, 0xE0,
  0x03, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0xFC,
  0x07, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0x81, 0xBF, 0x04, 0x3F, 0xF1, 0x8F,
  0xEC, 0x07, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0xFC,
  0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0x10, 0xFE, 0x01, 0xFF, 0xFF, 0xD0, 0x3F,
  0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x60,
  0x00, 0xFE, 0x03, 0xF8, 0x70, 0x00, 0x7F, 0x00, 0xFF, 0x30, 0x00, 0x1F,
  0x80, 0x3E, 0x18, 0x00, 0x07, 0xC0, 0x0E, 0x0C, 0x00, 0x03, 0xE0, 0x06,
  0x06, 0x00, 0x01, 0xF0, 0x06, 0x03, 0x00, 0x00, 0x78, 0x07, 0x00, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x1E, 0x03, 0xC0, 0x18, 0x02, 0x1E,
  0x03, 0xF0, 0x06, 0x03, 0x0F, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0x80, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x30,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0x07, 0xFE,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x7F, 0xFC, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x7F,
  0xF0, 0x3C, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x8F, 0xC6, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFB, 0x0D, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x3F, 0x80,
  0x7C, 0x1F, 0xF8, 0x18, 0x03, 0xF8, 0x1E, 0x00, 0xFF, 0x07, 0x00, 0x7F,
  0x03, 0x80, 0x07, 0xF0, 0xE0, 0x07, 0xF0, 0xE0, 0x00, 0xFE, 0x3C, 0x00,
  0xFE, 0x18, 0x00, 0x0F, 0xC7, 0x80, 0x0F, 0xE3, 0x00, 0x00, 0xF8, 0xF8,
  0x01, 0xFE, 0x60, 0x00, 0x1F, 0x3F, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0xE7,
  0xF0, 0x01, 0x80, 0x80, 0x00, 0x3C, 0x7F, 0x00, 0x60, 0x10, 0x00, 0x07,
  0x8F, 0xE0, 0x1C, 0x03, 0x00, 0x00, 0xF1, 0xFE, 0x07, 0x80, 0x30, 0x00,
  0x1C, 0x1F, 0xC1, 0xF8, 0x03, 0x00, 0x87, 0x83, 0xFC, 0x3F, 0x80, 0x3F,
  0xE0, 0xE0, 0x3F, 0x87, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x07, 0xC0, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0xF8, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x1E, 0x00,
  0xFE, 0x00, 0x0D, 0x00, 0x01, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x30,
  0x00, 0xF8, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0x03, 0xFF, 0xE0, 0x01,
  0xF0, 0x01, 0xC0, 0xC3, 0xFE, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x06, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x80, 0x00, 0x3F,
  0xFF, 0xBF, 0xF8, 0x60, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x30, 0x01, 0xFF, 0xC0, 0x3E, 0x21, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF,
  0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF9, 0xF0, 0x3F, 0x8F, 0xF8, 0xF0,
  0x07, 0xE4, 0x78, 0x70, 0x03, 0xF6, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x18,
  0x00, 0x3F, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x04, 0x00, 0x0F, 0x80, 0x03,
  0x00, 0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x00, 0x40, 0x01, 0xFF, 0xF0,
  0x10, 0x01, 0xFF, 0xF8, 0x06, 0x19, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x2F,
  0xC0, 0x00, 0x00, 0x17, 0xF0, 0x00, 0x3E, 0x11, 0xFC, 0x00, 0x3F, 0x98,
  0xFF, 0x8C, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0x09, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF1, 0x0F, 0xF0, 0x3F, 0xFF, 0xFA, 0x07, 0xF0, 0x7C, 0x07, 0xFE,
  0x03, 0xF8, 0x70, 0x01, 0xFE, 0x03, 0xF8, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0xC0, 0x00, 0x7E, 0x01, 0xFC, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0xC0, 0x00,
  0x3E, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0xC0, 0x00, 0x3E, 0x00,
  0x30, 0x40, 0x00, 0x1E, 0x00, 0x60, 0x60, 0x00, 0x1E, 0x01, 0xC0, 0x60,
  0x00, 0x1E, 0x03, 0xC0, 0x30, 0x04, 0x3C, 0x07, 0xC0, 0x1C, 0x18, 0x3C,
  0x0F, 0xC0, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0xE0,
  0x00, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0xF0, 0x00, 0x00,
  0x60, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x80, 0x03,
  0xFC, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0x80, 0x41, 0xFE, 0x00, 0x0F, 0xE0, 0xC0, 0xFE, 0x00, 0x1F, 0xF1,
  0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x6F, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x01,
  0xF0, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xE0,
  0x3F, 0xE0, 0x1E, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0x3F, 0x01, 0x80, 0x00,
  0xFC, 0x06, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x1F,
  0x01, 0x80, 0x00, 0x78, 0x06, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x0F, 0x00,
  0x18, 0x00, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0xFC, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x0E, 0x7F, 0xF0, 0x00, 0x3B, 0x3F,
  0xE0, 0x00, 0xC0, 0x7F, 0xC0, 0x07, 0x00, 0xFF, 0x80, 0x38, 0x01, 0xFF,
  0x01, 0xC0, 0x03, 0xFF, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF,
  0xC0, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3C, 0xF0, 0x1E, 0x1E, 0x0F, 0x03, 0xC3,
  0x80, 0x79, 0xC0, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xF3, 0xE3,
  0xC3, 0xC3, 0x83, 0x03, 0x02, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0x3F, 0xE0, 0x30, 0xFF, 0x83,
  0x81, 0xF0, 0x38, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0xFD,
  0x1F, 0xFF, 0xF8, 0x7F, 0x9F, 0x81, 0xF0, 0xFC, 0x07, 0x03, 0xC0, 0x30,
  0x04, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x83, 0x80, 0x04, 0x70, 0x00,
  0x6F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x20, 0x1F, 0x06, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x81, 0xF7,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF0, 0x7E, 0x1F, 0x07, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1,
  0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x1C, 0x1F, 0x01, 0xC1, 0xF0, 0x38,
  0x3F, 0x83, 0x07, 0xFE, 0x60, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0xE0,
  0x0F, 0xE0, 0x67, 0xC1, 0xC7, 0xC7, 0x0F, 0x8E, 0x0F, 0xBC, 0x1E, 0x78,
  0x20, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x47, 0xFF, 0x03, 0xF8, 0x03, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0B, 0xFC, 0x03, 0x0F, 0xE1, 0xF0,
  0x7E, 0x1F, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F,
  0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xE1,
  0xF0, 0x0E, 0x1F, 0x00, 0xE1, 0xF0, 0x0C, 0x3F, 0xC1, 0x87, 0xFF, 0x18,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x01, 0xF0, 0x03, 0xF8, 0x0C, 0xF8, 0x1C, 0xFC, 0x38,
  0x7C, 0x38, 0x7C, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x1F, 0x78, 0x18, 0xF8,
  0xE0, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE2, 0x1F, 0xFC, 0x07,
  0xF0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x43, 0xFF,
  0x0F, 0xF8, 0x67, 0xE1, 0x02, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xC0,
  0x07, 0x80, 0x3F, 0xF3, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x2F, 0xF0, 0x03,
  0x3F, 0xF0, 0x30, 0x7F, 0x83, 0x81, 0xF8, 0x38, 0x03, 0xC3, 0xC0, 0x0C,
  0x1E, 0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x01, 0xF0,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x87, 0xF0, 0x7F, 0xCF, 0x81, 0xF8,
  0x7C, 0x0F, 0x03, 0xE0, 0x60, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x80, 0x60, 0x3E, 0x06,
  0x00, 0xF8, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x87,
  0x80, 0x04, 0xF0, 0x00, 0x6F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x40, 0x1F, 0x0E, 0x01, 0xF1, 0xE0,
  0x1F, 0x7F, 0x01, 0xFB, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x07,
  0xE1, 0xF0, 0x7E, 0x1F, 0x03, 0xE1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0,
  0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F,
  0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x03, 0xC3, 0xF2, 0x3C, 0x7F, 0xE3, 0x83,
  0xFC, 0x38, 0x0F, 0x87, 0x00, 0x70, 0x60, 0x02, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x07, 0x01, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x70, 0x1F, 0x07, 0xF0,
  0xFF, 0xA7, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x47,
  0xF8, 0x7E, 0x0F, 0x80, 0xF0, 0x04, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x38, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xBF, 0x04, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF2, 0x03, 0x88, 0x1C, 0x11, 0xC0, 0x3C, 0x00,
  0x00, 0x3C, 0x03, 0x08, 0x38, 0x11, 0xE0, 0x2F, 0x1C, 0xFC, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1F, 0xFC, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x67, 0xFE, 0x03, 0xF0, 0x03, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x7C, 0x07, 0x08, 0x38, 0x11, 0xC0, 0x2F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x10, 0xFF, 0x47, 0xFE, 0x03, 0xF0, 0x07, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0xC0,
  0x07, 0x83, 0xE0, 0xF0, 0x07, 0xE3, 0xF8, 0xFC, 0x07, 0xF3, 0xFC, 0xFF,
  0x83, 0xFF, 0x3F, 0xDF, 0xF2, 0x7E, 0x1F, 0x87, 0xE0, 0x1F, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x3E, 0x01, 0xF0,
  0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x0F, 0x80, 0xFE, 0x3F, 0x87, 0xE8, 0xFF,
  0x3F, 0xC3, 0xFC, 0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0x01, 0xC0, 0x3E, 0x03,
  0x00, 0xC0, 0x0E, 0x00, 0x80, 0x20, 0x02, 0x00, 0x10, 0x06, 0x00, 0x38,
  0x0C, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0xFE, 0x07, 0xF3, 0xFF, 0x93, 0xF8,
  0xFE, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xFC, 0x3F, 0x47, 0xF8, 0x7F, 0x87,
  0xE0, 0x7E, 0x07, 0x80, 0xFC, 0x06, 0x00, 0xF0, 0x04, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x1F, 0xBF, 0x03, 0xE7, 0xF0, 0x7C,
  0x7F, 0x0F, 0x8F, 0xE1, 0xF0, 0xFE, 0x3E, 0x0F, 0xC7, 0xC0, 0xFC, 0xF8,
  0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x71, 0xF8, 0x0E, 0x3F, 0xC3, 0x8F, 0xFE,
  0x60, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x10, 0x3F, 0x01, 0x81, 0xFC, 0x3E, 0x0F, 0xE3, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x87,
  0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x0F, 0xC0, 0x71, 0xFE,
  0x03, 0x9F, 0xFC, 0x38, 0xFF, 0xF1, 0x84, 0x7F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7B, 0x80, 0x03, 0x88, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x2F, 0xE0, 0x18, 0xFF, 0xC7, 0x0F,
  0xF1, 0xC0, 0xFC, 0x38, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x3F, 0x07, 0xC7, 0xF1, 0xF8, 0x7F, 0xDF,
  0x07, 0xF3, 0xE0, 0x7C, 0x7C, 0x06, 0x0F, 0x80, 0x80, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x18, 0x08, 0x3C, 0x0C,
  0x3E, 0x1C, 0x7F, 0x3E, 0x7F, 0x7E, 0x9F, 0xFF, 0x1F, 0x9E, 0x0F, 0x1C,
  0x0F, 0x08, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x88,
  0x1F, 0xD0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x18, 0x04, 0x0F, 0x81, 0x07, 0xF0, 0xC3, 0xFF, 0xF1, 0x1F,
  0xF8, 0x81, 0xFC, 0x60, 0x1E, 0x18, 0x01, 0x0F, 0x00, 0x83, 0xE0, 0x70,
  0xFC, 0x3E, 0x1F, 0x9F, 0xC7, 0xFF, 0xF0, 0xFC, 0x7E, 0x1E, 0x0F, 0x83,
  0x01, 0xE0, 0x80, 0x38, 0x60, 0x0E, 0x3E, 0x03, 0x1F, 0xE0, 0x8F, 0xFE,
  0xC0, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFE, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xF6, 0x7F, 0xC0, 0xFE, 0x01,
  0xE0, 0x06, 0x00, 0x10, 0x18, 0x00, 0x80, 0x38, 0x03, 0x80, 0xF8, 0x0F,
  0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x93, 0xE0, 0x7E, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x01, 0xFC, 0x7F, 0x47, 0xFF, 0x7F, 0x83, 0xFC, 0x7E, 0x01, 0xF0,
  0x7C, 0x01, 0xC0, 0x70, 0x01, 0x00, 0x40, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x38, 0x07, 0x81, 0xF0, 0x3F, 0x07,
  0xE3, 0xFE, 0x1F, 0xD9, 0xFC, 0x7F, 0x83, 0xF0, 0xFE, 0x07, 0xE1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3C, 0x07,
  0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xE0, 0x18, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x80, 0x7C, 0x0C, 0x01, 0xFC,
  0x60, 0x0F, 0xFD, 0x00, 0x4F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x20, 0x7E,
  0x03, 0x80, 0x60, 0x7F, 0x07, 0xC0, 0xF0, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F,
  0x9F, 0xEF, 0xF8, 0x1F, 0xE3, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x1E, 0x0F,
  0x81, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x1E, 0x0F,
  0x81, 0xF0, 0x1C, 0x0F, 0x81, 0xF0, 0x38, 0x0F, 0x83, 0xF0, 0x30, 0x0F,
  0x83, 0xFC, 0x60, 0x1F, 0xC7, 0xFE, 0x40, 0x3F, 0xE1, 0xFF, 0x80, 0x0F,
  0x80, 0x7F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0x01, 0x03, 0xC1, 0xC3, 0xF1, 0xE3,
  0xFD, 0xF9, 0x7F, 0xFC, 0x1F, 0xBE, 0x0F, 0x8E, 0x07, 0xC6, 0x03, 0xE2,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x40,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x73, 0xE0, 0x20, 0xE0, 0x10, 0x10,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x3C, 0x18,
  0x3E, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x30, 0x7F, 0x03, 0x81,
  0xFC, 0x3E, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xC0, 0xFC, 0x3F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xE1,
  0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x1C, 0x1F,
  0x91, 0xE1, 0xFF, 0x0E, 0x07, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0x38, 0x30,
  0x00, 0x83, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x37, 0xF1, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x03, 0x1F, 0x30, 0xFF, 0x07, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x27, 0xE1, 0x8F, 0xCC, 0x3F, 0x30, 0x7D, 0x81,
  0xF6, 0x07, 0xD8, 0x1F, 0x60, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0E, 0xE0,
  0x39, 0x81, 0xC6, 0x07, 0x08, 0x18, 0x10, 0xC0, 0x3C, 0x00, 0x00, 0x38,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 36, 11, 1, -35 },
  { 42, 17, 14, 20, 1, -35 },
  { 72, 22, 27, 25, 2, -31 },
  { 147, 17, 39, 21, 2, -37 },
  { 230, 33, 35, 35, 1, -35 },
  { 375, 25, 30, 28, 2, -30 },
  { 469, 8, 14, 10, 1, -35 },
  { 483, 11, 40, 12, 1, -39 },
  { 538, 11, 39, 12, 1, -38 },
  { 592, 16, 20, 17, 0, -37 },
  { 632, 16, 18, 19, 2, -25 },
  { 668, 8, 14, 9, 0, -8 },
  { 682, 14, 9, 15, 1, -19 },
  { 698, 8, 9, 10, 1, -8 },
  { 707, 24, 39, 26, 1, -37 },
  { 824, 21, 35, 23, 1, -35 },
  { 916, 15, 34, 16, 0, -34 },
  { 980, 20, 33, 22, 1, -33 },
  { 1063, 21, 34, 23, 1, -34 },
  { 1153, 22, 33, 22, 0, -33 },
  { 1244, 21, 35, 23, 1, -35 },
  { 1336, 20, 34, 22, 1, -34 },
  { 1421, 20, 33, 21, 1, -33 },
  { 1504, 21, 34, 23, 1, -34 },
  { 1594, 20, 35, 22, 1, -35 },
  { 1682, 8, 24, 10, 1, -23 },
  { 1706, 9, 29, 8, 0, -23 },
  { 1739, 13, 18, 14, 0, -23 },
  { 1769, 17, 11, 19, 1, -20 },
  { 1793, 13, 18, 14, 0, -23 },
  { 1823, 18, 36, 22, 2, -35 },
  { 1904, 28, 30, 30, 1, -23 },
  { 2009, 38, 36, 40, 1, -35 },
  { 2180, 43, 37, 44, 0, -36 },
  { 2379, 32, 37, 34, 1, -36 },
  { 2527, 38, 38, 40, 1, -36 },
  { 2708, 33, 37, 34, 1, -36 },
  { 2861, 35, 42, 37, 1, -36 },
  { 3045, 35, 36, 38, 1, -35 },
  { 3203, 34, 45, 36, 1, -38 },
  { 3395, 31, 41, 34, 1, -36 },
  { 3554, 33, 47, 35, 1, -36 },
  { 3748, 38, 36, 40, 1, -35 },
  { 3919, 26, 35, 28, 1, -34 },
  { 4033, 52, 37, 54, 1, -34 },
  { 4274, 41, 36, 43, 1, -35 },
  { 4459, 35, 36, 37, 1, -35 },
  { 4617, 42, 43, 44, 1, -35 },
  { 4843, 37, 38, 39, 1, -35 },
  { 5019, 44, 36, 46, 1, -35 },
  { 5217, 35, 36, 37, 1, -35 },
  { 5375, 35, 35, 37, 1, -35 },
  { 5529, 33, 37, 35, 1, -34 },
  { 5682, 41, 37, 43, 1, -36 },
  { 5872, 51, 36, 53, 1, -35 },
  { 6102, 33, 37, 35, 1, -36 },
  { 6255, 40, 44, 42, 1, -36 },
  { 6475, 30, 42, 33, 1, -35 },
  { 6633, 7, 38, 9, 1, -36 },
  { 6667, 30, 34, 5, -9, -32 },
  { 6795, 7, 38, 9, 1, -36 },
  { 6829, 18, 14, 21, 1, -35 },
  { 6861, 23, 4, 22, 0, 5 },
  { 6873, 7, 9, 25, 8, -34 },
  { 6881, 21, 26, 23, 1, -25 },
  { 6950, 20, 36, 22, 1, -34 },
  { 7040, 15, 26, 17, 1, -25 },
  { 7089, 20, 35, 22, 1, -34 },
  { 7177, 16, 26, 18, 1, -25 },
  { 7229, 14, 44, 12, 0, -36 },
  { 7306, 21, 35, 23, 1, -25 },
  { 7398, 20, 43, 22, 1, -34 },
  { 7506, 11, 35, 13, 1, -34 },
  { 7555, 14, 44, 12, -3, -35 },
  { 7632, 14, 35, 16, 1, -34 },
  { 7694, 14, 35, 13, 1, -34 },
  { 7756, 33, 27, 35, 1, -26 },
  { 7868, 23, 26, 25, 1, -25 },
  { 7943, 19, 26, 20, 0, -25 },
  { 8005, 21, 39, 22, 0, -29 },
  { 8108, 19, 35, 21, 1, -25 },
  { 8192, 16, 26, 18, 1, -25 },
  { 8244, 18, 32, 20, 1, -31 },
  { 8316, 13, 32, 15, 1, -31 },
  { 8368, 23, 26, 25, 1, -25 },
  { 8443, 22, 29, 22, -1, -28 },
  { 8523, 32, 30, 34, 1, -29 },
  { 8643, 17, 36, 19, 1, -26 },
  { 8720, 21, 37, 23, 1, -29 },
  { 8818, 14, 34, 16, 1, -25 },
  { 8878, 13, 39, 16, 1, -38 },
  { 8942, 3, 40, 8, 2, -38 },
  { 8957, 13, 39, 16, 1, -38 },
  { 9021, 16, 4, 18, 1, -17 },
};

const GFXfont UnifrakturMaguntia_Regular49pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular49pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular49pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR49PT7B_H_
