#ifndef _UNIFRAKTURMAGUNTIA_REGULAR57PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0xC0, 0x38, 0x0F, 0x87, 0xFC, 0xFF, 0xDF, 0xF1, 0xFC,
  0x3F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x38, 0x0F, 0x83, 0xFC, 0xFF, 0x07, 0xC0, 0x70, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x10, 0x0E, 0x03, 0x81, 0xE0, 0x7C, 0x7F, 0x8F, 0xF7,
  0xF9, 0xFF, 0x1F, 0x87, 0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00, 0x80, 0x40, 0x18, 0x0C, 0x01,
  0x00, 0x80, 0x20, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83,
  0xE0, 0x03, 0xC1, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F,
  0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x07, 0xFE,
  0x00, 0xF0, 0x70, 0x1E, 0x03, 0x83, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80,
  0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x7F,
  0x01, 0xC7, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE7, 0x01, 0xFE, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x00,
  0x3C, 0x38, 0x03, 0xC1, 0xC0, 0x78, 0x0F, 0xBF, 0x00, 0x3F, 0xC0, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0x80, 0x00, 0x03, 0x8F,
  0x1E, 0x00, 0x00, 0x18, 0x78, 0xF0, 0x00, 0x01, 0x87, 0x83, 0xC0, 0x00,
  0x18, 0x7C, 0x1F, 0x00, 0x01, 0xC3, 0xE0, 0xF8, 0x00, 0x1C, 0x1F, 0x07,
  0xC0, 0x01, 0xC0, 0xF8, 0x3E, 0x00, 0x1C, 0x07, 0xC1, 0xF8, 0x00, 0xC0,
  0x3E, 0x0F, 0xC0, 0x0C, 0x01, 0xF0, 0x7E, 0x00, 0xC0, 0x0F, 0x83, 0xE0,
  0x0E, 0x00, 0x7C, 0x1F, 0x00, 0xE0, 0x03, 0xE0, 0xF8, 0x0E, 0x00, 0x1F,
  0x07, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x60,
  0x00, 0x0F, 0x1E, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x70, 0x7E, 0x00, 0x7C,
  0x07, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x79, 0xE0, 0x00, 0x07, 0x07, 0x87,
  0x80, 0x00, 0x70, 0x7C, 0x3E, 0x00, 0x03, 0x03, 0xE1, 0xF0, 0x00, 0x30,
  0x3F, 0x0F, 0xC0, 0x03, 0x01, 0xF8, 0x7E, 0x00, 0x38, 0x0F, 0xC3, 0xF0,
  0x03, 0x80, 0x7E, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0xFC, 0x03, 0x80, 0x1F,
  0x87, 0xE0, 0x38, 0x00, 0xFC, 0x3F, 0x01, 0x80, 0x07, 0xE1, 0xF8, 0x18,
  0x00, 0x1F, 0x0F, 0x81, 0xC0, 0x00, 0xF8, 0x7C, 0x1C, 0x00, 0x03, 0xC3,
  0xC1, 0xC0, 0x00, 0x0F, 0x3C, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x7C, 0x1E, 0x00,
  0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x07,
  0xF7, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0xE0, 0x3F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x0E,
  0x03, 0x9F, 0xC0, 0x70, 0x38, 0xFE, 0x03, 0x03, 0xC7, 0xF8, 0x18, 0x3C,
  0x1F, 0xC0, 0xC1, 0xE0, 0xFF, 0x04, 0x1F, 0x03, 0xF8, 0x60, 0xF8, 0x1F,
  0xE3, 0x07, 0xE0, 0x7F, 0x30, 0x3F, 0x03, 0xFD, 0x81, 0xF8, 0x0F, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x2F,
  0xF0, 0x3F, 0xC3, 0x3F, 0xC3, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xCF, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x04, 0x07, 0x07, 0xC7, 0xF7,
  0xFC, 0xFE, 0x1F, 0x0F, 0x03, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x78, 0x40, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x33, 0xE6, 0x3E, 0x38,
  0xFB, 0xE7, 0x3E, 0x7C, 0x67, 0xCF, 0xC9, 0xF9, 0xFF, 0xFF, 0x00, 0x70,
  0x06, 0x3F, 0x8C, 0xFE, 0xBF, 0x9F, 0x93, 0xF3, 0xE7, 0x3E, 0xFC, 0xE7,
  0xE1, 0xBE, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x07, 0x87, 0xE7, 0xFB, 0xFC, 0x7E, 0x1F,
  0x07, 0x83, 0x81, 0xC0, 0xC0, 0x60, 0x20, 0x20, 0x10, 0x01, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x10, 0x00, 0x00, 0x1C, 0x3F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x70, 0x00, 0x00, 0x04, 0x07, 0x07, 0xC7,
  0xF7, 0xFC, 0xF8, 0x38, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0xF8, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xFC,
  0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF9, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0x80,
  0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x37, 0xF0, 0x21, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3E,
  0x0F, 0xFC, 0x38, 0x03, 0xFC, 0x70, 0x01, 0xFE, 0x70, 0x01, 0xFE, 0x60,
  0x00, 0xFE, 0x40, 0x00, 0xFE, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x02, 0x01,
  0xC0, 0x03, 0x03, 0x80, 0x02, 0x07, 0x00, 0x02, 0x06, 0x00, 0x02, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xC1, 0xFF, 0x83, 0x80, 0x3F, 0xC1, 0x80, 0x0F, 0xF1,
  0x80, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF3,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x3E,
  0x7F, 0x00, 0x1E, 0x1F, 0x80, 0x1E, 0x0F, 0xC0, 0x0E, 0x03, 0xF0, 0x0E,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x6F, 0xC0, 0x00, 0x6F, 0xC0, 0x00, 0xCF,
  0xC0, 0x00, 0xCF, 0xC0, 0x01, 0x8F, 0xC0, 0x03, 0x0F, 0xC0, 0x03, 0x0F,
  0xC0, 0x06, 0x0F, 0xC0, 0x0C, 0x0F, 0xC0, 0x0C, 0x0F, 0xC0, 0x18, 0x0F,
  0xC0, 0x30, 0x0F, 0xC0, 0x30, 0x0F, 0xC0, 0x60, 0x0F, 0xC0, 0xC0, 0x0F,
  0xC0, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFE, 0x08, 0x00, 0x08, 0x07, 0xC0, 0x3C, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC7, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0xC3, 0xC0, 0x0F, 0xF1, 0x80, 0x03,
  0xF8, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x3E, 0x7F,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x0F, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x01,
  0xF8, 0x07, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xE3, 0xF0, 0x01, 0xC1, 0xF8, 0x03, 0x80, 0xFC, 0x07, 0x80, 0xFC,
  0x0F, 0x80, 0xFC, 0x0F, 0x00, 0xFE, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E,
  0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xE0, 0x7E, 0x3F, 0xF8,
  0x7E, 0x73, 0xFC, 0x7E, 0xC1, 0xFC, 0xFE, 0xC0, 0xFE, 0xFF, 0x80, 0xFE,
  0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x70, 0x0F, 0x80, 0xE0,
  0x07, 0x80, 0xC0, 0x01, 0xE1, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x62, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7E, 0x00, 0x1C, 0x7F,
  0x00, 0x3C, 0x3F, 0xC0, 0x38, 0x3F, 0xE0, 0x78, 0x3F, 0xF8, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0E, 0x3F, 0xFC, 0x1E, 0x0F, 0xFE, 0x3C,
  0x03, 0xFE, 0x78, 0x01, 0xFE, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x3C, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x07, 0x81, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x87, 0x80, 0x03, 0x03, 0xC0, 0x07,
  0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x1E, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFE, 0x7C, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x03, 0xFE, 0x3F, 0x83, 0xFE, 0x3F, 0xFE, 0xFE, 0x1F,
  0xFC, 0xFE, 0x0F, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7F, 0x00, 0xF0, 0x7F, 0x01, 0xE0, 0x3F,
  0x01, 0xE0, 0x3F, 0x01, 0xC0, 0x1F, 0x03, 0x80, 0x0F, 0x87, 0x00, 0x03,
  0xFC, 0x00, 0x08, 0x0C, 0x07, 0x07, 0xCF, 0xFB, 0xF8, 0xF8, 0x38, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x01, 0xC1, 0xF1, 0xFD, 0xFF, 0x3E, 0x0E, 0x02, 0x00, 0x00, 0x04, 0x03,
  0x00, 0xE0, 0x7C, 0x7F, 0xCF, 0xE1, 0xF0, 0x38, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1E,
  0x0F, 0xC7, 0xF9, 0xFE, 0x1F, 0x83, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x10, 0x08, 0x02, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x70, 0x3E, 0x0E, 0x00, 0xF8, 0xE0, 0x03, 0xE7, 0x00, 0x1F,
  0x78, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0x78, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x08, 0x1E, 0x00, 0x40, 0x78, 0x06, 0x01, 0xE0, 0x60, 0x07, 0x86,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x3E, 0x01, 0xF7, 0x8E,
  0x1E, 0x01, 0xFF, 0xC7, 0x1F, 0x03, 0xE7, 0xE3, 0x8F, 0x03, 0xE3, 0xE1,
  0xE7, 0x83, 0xE1, 0xF0, 0xF7, 0x81, 0xE0, 0xF8, 0x7B, 0xC1, 0xF0, 0x78,
  0x39, 0xE1, 0xF0, 0x7C, 0x1C, 0xF0, 0xF8, 0x3E, 0x0E, 0x78, 0xFC, 0x1F,
  0x0F, 0x3C, 0x7C, 0x1F, 0x0F, 0x1E, 0x3E, 0x1F, 0x87, 0x8F, 0x1F, 0x1F,
  0xC7, 0x87, 0x8F, 0x9F, 0xE7, 0x81, 0xC7, 0xFF, 0xFF, 0x8E, 0xE1, 0xFC,
  0xFF, 0x8F, 0x78, 0x7C, 0x3F, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0x80, 0x7F, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x01,
  0xC0, 0x3F, 0xF8, 0x1F, 0xE0, 0x38, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x60, 0x00, 0x3F, 0xC1, 0xFE, 0x06, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x60, 0x00, 0x1F, 0xE1, 0xFE, 0x0C, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x0E, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x0F, 0x00, 0x00, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0x0F, 0xE1, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xC1, 0xFE, 0x03, 0xFF, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0xF8,
  0x0F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xF0, 0x1F, 0xE0, 0x01, 0xF8, 0x1E,
  0x01, 0xFE, 0x00, 0x07, 0x83, 0xC0, 0x1F, 0xE0, 0x00, 0x38, 0x38, 0x01,
  0xFE, 0x00, 0x03, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x20, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x31, 0xFF, 0xE0,
  0xEF, 0xF3, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x8F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE1, 0xC7, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0xC0, 0x7F, 0x80,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x7C, 0x00, 0x7F, 0xE0, 0x0F, 0xF0,
  0x3C, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x3C, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x1C, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xC6, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF3, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xE1, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xE0, 0x03,
  0x00, 0x70, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x00, 0xF8, 0x1F,
  0xF8, 0x0E, 0x00, 0x00, 0x78, 0x3F, 0xFE, 0x03, 0x80, 0x10, 0x7C, 0x7F,
  0xFF, 0x81, 0xE0, 0x08, 0x3C, 0x7F, 0xFF, 0xE0, 0x3E, 0x38, 0x1C, 0x00,
  0x7F, 0xF8, 0x07, 0xF0, 0x1E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x21, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x38, 0x00, 0x03, 0xE7,
  0x83, 0xF0, 0x00, 0x3C, 0x04, 0x3F, 0xE0, 0x03, 0xC0, 0x13, 0xFF, 0xF0,
  0x3C, 0x00, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x3E, 0x00, 0x60,
  0x7E, 0x01, 0xF0, 0x0E, 0x00, 0xE0, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x00, 0xFE, 0x03, 0xFF,
  0x80, 0x07, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x70, 0x00, 0x07, 0xFE, 0x06,
  0x00, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0x80, 0x07, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x08, 0x7F, 0xFC, 0x03, 0xF0, 0x01,
  0x80, 0xFF, 0xE0, 0x3E, 0x00, 0x70, 0x07, 0xFF, 0x07, 0xC0, 0x0E, 0x00,
  0x1F, 0xF0, 0x78, 0x01, 0xE0, 0x00, 0xFF, 0x87, 0x00, 0x3E, 0x00, 0x07,
  0xF8, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xCE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xCE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0xE0,
  0x03, 0xFF, 0x00, 0x07, 0xE6, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x60, 0x01,
  0xFF, 0xC0, 0x03, 0xE6, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0x60, 0x00, 0x7F,
  0xE0, 0x01, 0xE3, 0x00, 0x03, 0xFE, 0x00, 0x1E, 0x18, 0x00, 0x1F, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x07, 0x87, 0x07, 0xE0, 0x00,
  0xE0, 0x1F, 0xE0, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x0F, 0x88, 0x00, 0x01, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x60, 0x03, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x73, 0xFF, 0xFF, 0x03,
  0x80, 0x0C, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x38, 0x00, 0x01, 0xF1, 0xC1, 0xF8, 0x00, 0x0F, 0x01, 0x0F, 0xF8,
  0x80, 0x78, 0x02, 0x7F, 0xFE, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00,
  0x3F, 0xFF, 0x80, 0xF8, 0x01, 0x81, 0xF8, 0x03, 0xE0, 0x1C, 0x01, 0xC0,
  0x1F, 0x81, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x81, 0xF0, 0x1F, 0xC3, 0xFF,
  0x0F, 0xE0, 0x7F, 0x07, 0xFE, 0x3F, 0xFD, 0xFC, 0x1F, 0xFD, 0xFF, 0xE7,
  0xF0, 0x3F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xF1, 0xFC, 0x7F, 0x00, 0xFF,
  0xE3, 0xE1, 0xFC, 0x01, 0xFF, 0xC2, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x3C,
  0x00, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x06, 0x00, 0x00, 0x0F,
  0xFC, 0x70, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x06, 0x00, 0xFF, 0xFC, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x1F,
  0x00, 0x01, 0xFF, 0xFC, 0x1F, 0x00, 0x00, 0xBF, 0xFC, 0x0F, 0x00, 0x00,
  0xC7, 0xF8, 0x0F, 0x00, 0x00, 0xC0, 0xF8, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x10, 0x30, 0x00, 0x3F,
  0xE0, 0x1C, 0x18, 0x00, 0x0F, 0xF0, 0x1F, 0x0C, 0x00, 0x07, 0xFC, 0x0F,
  0xE6, 0x00, 0x03, 0xFF, 0x0F, 0xF9, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0xE0,
  0x00, 0x7F, 0xEF, 0xFC, 0x30, 0x00, 0x1F, 0xFE, 0xFC, 0x0C, 0x00, 0x07,
  0xFE, 0x1C, 0x03, 0x80, 0x61, 0xFF, 0x0C, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x38,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x00,
  0x0F, 0xFC, 0x07, 0x80, 0x00, 0x1F, 0x01, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x47, 0xF0, 0x00, 0x1E, 0x00, 0x2F, 0xFC, 0x00, 0x1F, 0x00, 0x1D, 0xFF,
  0x80, 0x1F, 0x00, 0x18, 0x7F, 0xE0, 0x1F, 0x80, 0x18, 0x1F, 0xF8, 0x0F,
  0x80, 0x38, 0x07, 0xFE, 0x0F, 0xC0, 0x38, 0x01, 0xFF, 0x87, 0xE0, 0x78,
  0x00, 0x7F, 0x07, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xF0, 0x7E, 0x00, 0x0E,
  0x01, 0xF8, 0x3F, 0x00, 0x0C, 0x01, 0xFC, 0x1F, 0xC0, 0x1C, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0x81, 0xFE,
  0x3F, 0xFE, 0x1F, 0xC0, 0xFF, 0xBF, 0xFF, 0x8F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC7, 0xF0, 0x1F, 0xF0, 0x1F, 0xF3, 0xF8, 0x07, 0xFC, 0x07, 0xF9, 0xFC,
  0x01, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xBF, 0xC0, 0x0F, 0xF0, 0x1F, 0xDF, 0xE0, 0x03, 0xF8, 0x07,
  0xE7, 0xF8, 0x01, 0xFC, 0x03, 0xF3, 0xFC, 0x00, 0x7E, 0x01, 0xF9, 0xFE,
  0x00, 0x3E, 0x00, 0xFC, 0x7F, 0x80, 0x1E, 0x00, 0x7C, 0x3F, 0xC0, 0x0E,
  0x00, 0x3E, 0x0F, 0xF0, 0x0E, 0x00, 0x3F, 0x03, 0xFC, 0x0E, 0x00, 0x1F,
  0x00, 0xFE, 0x0C, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x3F, 0xF0, 0x00, 0x00, 0x18, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x0F, 0xFC,
  0x00, 0x00, 0x70, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x1E, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x02, 0x00, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x3F,
  0xC0, 0x38, 0x00, 0x7E, 0x7F, 0xE0, 0x30, 0x00, 0xFC, 0xFF, 0xF0, 0x30,
  0x00, 0xFC, 0x9F, 0xFC, 0x60, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x81, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x0F, 0xFF,
  0xF0, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x38, 0x00,
  0x01, 0xFE, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x01, 0xFE,
  0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x07, 0x3F, 0xC0, 0x00, 0x7F,
  0xE1, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0x87, 0xFF, 0xC0, 0x00, 0x7C,
  0x7F, 0xFF, 0x00, 0x03, 0xC6, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x7F, 0xF0,
  0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0xE0, 0x00,
  0x0F, 0xFF, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFC,
  0x07, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xE0, 0x70, 0x00, 0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x0E, 0x00,
  0x00, 0x3F, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x01, 0x80, 0x00, 0x1F, 0x80,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x18, 0x00,
  0x07, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x0E, 0x7F, 0x80,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xF0, 0x00, 0x00, 0xE0, 0x7F, 0xF0, 0x00, 0x03, 0x83, 0xFF, 0xE0, 0x00,
  0x1E, 0x1F, 0xFF, 0xC0, 0x00, 0x70, 0xC3, 0xFF, 0x80, 0x01, 0x80, 0x07,
  0xFF, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x03,
  0x80, 0x00, 0x3F, 0xFE, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x3F, 0xC0, 0x38, 0x00, 0x3E, 0x0F, 0xFE, 0x03, 0xC0, 0x07, 0xC1,
  0xFF, 0xF8, 0x1C, 0x00, 0x7C, 0x3F, 0xFF, 0xC1, 0xE0, 0x0F, 0xC3, 0x87,
  0xFC, 0x0E, 0x00, 0xFC, 0x60, 0x3F, 0xE0, 0xE0, 0x0F, 0xC4, 0x01, 0xFE,
  0x0E, 0x00, 0xFC, 0x40, 0x0F, 0xF0, 0xF0, 0x0F, 0xE4, 0x00, 0xFF, 0x0F,
  0x00, 0xFE, 0x40, 0x07, 0xF8, 0xF0, 0x0F, 0xF4, 0x00, 0x7F, 0xCE, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x0E, 0x00, 0x7F,
  0xC0, 0x00, 0xC0, 0xC0, 0x07, 0xFE, 0x00, 0x30, 0x18, 0x00, 0x3F, 0xF0,
  0x0E, 0x03, 0x00, 0x03, 0xFF, 0x03, 0xF0, 0x60, 0x00, 0x1F, 0xF8, 0x7F,
  0x8C, 0x00, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x7F, 0x80, 0x07, 0x80, 0x7C, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x38, 0x03, 0xFC, 0x07, 0xFF, 0x03, 0x00,
  0x1F, 0xE0, 0xDF, 0xF8, 0x60, 0x01, 0xFF, 0x10, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0xFE, 0x00, 0x01,
  0xF3, 0xFC, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x7C,
  0xFF, 0x80, 0x03, 0xF1, 0xFF, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x3E, 0x0F,
  0xF8, 0x01, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x7F, 0xDF, 0xFC, 0x01, 0xFF,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x05, 0xFF, 0xFE, 0x00, 0x3C, 0x7F, 0xFE, 0x01, 0x80, 0x7F,
  0xFE, 0x1C, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xF6, 0x0F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0x80, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFC, 0x07, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x60, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x83, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x10, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE1, 0x80, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x8C, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x60, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFB, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x08, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x60,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x0E, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0xE0, 0x1C, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0E, 0x00, 0x7F, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x07,
  0x00, 0x07, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x70, 0x00, 0x0F, 0xFC, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x20, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x01, 0x01, 0xF0, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE1, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x83, 0xF8, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xC0, 0xFF,
  0x00, 0x01, 0xFC, 0x03, 0x3C, 0x0C, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x33,
  0xF8, 0x60, 0x1F, 0xE0, 0x03, 0xFF, 0xC3, 0x3F, 0xE6, 0x00, 0x7F, 0xFC,
  0x3F, 0xFF, 0x33, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0x0F, 0xFF, 0xBF, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x90, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x0C, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x18, 0x1F,
  0xE0, 0x3C, 0x01, 0xFF, 0x90, 0x0F, 0xE0, 0x70, 0x00, 0xFF, 0xF0, 0x0F,
  0xF0, 0x60, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x60, 0x00, 0x3F, 0xE0, 0x07,
  0xF0, 0x40, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0xC0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xFE, 0x40, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x40, 0x00, 0x03, 0xF8, 0x00,
  0xE0, 0x60, 0x00, 0x03, 0xF8, 0x01, 0x80, 0x70, 0x00, 0x01, 0xF8, 0x03,
  0x80, 0x38, 0xFE, 0x01, 0xF8, 0x07, 0x00, 0x3F, 0xFF, 0x01, 0xF8, 0x0E,
  0x00, 0x1F, 0xFF, 0x01, 0xF8, 0x0E, 0x00, 0x0F, 0xFF, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xE3, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x01, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x80, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x06, 0x00, 0x7F,
  0xC3, 0x0F, 0xFF, 0x0C, 0x00, 0x3F, 0xFE, 0x19, 0xFF, 0x9C, 0x00, 0x1F,
  0xFC, 0x10, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0x80,
  0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0x80,
  0x00, 0x0F, 0xFE, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0xC0, 0x00,
  0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0xF8,
  0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x0F, 0xC8, 0x00, 0x00, 0x70, 0x0F, 0xF0,
  0x00, 0x00, 0x30, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0x80, 0x00,
  0x18, 0x1F, 0xFF, 0xF0, 0x00, 0x18, 0x10, 0x7F, 0xFC, 0x00, 0x18, 0x00,
  0x1F, 0xFF, 0x80, 0x38, 0x00, 0x03, 0xFF, 0xF8, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0x01, 0xF8, 0x7F, 0xF8, 0xFF, 0xC0, 0x01, 0xE0, 0x07, 0xFD, 0xCF,
  0xF0, 0x00, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0x83,
  0xFF, 0x00, 0x60, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x30, 0x00, 0x0F, 0xF0,
  0x7F, 0xF0, 0x18, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x0C, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0x06, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC3, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF1, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x60, 0x00, 0x1F,
  0xC0, 0x07, 0xFE, 0x30, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x8C, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC3, 0x80, 0x61, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0xC7, 0xFF, 0xFE, 0x78, 0x00,
  0x01, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x78, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0x83, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x3E,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x80, 0x07, 0xC6,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0x04, 0x7F, 0xC1, 0xC1, 0xFF,
  0xF1, 0x03, 0xFE, 0x60, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x83,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x0C, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xE3, 0x03, 0xFC,
  0x01, 0xF8, 0x1F, 0xFE, 0x40, 0x3F, 0xC0, 0x3C, 0x00, 0x7F, 0xF8, 0x07,
  0xF8, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x30, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x06, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xE9, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x38, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x87, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xF0, 0xFE, 0x00,
  0x07, 0x80, 0x30, 0x3E, 0x7F, 0xE0, 0x00, 0x3C, 0x1C, 0x07, 0xDF, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x30, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xC1, 0x00, 0x03, 0xFE, 0x20, 0xFF, 0xFC, 0x60, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xE0, 0x01, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x1F, 0xC0, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x3C,
  0x00, 0x01, 0xFF, 0xF8, 0x1E, 0x04, 0x03, 0xFF, 0xFF, 0x0F, 0x01, 0x07,
  0xFF, 0xFF, 0x87, 0x80, 0xFF, 0xFF, 0xE0, 0xE3, 0xC0, 0x3F, 0xFF, 0xC0,
  0x11, 0xE0, 0x0F, 0xFF, 0x80, 0x0C, 0xF8, 0x03, 0xFF, 0x00, 0x02, 0x7C,
  0x00, 0xFE, 0x00, 0x01, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x9F, 0x80, 0x00,
  0x00, 0x00, 0x4F, 0xE0, 0x00, 0x00, 0x00, 0x27, 0xF8, 0x00, 0x00, 0x00,
  0x31, 0xFE, 0x00, 0x00, 0x00, 0x18, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x3F,
  0xE0, 0x00, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x00, 0x3C, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0x01, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0xFF,
  0xC6, 0x60, 0x00, 0x19, 0xFF, 0xFE, 0x30, 0x00, 0x18, 0x3F, 0xFE, 0x30,
  0x00, 0x3C, 0x07, 0xFE, 0x18, 0x00, 0x3C, 0x01, 0xFE, 0x0C, 0x00, 0x1F,
  0x00, 0x3C, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x9F,
  0xFC, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0x80, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x3C, 0x00,
  0x03, 0xFF, 0xF8, 0x38, 0x00, 0x01, 0x0F, 0xFF, 0x30, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x06, 0x00, 0x01, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x3F, 0xFE, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xE0, 0x1E, 0x0C, 0x00, 0x0E, 0x00, 0xF0, 0x18, 0x00, 0xF8, 0x07, 0xC0,
  0x20, 0x0F, 0xC0, 0x3E, 0x00, 0x80, 0xFF, 0x00, 0xF8, 0x06, 0x0F, 0xF8,
  0x07, 0xE0, 0x30, 0x3F, 0xE0, 0x1F, 0xC0, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0x3F, 0x80, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x06, 0xFE, 0x0C, 0x3F, 0xF8, 0x73,
  0xFC, 0x40, 0x7F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01,
  0xE0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x1C,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x30, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xA0,
  0x3F, 0xC0, 0x3E, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x7C, 0x00, 0x7F, 0xE0,
  0x1F, 0xE0, 0x70, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x60, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0xE0, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0xC0, 0x00, 0x07, 0xE0,
  0x01, 0x80, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x60, 0x00, 0x03, 0xE0,
  0x07, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x60, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x18, 0x00, 0x83, 0xC0,
  0x3F, 0x80, 0x0C, 0x03, 0x07, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0x80,
  0x3F, 0xE0, 0x01, 0xF8, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x78, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x03, 0x07, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x03, 0xC0, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x1D, 0xC6, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF6, 0x0D,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0,
  0xFF, 0xE0, 0x18, 0x01, 0xFE, 0x01, 0xF0, 0x07, 0xFE, 0x07, 0x00, 0x1F,
  0xE0, 0x78, 0x00, 0x3F, 0xC0, 0xE0, 0x03, 0xFC, 0x0E, 0x00, 0x03, 0xFC,
  0x3C, 0x00, 0x3F, 0x83, 0x80, 0x00, 0x7F, 0x87, 0x80, 0x07, 0xF8, 0x70,
  0x00, 0x07, 0xF1, 0xF0, 0x00, 0x7F, 0x8E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xF9, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x30, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1F, 0x1F, 0xE0, 0x01, 0x80,
  0x60, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x7C, 0x7F,
  0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x0F, 0x87, 0xF8, 0x07, 0xC0, 0x1C, 0x00,
  0x01, 0xE0, 0xFF, 0x81, 0xFC, 0x01, 0xC0, 0x18, 0x3C, 0x0F, 0xF0, 0x3F,
  0x80, 0x0E, 0x0C, 0x0F, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xE0,
  0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x3F, 0x81, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x03, 0xF0,
  0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0x03,
  0x80, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0x80, 0xC3, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x70, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0C, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFF, 0xC0, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x3F, 0xFE, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x30, 0xFF, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0x81,
  0xFF, 0x1F, 0xFC, 0x3C, 0x00, 0xFE, 0x73, 0xF0, 0xF0, 0x00, 0xFE, 0xC1,
  0xC1, 0xC0, 0x01, 0xFD, 0x00, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x06, 0x00,
  0x03, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x07, 0xE0,
  0x00, 0x30, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x60,
  0x00, 0x3F, 0xFF, 0x80, 0x60, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xE0, 0xCF, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x17, 0xF0, 0x00,
  0x00, 0x00, 0x2F, 0xF0, 0x00, 0x01, 0x00, 0x9F, 0xE0, 0x00, 0x0F, 0x81,
  0x1F, 0xE0, 0x00, 0x3F, 0xC6, 0x3F, 0xF0, 0x40, 0x7F, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x11, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x1C, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xFA, 0x03, 0xFC, 0x0F, 0x80,
  0x7F, 0xF8, 0x07, 0xF8, 0x78, 0x00, 0x7F, 0xE0, 0x1F, 0xE1, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0x86, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x38, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xFB, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xB0, 0x00, 0x00, 0xF8,
  0x00, 0x78, 0x60, 0x00, 0x03, 0xE0, 0x01, 0x81, 0x80, 0x00, 0x0F, 0x80,
  0x1C, 0x06, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x18, 0x00, 0x83, 0xC0, 0x3F, 0x00, 0x30, 0x0C, 0x1F, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x78, 0x07, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x10, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0xC7, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xF0,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x00,
  0x3F, 0x80, 0x70, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x70,
  0x00, 0x01, 0xF0, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x03, 0xE0,
  0x01, 0x80, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE1, 0xFF,
  0x00, 0x00, 0x3C, 0x3F, 0xFC, 0x00, 0x03, 0xC7, 0xFF, 0xE0, 0x00, 0x3C,
  0xC7, 0xFE, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0x00, 0x70, 0x01, 0xFF, 0x80,
  0x06, 0x00, 0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x03,
  0xFF, 0xEE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0x00, 0x20,
  0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x0F, 0x87, 0x80, 0xF8, 0x1E,
  0x0F, 0x00, 0x78, 0x70, 0x01, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x78,
  0x1E, 0x07, 0x01, 0x80, 0x60, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xBF, 0xE0, 0x03,
  0x1F, 0xFC, 0x06, 0x0F, 0xF8, 0x0E, 0x03, 0xF0, 0x1E, 0x01, 0xF0, 0x3C,
  0x03, 0xF0, 0x3C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x83, 0xF1, 0x3F, 0xE7, 0xFE, 0x1F, 0xF9, 0xFE, 0x0F,
  0xF1, 0xFC, 0x07, 0xE1, 0xFC, 0x03, 0x80, 0xF8, 0x01, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x03, 0x1E,
  0x00, 0x02, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0x00, 0xFC, 0x06,
  0x01, 0xF8, 0x1C, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xC3, 0xF8, 0x1F, 0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xF0,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8,
  0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x38, 0x1F, 0xE0,
  0xE0, 0x7F, 0xF1, 0x81, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0D, 0xF8, 0x06, 0x3F, 0x03,
  0x8F, 0xC1, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C, 0x0F, 0xDF, 0x03, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x7F,
  0xE0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x47, 0xFC, 0x01,
  0x81, 0xFC, 0x0F, 0x80, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0x1C, 0x1F, 0x80, 0x1C, 0x1F, 0xC0, 0x38, 0x3F,
  0xF0, 0x38, 0x7F, 0xFC, 0x30, 0x0F, 0xFE, 0x60, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0D, 0xF8, 0x0E, 0x3F, 0x03, 0x8F,
  0xC1, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C, 0x1F, 0x9F, 0x03, 0xF7, 0xC0, 0xFD,
  0xF0, 0x1E, 0x7C, 0x0E, 0x1F, 0x1C, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xE0,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x10,
  0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0x9F, 0xC0, 0x40, 0xC0, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x3F, 0xF0, 0x03,
  0x1F, 0xFC, 0x0E, 0x07, 0xFC, 0x0E, 0x03, 0xF8, 0x1E, 0x00, 0xF8, 0x3C,
  0x00, 0x70, 0x7C, 0x00, 0x70, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F,
  0xFC, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0x80, 0x7E, 0x06, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x1C,
  0x00, 0x78, 0x3E, 0x00, 0x70, 0x3E, 0x00, 0xE0, 0x1F, 0x01, 0xC0, 0x0F,
  0x83, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7D, 0x02, 0x03, 0xC0, 0x02, 0x1F, 0x00, 0x06, 0x7C, 0x00, 0x04, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x0C, 0x01, 0xF8, 0x38, 0x03, 0xF0, 0xF8,
  0x07, 0xE7, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0,
  0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x21,
  0xE1, 0xFE, 0xC3, 0xC3, 0xFF, 0x0F, 0x03, 0xFC, 0x1C, 0x01, 0xF0, 0x30,
  0x01, 0xC0, 0xE0, 0x01, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0xFE, 0x0F, 0xFC, 0x7F, 0xE4,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF2, 0x1F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0x80,
  0x38, 0x00, 0xC0, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1B,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xE4, 0x03, 0xE4, 0x03,
  0xC2, 0x07, 0x81, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00,
  0xF0, 0xC1, 0xE0, 0x63, 0xC0, 0x27, 0xC3, 0x17, 0xCF, 0x1F, 0xDF, 0x1F,
  0xDF, 0x0F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xE6, 0x3F, 0xFC, 0x3F, 0xF8, 0x07, 0xF0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0xC1,
  0xE0, 0x63, 0xC0, 0x27, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0xE6, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x07, 0xE0, 0xFE, 0x1F, 0x80, 0x3F, 0xC7,
  0xF8, 0xFF, 0x81, 0xFF, 0x7F, 0xF7, 0xFF, 0xC5, 0xFF, 0x1F, 0xF3, 0xFE,
  0x23, 0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0x03,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE4, 0x7F, 0xCF, 0xFC, 0x3F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x81,
  0xF0, 0x1F, 0x01, 0xFC, 0x03, 0x80, 0x78, 0x03, 0xF0, 0x0E, 0x00, 0xC0,
  0x07, 0x80, 0x10, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x07, 0x80,
  0x70, 0x01, 0xF0, 0x1E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xCF, 0xFC, 0x1F,
  0xF6, 0xFF, 0xC4, 0xFF, 0x1F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xC0, 0x7F, 0x81,
  0xF9, 0x3F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x1E,
  0x00, 0xFC, 0x03, 0x80, 0x1F, 0x00, 0x40, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC,
  0x7F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xFC, 0x3F, 0x07, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0,
  0x07, 0x8F, 0xC0, 0x1E, 0x3F, 0x00, 0xF0, 0xFE, 0x03, 0x87, 0xFC, 0x0C,
  0x3F, 0xFC, 0x60, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xE0, 0x02, 0x01, 0xFC, 0x03, 0x80, 0xFF, 0x03, 0xC0, 0x7F, 0xC7, 0xF0,
  0x1F, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F,
  0xE0, 0x3E, 0x07, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07,
  0xC0, 0x1E, 0x0F, 0xE0, 0x0F, 0x1F, 0xF8, 0x0F, 0x0F, 0xFE, 0x07, 0x0F,
  0xFF, 0xC7, 0x07, 0xFF, 0xFB, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x37, 0xFE,
  0x01, 0x87, 0xFF, 0x0E, 0x0F, 0xF8, 0x70, 0x1F, 0xC3, 0xC0, 0x3F, 0x0F,
  0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F,
  0x83, 0xF0, 0xFF, 0xBF, 0xC1, 0xFF, 0xBF, 0x03, 0xF8, 0xFC, 0x07, 0xC1,
  0xF0, 0x0E, 0x07, 0xC0, 0x20, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x0C, 0x01, 0x03, 0xC0, 0x60, 0xFC, 0x1E, 0x1F, 0xC7, 0xC7, 0xFD,
  0xFC, 0xFF, 0xFF, 0xA3, 0xFB, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0x81, 0xF8,
  0x60, 0x3F, 0x08, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x80, 0x7F, 0xB0, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x18, 0x02, 0x00,
  0xF0, 0x08, 0x07, 0xF0, 0x60, 0x7F, 0xFF, 0x83, 0x7F, 0xFE, 0x18, 0x7F,
  0xF0, 0xC0, 0x7F, 0x87, 0x00, 0x78, 0x1C, 0x00, 0x40, 0x78, 0x03, 0x03,
  0xF0, 0x1C, 0x0F, 0xE0, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0xBF, 0xE0, 0xFF,
  0xFF, 0x81, 0xF8, 0xFF, 0x03, 0xC0, 0xFC, 0x0E, 0x01, 0xF0, 0x10, 0x03,
  0xC0, 0x80, 0x0F, 0x07, 0x00, 0x18, 0x3F, 0x00, 0x61, 0xFF, 0x03, 0x0F,
  0xFF, 0x98, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF9, 0x9F, 0xFE, 0x3F, 0xF8, 0x0F, 0xE0, 0x07,
  0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x04, 0x01,
  0xE0, 0x03, 0x80, 0x7C, 0x01, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF2, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03,
  0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xE1, 0xFE, 0x4F, 0xFE, 0xDF, 0xF0, 0xFF, 0xC7, 0xF8, 0x0F, 0xE0, 0xFC,
  0x00, 0xF0, 0x1F, 0x00, 0x18, 0x03, 0x80, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0xE0, 0x01, 0x80, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xFC, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF8,
  0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x06, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x0E, 0x00, 0x7F,
  0x83, 0x00, 0x1F, 0xF9, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0x01, 0xFC, 0x03, 0x80, 0x1C, 0x0F, 0xF0, 0x3F, 0x01, 0xE0, 0x7F,
  0xC3, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xE3, 0xFE, 0x07, 0xF3, 0x7F, 0xE7,
  0xF8, 0x1F, 0xF1, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x3F,
  0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F,
  0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x0F, 0x03,
  0xE0, 0x3F, 0x00, 0x78, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0,
  0x3C, 0x07, 0xE0, 0x7E, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x0E, 0x01, 0xF8,
  0x1F, 0x80, 0xE0, 0x1F, 0xC1, 0xFF, 0x06, 0x00, 0xFE, 0x1F, 0xFE, 0x60,
  0x0F, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x0C, 0x0F, 0xC1, 0xC0, 0xFC, 0x3E, 0x1F, 0xE7, 0xE1, 0xFE, 0xFF,
  0x27, 0xFF, 0xF0, 0x3F, 0x3F, 0x03, 0xF1, 0xE0, 0x3F, 0x1C, 0x03, 0xF0,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x98, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x70, 0xF8, 0x06, 0x07, 0x00,
  0x40, 0x20, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x07, 0x81, 0xC0, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x02,
  0x01, 0xFE, 0x07, 0x80, 0xFF, 0x07, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xEF,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x3F, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x43,
  0xC0, 0xFF, 0x61, 0xE0, 0xFF, 0xE0, 0xE0, 0x0F, 0xE0, 0xF0, 0x03, 0xE0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0x20, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0x83, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x1C, 0x1C, 0x18, 0x3F, 0xB0, 0x3F, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x67, 0xF8, 0x71,
  0xFC, 0x30, 0x7E, 0x30, 0x3F, 0x18, 0x0F, 0x9C, 0x07, 0xEC, 0x03, 0xF6,
  0x01, 0xFB, 0x00, 0xF9, 0x80, 0x7C, 0xC0, 0x3E, 0x60, 0x1F, 0x30, 0x0F,
  0x18, 0x07, 0x8C, 0x03, 0x83, 0x01, 0x80, 0x81, 0x80, 0x20, 0x80, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 11, 42, 13, 1, -41 },
  { 59, 20, 16, 23, 1, -41 },
  { 99, 25, 32, 29, 2, -36 },
  { 199, 20, 46, 24, 2, -43 },
  { 314, 37, 40, 41, 2, -40 },
  { 499, 29, 36, 33, 2, -35 },
  { 630, 9, 16, 11, 1, -41 },
  { 648, 13, 46, 14, 1, -45 },
  { 723, 13, 47, 14, 1, -45 },
  { 800, 19, 23, 20, 0, -43 },
  { 855, 19, 20, 23, 2, -29 },
  { 903, 9, 16, 10, 0, -9 },
  { 921, 16, 11, 17, 1, -22 },
  { 943, 9, 10, 11, 1, -9 },
  { 955, 27, 45, 30, 2, -43 },
  { 1107, 25, 41, 27, 1, -40 },
  { 1236, 17, 39, 18, 1, -39 },
  { 1319, 24, 38, 26, 1, -38 },
  { 1433, 25, 39, 27, 1, -39 },
  { 1555, 24, 39, 26, 1, -39 },
  { 1672, 25, 40, 27, 1, -40 },
  { 1797, 24, 40, 26, 1, -40 },
  { 1917, 23, 39, 25, 1, -39 },
  { 2030, 24, 40, 27, 1, -40 },
  { 2150, 24, 40, 26, 1, -40 },
  { 2270, 9, 28, 11, 1, -27 },
  { 2302, 10, 34, 10, 0, -27 },
  { 2345, 16, 21, 16, 0, -27 },
  { 2387, 20, 12, 22, 1, -23 },
  { 2417, 16, 21, 16, 0, -27 },
  { 2459, 21, 41, 26, 2, -40 },
  { 2567, 33, 34, 35, 1, -26 },
  { 2708, 44, 42, 46, 1, -41 },
  { 2939, 49, 42, 51, 0, -41 },
  { 3197, 37, 42, 39, 1, -41 },
  { 3392, 44, 44, 46, 1, -42 },
  { 3634, 38, 42, 40, 1, -41 },
  { 3834, 41, 49, 43, 1, -42 },
  { 4086, 41, 43, 44, 1, -41 },
  { 4307, 40, 52, 42, 1, -44 },
  { 4567, 37, 49, 39, 1, -42 },
  { 4794, 38, 56, 40, 1, -42 },
  { 5060, 44, 42, 46, 1, -41 },
  { 5291, 30, 41, 33, 1, -40 },
  { 5445, 61, 43, 63, 1, -40 },
  { 5773, 48, 41, 50, 1, -40 },
  { 6019, 41, 42, 43, 1, -41 },
  { 6235, 49, 50, 51, 1, -40 },
  { 6542, 43, 45, 45, 1, -41 },
  { 6784, 51, 42, 53, 1, -41 },
  { 7052, 41, 42, 43, 1, -41 },
  { 7268, 41, 41, 43, 1, -40 },
  { 7479, 38, 44, 41, 1, -40 },
  { 7688, 48, 43, 51, 1, -42 },
  { 7946, 59, 42, 61, 1, -41 },
  { 8256, 39, 43, 41, 1, -42 },
  { 8466, 46, 51, 49, 1, -42 },
  { 8760, 36, 50, 38, 1, -42 },
  { 8985, 8, 45, 10, 1, -42 },
  { 9030, 35, 40, 6, -11, -37 },
  { 9205, 8, 45, 10, 1, -42 },
  { 9250, 21, 15, 24, 1, -40 },
  { 9290, 27, 4, 26, -1, 6 },
  { 9304, 9, 11, 29, 9, -40 },
  { 9317, 24, 31, 26, 1, -29 },
  { 9410, 23, 41, 25, 1, -39 },
  { 9528, 18, 30, 20, 1, -29 },
  { 9596, 24, 41, 26, 1, -40 },
  { 9719, 18, 30, 21, 1, -29 },
  { 9787, 18, 51, 14, -1, -41 },
  { 9902, 24, 42, 27, 1, -30 },
  { 10028, 23, 50, 25, 1, -40 },
  { 10172, 13, 41, 16, 1, -40 },
  { 10239, 16, 50, 14, -3, -40 },
  { 10339, 16, 41, 19, 1, -40 },
  { 10421, 16, 41, 16, 1, -40 },
  { 10503, 38, 31, 40, 1, -30 },
  { 10651, 26, 30, 29, 1, -29 },
  { 10749, 22, 30, 24, 0, -29 },
  { 10832, 25, 45, 26, 0, -34 },
  { 10973, 22, 42, 25, 1, -30 },
  { 11089, 19, 30, 21, 1, -29 },
  { 11161, 22, 37, 24, 1, -36 },
  { 11263, 15, 37, 18, 1, -36 },
  { 11333, 26, 31, 29, 1, -30 },
  { 11434, 26, 33, 26, -1, -32 },
  { 11542, 37, 36, 39, 1, -34 },
  { 11709, 20, 42, 22, 1, -30 },
  { 11814, 25, 44, 27, 1, -34 },
  { 11952, 17, 40, 19, 1, -30 },
  { 12037, 15, 45, 19, 1, -44 },
  { 12122, 3, 47, 9, 3, -44 },
  { 12140, 15, 45, 19, 1, -44 },
  { 12225, 19, 4, 21, 1, -19 },
};

const GFXfont UnifrakturMaguntia_Regular57pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular57pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular57pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR57PT7B_H_
