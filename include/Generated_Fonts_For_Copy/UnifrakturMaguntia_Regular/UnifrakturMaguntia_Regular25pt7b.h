#ifndef _UNIFRAKTURMAGUNTIA_REGULAR25PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0x46, 0xFE, 0x66, 0x66, 0x44, 0x44, 0x00, 0x46, 0xF4, 0x42, 0x66,
  0xFF, 0x63, 0x23, 0x42, 0x44, 0x19, 0x83, 0x30, 0x66, 0x3F, 0xF7, 0xFE,
  0x33, 0x04, 0x41, 0x88, 0xFF, 0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x30, 0x46,
  0x00, 0x08, 0x08, 0x3C, 0x62, 0x43, 0xC3, 0xE3, 0xF0, 0x78, 0x7E, 0x1F,
  0x0F, 0xC3, 0xC3, 0xC3, 0x43, 0x66, 0x08, 0x08, 0x08, 0x38, 0x01, 0x4C,
  0x02, 0xCC, 0x06, 0xCE, 0x0C, 0xCE, 0x08, 0xCE, 0x10, 0xCE, 0x20, 0xCC,
  0x40, 0x4C, 0x80, 0x39, 0x1C, 0x03, 0x36, 0x02, 0x73, 0x04, 0x73, 0x08,
  0x73, 0x10, 0x73, 0x20, 0x73, 0x40, 0x36, 0x40, 0x1C, 0x0F, 0x00, 0xCC,
  0x06, 0x60, 0x73, 0x03, 0x90, 0x0D, 0x00, 0x73, 0xE7, 0x86, 0x6E, 0x26,
  0x71, 0x33, 0xD1, 0x8E, 0x8E, 0x78, 0x71, 0xE5, 0xC7, 0xC7, 0xDC, 0x26,
  0x73, 0x12, 0x20, 0x04, 0x63, 0x08, 0x61, 0x86, 0x18, 0xE3, 0x8E, 0x38,
  0xE1, 0x86, 0x18, 0x60, 0x83, 0x04, 0x0C, 0xC0, 0x81, 0x04, 0x18, 0x61,
  0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x61, 0x08, 0x40, 0x18,
  0x5C, 0xCB, 0x6F, 0x19, 0x77, 0xEB, 0x5C, 0x18, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x46, 0xF3, 0x22, 0x40, 0x1E, 0xF8, 0x07,
  0xEF, 0x80, 0x23, 0x3C, 0x40, 0x00, 0x20, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x03, 0x30, 0xC7, 0x18, 0x67, 0x0E, 0xE1, 0xDC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xCC, 0x31, 0x8E, 0x19, 0x81, 0xE0,
  0x08, 0x18, 0x38, 0x78, 0x98, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1C, 0x3C, 0x7F, 0x1F, 0x07, 0xF9, 0x8F, 0x20, 0xE8, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x82, 0x20,
  0x4F, 0xFB, 0xFE, 0xFF, 0xC0, 0x1F, 0x04, 0x79, 0x07, 0x00, 0xF0, 0x1C,
  0x03, 0x80, 0xE0, 0x7E, 0x13, 0xC0, 0x1C, 0x03, 0x80, 0x76, 0x0F, 0xC1,
  0xD8, 0x33, 0x8C, 0x1F, 0x00, 0x03, 0x00, 0x60, 0x1C, 0x05, 0x80, 0xB0,
  0x26, 0x08, 0xC1, 0x18, 0x43, 0x10, 0x63, 0xFF, 0xFF, 0xF0, 0x30, 0x06,
  0x00, 0xE0, 0x3C, 0x0F, 0xE0, 0x40, 0x47, 0xF0, 0xFE, 0x16, 0x02, 0x00,
  0x40, 0x0F, 0xC1, 0xFE, 0x3F, 0xCC, 0x3D, 0x03, 0x80, 0x30, 0x06, 0xC0,
  0xF8, 0x1B, 0x06, 0x71, 0x83, 0xE0, 0x0F, 0x03, 0x30, 0xC7, 0x18, 0x67,
  0x0C, 0xE0, 0x1C, 0x03, 0xBC, 0x79, 0xCE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E,
  0xE1, 0xDC, 0x31, 0x86, 0x39, 0x81, 0xE0, 0x7F, 0xDF, 0xF4, 0x06, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x00, 0x06, 0x03, 0x30, 0x81, 0x30, 0x26, 0x04,
  0xE1, 0x9F, 0x21, 0xF8, 0x1F, 0x82, 0xF8, 0x87, 0x20, 0x74, 0x07, 0x80,
  0xF0, 0x1B, 0x06, 0x30, 0xC3, 0xE0, 0x0F, 0x06, 0x30, 0xC7, 0x30, 0xE6,
  0x1C, 0xC3, 0xF8, 0x3B, 0x0F, 0x71, 0xEE, 0x5C, 0xFB, 0x80, 0x60, 0x0C,
  0xC3, 0x9C, 0x63, 0x8C, 0x31, 0x03, 0xC0, 0x23, 0x3C, 0x40, 0x00, 0x00,
  0x23, 0x3C, 0x40, 0x23, 0x3C, 0x40, 0x00, 0x00, 0x43, 0x3C, 0x62, 0x11,
  0x00, 0x06, 0x18, 0x61, 0x86, 0x1E, 0x0E, 0x0E, 0x0E, 0x0C, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xCE, 0x38, 0xE1, 0x80,
  0x3E, 0x31, 0xE0, 0x78, 0x3E, 0x1A, 0x1C, 0x3C, 0x7C, 0x78, 0x30, 0x18,
  0x46, 0x41, 0xE0, 0x00, 0x20, 0x18, 0x1E, 0x04, 0x00, 0x03, 0xE0, 0x18,
  0x70, 0xC0, 0x21, 0x80, 0x66, 0x1F, 0x4C, 0xEC, 0xB1, 0x99, 0x66, 0x32,
  0xCC, 0xCC, 0xB9, 0x91, 0x37, 0x63, 0x77, 0xB3, 0x00, 0xC3, 0x03, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x47, 0xF0, 0x31, 0x0F, 0x1E, 0x40, 0xF7, 0x88,
  0x0E, 0x71, 0x01, 0xCE, 0x20, 0x39, 0xC7, 0x07, 0x38, 0xF8, 0xE7, 0x07,
  0x18, 0xE0, 0x26, 0x1C, 0x08, 0x83, 0x80, 0x20, 0x70, 0x0C, 0x0E, 0x07,
  0xC1, 0xC1, 0x7E, 0x7D, 0x03, 0xF3, 0xC0, 0x3C, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0xFF, 0x97, 0x87, 0xBE, 0x8E, 0x18, 0x3C, 0x3C, 0xC0,
  0x70, 0xF3, 0x01, 0xC1, 0xEC, 0x03, 0x02, 0x10, 0x0C, 0x78, 0x61, 0x37,
  0xF0, 0xF8, 0x83, 0xE0, 0x04, 0x03, 0x80, 0x20, 0x07, 0x01, 0x00, 0x1C,
  0x1F, 0x00, 0x60, 0xBE, 0x01, 0x80, 0x7C, 0x0C, 0x00, 0xFC, 0x60, 0x00,
  0xFE, 0x00, 0x0F, 0x18, 0x30, 0xBF, 0x30, 0xFE, 0x61, 0x08, 0xE7, 0x00,
  0xE7, 0x00, 0xE7, 0x80, 0xE7, 0xC0, 0xE3, 0xE0, 0xE1, 0xF0, 0xF0, 0xF0,
  0xF0, 0x70, 0x70, 0x70, 0x78, 0x60, 0x3C, 0x80, 0x1F, 0x02, 0x0F, 0xFF,
  0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0x38, 0x4F, 0x8C,
  0x10, 0x79, 0x06, 0x07, 0xA1, 0xE0, 0x74, 0x3E, 0x06, 0x83, 0xE0, 0xD0,
  0x3C, 0x09, 0x03, 0x81, 0x1E, 0x30, 0x20, 0x04, 0x04, 0x01, 0x00, 0x87,
  0xE0, 0x21, 0xFE, 0x08, 0x47, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x18, 0x30, 0xBF, 0x30, 0xFE, 0x61, 0x08, 0x67, 0x00, 0xE7, 0x00,
  0xE7, 0x9C, 0xE7, 0xFF, 0xE3, 0xEE, 0xE1, 0xF4, 0xE0, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x78, 0x60, 0x3C, 0x80, 0x1F, 0x02, 0x0F, 0xFF, 0x07, 0xF8,
  0x07, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xF4, 0xC0, 0xFE, 0x60, 0x6F, 0x10,
  0x10, 0x84, 0x0E, 0x01, 0x03, 0xC6, 0x40, 0x7B, 0xD0, 0x1F, 0xF2, 0x03,
  0xC8, 0x7E, 0x78, 0x18, 0x1E, 0x03, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x60, 0x03, 0xE0, 0x00,
  0x07, 0x08, 0x06, 0x27, 0x03, 0x07, 0xE1, 0xC2, 0x3C, 0x63, 0x07, 0xB9,
  0xC0, 0x8E, 0x70, 0xC3, 0x9E, 0x7C, 0xE3, 0xEF, 0xB8, 0xF0, 0xEE, 0x1E,
  0x3B, 0x83, 0x87, 0xF0, 0x61, 0x9C, 0x10, 0x67, 0x88, 0x38, 0xF4, 0x0C,
  0x1E, 0x06, 0x01, 0xE6, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0x00, 0x11, 0xF0, 0x08, 0x38, 0x02, 0x00, 0x01, 0xC0, 0x40, 0x70,
  0x78, 0x1E, 0x3F, 0x03, 0xF3, 0xC0, 0xF8, 0x78, 0x1E, 0x0E, 0x03, 0xC3,
  0xC0, 0x70, 0x70, 0x0C, 0x1C, 0xE3, 0x06, 0x7C, 0x81, 0xA7, 0xC0, 0xC0,
  0xE0, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F,
  0xF8, 0x0C, 0x3E, 0x04, 0x07, 0xE2, 0x00, 0xC3, 0x00, 0x40, 0x80, 0x60,
  0x40, 0x70, 0x30, 0x38, 0x0C, 0x5E, 0x01, 0xC7, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x10, 0x0E, 0x3E, 0x03, 0x2F, 0x81, 0x23,
  0xE1, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x0C, 0x3E,
  0x04, 0x07, 0xE6, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x60, 0x40, 0x30, 0x20,
  0x3C, 0x0C, 0x4E, 0x01, 0xC7, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC7, 0xC0,
  0x65, 0xF0, 0x20, 0x7C, 0x20, 0x1F, 0xA0, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x1C, 0x38, 0x03, 0x00, 0xC0, 0x63, 0xC6, 0x0E, 0xFE, 0x20, 0xE8, 0xF2,
  0x0F, 0x07, 0x30, 0xF0, 0x7B, 0x0F, 0x03, 0x20, 0x78, 0x24, 0x07, 0x8E,
  0x80, 0x3F, 0xF0, 0x01, 0xC7, 0x00, 0x0C, 0x70, 0x38, 0xC7, 0x87, 0xC8,
  0x38, 0xBF, 0x03, 0xF1, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x39,
  0xC1, 0x81, 0x8C, 0x06, 0x38, 0x1D, 0xE0, 0x73, 0x81, 0x8F, 0x06, 0x1D,
  0xF0, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0xE0, 0x3F,
  0xC3, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x04, 0x04, 0x00, 0x0F, 0xE7,
  0xCF, 0x87, 0xFF, 0xFC, 0xF3, 0x0F, 0x8F, 0x1C, 0x81, 0xE3, 0xC7, 0x20,
  0x3C, 0x71, 0xE8, 0x07, 0x1C, 0x3E, 0x01, 0xC3, 0x04, 0x88, 0x70, 0xC2,
  0x1F, 0x0C, 0x31, 0x03, 0x23, 0x0C, 0xC0, 0x10, 0x83, 0x70, 0x00, 0x20,
  0x9C, 0x00, 0x18, 0x27, 0x01, 0x85, 0x11, 0xE1, 0xF2, 0xF4, 0x3D, 0x9F,
  0x7E, 0x0F, 0x83, 0x87, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x03, 0x01,
  0xFC, 0x7E, 0x1F, 0xF2, 0xF1, 0x87, 0xE3, 0xC8, 0x1E, 0x0E, 0x40, 0x78,
  0x72, 0x01, 0xC3, 0xD0, 0x0E, 0x08, 0xDC, 0x70, 0x83, 0xE1, 0x88, 0x08,
  0x8C, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x33, 0xC0, 0x61, 0x0E,
  0x0F, 0x90, 0x7E, 0x9F, 0x01, 0xE0, 0x70, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0x1F, 0xC6, 0x03, 0xE6, 0x00, 0x7B,
  0x00, 0x1D, 0xE0, 0x07, 0xFC, 0x03, 0xBF, 0x00, 0xCF, 0xC0, 0x60, 0xE0,
  0x30, 0x20, 0x11, 0xE0, 0x0B, 0xF0, 0x09, 0x7E, 0x08, 0x1F, 0xD8, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x7E, 0x06, 0x07, 0xFE, 0x78,
  0x10, 0x7F, 0xE0, 0xC0, 0xF3, 0xC2, 0x03, 0xCF, 0x88, 0x07, 0x1F, 0x20,
  0x1C, 0x1E, 0x40, 0x70, 0x38, 0xFD, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C,
  0x02, 0x00, 0x70, 0x08, 0x01, 0xC0, 0x20, 0x1F, 0x01, 0x00, 0xFF, 0x08,
  0x04, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x63, 0xF8, 0x60, 0x3E, 0x30, 0x03, 0xCC, 0x00, 0x73, 0xC0, 0x0E, 0xFC,
  0x03, 0x9F, 0x80, 0x63, 0xF0, 0x18, 0x18, 0x06, 0x02, 0x01, 0x0F, 0x07,
  0x4F, 0xC3, 0xE2, 0xFD, 0x3D, 0x1F, 0xDF, 0x81, 0xF8, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x03, 0x00, 0xFE, 0x1F, 0x07, 0xFC, 0x9E, 0x30, 0xFC,
  0x38, 0x80, 0xF0, 0xF2, 0x01, 0xC3, 0xE8, 0x07, 0x07, 0x20, 0x0C, 0x10,
  0x80, 0x31, 0x81, 0x00, 0xCE, 0x03, 0xE3, 0x7C, 0x00, 0x0C, 0xF0, 0x00,
  0x31, 0xC0, 0x00, 0x87, 0x81, 0xC6, 0x1E, 0x0F, 0x90, 0x3C, 0x5F, 0x80,
  0xFC, 0x3C, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xF8, 0x83, 0xFF, 0xE2, 0x0F,
  0xC2, 0x00, 0x82, 0x00, 0x03, 0x00, 0x61, 0x80, 0xFC, 0xC9, 0xFF, 0x63,
  0xF8, 0x70, 0xF0, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x05, 0xF0, 0x0C,
  0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x10,
  0x7E, 0x10, 0x0F, 0xD8, 0x19, 0xF4, 0x18, 0x72, 0x0E, 0x01, 0x07, 0x80,
  0x43, 0xE0, 0x1E, 0xF8, 0x00, 0x3C, 0x02, 0x0E, 0x07, 0xC6, 0x07, 0xF2,
  0x00, 0x7E, 0x00, 0x1F, 0x02, 0x07, 0xE6, 0x00, 0xFC, 0x00, 0x0F, 0x01,
  0x8C, 0x43, 0x0E, 0x27, 0x87, 0x21, 0xC3, 0xC0, 0xE1, 0xF0, 0x70, 0x78,
  0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0x07, 0x01, 0x03, 0x81, 0x01, 0xC1,
  0x80, 0xE1, 0xE0, 0xF1, 0x7C, 0xB8, 0x1F, 0x9F, 0x07, 0x86, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x07, 0x01, 0xFC, 0xFC, 0x1F, 0xF8, 0xF1, 0x83,
  0xC3, 0x88, 0x0E, 0x1E, 0x40, 0x30, 0x62, 0x01, 0x82, 0x10, 0x0C, 0x30,
  0x82, 0x61, 0x83, 0xE2, 0x1E, 0x00, 0x30, 0x78, 0x01, 0x01, 0xE0, 0x70,
  0x07, 0x0F, 0xC0, 0x38, 0x9F, 0x00, 0x80, 0x7E, 0x08, 0x01, 0xFC, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x04, 0x38, 0x07, 0xF3, 0xBF, 0x83,
  0xFF, 0x10, 0xF1, 0x83, 0xCC, 0x1C, 0x40, 0x73, 0x07, 0x90, 0x1C, 0xC0,
  0xE4, 0x03, 0x78, 0x21, 0x00, 0xCE, 0x18, 0x40, 0x33, 0xC6, 0x0C, 0xC8,
  0x73, 0xE0, 0xC6, 0x1C, 0x7C, 0x01, 0x03, 0x0F, 0x00, 0x80, 0xC1, 0xC3,
  0xE0, 0x20, 0x31, 0xFC, 0x0E, 0x08, 0x07, 0x87, 0xC2, 0x01, 0xFE, 0xFD,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x06, 0x1F, 0xC7, 0xCF,
  0xF3, 0xEC, 0x3E, 0x64, 0x0F, 0x02, 0x03, 0x81, 0x01, 0x80, 0x80, 0xFE,
  0x24, 0xFE, 0x0D, 0xFE, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x65, 0xE0, 0x7E, 0x7F, 0x3F, 0x1F, 0x27, 0x07, 0x00, 0x1F, 0x0F,
  0x07, 0xF9, 0xF8, 0x7F, 0xE3, 0xCC, 0x1E, 0x1C, 0x80, 0xE1, 0xE8, 0x06,
  0x0F, 0x80, 0x60, 0x48, 0x06, 0x18, 0x42, 0x63, 0x83, 0xC6, 0x38, 0x00,
  0xC3, 0xC0, 0x08, 0x3C, 0x01, 0x01, 0xE0, 0x10, 0x1E, 0x03, 0x88, 0xE0,
  0x7F, 0x0E, 0x0B, 0xE0, 0xE0, 0x0C, 0x0E, 0x08, 0x01, 0xC0, 0x40, 0x18,
  0x02, 0x07, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xFC, 0x18, 0x3C, 0x10,
  0x0E, 0x10, 0x0E, 0x10, 0x0E, 0x18, 0x0C, 0x0E, 0x18, 0x00, 0x30, 0x01,
  0xFC, 0x02, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x38,
  0x03, 0x7E, 0x02, 0x9F, 0x06, 0x0F, 0x84, 0x07, 0xF8, 0x01, 0xC0, 0xFE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xF0, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xF3, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xF0, 0x08, 0x0C, 0x0F, 0x0E, 0xC4, 0x34, 0x0A,
  0x02, 0xFF, 0xFF, 0xFF, 0xCE, 0x62, 0x10, 0x08, 0x03, 0x01, 0xE0, 0x9E,
  0x43, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x38, 0xCE, 0x35, 0xFE, 0x33, 0x88,
  0x40, 0x1C, 0x2C, 0x0E, 0x01, 0x80, 0x62, 0x18, 0xC7, 0xF1, 0xCE, 0x71,
  0x9C, 0x77, 0x1D, 0xC6, 0x71, 0x9C, 0x4F, 0xA0, 0xF0, 0x18, 0x02, 0x00,
  0x08, 0x79, 0x3E, 0x7C, 0x58, 0x30, 0x60, 0xC1, 0xC3, 0xC3, 0xF3, 0x82,
  0x00, 0xC0, 0x20, 0x0C, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0x79, 0xCE, 0x71,
  0xDC, 0x77, 0x0D, 0xC3, 0x70, 0x9C, 0x2F, 0x90, 0xF8, 0x0C, 0x00, 0x04,
  0x3C, 0x4C, 0xCE, 0xC6, 0xC6, 0xD8, 0xE0, 0xC0, 0xE0, 0xF0, 0x7E, 0x38,
  0x10, 0x10, 0x7C, 0xFA, 0x04, 0x0C, 0x3F, 0x38, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x00, 0x08, 0x03, 0x03,
  0xF1, 0x9E, 0x41, 0xB0, 0x4C, 0x33, 0x0C, 0xC3, 0x38, 0xEE, 0x39, 0xDE,
  0x39, 0x90, 0x60, 0x1B, 0x06, 0x63, 0x0F, 0x00, 0x00, 0x07, 0x8B, 0x03,
  0x80, 0x60, 0x18, 0x86, 0x61, 0xFC, 0x63, 0x98, 0xE6, 0x19, 0xC7, 0x71,
  0xDC, 0x67, 0x19, 0xC6, 0xF9, 0x0C, 0x82, 0x60, 0x30, 0x10, 0x08, 0x00,
  0x38, 0xE3, 0x00, 0x20, 0xC7, 0xAE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xCF,
  0x18, 0x00, 0x1C, 0x38, 0x60, 0x00, 0x02, 0x0E, 0x3E, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0x44, 0x70, 0x00, 0x0F,
  0x5A, 0x3B, 0x3F, 0x38, 0x38, 0x7E, 0xB8, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3A, 0x7C, 0x08, 0x00, 0x0F, 0x58, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3A, 0x7C, 0x08, 0x00, 0x42,
  0x10, 0x67, 0xB8, 0xFB, 0xDE, 0x71, 0x8C, 0x71, 0x8C, 0x71, 0x8C, 0x71,
  0x8C, 0x71, 0x8C, 0x71, 0x8C, 0x71, 0x8C, 0x73, 0x8F, 0x7B, 0xCF, 0x21,
  0x86, 0x42, 0x0C, 0x63, 0xDF, 0x3C, 0xC7, 0x18, 0xE3, 0x1C, 0x63, 0x8C,
  0x71, 0x8E, 0x31, 0xC6, 0xBC, 0xE2, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x87,
  0x71, 0x9E, 0x63, 0x98, 0x76, 0x1D, 0x87, 0x61, 0x9C, 0x6F, 0x90, 0xF8,
  0x08, 0x00, 0x00, 0x40, 0x08, 0x03, 0x84, 0x79, 0xC7, 0x78, 0x73, 0x8C,
  0x79, 0x87, 0x30, 0xE7, 0x1C, 0xE3, 0x3C, 0x6F, 0xC8, 0x7E, 0x0F, 0x81,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x04, 0x03, 0x81, 0xF0, 0x8F,
  0x61, 0x98, 0x66, 0x1B, 0x86, 0xE1, 0x9C, 0x67, 0x38, 0xF6, 0x19, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x22, 0x39, 0x9F, 0xC7, 0x73, 0xA1,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x8F, 0x80, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x08, 0x21, 0x1E, 0x4B, 0xE4, 0x31, 0x88, 0x73, 0x1F, 0xE3, 0x38,
  0x86, 0x30, 0x9F, 0x41, 0xE0, 0x10, 0x06, 0x08, 0x20, 0xC3, 0x9F, 0xCE,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x5F, 0x04, 0x00, 0x41, 0x0C, 0x33,
  0xCF, 0x38, 0xC7, 0x18, 0xE3, 0x1C, 0x63, 0x8C, 0x71, 0x8E, 0x31, 0xCE,
  0xFE, 0xE1, 0x8C, 0x00, 0x00, 0x40, 0x08, 0x23, 0x8E, 0x77, 0xCF, 0x1C,
  0xE3, 0x8E, 0x38, 0xC7, 0x10, 0xC2, 0x18, 0xC2, 0x1C, 0x87, 0xE0, 0x18,
  0x00, 0x40, 0x00, 0x80, 0x00, 0xC0, 0x08, 0xF3, 0x8C, 0xF7, 0xBC, 0x79,
  0xCE, 0x31, 0xC6, 0x31, 0xC7, 0x31, 0xC7, 0x31, 0xC6, 0x31, 0xC6, 0x31,
  0xC4, 0x73, 0xE8, 0x78, 0xF0, 0x30, 0x20, 0x20, 0x20, 0x22, 0x73, 0xFF,
  0x3B, 0x3A, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3E, 0x7C, 0x98, 0x80, 0x80,
  0x84, 0x4E, 0x3C, 0x40, 0x20, 0x0C, 0x23, 0xDC, 0x7F, 0x9C, 0xE7, 0x1D,
  0xC7, 0x71, 0xDC, 0x37, 0x0D, 0xC3, 0x75, 0xBE, 0x63, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x00, 0x20, 0x61, 0xE4, 0xE1, 0x82, 0x09, 0xFC, 0x78, 0xBA,
  0x3C, 0x78, 0xF1, 0xE3, 0x46, 0x88, 0xE0, 0x0E, 0x30, 0x61, 0xC3, 0x83,
  0x06, 0x0C, 0x31, 0x80, 0xC0, 0xC1, 0x83, 0x0E, 0x1C, 0x18, 0x30, 0x30,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x20, 0x60, 0xC1, 0x87,
  0x0E, 0x0C, 0x08, 0x0C, 0x30, 0xC3, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x86,
  0x00, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 18, 6, 1, -18 },
  { 10, 8, 7, 10, 1, -18 },
  { 17, 11, 14, 13, 1, -16 },
  { 37, 8, 20, 10, 1, -19 },
  { 57, 16, 18, 18, 1, -18 },
  { 93, 13, 16, 14, 1, -16 },
  { 119, 4, 7, 5, 0, -18 },
  { 123, 6, 21, 6, 0, -20 },
  { 139, 6, 21, 6, 0, -20 },
  { 155, 8, 9, 9, 0, -18 },
  { 164, 8, 9, 10, 1, -13 },
  { 173, 4, 7, 5, 0, -4 },
  { 177, 7, 5, 7, 1, -10 },
  { 182, 5, 4, 5, 0, -4 },
  { 185, 12, 20, 13, 1, -19 },
  { 215, 11, 18, 12, 0, -18 },
  { 240, 8, 17, 8, 0, -17 },
  { 257, 11, 17, 11, 0, -17 },
  { 281, 11, 17, 12, 0, -17 },
  { 305, 11, 17, 11, 0, -17 },
  { 329, 11, 18, 12, 0, -18 },
  { 354, 11, 18, 11, 0, -18 },
  { 379, 10, 17, 11, 0, -17 },
  { 401, 11, 18, 12, 0, -18 },
  { 426, 11, 18, 11, 0, -18 },
  { 451, 5, 12, 5, 0, -12 },
  { 459, 5, 15, 4, 0, -12 },
  { 469, 7, 10, 7, 0, -12 },
  { 478, 8, 5, 10, 1, -10 },
  { 483, 7, 10, 7, 0, -12 },
  { 492, 9, 18, 11, 1, -18 },
  { 513, 15, 15, 15, 0, -12 },
  { 542, 19, 19, 20, 1, -18 },
  { 588, 22, 18, 22, 0, -18 },
  { 638, 16, 18, 17, 1, -18 },
  { 674, 19, 19, 20, 1, -18 },
  { 720, 16, 18, 18, 1, -18 },
  { 756, 18, 21, 19, 0, -18 },
  { 804, 18, 19, 19, 1, -18 },
  { 847, 18, 22, 18, 0, -19 },
  { 897, 17, 21, 17, 0, -18 },
  { 942, 17, 24, 18, 0, -18 },
  { 993, 20, 19, 20, 0, -18 },
  { 1041, 14, 19, 14, 0, -18 },
  { 1075, 26, 19, 28, 1, -18 },
  { 1137, 21, 19, 22, 1, -18 },
  { 1187, 17, 19, 19, 1, -18 },
  { 1228, 22, 22, 22, 0, -18 },
  { 1289, 18, 20, 20, 1, -18 },
  { 1334, 22, 18, 23, 1, -18 },
  { 1384, 17, 18, 19, 1, -18 },
  { 1423, 17, 18, 19, 1, -18 },
  { 1462, 17, 19, 18, 0, -17 },
  { 1503, 21, 19, 22, 1, -18 },
  { 1553, 26, 19, 27, 0, -18 },
  { 1615, 17, 18, 18, 0, -18 },
  { 1654, 20, 22, 21, 1, -18 },
  { 1709, 16, 21, 17, 0, -18 },
  { 1751, 4, 19, 5, 0, -18 },
  { 1761, 16, 17, 3, -5, -16 },
  { 1795, 4, 19, 5, 0, -18 },
  { 1805, 9, 7, 10, 1, -18 },
  { 1813, 12, 2, 11, 0, 3 },
  { 1816, 4, 5, 13, 4, -18 },
  { 1819, 10, 14, 12, 1, -13 },
  { 1837, 10, 18, 11, 1, -17 },
  { 1860, 7, 14, 9, 1, -13 },
  { 1873, 10, 17, 11, 1, -17 },
  { 1895, 8, 14, 9, 1, -13 },
  { 1909, 7, 22, 6, 0, -18 },
  { 1929, 10, 18, 12, 1, -13 },
  { 1952, 10, 22, 11, 1, -18 },
  { 1980, 6, 18, 7, 0, -17 },
  { 1994, 7, 23, 6, -1, -18 },
  { 2015, 8, 18, 8, 0, -17 },
  { 2033, 8, 18, 7, 0, -17 },
  { 2051, 16, 13, 18, 1, -13 },
  { 2077, 11, 14, 13, 1, -13 },
  { 2097, 10, 14, 10, 0, -13 },
  { 2115, 11, 20, 11, 0, -15 },
  { 2143, 10, 18, 11, 0, -13 },
  { 2166, 9, 14, 9, 0, -13 },
  { 2182, 10, 16, 10, 0, -16 },
  { 2202, 7, 17, 8, 0, -16 },
  { 2217, 11, 14, 13, 1, -13 },
  { 2237, 11, 14, 11, 0, -14 },
  { 2257, 16, 16, 17, 1, -15 },
  { 2289, 8, 18, 10, 1, -13 },
  { 2307, 10, 19, 12, 1, -15 },
  { 2331, 7, 18, 8, 1, -13 },
  { 2347, 7, 20, 8, 0, -19 },
  { 2365, 2, 21, 4, 1, -20 },
  { 2371, 7, 20, 8, 0, -19 },
  { 2389, 8, 2, 9, 1, -8 },
};

const GFXfont UnifrakturMaguntia_Regular25pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular25pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular25pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR25PT7B_H_
