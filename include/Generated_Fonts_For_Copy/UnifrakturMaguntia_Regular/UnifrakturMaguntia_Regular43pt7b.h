#ifndef _UNIFRAKTURMAGUNTIA_REGULAR43PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x18, 0x3C, 0x7E, 0xFF, 0x7E, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x38, 0x7E, 0x7E, 0x18, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x20, 0xE0, 0xE3, 0xE3, 0xFF, 0xEF, 0xE7, 0xC3, 0xC7, 0x07, 0x06, 0x06,
  0x08, 0x08, 0x10, 0x10, 0x40, 0x40, 0x80, 0x80, 0x03, 0xC7, 0x80, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x0F, 0x80, 0x7F, 0x83, 0x87, 0x1C, 0x06, 0x70, 0x1B,
  0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x27, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xD8, 0x0E, 0x30, 0x70, 0x7F,
  0x80, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0x31, 0xFC, 0x00, 0x06, 0x39, 0xE0, 0x00, 0xC7, 0x8E, 0x00, 0x0C,
  0x78, 0xF0, 0x01, 0x8F, 0x0F, 0x00, 0x30, 0xF0, 0xF0, 0x06, 0x0F, 0x0F,
  0x00, 0xC0, 0xF0, 0xF0, 0x18, 0x0F, 0x0F, 0x03, 0x00, 0xF0, 0xF0, 0x60,
  0x07, 0x8F, 0x06, 0x00, 0x78, 0xE0, 0xC0, 0x03, 0x9E, 0x18, 0x00, 0x1F,
  0xC3, 0x0F, 0x80, 0xF0, 0x61, 0xFC, 0x00, 0x0C, 0x39, 0xE0, 0x01, 0x87,
  0x8E, 0x00, 0x18, 0x78, 0xF0, 0x03, 0x07, 0x8F, 0x00, 0x60, 0xF8, 0xF0,
  0x0C, 0x0F, 0x8F, 0x01, 0x80, 0xF8, 0xF0, 0x30, 0x0F, 0x8F, 0x06, 0x00,
  0x78, 0xF0, 0xC0, 0x07, 0x8F, 0x0C, 0x00, 0x78, 0xE1, 0x80, 0x03, 0x9E,
  0x30, 0x00, 0x1F, 0xC2, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0,
  0x01, 0xE1, 0x80, 0x03, 0xE7, 0x00, 0x07, 0xDC, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x87, 0xF0, 0x1F, 0x0F, 0xE0, 0xDF, 0x07, 0x03, 0x3E, 0x06, 0x0E,
  0x3E, 0x08, 0x3C, 0x7C, 0x10, 0x78, 0x7C, 0x60, 0xF0, 0xF8, 0x83, 0xE1,
  0xFB, 0x07, 0xC1, 0xFC, 0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xF0, 0x9F, 0x83,
  0xF1, 0x9F, 0x8F, 0xFE, 0x1F, 0xFB, 0xF8, 0x1F, 0xC3, 0xC0, 0x00, 0x20,
  0xE7, 0xE7, 0xE7, 0x87, 0x0E, 0x18, 0x20, 0x41, 0x00, 0x01, 0x83, 0x03,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x80, 0x38, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0x07,
  0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x30,
  0x38, 0x18, 0x18, 0x38, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x07, 0xF8,
  0xF3, 0xBD, 0xEC, 0xF7, 0x97, 0x93, 0xF6, 0x47, 0x89, 0xF5, 0xE7, 0xB7,
  0xFC, 0xCF, 0x17, 0xA0, 0x3F, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x20, 0xE3, 0xFF, 0xE3, 0xC7, 0x06, 0x0C, 0x10, 0x40, 0x80, 0x00,
  0xF1, 0xFE, 0x1F, 0xE3, 0xC0, 0x00, 0x47, 0xFC, 0x7F, 0x8F, 0xC0, 0x00,
  0x60, 0xE7, 0xEF, 0xE7, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3C, 0x70, 0x0F, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1E, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0xDF, 0x80, 0xFB,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0x78, 0x07, 0x8E, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x08,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0xC7, 0xFF, 0x80,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xE1, 0xFC, 0x60, 0x1F, 0x98,
  0x07, 0xEC, 0x00, 0xFA, 0x00, 0x3E, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x20, 0xE0, 0x0C, 0x30, 0x02, 0x18, 0x00, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0x83, 0x87,
  0xF1, 0x80, 0x7C, 0x40, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x7F, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF7, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x71, 0xE0, 0x38, 0x3C, 0x18, 0x03,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0x78, 0x00, 0x6F, 0x00, 0x09, 0xE0, 0x02, 0x3C, 0x00,
  0xC7, 0x80, 0x10, 0xF0, 0x04, 0x1E, 0x01, 0x83, 0xC0, 0x20, 0x78, 0x0C,
  0x0F, 0x03, 0x01, 0xE0, 0x40, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x20,
  0x01, 0x07, 0xC7, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x05, 0xF8,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x7F, 0x00,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x83, 0xF9, 0xC0, 0x3E, 0x40,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xBE, 0x01, 0xEF, 0x80, 0x71,
  0xE0, 0x38, 0x3C, 0x1C, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xC7, 0x80,
  0xE0, 0xF0, 0x30, 0x3C, 0x1C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0,
  0x1C, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE3, 0xF0, 0xF9, 0xFE,
  0x3E, 0xC7, 0xCF, 0xA0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xE7, 0xC0, 0x79, 0xF0,
  0x1E, 0x7C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0x78, 0x30, 0x0E, 0x18,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEE,
  0x00, 0x36, 0x00, 0x12, 0x00, 0x19, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0x03, 0x83, 0x80, 0x70,
  0xE0, 0x0C, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x0E, 0x7C,
  0x03, 0x1F, 0x81, 0xC7, 0xF8, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x37, 0xFC, 0x38, 0x7F, 0x9C, 0x0F, 0xE7, 0x00, 0xFB,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xB8, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x1C, 0x1C, 0x1C, 0x01, 0xFC,
  0x00, 0x03, 0xE0, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0xE0, 0x78, 0x38, 0x1F,
  0x1E, 0x03, 0xC7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x81, 0xF9, 0xF0,
  0x7E, 0x7C, 0x2F, 0x8F, 0xFB, 0xE1, 0xFC, 0xF8, 0x08, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC3, 0x00, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x3F, 0x07, 0x87,
  0xC1, 0xC0, 0xF0, 0x60, 0x1E, 0x30, 0x03, 0xF0, 0x00, 0x10, 0x61, 0xF7,
  0xF3, 0x86, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1C, 0xFD,
  0xFC, 0xE0, 0x80, 0x00, 0x08, 0x18, 0x3E, 0x7F, 0x1C, 0x18, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x38, 0x7E, 0xFE, 0x1E, 0x1C,
  0x0C, 0x0C, 0x08, 0x10, 0x10, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x7C, 0x0F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x07, 0xF0,
  0x0E, 0x1E, 0x0C, 0x07, 0x8C, 0x01, 0xE6, 0x00, 0xF7, 0xC0, 0x7B, 0xF0,
  0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x01, 0x03, 0x80, 0x80, 0xE0, 0xC0, 0x38, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0xC1, 0xE0, 0x00,
  0x70, 0xE0, 0x7F, 0x98, 0xE0, 0x7F, 0xCC, 0x70, 0xF3, 0xC7, 0x70, 0x71,
  0xE3, 0xB8, 0x78, 0xF1, 0xDC, 0x78, 0x70, 0xCE, 0x3C, 0x38, 0x67, 0x3C,
  0x3C, 0x73, 0x9E, 0x1C, 0x31, 0xCF, 0x1E, 0x38, 0xE7, 0x9F, 0x38, 0x71,
  0xFB, 0xF9, 0xD8, 0xF1, 0xF0, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x1F, 0x01, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0x03, 0xFF, 0xE0, 0x07, 0x03, 0xFF, 0xF8, 0x0F, 0x83, 0x01, 0xFE, 0x1F,
  0x83, 0x00, 0x7F, 0x1F, 0xC1, 0x00, 0x1F, 0xC7, 0xE1, 0x80, 0x07, 0xE3,
  0xF0, 0xC0, 0x03, 0xF1, 0xF8, 0x60, 0x00, 0xF8, 0xFC, 0x30, 0x00, 0x7C,
  0x7E, 0x1C, 0x00, 0x3E, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x83, 0xF8, 0x0F,
  0x0F, 0xC1, 0xFE, 0x07, 0x87, 0xE0, 0x7F, 0x83, 0x83, 0xF0, 0x0F, 0xC3,
  0xC1, 0xF8, 0x01, 0xE1, 0xC0, 0xFC, 0x00, 0x61, 0xC0, 0x7E, 0x00, 0x30,
  0xC0, 0x3F, 0x00, 0x20, 0xC0, 0x1F, 0x80, 0x00, 0xC0, 0x0F, 0xC0, 0x00,
  0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xE0, 0xBF, 0x20, 0x0F, 0xFD, 0x9F, 0xE0,
  0x03, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x1F, 0x80, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x0F,
  0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xC8, 0x3F, 0x03, 0xF0,
  0xFF, 0x41, 0xF8, 0x1E, 0x01, 0xFC, 0x07, 0xE1, 0xC0, 0x07, 0xE0, 0x3F,
  0x0C, 0x00, 0x3F, 0x01, 0xF8, 0x60, 0x00, 0xF8, 0x07, 0xE3, 0x00, 0x07,
  0xC0, 0x3F, 0x98, 0x00, 0x1E, 0x00, 0xF0, 0xC0, 0x00, 0xF0, 0x06, 0x06,
  0x00, 0x07, 0x81, 0xE0, 0x30, 0x00, 0x3C, 0x3F, 0xC0, 0xC0, 0x01, 0xC7,
  0xFF, 0x83, 0x01, 0x0E, 0x7F, 0xFE, 0x0F, 0xF0, 0xE0, 0x0F, 0xF0, 0x00,
  0x06, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x01,
  0xF0, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x00, 0x3C, 0x00, 0xFC,
  0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0x01, 0xFF, 0xE0, 0x00, 0x70,
  0x00, 0xFF, 0x80, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x30, 0x00, 0x0F, 0xFC,
  0x03, 0x00, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x1C, 0x00,
  0x3C, 0x63, 0xF0, 0x07, 0x02, 0x7F, 0xF0, 0xF0, 0x1F, 0xFE, 0x1E, 0x01,
  0xBF, 0xC1, 0xE0, 0x60, 0x70, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7,
  0xF0, 0x00, 0x7C, 0x7F, 0x80, 0x0F, 0xC3, 0xFC, 0x00, 0xFC, 0x1F, 0xE0,
  0x0F, 0xC0, 0xFF, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x3F, 0x80, 0x70, 0x01, 0xFC, 0x0E, 0x00, 0x1F, 0xE1, 0xC0, 0x00,
  0xFF, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x06, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x01, 0xFF,
  0x81, 0xF0, 0x0C, 0x1F, 0xE0, 0xF0, 0x0C, 0x07, 0xF8, 0xE0, 0x1C, 0x00,
  0xFC, 0x70, 0x0E, 0x00, 0x3F, 0x30, 0x0F, 0x80, 0x0F, 0x98, 0x07, 0xE0,
  0x03, 0xEC, 0x03, 0xF8, 0x01, 0xF6, 0x01, 0xFE, 0x00, 0x7B, 0x00, 0x7F,
  0x80, 0x3C, 0x80, 0x1F, 0xE0, 0x0E, 0x40, 0x07, 0xF0, 0x07, 0x90, 0x01,
  0xF8, 0x01, 0x8E, 0x00, 0x7C, 0x00, 0xC1, 0xFE, 0x1E, 0x00, 0x60, 0x18,
  0x0F, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x04, 0x01, 0xFF, 0x80, 0x06, 0x01,
  0xFF, 0xF0, 0x06, 0x03, 0xFF, 0xFE, 0x06, 0x01, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x38, 0x63, 0xF0,
  0x07, 0x03, 0x7F, 0xF0, 0xE0, 0x1F, 0xFE, 0x1E, 0x01, 0xBF, 0xC1, 0xC0,
  0x60, 0x70, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7E, 0x04, 0x07, 0xC7, 0xF0, 0xF0, 0x7C,
  0x7F, 0x9F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xE7, 0xEF, 0xC0, 0xFF,
  0x3C, 0x7C, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x3F, 0x80,
  0x70, 0x01, 0xFC, 0x0E, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0xFF, 0x30, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x06, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x3F, 0xFF, 0x0E, 0x00, 0x0F, 0xFC,
  0x38, 0x00, 0x27, 0xF0, 0x60, 0x00, 0xC7, 0x80, 0xC0, 0x03, 0x02, 0x03,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x18,
  0x00, 0xFC, 0x06, 0x10, 0x01, 0xFC, 0x1E, 0x30, 0x03, 0xF8, 0x7E, 0x60,
  0x03, 0xF9, 0xFE, 0x60, 0x07, 0xFF, 0xF8, 0x60, 0x07, 0xF9, 0xE0, 0x7B,
  0xE7, 0xF1, 0x80, 0x1C, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x07, 0x80,
  0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x0F, 0x83, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x02, 0x00, 0x03, 0xC6, 0x0E, 0x00, 0x0E, 0x02, 0x7E,
  0x00, 0x38, 0x05, 0xFE, 0x00, 0xF0, 0x0C, 0xFE, 0x03, 0xC0, 0x20, 0xFE,
  0x07, 0x81, 0x80, 0xFE, 0x1E, 0x07, 0x00, 0xFE, 0x3C, 0x1C, 0x00, 0xF0,
  0xF8, 0x78, 0x01, 0x81, 0xF0, 0xF8, 0x06, 0x03, 0xE1, 0xF0, 0x3E, 0x07,
  0xC3, 0xF0, 0xFF, 0x1F, 0x87, 0xE7, 0xFE, 0x3F, 0x07, 0xE0, 0xFE, 0x7E,
  0x0F, 0xE0, 0xFE, 0xFC, 0x0F, 0xE0, 0xFD, 0xF8, 0x0F, 0xC0, 0xFB, 0xF0,
  0x1F, 0xC1, 0xFB, 0xF0, 0x1F, 0x81, 0xF7, 0xE0, 0x1F, 0x03, 0xEF, 0xC0,
  0x3E, 0x07, 0xCF, 0xC0, 0x38, 0x0F, 0x1F, 0x80, 0x70, 0x1E, 0x1F, 0x81,
  0x80, 0x3C, 0x3F, 0x06, 0x00, 0xF0, 0x3F, 0x10, 0x01, 0xC0, 0x3F, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x06, 0x7F, 0x80, 0x00, 0x10, 0x3F, 0xC0, 0x00, 0x60, 0x7F, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x18, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xFC, 0x1F, 0xF8, 0x01, 0xFC, 0x7F, 0xF8, 0x01, 0xFB, 0x8F, 0xF0, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x3C, 0x0E,
  0x01, 0xF1, 0xFC, 0x1C, 0x03, 0xE7, 0xFC, 0x30, 0x07, 0x8B, 0xFC, 0xC0,
  0x0F, 0x03, 0xFF, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0xE0, 0x01, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x01, 0xF0, 0x7F, 0xC0, 0x38, 0x07, 0xFC, 0x8E, 0x00, 0x3F,
  0xF9, 0x80, 0x03, 0xFC, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x80, 0x60, 0x00, 0xF0,
  0x0E, 0x00, 0x1F, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0x79,
  0xCF, 0xC0, 0x03, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF3,
  0xFC, 0x00, 0x3C, 0xFF, 0xC0, 0x03, 0xB3, 0xFC, 0x00, 0x60, 0x3F, 0xC0,
  0x18, 0x03, 0xFE, 0x02, 0x00, 0x3F, 0xE1, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xE0, 0xFF, 0xC0,
  0x1E, 0x01, 0xFF, 0x20, 0xE0, 0x07, 0xFF, 0x86, 0x00, 0x0F, 0xE0, 0x30,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x78, 0x02, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x3E, 0x00, 0xC0, 0x01, 0xF0,
  0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x3C, 0x73, 0xF0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x06, 0x1F, 0xF8, 0x00,
  0x71, 0xFF, 0xE0, 0x03, 0x08, 0x7F, 0x80, 0x18, 0x01, 0xFE, 0x01, 0x80,
  0x07, 0xFC, 0x18, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0x03, 0xC0, 0x70, 0x07, 0x87, 0xF8, 0x18, 0x03, 0xC7, 0xFF, 0x0E,
  0x03, 0xC7, 0x3F, 0x83, 0x01, 0xE2, 0x07, 0xE1, 0x80, 0xF3, 0x03, 0xF0,
  0xE0, 0xFD, 0x00, 0xFC, 0x70, 0x3E, 0x80, 0x7E, 0x38, 0x1F, 0xC0, 0x1F,
  0xD8, 0x0F, 0xE0, 0x07, 0x8C, 0x07, 0xF8, 0x01, 0x86, 0x01, 0xFC, 0x03,
  0x06, 0x00, 0xFF, 0x07, 0x86, 0x00, 0x3F, 0xCF, 0xE4, 0x00, 0x0F, 0xEF,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x1C, 0x07, 0x03, 0xF0, 0x1F, 0x83,
  0x81, 0xF8, 0x1F, 0xC1, 0x80, 0x7E, 0x17, 0xF0, 0x80, 0x3F, 0x81, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xE0, 0x02,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x07, 0x03, 0xE0, 0x3C, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1F,
  0x00, 0x1E, 0x7E, 0x00, 0x3C, 0x7E, 0x00, 0x78, 0xFE, 0x00, 0xF1, 0xFC,
  0x01, 0xE1, 0xFC, 0x07, 0x83, 0xFB, 0x3E, 0x03, 0xF1, 0xF0, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x05, 0xFF, 0xF0, 0x0C, 0x1F, 0xF8, 0x60, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0xF8, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0xF9, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFF, 0xFC, 0xFF, 0x43, 0xF0, 0x38, 0x7F, 0xE0, 0xFE,
  0x07, 0xC1, 0x80, 0x3F, 0x81, 0xF8, 0x1F, 0x84, 0x00, 0x7F, 0x07, 0xE0,
  0x7E, 0x20, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x80, 0x01, 0xF8, 0x3F, 0x03,
  0xE2, 0x00, 0x07, 0xE0, 0x7C, 0x0F, 0xE8, 0x00, 0x0F, 0x81, 0xF0, 0x3F,
  0x20, 0x00, 0x3E, 0x07, 0xC0, 0x70, 0xC0, 0x00, 0x78, 0x0F, 0x01, 0x81,
  0x83, 0x01, 0xE0, 0x3C, 0x0C, 0x07, 0xFE, 0x07, 0x80, 0xF0, 0x60, 0x0F,
  0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x1F, 0xF0, 0x78, 0x0F, 0x1C, 0x00, 0x00,
  0x41, 0xE0, 0x38, 0x70, 0x00, 0x01, 0x07, 0x80, 0xE3, 0xC0, 0x00, 0x00,
  0x1C, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x3E, 0x00, 0x00, 0x01,
  0x80, 0x30, 0xF8, 0x00, 0x00, 0x06, 0x00, 0xC3, 0xE0, 0x00, 0x60, 0x30,
  0x06, 0x0F, 0xC0, 0x07, 0xC0, 0x9E, 0x18, 0x3F, 0x00, 0x7F, 0x86, 0xFC,
  0x40, 0x7E, 0x23, 0xFF, 0x17, 0xFE, 0x01, 0xFF, 0x88, 0xFF, 0xBF, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x9F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0xFC, 0xC3, 0xF0, 0x78, 0x3F, 0xE8, 0x1F, 0x06,
  0x00, 0xFF, 0x81, 0xF8, 0xC0, 0x07, 0xF0, 0x1F, 0x88, 0x00, 0x3F, 0x00,
  0xF8, 0x80, 0x01, 0xF8, 0x0F, 0xC8, 0x00, 0x1F, 0x80, 0xFE, 0x80, 0x00,
  0xF8, 0x07, 0xCC, 0x00, 0x0F, 0x80, 0x30, 0xC0, 0x00, 0x78, 0x06, 0x06,
  0x1C, 0x07, 0x80, 0xC0, 0x7F, 0xF0, 0x78, 0x18, 0x03, 0xFF, 0x07, 0x83,
  0x80, 0x0F, 0xF0, 0x78, 0x38, 0x00, 0x01, 0x07, 0x87, 0x80, 0x00, 0x10,
  0x78, 0x78, 0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x00, 0x70, 0xF8, 0x00,
  0x00, 0x06, 0x0F, 0x80, 0x00, 0x00, 0x60, 0xFC, 0x00, 0x38, 0x0C, 0x0F,
  0xC0, 0x0F, 0xE0, 0xC0, 0x7E, 0x01, 0xFF, 0x18, 0x07, 0xF3, 0x37, 0xF3,
  0x00, 0x3F, 0xE4, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xBF, 0xFE, 0x00, 0x60, 0x0F, 0xFC, 0x07,
  0x00, 0x0F, 0xF8, 0x38, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x1F, 0xC7, 0x80,
  0x00, 0x3F, 0x9E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xFC, 0x00,
  0x01, 0xF7, 0xFC, 0x00, 0x07, 0xDF, 0xFC, 0x00, 0x0F, 0x3F, 0xF8, 0x00,
  0x3C, 0x3F, 0xF0, 0x00, 0xF0, 0x3F, 0xC0, 0x03, 0xC0, 0x3F, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x23, 0x00, 0x03, 0x03,
  0xE0, 0x00, 0x0C, 0x3F, 0xE0, 0x00, 0x21, 0xFF, 0xC0, 0x01, 0x09, 0xFF,
  0xC0, 0x0C, 0x01, 0xFF, 0xC0, 0x40, 0x01, 0xFF, 0xEE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x10, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0x01, 0xE0, 0x07, 0xFF,
  0xF8, 0x7F, 0x00, 0x70, 0x3F, 0xDB, 0xF0, 0x0E, 0x00, 0xFE, 0x3F, 0x80,
  0xC0, 0x0F, 0xE3, 0xFC, 0x08, 0x00, 0x7E, 0x1F, 0xE0, 0x80, 0x03, 0xE0,
  0xFF, 0x08, 0x00, 0x3E, 0x07, 0xF8, 0x80, 0x03, 0xE0, 0x3F, 0xC8, 0x00,
  0x3E, 0x01, 0xFE, 0xC0, 0x03, 0xE0, 0x0F, 0xE6, 0x00, 0x3E, 0x00, 0x7F,
  0x30, 0x11, 0xE0, 0x03, 0xF0, 0xFE, 0x1E, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x06,
  0x00, 0x01, 0xE0, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x1F, 0xF8,
  0x00, 0x80, 0x03, 0xFF, 0xE0, 0x10, 0x00, 0x77, 0xFF, 0xC6, 0x00, 0x08,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0xFF, 0x00,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xCF, 0xFF, 0x80, 0x06, 0x00, 0xFF, 0xC0,
  0x18, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x07, 0xF0,
  0x78, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8,
  0xFF, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x7C, 0x7F, 0xF0, 0x00, 0x3C,
  0x3F, 0xF8, 0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x3C,
  0x00, 0xFC, 0x00, 0x18, 0x00, 0x38, 0x00, 0x18, 0x00, 0x10, 0x00, 0x18,
  0x02, 0x20, 0x06, 0x30, 0x0F, 0x80, 0x0F, 0xB0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xE1, 0x9F, 0xFC, 0x87, 0xF3, 0x07, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xE6, 0x3F, 0x80,
  0xF0, 0xFF, 0x90, 0x7E, 0x07, 0x00, 0xFF, 0x80, 0xFC, 0x18, 0x00, 0xFE,
  0x03, 0xF0, 0xC0, 0x01, 0xF8, 0x0F, 0xE3, 0x00, 0x03, 0xE0, 0x1F, 0xCC,
  0x00, 0x0F, 0x80, 0x3F, 0xB0, 0x00, 0x1F, 0x00, 0x70, 0xC0, 0x00, 0x7C,
  0x03, 0x83, 0x00, 0x01, 0xF0, 0x18, 0x04, 0x00, 0x03, 0xC1, 0x80, 0x18,
  0x00, 0x0F, 0x0E, 0x00, 0x30, 0x00, 0x3C, 0xFC, 0x00, 0x70, 0x60, 0xF7,
  0xF8, 0x00, 0x7E, 0x03, 0xC7, 0xE0, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x00,
  0x00, 0x38, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0x01,
  0xF8, 0x00, 0x00, 0x0C, 0x07, 0xE0, 0x01, 0xC0, 0x60, 0x1F, 0x80, 0x1F,
  0x81, 0x80, 0x7F, 0x00, 0xFF, 0x0C, 0x00, 0xFC, 0x07, 0xFE, 0x60, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x20, 0x03, 0xFF, 0xF9, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x60, 0x3F, 0xFC, 0x01, 0x80, 0x1F, 0xF0, 0x06,
  0x00, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x07, 0x00, 0x07, 0xFC, 0x0C, 0x00,
  0x1F, 0xFE, 0x38, 0x20, 0xFF, 0xFC, 0x78, 0x3F, 0xFF, 0x0C, 0xF0, 0x3F,
  0xF8, 0x0D, 0xE0, 0x3F, 0xC0, 0x0B, 0xC0, 0x3E, 0x00, 0x17, 0xC0, 0x30,
  0x00, 0x27, 0x80, 0x00, 0x00, 0x4F, 0x80, 0x00, 0x00, 0x9F, 0x80, 0x00,
  0x03, 0x1F, 0xC0, 0x00, 0x0C, 0x3F, 0xC0, 0x00, 0x38, 0x3F, 0xF0, 0x03,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0E, 0x07, 0xFF, 0x80,
  0x70, 0x03, 0xFF, 0x81, 0x80, 0x03, 0xFF, 0x1C, 0x00, 0x33, 0xFF, 0xB0,
  0x01, 0x87, 0xFC, 0x80, 0x1C, 0x07, 0xE2, 0x00, 0x78, 0x06, 0x08, 0x03,
  0xF0, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x80, 0x7F,
  0x80, 0x01, 0x02, 0xFF, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x1E, 0x00,
  0x1F, 0xE0, 0x70, 0x01, 0xFF, 0xC3, 0x80, 0x05, 0xFF, 0x98, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x07,
  0xFC, 0x06, 0x00, 0x0F, 0xFE, 0x70, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x38, 0x40, 0x07, 0x03, 0x81, 0x00,
  0xF0, 0x3C, 0x08, 0x1F, 0x01, 0xE0, 0x43, 0xF8, 0x1F, 0x04, 0x1F, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x80, 0x1F, 0x01, 0xFE,
  0x00, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0xFF, 0x01,
  0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x70, 0x07, 0xE0, 0x03,
  0x00, 0x3F, 0x00, 0x30, 0x01, 0xF8, 0x03, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0x3F, 0x87, 0xFF, 0x86, 0x7C,
  0x21, 0xFF, 0xE3, 0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x0F,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFC, 0x87, 0xE0, 0x3E, 0x3F, 0xF0, 0x7E,
  0x07, 0x00, 0xFF, 0x03, 0xF0, 0xE0, 0x07, 0xF0, 0x3F, 0x0C, 0x00, 0x3F,
  0x01, 0xFC, 0xC0, 0x01, 0xF0, 0x1F, 0x8C, 0x00, 0x1F, 0x00, 0x60, 0xC0,
  0x00, 0xF0, 0x04, 0x0C, 0x00, 0x0F, 0x00, 0xC0, 0xC0, 0x00, 0xF0, 0x1C,
  0x04, 0x00, 0x0F, 0x03, 0xC0, 0x60, 0x00, 0xE0, 0x3E, 0x03, 0x03, 0x0E,
  0x03, 0xE0, 0x0F, 0xE0, 0xC0, 0x3F, 0x80, 0x00, 0x1C, 0x03, 0xFC, 0x00,
  0x01, 0x80, 0x1F, 0xC0, 0x00, 0x30, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xF8,
  0x00, 0x1C, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0xC3, 0xFE, 0x00, 0x18, 0x00,
  0x1F, 0xF8, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0x03, 0xFF, 0x0C,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0xF0, 0x7F,
  0x80, 0x0F, 0xFF, 0x1F, 0x9B, 0xFC, 0x01, 0xFF, 0xFD, 0x0A, 0x0F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x60, 0x7F, 0x07, 0x80, 0xFE, 0x0C, 0x03, 0xF0, 0x70,
  0x07, 0xF0, 0xC0, 0x3F, 0x8E, 0x00, 0x3F, 0x1C, 0x01, 0xF8, 0xC0, 0x01,
  0xF1, 0xC0, 0x1F, 0xCC, 0x00, 0x1F, 0x3E, 0x00, 0xFE, 0xC0, 0x00, 0xF3,
  0xE0, 0x07, 0x0C, 0x00, 0x0F, 0x3F, 0x00, 0x60, 0xC0, 0x00, 0xF3, 0xF8,
  0x0E, 0x04, 0x00, 0x0F, 0x1F, 0x81, 0xE0, 0x60, 0x00, 0xF1, 0xFC, 0x1E,
  0x03, 0x01, 0x8E, 0x0F, 0xC3, 0xF0, 0x0E, 0xE0, 0xE0, 0xFC, 0x3F, 0x80,
  0x18, 0x0C, 0x07, 0xE3, 0xFC, 0x00, 0x01, 0x80, 0x3E, 0x1F, 0xE0, 0x00,
  0x10, 0x03, 0xE0, 0xFF, 0x00, 0x02, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x40,
  0x01, 0xC0, 0x3F, 0x01, 0xFC, 0x00, 0x18, 0x01, 0xF0, 0x3F, 0xE0, 0x01,
  0x80, 0x0E, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0xE1, 0x87, 0xF8, 0x07, 0xF0,
  0x0C, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0xC0, 0x01, 0xFE, 0x1F, 0xFC, 0x18,
  0x00, 0x0F, 0xFE, 0x1F, 0xF2, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x3C, 0x47, 0xFF, 0x83, 0xFE, 0x7F, 0xFE, 0x1F,
  0xE3, 0xFF, 0xF9, 0xFF, 0x3C, 0x0F, 0xCD, 0xF1, 0x80, 0x3F, 0x43, 0x1C,
  0x00, 0xFC, 0x00, 0xC0, 0x07, 0xE0, 0x06, 0x00, 0x1F, 0x00, 0x10, 0x00,
  0xF8, 0x00, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x3F, 0xFC, 0x10, 0x03, 0xFF,
  0xC0, 0x60, 0x3F, 0xFE, 0x01, 0xFB, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xBE,
  0x00, 0x00, 0x05, 0xF8, 0x00, 0x7C, 0x4F, 0xE0, 0x07, 0xF6, 0x3F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x17, 0xF8, 0x1F, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0x03,
  0xFF, 0xFC, 0x87, 0xE0, 0xF8, 0x7F, 0xE0, 0x7E, 0x1C, 0x03, 0xFC, 0x0F,
  0xC7, 0x00, 0x3F, 0x81, 0xF8, 0xC0, 0x03, 0xF0, 0x1F, 0x98, 0x00, 0x3E,
  0x03, 0xF3, 0x00, 0x07, 0xC0, 0x7F, 0xE0, 0x00, 0x78, 0x07, 0xCC, 0x00,
  0x0F, 0x00, 0x61, 0x80, 0x01, 0xE0, 0x18, 0x10, 0x00, 0x3C, 0x07, 0x01,
  0x00, 0x87, 0x81, 0xE0, 0x10, 0x30, 0xE0, 0x7C, 0x01, 0xF8, 0x1C, 0x1F,
  0x80, 0x00, 0x07, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x18,
  0x07, 0xF0, 0x00, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x0F, 0xE0, 0x00,
  0x20, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x43, 0xF8,
  0x00, 0xFE, 0x18, 0x3F, 0x00, 0x3F, 0xFE, 0x07, 0xE0, 0x0F, 0xFF, 0x80,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x78, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x01,
  0x00, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x78,
  0x0F, 0xF0, 0x1C, 0x00, 0x7E, 0x03, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x78,
  0x0C, 0x00, 0x0F, 0x01, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x3C, 0x02, 0x00,
  0x07, 0x00, 0x30, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x10, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0xE7, 0xFC, 0x00, 0x19, 0xFF,
  0xC0, 0x07, 0x03, 0xFC, 0x00, 0xC0, 0x3F, 0xC0, 0x30, 0x03, 0xFC, 0x0C,
  0x00, 0x3F, 0xE3, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xF0, 0x01, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1C, 0x78, 0x38, 0x1C,
  0x70, 0x0E, 0xE0, 0x06, 0x80, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xCF, 0x9E, 0x38, 0x70, 0xC1, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x05, 0xFE, 0x02, 0x3F, 0xC1,
  0x83, 0xE0, 0xE0, 0x78, 0x70, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0x78, 0x7C, 0x1E,
  0x1F, 0x07, 0x87, 0xF3, 0xFC, 0xFF, 0x7E, 0x1F, 0x1F, 0x03, 0x83, 0xC0,
  0x40, 0x20, 0x00, 0x20, 0x01, 0xE0, 0x21, 0x80, 0x09, 0xC0, 0x05, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x08, 0x1F, 0x04, 0x0F,
  0x8F, 0x07, 0xCF, 0xC3, 0xFB, 0xF1, 0xF0, 0xF8, 0xF8, 0x7E, 0x7C, 0x1F,
  0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xE0, 0x79, 0xF0,
  0x3C, 0xF8, 0x1C, 0x7C, 0x0C, 0x3E, 0x0E, 0x3F, 0xC4, 0x1F, 0xF4, 0x01,
  0xFC, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0x03,
  0x78, 0x33, 0xE3, 0x8F, 0x18, 0x7D, 0xC1, 0xEE, 0x08, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0xF0, 0xFE, 0x03, 0xC0, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x02, 0x3F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x1E, 0x3E, 0x07,
  0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0E, 0x3E, 0x03, 0x8F, 0x80, 0xE3,
  0xE0, 0x38, 0xF8, 0x0C, 0x3F, 0x03, 0x1F, 0xE1, 0x83, 0xFE, 0x40, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x40, 0x0F, 0x80,
  0xDE, 0x06, 0x7C, 0x38, 0xF0, 0xC3, 0xC7, 0x0F, 0x9C, 0x1E, 0xF0, 0x7F,
  0xC1, 0x8F, 0x38, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xE0, 0x1E, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x7E, 0xC7, 0xFC, 0x3F, 0xE1, 0x1E, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x01, 0xE0, 0x0F, 0xF9, 0xFF, 0xC3, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x04, 0xFF, 0x06, 0x1F, 0xE3, 0x83, 0xF0, 0xE0, 0x38, 0x70, 0x06, 0x1C,
  0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x1E, 0x3E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0xFD, 0xBE,
  0x1F, 0x8F, 0x87, 0x81, 0xE0, 0x80, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC7, 0x80, 0x61, 0xE0, 0x30, 0x3C, 0x18, 0x07, 0x9C, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x01, 0xC0, 0x21, 0xC0, 0x09, 0xC0, 0x05, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x18, 0x1F, 0x1C, 0x0F, 0x9F,
  0x07, 0xFF, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x3C,
  0xF8, 0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0x1F, 0x07, 0x8F, 0xB3, 0x8F, 0xF1,
  0xC1, 0xF0, 0xC0, 0x70, 0xC0, 0x10, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0E, 0x07, 0xC1, 0xF0,
  0x78, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x10, 0x0E, 0x07, 0xC1, 0xFC, 0xBF,
  0x2F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xFC, 0x7E, 0x0F, 0x01, 0xC0, 0x20, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x40, 0x06,
  0x00, 0xF0, 0x0F, 0xC1, 0xFE, 0x27, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x74, 0x0F, 0x20, 0xE1, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x87,
  0x04, 0xE1, 0x3E, 0x73, 0xEF, 0x3E, 0xF3, 0xFF, 0x1F, 0x03, 0xE0, 0x3F,
  0xF7, 0xFF, 0xBE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE2, 0x3F,
  0xC7, 0xF8, 0x07, 0x80, 0x30, 0x02, 0x00, 0x00, 0xF0, 0x38, 0x87, 0x04,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE2, 0x7F, 0xC3,
  0xF8, 0x0F, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x80,
  0xC0, 0x3C, 0x1E, 0x1E, 0x07, 0xE3, 0xF3, 0xF0, 0x7E, 0xFF, 0x7F, 0xE9,
  0xF9, 0xF8, 0xFC, 0x1F, 0x0F, 0x07, 0xC1, 0xF0, 0xF0, 0x78, 0x1F, 0x0F,
  0x07, 0x81, 0xF0, 0xF0, 0x78, 0x1F, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x78,
  0x1F, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x78, 0x1F, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x78, 0x1F, 0x0F, 0x87,
  0xD3, 0xF9, 0xFC, 0x7F, 0x1F, 0x0F, 0x83, 0xE0, 0xE0, 0x70, 0x3E, 0x0C,
  0x06, 0x01, 0xC0, 0x40, 0x20, 0x08, 0x10, 0x08, 0x03, 0x81, 0xC0, 0x3C,
  0x3E, 0x07, 0xE7, 0xF8, 0xFE, 0x9F, 0xC9, 0xF0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8,
  0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x3F, 0x8F, 0xF1, 0xF0, 0x7E, 0x0E, 0x07, 0xC0, 0xC0,
  0x3C, 0x04, 0x00, 0x80, 0x00, 0x10, 0x00, 0x3C, 0x00, 0xFE, 0x0F, 0x9F,
  0x83, 0xCF, 0xC1, 0xE3, 0xF0, 0xF0, 0xFC, 0x78, 0x3E, 0x3C, 0x1F, 0x1E,
  0x07, 0xCF, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x1C,
  0xF8, 0x1C, 0x7E, 0x0C, 0x7F, 0x8C, 0x0F, 0xF4, 0x01, 0xFC, 0x00, 0x7C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x80, 0x41, 0xF8, 0x18, 0x1F, 0x8F, 0x83, 0xF3, 0xF8,
  0x3F, 0xBF, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xE0, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x1F, 0x81, 0xC7, 0xF0, 0x31, 0xFF, 0x8C, 0x3F, 0xFD, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xEC, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0xDF, 0xE0, 0xC7, 0xF8, 0xE0, 0xF8, 0xE0, 0x7C, 0x70, 0x3E,
  0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xE0,
  0x79, 0xF0, 0x3C, 0xFC, 0x1E, 0x3E, 0x1F, 0x1F, 0xDF, 0x87, 0xF3, 0xC1,
  0xF1, 0xE0, 0x60, 0xF0, 0x20, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x30,
  0x10, 0xE0, 0xC7, 0xC7, 0x9F, 0xBE, 0xBF, 0xFC, 0x7D, 0xE1, 0xE3, 0x07,
  0x8C, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x83, 0xFC, 0x17, 0xE0, 0x07, 0x80,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x03, 0x01, 0x07, 0x81, 0x0F, 0xF7, 0x17, 0xFE, 0x21, 0xFC,
  0x60, 0x78, 0xE0, 0x10, 0xE0, 0x20, 0xF0, 0x70, 0xFC, 0xF8, 0x7F, 0xFC,
  0x7E, 0x7E, 0x3C, 0x3E, 0x18, 0x1E, 0x10, 0x0E, 0x30, 0x0C, 0x7C, 0x0C,
  0xFF, 0x88, 0x7F, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xFF, 0xFF,
  0xFF, 0xFC, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x89, 0xFE, 0x7F, 0x81, 0xF0,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x03, 0x80, 0x70, 0x7C, 0x0F, 0x87, 0xE1,
  0xFC, 0xBE, 0x1F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E,
  0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0xFA,
  0x3F, 0xBF, 0xF5, 0xFE, 0x7E, 0x07, 0x87, 0xC0, 0x30, 0x18, 0x01, 0x00,
  0x80, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0xC3, 0xC0, 0x70, 0xF8, 0x7E,
  0x3E, 0x3F, 0xCF, 0xF1, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1,
  0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x18,
  0x0F, 0x06, 0x03, 0x83, 0x00, 0xE0, 0xE0, 0x70, 0x3E, 0x18, 0x1F, 0xCC,
  0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x20,
  0xFC, 0x0E, 0x03, 0x07, 0xE1, 0xF0, 0xF0, 0x7E, 0x3F, 0xBF, 0x83, 0xF4,
  0xFC, 0xFC, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x81,
  0xE1, 0xF0, 0x78, 0x1E, 0x1F, 0x07, 0x81, 0xE1, 0xF0, 0x78, 0x0E, 0x1F,
  0x07, 0x80, 0xE1, 0xF0, 0x78, 0x0E, 0x1F, 0x07, 0x81, 0xE1, 0xF0, 0x78,
  0x1C, 0x1F, 0x07, 0x81, 0xC1, 0xF0, 0xFC, 0x18, 0x1F, 0x0F, 0xE3, 0x03,
  0xF9, 0xFF, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0xE0, 0x0F, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0x40, 0x02, 0x00, 0x00, 0x00, 0x38, 0x10, 0x78, 0x71, 0xF9,
  0xE3, 0xF7, 0xE9, 0xFF, 0xC3, 0xE7, 0x07, 0xCC, 0x0F, 0x88, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x40, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x10, 0xE0,
  0x40, 0x80, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x01, 0x83, 0x07, 0x83,
  0xFF, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xF8, 0x0C, 0x3F, 0x07, 0x07, 0xE3, 0xE1, 0xFB, 0xFC, 0x3F,
  0x1F, 0x07, 0x83, 0xE1, 0xE0, 0xF8, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81,
  0xF1, 0xE0, 0x7C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0x87, 0xC1, 0xE3, 0xF6, 0x71, 0xFE, 0x1C, 0x0F,
  0x06, 0x01, 0x83, 0x00, 0x21, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0xF0, 0x1F,
  0x83, 0xFC, 0x47, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x41, 0x08,
  0x23, 0xEC, 0x7F, 0x89, 0xFC, 0x0F, 0xE1, 0xBE, 0x11, 0xF2, 0x1F, 0x60,
  0xF6, 0x0F, 0x40, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xEC, 0x0E, 0x40,
  0xC6, 0x0C, 0x21, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x01, 0xC0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xE0, 0x78, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 32, 10, 1, -31 },
  { 33, 15, 12, 17, 1, -31 },
  { 56, 20, 24, 22, 1, -27 },
  { 116, 14, 35, 18, 2, -33 },
  { 178, 28, 30, 31, 1, -30 },
  { 283, 23, 26, 25, 1, -26 },
  { 358, 7, 12, 9, 1, -31 },
  { 369, 9, 35, 11, 1, -34 },
  { 409, 9, 35, 11, 1, -34 },
  { 449, 14, 16, 15, 0, -32 },
  { 477, 14, 15, 17, 2, -22 },
  { 504, 7, 12, 8, 0, -7 },
  { 515, 12, 8, 13, 1, -17 },
  { 527, 7, 8, 9, 1, -7 },
  { 534, 21, 34, 22, 1, -32 },
  { 624, 19, 30, 20, 1, -30 },
  { 696, 13, 29, 14, 0, -29 },
  { 744, 18, 29, 19, 1, -29 },
  { 810, 18, 30, 20, 1, -30 },
  { 878, 19, 29, 20, 0, -29 },
  { 947, 18, 30, 20, 1, -30 },
  { 1015, 18, 30, 20, 1, -30 },
  { 1083, 17, 29, 18, 1, -29 },
  { 1145, 18, 30, 20, 1, -30 },
  { 1213, 18, 30, 20, 1, -30 },
  { 1281, 7, 21, 9, 1, -20 },
  { 1300, 8, 25, 7, 0, -20 },
  { 1325, 12, 16, 12, 0, -20 },
  { 1349, 15, 9, 17, 1, -17 },
  { 1366, 12, 16, 12, 0, -20 },
  { 1390, 17, 32, 20, 1, -31 },
  { 1458, 25, 26, 26, 1, -20 },
  { 1540, 33, 32, 35, 1, -31 },
  { 1672, 37, 32, 38, 0, -31 },
  { 1820, 28, 32, 30, 1, -31 },
  { 1932, 33, 33, 35, 1, -31 },
  { 2069, 28, 32, 30, 1, -31 },
  { 2181, 31, 38, 32, 1, -32 },
  { 2329, 31, 32, 33, 1, -31 },
  { 2453, 31, 39, 32, 0, -33 },
  { 2605, 27, 37, 29, 1, -31 },
  { 2730, 29, 42, 31, 1, -31 },
  { 2883, 33, 32, 35, 1, -31 },
  { 3015, 23, 31, 25, 1, -30 },
  { 3105, 46, 32, 48, 1, -30 },
  { 3289, 36, 31, 38, 1, -30 },
  { 3429, 30, 32, 32, 1, -31 },
  { 3549, 36, 37, 38, 1, -30 },
  { 3716, 32, 34, 34, 1, -31 },
  { 3852, 38, 32, 40, 1, -31 },
  { 4004, 31, 31, 33, 1, -31 },
  { 4125, 30, 30, 32, 1, -30 },
  { 4238, 29, 33, 31, 1, -30 },
  { 4358, 36, 32, 38, 1, -31 },
  { 4502, 44, 32, 46, 1, -31 },
  { 4678, 29, 32, 31, 1, -31 },
  { 4794, 35, 39, 37, 1, -32 },
  { 4965, 27, 37, 29, 1, -31 },
  { 5090, 6, 34, 8, 1, -32 },
  { 5116, 26, 30, 5, -8, -28 },
  { 5214, 6, 34, 8, 1, -32 },
  { 5240, 16, 12, 18, 1, -30 },
  { 5264, 20, 3, 20, 0, 5 },
  { 5272, 6, 8, 22, 7, -30 },
  { 5278, 18, 23, 20, 1, -22 },
  { 5330, 17, 31, 19, 1, -30 },
  { 5396, 13, 23, 15, 1, -22 },
  { 5434, 18, 31, 20, 1, -30 },
  { 5504, 14, 23, 16, 1, -22 },
  { 5545, 13, 38, 11, 0, -31 },
  { 5607, 18, 31, 20, 1, -22 },
  { 5677, 17, 37, 19, 1, -30 },
  { 5756, 10, 31, 12, 1, -30 },
  { 5795, 12, 38, 10, -2, -30 },
  { 5852, 12, 31, 14, 1, -30 },
  { 5899, 12, 31, 12, 1, -30 },
  { 5946, 28, 24, 31, 1, -23 },
  { 6030, 20, 23, 22, 1, -22 },
  { 6088, 17, 23, 18, 0, -22 },
  { 6137, 19, 35, 19, 0, -26 },
  { 6221, 17, 31, 19, 1, -22 },
  { 6287, 14, 23, 16, 1, -22 },
  { 6328, 16, 28, 18, 1, -27 },
  { 6384, 11, 28, 13, 1, -27 },
  { 6423, 20, 23, 22, 1, -22 },
  { 6481, 18, 25, 19, 0, -24 },
  { 6538, 28, 26, 30, 1, -25 },
  { 6629, 15, 32, 17, 1, -23 },
  { 6689, 18, 33, 20, 1, -26 },
  { 6764, 12, 30, 14, 1, -22 },
  { 6809, 11, 34, 14, 1, -33 },
  { 6856, 3, 36, 7, 2, -34 },
  { 6870, 11, 34, 14, 1, -33 },
  { 6917, 14, 3, 16, 1, -14 },
};

const GFXfont UnifrakturMaguntia_Regular43pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular43pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular43pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR43PT7B_H_
