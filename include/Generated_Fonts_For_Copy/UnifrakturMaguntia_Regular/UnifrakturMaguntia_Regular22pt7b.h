#ifndef _UNIFRAKTURMAGUNTIA_REGULAR22PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0x4E, 0xEE, 0x64, 0x44, 0x44, 0x40, 0x04, 0xE4, 0x85, 0x8B, 0xBB,
  0x34, 0x48, 0x80, 0x13, 0x04, 0xC1, 0x33, 0xFF, 0xFF, 0xCC, 0x83, 0x23,
  0xFE, 0xFF, 0x89, 0x86, 0x61, 0x98, 0x10, 0x20, 0xE2, 0x2C, 0x78, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x38, 0x30, 0x51, 0x1C, 0x10, 0x20, 0x70, 0x0B,
  0x60, 0x3C, 0x80, 0xB3, 0x04, 0xCC, 0x23, 0x31, 0x0C, 0x88, 0x36, 0x40,
  0x72, 0x70, 0x11, 0x20, 0x4C, 0xC2, 0x33, 0x10, 0xCC, 0x83, 0x34, 0x04,
  0xA0, 0x1E, 0x0E, 0x02, 0x60, 0xCC, 0x19, 0x03, 0xC0, 0x73, 0xCF, 0x32,
  0xE4, 0xCE, 0x99, 0xD3, 0x3C, 0x63, 0x9E, 0x3C, 0xFB, 0x80, 0x46, 0xF3,
  0x22, 0x19, 0x08, 0xC6, 0x33, 0x9C, 0xE7, 0x38, 0xC6, 0x31, 0x84, 0x10,
  0x40, 0x61, 0x0C, 0x21, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x88, 0x46, 0x26,
  0x00, 0x10, 0x73, 0x5B, 0xF7, 0xFA, 0xCE, 0x08, 0x10, 0x20, 0x47, 0xF1,
  0x02, 0x04, 0x08, 0x6F, 0x22, 0x44, 0x0D, 0xE0, 0x1E, 0xF0, 0x6F, 0x20,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x0C,
  0xC3, 0x19, 0xC6, 0x71, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x76, 0x1D,
  0xC7, 0x71, 0x8C, 0x63, 0x30, 0x78, 0x08, 0x30, 0xE3, 0xC9, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x1F, 0x80, 0x1E, 0x1F, 0xD8, 0xE8,
  0x78, 0x18, 0x0C, 0x0E, 0x06, 0x06, 0x02, 0x02, 0x02, 0x12, 0x0B, 0xFF,
  0xFE, 0x1F, 0x18, 0xE8, 0x38, 0x06, 0x03, 0x80, 0xC0, 0xF0, 0x5E, 0x01,
  0xC0, 0x74, 0x1F, 0x87, 0x61, 0x98, 0x43, 0xE0, 0x02, 0x01, 0x80, 0xE0,
  0x38, 0x16, 0x09, 0x82, 0x61, 0x18, 0x86, 0x3F, 0xFF, 0xFC, 0x18, 0x06,
  0x01, 0xC1, 0xF8, 0x21, 0x8F, 0xC3, 0xE0, 0x80, 0x40, 0x0F, 0x87, 0xF9,
  0x8E, 0x81, 0xC0, 0x34, 0x0F, 0x83, 0x61, 0x98, 0x41, 0xE0, 0x0E, 0x04,
  0xC3, 0x19, 0xC6, 0x61, 0x18, 0x06, 0x71, 0xEE, 0x71, 0x98, 0x76, 0x1D,
  0x86, 0x71, 0x9C, 0x63, 0x30, 0x78, 0x7F, 0xBF, 0xD0, 0x50, 0x20, 0x10,
  0x18, 0x08, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x3F,
  0x18, 0x26, 0x09, 0x82, 0x71, 0x8F, 0x83, 0xF0, 0x9E, 0x43, 0x90, 0x7C,
  0x0F, 0x03, 0x40, 0x98, 0x61, 0xE0, 0x1E, 0x0C, 0xC6, 0x39, 0x8E, 0x61,
  0xB8, 0x6E, 0x19, 0x8E, 0x75, 0x8F, 0x60, 0x18, 0x06, 0x63, 0x98, 0xC3,
  0x20, 0x70, 0x6F, 0x20, 0x00, 0x06, 0xF2, 0x6F, 0x20, 0x00, 0x06, 0xF2,
  0x24, 0x40, 0x04, 0x63, 0x18, 0xE0, 0xC1, 0x81, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x81, 0x83, 0x06, 0x1C, 0xC6, 0x20, 0x3C, 0xC6, 0x83, 0xC3, 0xC3,
  0x0F, 0x3E, 0x78, 0x60, 0x62, 0x64, 0x3C, 0x00, 0x08, 0x1C, 0x08, 0x07,
  0xC0, 0xC3, 0x0C, 0x04, 0xC7, 0xA4, 0x6D, 0xE6, 0x6F, 0x66, 0x5B, 0x32,
  0x5B, 0xA2, 0x6E, 0x48, 0x04, 0x60, 0xC0, 0xFC, 0x00, 0x0E, 0x00, 0x8F,
  0xC1, 0x98, 0xF3, 0x88, 0x3D, 0xC8, 0x0E, 0x64, 0x07, 0x31, 0x83, 0x98,
  0xF1, 0x8C, 0x3C, 0xC6, 0x04, 0xC3, 0x02, 0x41, 0x80, 0x40, 0xC0, 0xF0,
  0x60, 0xFC, 0x70, 0x0F, 0xDE, 0x03, 0x8E, 0x1F, 0x0E, 0x07, 0xF2, 0xE1,
  0xCF, 0x8E, 0x20, 0x71, 0xC8, 0x0E, 0x1D, 0x00, 0xC3, 0x20, 0x18, 0xC2,
  0x02, 0x7E, 0x36, 0xD3, 0xE1, 0x10, 0x1C, 0x04, 0x03, 0x83, 0x80, 0x30,
  0xF8, 0x06, 0x27, 0xC1, 0x80, 0x7C, 0x20, 0x07, 0xF8, 0x1E, 0x60, 0xCB,
  0xF6, 0x17, 0x19, 0x80, 0xEE, 0x03, 0x38, 0x0C, 0xF0, 0x39, 0xE0, 0xE3,
  0xC3, 0x87, 0x8E, 0x0E, 0x1C, 0x30, 0x78, 0x80, 0xF4, 0x01, 0xF9, 0xC3,
  0xF8, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8E, 0x13, 0xC4, 0x30, 0x72,
  0x18, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x41, 0xE1, 0x90, 0x70, 0x47, 0x18,
  0x20, 0x08, 0x10, 0x78, 0x10, 0xFC, 0x10, 0x9F, 0xD0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x60, 0xCB, 0xF6, 0x17, 0x19, 0x80, 0xCE, 0x03, 0x38,
  0x8C, 0xF7, 0xF1, 0xEE, 0xE3, 0xD3, 0x87, 0x8E, 0x0E, 0x1C, 0x30, 0x78,
  0x80, 0xF4, 0x01, 0xF9, 0xC3, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x30, 0x7F,
  0x40, 0x5C, 0x40, 0x80, 0x41, 0x80, 0x41, 0xC2, 0x41, 0xE7, 0x20, 0xFF,
  0x1F, 0x72, 0x00, 0x78, 0x30, 0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x1C, 0x18,
  0x1C, 0x18, 0x1C, 0x30, 0x0C, 0x20, 0x07, 0xC0, 0x0E, 0x20, 0x22, 0xE0,
  0x82, 0xE3, 0x18, 0xFE, 0x60, 0xD9, 0xC2, 0x33, 0x8F, 0x63, 0xBE, 0xE3,
  0x8F, 0xC7, 0x9F, 0x87, 0x1F, 0x06, 0x37, 0x18, 0x67, 0x41, 0x87, 0x02,
  0x07, 0x98, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x0C, 0xF0,
  0x08, 0x60, 0x18, 0x00, 0x18, 0x38, 0x1C, 0x7C, 0x1F, 0xBC, 0x0F, 0x1E,
  0x07, 0x0E, 0x07, 0x87, 0x03, 0x87, 0x31, 0x86, 0x79, 0x06, 0xBE, 0x06,
  0x1C, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0xC0,
  0xC3, 0xC1, 0x03, 0xE6, 0x01, 0x08, 0x04, 0x18, 0x18, 0x10, 0x38, 0x10,
  0x70, 0x1E, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x8F, 0x03,
  0x3F, 0x04, 0x8F, 0x08, 0x0F, 0xE0, 0x04, 0x00, 0x0F, 0x80, 0x3F, 0xC0,
  0xC7, 0xC3, 0x03, 0xE4, 0x01, 0x08, 0x06, 0x10, 0x1C, 0x10, 0x38, 0x10,
  0x70, 0x1E, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x04, 0xF8, 0x0A, 0x78, 0x20, 0x78, 0x80, 0x7E, 0x00,
  0x00, 0x70, 0x01, 0xC7, 0x01, 0x80, 0x41, 0x9F, 0x20, 0xDB, 0xC8, 0xF0,
  0xE4, 0x78, 0x72, 0x1C, 0x1D, 0x0F, 0x09, 0x03, 0x9D, 0x01, 0xF7, 0x00,
  0x73, 0x82, 0x18, 0xE3, 0xC8, 0x72, 0xF4, 0x1E, 0x3C, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xE3, 0x06, 0x30, 0x37, 0x03, 0x78, 0x33, 0x83, 0x3E, 0xE1,
  0xD0, 0x1C, 0x00, 0x80, 0x10, 0x03, 0xC0, 0x7E, 0x18, 0xFE, 0x07, 0xC0,
  0x3E, 0x7C, 0xF0, 0xFF, 0xBE, 0x72, 0x0E, 0x38, 0xE4, 0x0E, 0x38, 0xE8,
  0x1C, 0x71, 0xF0, 0x18, 0x61, 0x20, 0x30, 0xC4, 0x3E, 0x61, 0x90, 0x04,
  0xC3, 0x60, 0x01, 0x84, 0xC0, 0x02, 0x09, 0x80, 0x04, 0x13, 0x87, 0x97,
  0x47, 0x17, 0xDF, 0x07, 0xC7, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xC7, 0x8F, 0xFA, 0x72, 0x0F, 0x1C, 0x81, 0xC3, 0xA0, 0x70, 0xF8,
  0x0C, 0x12, 0x63, 0x08, 0x7C, 0xC4, 0x01, 0x33, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x10, 0x8E, 0x1E, 0x43, 0xDB, 0xE0, 0x78, 0x70, 0x0C, 0x01, 0x80,
  0x03, 0xE0, 0x07, 0xF8, 0x18, 0x7C, 0x20, 0x1E, 0x60, 0x0E, 0x70, 0x06,
  0x7C, 0x07, 0x3E, 0x03, 0x1F, 0x03, 0x06, 0x02, 0x02, 0x02, 0x3C, 0x02,
  0x7E, 0x04, 0x0F, 0x88, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x06, 0x0F, 0xF3,
  0xC1, 0x07, 0xB8, 0x40, 0xE7, 0xC8, 0x0C, 0x7D, 0x01, 0x87, 0x90, 0x30,
  0x79, 0xB6, 0x07, 0x08, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x00, 0xE0,
  0x20, 0x3F, 0x08, 0x09, 0xFE, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x01, 0xF0, 0x01, 0xFE,
  0x03, 0x0F, 0x82, 0x01, 0xE3, 0x00, 0x71, 0xC0, 0x18, 0xF8, 0x0E, 0x3E,
  0x03, 0x0F, 0x81, 0x81, 0x80, 0x80, 0x40, 0x43, 0xC3, 0xE3, 0xF2, 0xE4,
  0x3E, 0x3C, 0x0F, 0xEC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE3, 0xE1, 0xFE, 0x9C, 0x61, 0xE1, 0xC8, 0x1C, 0x39, 0x01, 0x83, 0xA0,
  0x38, 0x44, 0x03, 0x10, 0x80, 0x6E, 0x0F, 0x8F, 0xC0, 0x01, 0x1C, 0x00,
  0x23, 0x81, 0x08, 0x70, 0x79, 0x07, 0x37, 0xC0, 0xF8, 0x70, 0x0C, 0x01,
  0x00, 0x0F, 0x88, 0x6F, 0xF1, 0x03, 0xC4, 0x00, 0x18, 0x00, 0x20, 0x1E,
  0x48, 0xFE, 0x8F, 0xC3, 0x8F, 0x07, 0x00, 0x0F, 0x00, 0x17, 0x00, 0x4F,
  0xE7, 0x87, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0xFF, 0x83, 0x0F, 0xC4, 0x07,
  0xD8, 0x33, 0xD0, 0xC0, 0x21, 0xC0, 0x43, 0xC0, 0x7B, 0xC0, 0x03, 0x80,
  0xC3, 0x87, 0xC4, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE3, 0x01, 0xF8, 0x1E,
  0x06, 0x62, 0x30, 0xC8, 0xE3, 0x81, 0xC3, 0xC3, 0x87, 0x87, 0x07, 0x8E,
  0x07, 0x1C, 0x0C, 0x38, 0x10, 0x70, 0x40, 0xE1, 0xC1, 0xC7, 0xC5, 0x91,
  0xF3, 0xC1, 0xC7, 0x00, 0x00, 0x0E, 0x0E, 0x07, 0xF2, 0xE1, 0xCF, 0x8E,
  0x20, 0xF1, 0xC8, 0x0E, 0x1D, 0x00, 0xC2, 0x20, 0x18, 0xC2, 0x02, 0x18,
  0x3E, 0x43, 0x80, 0x10, 0x78, 0x04, 0x07, 0x03, 0x80, 0x61, 0xFC, 0x0C,
  0x07, 0xC1, 0x00, 0x7C, 0x40, 0x03, 0xF0, 0x06, 0x10, 0xC0, 0x7F, 0x77,
  0xE1, 0xFF, 0x10, 0xE2, 0x0F, 0x21, 0xC4, 0x0E, 0xC1, 0xD0, 0x0D, 0x83,
  0x20, 0x1B, 0x84, 0x20, 0x37, 0x98, 0x36, 0x47, 0x3C, 0x11, 0x06, 0x7C,
  0x04, 0x0C, 0x78, 0x30, 0x18, 0x71, 0xF0, 0x30, 0x64, 0xF0, 0xF0, 0x80,
  0xFE, 0xF2, 0x00, 0xF0, 0xF8, 0x0C, 0x08, 0x7E, 0x3D, 0xFE, 0xFA, 0x0D,
  0x24, 0x1C, 0x08, 0x18, 0x10, 0x3F, 0x10, 0xFC, 0x1F, 0xF0, 0x01, 0x80,
  0x03, 0x00, 0x0F, 0x00, 0x1E, 0x07, 0x4E, 0x4F, 0x9F, 0x2E, 0x1C, 0x0E,
  0x0E, 0x0F, 0xE5, 0xC7, 0x3E, 0x39, 0x07, 0x8E, 0x80, 0xE3, 0xE0, 0x18,
  0x68, 0x06, 0x11, 0x01, 0x8C, 0x3E, 0x47, 0x00, 0x31, 0xC0, 0x08, 0x78,
  0x04, 0x0E, 0x01, 0x03, 0xC1, 0xF4, 0x70, 0xBE, 0x1C, 0x03, 0x06, 0x08,
  0x01, 0x81, 0x00, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x3F, 0xC1, 0x87, 0x84,
  0x0E, 0x20, 0x18, 0x40, 0x61, 0x03, 0x03, 0x10, 0x01, 0xF0, 0x19, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0C, 0x40, 0x37, 0xC0, 0xEF, 0x82, 0x0F, 0x10,
  0x1F, 0x80, 0x00, 0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xE0, 0x00,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x00,
  0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0xE0, 0x08, 0x04, 0x07, 0x07, 0xC2,
  0x22, 0x0A, 0x02, 0xFF, 0xFF, 0xF0, 0xD9, 0x10, 0x04, 0x03, 0x83, 0x79,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x73, 0x1F, 0xF3, 0x38, 0x04, 0x0C,
  0x58, 0x1C, 0x06, 0x03, 0x21, 0xB8, 0xEE, 0x63, 0x31, 0x98, 0xCC, 0x66,
  0x37, 0x91, 0xF0, 0x30, 0x10, 0x0C, 0x7D, 0x9B, 0x26, 0x0C, 0x18, 0x30,
  0x70, 0x7C, 0x60, 0xC0, 0x40, 0x38, 0x1F, 0x07, 0xC0, 0xF9, 0x9C, 0xC6,
  0x61, 0xB0, 0x98, 0x4C, 0x2F, 0x21, 0xE0, 0x60, 0x0C, 0x3C, 0x66, 0x66,
  0x64, 0x78, 0x60, 0x60, 0x70, 0x3E, 0x18, 0x34, 0xF4, 0x90, 0x63, 0xF7,
  0x1C, 0x70, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x0C, 0x03,
  0x83, 0x79, 0x84, 0x61, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x8C, 0xE3, 0xD8,
  0x06, 0x01, 0x98, 0x43, 0x20, 0x30, 0x1E, 0x38, 0x1C, 0x06, 0x03, 0x21,
  0xF8, 0xCE, 0x67, 0x31, 0x98, 0xCC, 0x66, 0x33, 0x1B, 0xE8, 0xC8, 0x04,
  0x04, 0x0C, 0x08, 0x00, 0x30, 0xC2, 0x00, 0x21, 0xCB, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xE1, 0x80, 0x18, 0x61, 0x00, 0x20, 0xC7, 0xCE, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x70, 0x0E, 0xA4, 0xD9, 0xF3, 0x0F,
  0xEC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0F, 0x86, 0x00, 0x0F, 0xA0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x4F, 0x06, 0x00, 0x00,
  0x01, 0x98, 0x8E, 0xFF, 0x9C, 0xCE, 0x63, 0x31, 0x8C, 0xC6, 0x33, 0x18,
  0xCC, 0x63, 0x31, 0xCC, 0xEF, 0x7B, 0xC8, 0x86, 0x44, 0x3B, 0xCF, 0x39,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x3C, 0xF2, 0x18, 0x00, 0x04,
  0x3F, 0x19, 0xCC, 0xE6, 0x33, 0x1D, 0x84, 0xC6, 0xF2, 0x1E, 0x06, 0x00,
  0x40, 0x30, 0x0E, 0x21, 0xDC, 0x3B, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x6F, 0x92, 0xF8, 0x3C, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x0F,
  0x09, 0xEC, 0x66, 0x37, 0x1B, 0x8C, 0xC6, 0x73, 0x3F, 0x8C, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x04, 0x62, 0x76, 0x3F, 0x32, 0x30, 0x30, 0x30, 0x30,
  0x34, 0x7C, 0x18, 0x00, 0x07, 0x80, 0x23, 0x13, 0xF2, 0x31, 0x10, 0xCC,
  0x7F, 0x11, 0x90, 0x4E, 0x43, 0xC0, 0x40, 0x04, 0x21, 0x0C, 0x7E, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x7C, 0x60, 0x00, 0x21, 0x8E, 0x78, 0xC6, 0x18,
  0xC3, 0x18, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0x8F, 0xF8, 0x63, 0x00, 0x40,
  0x63, 0x3B, 0xDE, 0x77, 0x19, 0x8C, 0xC6, 0x23, 0x21, 0x98, 0x9F, 0x81,
  0x80, 0x80, 0x02, 0x00, 0x0E, 0x21, 0x39, 0xDC, 0x7B, 0xB9, 0x8C, 0x66,
  0x31, 0xD8, 0xC3, 0x63, 0x09, 0x8C, 0x67, 0x39, 0x3D, 0x78, 0x20, 0xC1,
  0x00, 0x00, 0x00, 0x32, 0x7F, 0x1B, 0x1A, 0x18, 0x18, 0x18, 0x18, 0x1A,
  0x3C, 0x58, 0x80, 0x80, 0x42, 0x3E, 0x00, 0x40, 0x10, 0x07, 0x31, 0xDC,
  0x3B, 0x8C, 0x73, 0x1C, 0xC7, 0x30, 0xCC, 0x33, 0x19, 0xF6, 0x11, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x00, 0x18, 0x79, 0x30, 0x41, 0x27, 0x9F, 0x1E,
  0x4E, 0x8D, 0x1A, 0x34, 0x48, 0x8E, 0x00, 0x0C, 0x43, 0x0C, 0x38, 0xE1,
  0x0C, 0xC0, 0x81, 0x0E, 0x38, 0xC3, 0x04, 0x0C, 0xFF, 0xFF, 0xC0, 0xE0,
  0xC1, 0x0E, 0x38, 0xC3, 0x04, 0x0C, 0x63, 0x0C, 0x30, 0xE3, 0x8C, 0xE0,
  0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 7, 6, 9, 1, -16 },
  { 15, 10, 12, 11, 1, -14 },
  { 30, 7, 18, 9, 1, -17 },
  { 46, 14, 16, 16, 1, -16 },
  { 74, 11, 14, 13, 1, -14 },
  { 94, 4, 6, 4, 0, -16 },
  { 97, 5, 18, 5, 0, -17 },
  { 109, 5, 18, 5, 0, -17 },
  { 121, 7, 8, 8, 0, -16 },
  { 128, 7, 8, 9, 1, -11 },
  { 135, 4, 6, 4, 0, -3 },
  { 138, 6, 5, 7, 1, -9 },
  { 142, 4, 3, 4, 0, -3 },
  { 144, 10, 17, 11, 1, -16 },
  { 166, 10, 16, 10, 0, -16 },
  { 186, 7, 15, 7, 0, -15 },
  { 200, 9, 15, 10, 0, -15 },
  { 217, 10, 15, 10, 0, -15 },
  { 236, 10, 15, 10, 0, -15 },
  { 255, 10, 15, 10, 0, -15 },
  { 274, 10, 16, 10, 0, -16 },
  { 294, 9, 15, 9, 0, -15 },
  { 311, 10, 15, 10, 0, -15 },
  { 330, 10, 16, 10, 0, -16 },
  { 350, 4, 10, 4, 0, -10 },
  { 355, 4, 13, 4, 0, -10 },
  { 362, 6, 8, 6, 0, -10 },
  { 368, 8, 5, 9, 0, -9 },
  { 373, 6, 8, 6, 0, -10 },
  { 379, 8, 16, 10, 1, -16 },
  { 395, 13, 13, 13, 0, -10 },
  { 417, 17, 16, 18, 0, -16 },
  { 451, 19, 16, 20, 0, -16 },
  { 489, 14, 16, 15, 1, -16 },
  { 517, 17, 17, 18, 0, -16 },
  { 554, 14, 16, 15, 1, -16 },
  { 582, 16, 19, 17, 0, -16 },
  { 620, 15, 17, 17, 1, -16 },
  { 652, 16, 20, 16, 0, -17 },
  { 692, 15, 19, 15, 0, -16 },
  { 728, 15, 21, 16, 0, -16 },
  { 768, 17, 17, 18, 0, -16 },
  { 805, 12, 15, 13, 0, -15 },
  { 828, 23, 16, 24, 1, -15 },
  { 874, 18, 16, 19, 1, -16 },
  { 910, 16, 17, 17, 0, -16 },
  { 944, 19, 19, 20, 0, -15 },
  { 990, 17, 18, 18, 0, -16 },
  { 1029, 19, 16, 20, 1, -16 },
  { 1067, 15, 16, 17, 1, -16 },
  { 1097, 15, 16, 16, 1, -16 },
  { 1127, 15, 16, 16, 0, -15 },
  { 1157, 19, 16, 20, 0, -16 },
  { 1195, 23, 16, 24, 0, -16 },
  { 1241, 15, 16, 16, 0, -16 },
  { 1271, 18, 19, 19, 0, -16 },
  { 1314, 14, 19, 15, 0, -16 },
  { 1348, 3, 17, 4, 0, -16 },
  { 1355, 13, 15, 2, -4, -14 },
  { 1380, 3, 17, 4, 0, -16 },
  { 1387, 9, 7, 9, 0, -16 },
  { 1395, 10, 2, 10, 0, 2 },
  { 1398, 3, 4, 11, 4, -15 },
  { 1400, 10, 12, 10, 0, -11 },
  { 1415, 9, 16, 10, 0, -15 },
  { 1433, 7, 11, 8, 0, -11 },
  { 1443, 9, 15, 10, 1, -15 },
  { 1460, 8, 11, 8, 0, -11 },
  { 1471, 6, 20, 5, 0, -16 },
  { 1486, 10, 16, 10, 0, -11 },
  { 1506, 9, 19, 10, 0, -15 },
  { 1528, 6, 15, 6, 0, -15 },
  { 1540, 6, 20, 5, -1, -16 },
  { 1555, 7, 16, 7, 0, -15 },
  { 1569, 7, 16, 6, 0, -15 },
  { 1583, 14, 12, 16, 1, -12 },
  { 1604, 10, 12, 11, 1, -11 },
  { 1619, 9, 11, 9, 0, -11 },
  { 1632, 10, 17, 10, 0, -13 },
  { 1654, 9, 16, 9, 0, -11 },
  { 1672, 8, 11, 8, 0, -11 },
  { 1683, 9, 14, 9, 0, -14 },
  { 1699, 6, 15, 7, 0, -14 },
  { 1711, 11, 11, 11, 0, -11 },
  { 1727, 9, 12, 10, 0, -12 },
  { 1741, 14, 14, 15, 1, -13 },
  { 1766, 8, 17, 9, 0, -12 },
  { 1783, 10, 17, 10, 0, -13 },
  { 1805, 7, 15, 7, 0, -11 },
  { 1819, 6, 17, 7, 0, -17 },
  { 1832, 1, 18, 3, 1, -17 },
  { 1835, 6, 17, 7, 0, -17 },
  { 1848, 8, 2, 8, 0, -8 },
};

const GFXfont UnifrakturMaguntia_Regular22pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular22pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular22pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR22PT7B_H_
