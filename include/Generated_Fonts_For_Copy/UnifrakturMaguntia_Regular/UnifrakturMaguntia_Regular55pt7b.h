#ifndef _UNIFRAKTURMAGUNTIA_REGULAR55PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xE1, 0xFC,
  0x3F, 0x87, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0xC0,
  0x7C, 0x1F, 0xC7, 0xFC, 0x3E, 0x03, 0x80, 0x20, 0x00, 0x00, 0x08, 0x01,
  0x01, 0x80, 0x60, 0x78, 0x1E, 0x1F, 0x87, 0xE7, 0xF9, 0xFE, 0x7F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x18, 0x06,
  0x02, 0x00, 0xC0, 0x40, 0x10, 0x10, 0x06, 0x02, 0x00, 0x80, 0x01, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1,
  0xC0, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x87,
  0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00,
  0x78, 0x70, 0x1C, 0x03, 0x07, 0x00, 0x70, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x7F, 0x01, 0x8F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF9, 0x00, 0xFF, 0x78,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x18, 0x03, 0xC1, 0x80, 0x70, 0x1E,
  0x3C, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x20, 0x7F,
  0x80, 0x00, 0x01, 0x87, 0x9E, 0x00, 0x00, 0x18, 0x78, 0x78, 0x00, 0x01,
  0x83, 0xC3, 0xE0, 0x00, 0x18, 0x3E, 0x1F, 0x00, 0x01, 0xC1, 0xF0, 0xF8,
  0x00, 0x1C, 0x0F, 0x83, 0xE0, 0x01, 0xC0, 0x7C, 0x1F, 0x00, 0x1C, 0x07,
  0xE0, 0xF8, 0x00, 0xC0, 0x3F, 0x07, 0xC0, 0x0C, 0x00, 0xF8, 0x3E, 0x00,
  0xC0, 0x07, 0xC1, 0xF0, 0x0E, 0x00, 0x3E, 0x0F, 0x80, 0xE0, 0x01, 0xF0,
  0xF8, 0x0E, 0x00, 0x0F, 0x87, 0xC0, 0xE0, 0x00, 0x3C, 0x3E, 0x06, 0x00,
  0x01, 0xE1, 0xE0, 0x60, 0x00, 0x07, 0x9E, 0x06, 0x00, 0x00, 0x1F, 0xE0,
  0x60, 0x7C, 0x00, 0x3E, 0x07, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x79, 0xE0,
  0x00, 0x07, 0x07, 0x87, 0x80, 0x00, 0x70, 0x7C, 0x3E, 0x00, 0x03, 0x03,
  0xE1, 0xF0, 0x00, 0x30, 0x1F, 0x0F, 0x80, 0x03, 0x01, 0xF8, 0x7E, 0x00,
  0x38, 0x0F, 0xC3, 0xF0, 0x03, 0x80, 0x7E, 0x1F, 0x80, 0x38, 0x03, 0xF0,
  0xFC, 0x03, 0x80, 0x1F, 0x87, 0xE0, 0x18, 0x00, 0x7C, 0x3E, 0x01, 0x80,
  0x03, 0xE1, 0xF0, 0x18, 0x00, 0x1F, 0x0F, 0x81, 0xC0, 0x00, 0x78, 0x78,
  0x1C, 0x00, 0x01, 0xE7, 0x81, 0xC0, 0x00, 0x07, 0xF8, 0x0C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0E, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3F, 0x1E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3F, 0x78,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xF0,
  0x1F, 0xC1, 0xFF, 0x07, 0xFC, 0x07, 0xC0, 0xEF, 0xE0, 0x38, 0x1C, 0xFE,
  0x03, 0x03, 0xC7, 0xF0, 0x30, 0x78, 0x7F, 0x03, 0x07, 0x83, 0xF8, 0x20,
  0xF8, 0x3F, 0x82, 0x0F, 0x81, 0xFC, 0x60, 0xF8, 0x1F, 0xC4, 0x0F, 0xC0,
  0xFE, 0xC0, 0xFC, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0x81, 0x7F, 0x01, 0xFC, 0x37, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE7, 0xF8, 0x07, 0xF8, 0x1F, 0x00, 0x08, 0x0E,
  0x0F, 0x0F, 0xEF, 0xF9, 0xFC, 0x7C, 0x1E, 0x0F, 0x03, 0x01, 0x81, 0x80,
  0x80, 0x40, 0x40, 0x00, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x0E, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x0F, 0xE0, 0x19, 0xF6, 0x3E, 0x39, 0xF7, 0xCE, 0x7D, 0xF3, 0x3E, 0x7E,
  0x5F, 0x9F, 0xFF, 0xE0, 0x0E, 0x01, 0x8F, 0xE6, 0x7F, 0x5F, 0x9F, 0xB3,
  0xE7, 0xCC, 0xFF, 0xF3, 0x9F, 0x09, 0xF6, 0x00, 0xFE, 0x00, 0x1E, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x08, 0x0E, 0x07, 0x8F, 0xE7, 0xF8, 0xFC, 0x3E, 0x1E, 0x07,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x00, 0x03, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x3F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF0, 0x7E, 0x00, 0x08, 0x0E, 0x0F, 0x0F, 0xEF, 0xF9, 0xF0,
  0x70, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xC7, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xC7, 0xE0, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xE0, 0xFF,
  0x87, 0x00, 0x7F, 0x1C, 0x00, 0xFF, 0x30, 0x00, 0xFE, 0x60, 0x01, 0xFD,
  0x80, 0x03, 0xFB, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x30, 0x38, 0x00, 0x60, 0xE0, 0x00,
  0x81, 0x80, 0x01, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1C, 0x0F, 0xF8, 0x38, 0x07, 0xF8,
  0x30, 0x03, 0xFC, 0x60, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0x7F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3C, 0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x78,
  0x7E, 0x00, 0x78, 0x7E, 0x00, 0xF0, 0x3E, 0x00, 0xC0, 0x1F, 0x03, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x37, 0xE0, 0x00, 0xCF, 0xC0, 0x01, 0x1F, 0x80, 0x06, 0x3F, 0x00, 0x18,
  0x7E, 0x00, 0x30, 0xFC, 0x00, 0xC1, 0xF8, 0x03, 0x03, 0xF0, 0x06, 0x07,
  0xE0, 0x18, 0x0F, 0xC0, 0x20, 0x1F, 0x80, 0xC0, 0x3F, 0x03, 0x00, 0x7E,
  0x04, 0x00, 0xFC, 0x18, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0C,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3E,
  0x07, 0xFC, 0x38, 0x01, 0xFE, 0x30, 0x00, 0xFE, 0x20, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3C, 0xFE, 0x00, 0x78, 0x7E, 0x00, 0x78, 0x7E,
  0x00, 0xF0, 0x3E, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0x87, 0xC0, 0x06, 0x07, 0xC0, 0x1C, 0x0F, 0xC0, 0x70,
  0x1F, 0x81, 0xE0, 0x3F, 0x83, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00,
  0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xE0, 0x1F, 0x8F, 0xF0, 0x3F, 0x3F, 0xF8, 0x7E, 0x63, 0xF9,
  0xFD, 0x83, 0xF3, 0xFE, 0x07, 0xF7, 0xFC, 0x07, 0xEF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xCF, 0xE0,
  0x0F, 0x8F, 0xC0, 0x1E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xC0, 0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x62, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF7,
  0x80, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x7E, 0x00, 0x3C, 0x7F, 0x00, 0x38, 0x3F, 0x80, 0x78, 0x3F, 0xE0,
  0x70, 0x3F, 0xF8, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0E, 0x1F,
  0xF8, 0x1C, 0x0F, 0xFC, 0x38, 0x03, 0xFC, 0x78, 0x01, 0xFE, 0x70, 0x00,
  0xFE, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x07, 0x03,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0F,
  0x00, 0x70, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x7E,
  0x1E, 0x00, 0xFC, 0x7C, 0x01, 0xFC, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFB, 0xF8,
  0x1F, 0xF7, 0xF0, 0x6F, 0xC7, 0xF1, 0xDF, 0x87, 0xFF, 0x3F, 0x07, 0xFC,
  0x7E, 0x07, 0xF0, 0xFC, 0x01, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0x00, 0x3F, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8,
  0x7E, 0x01, 0xE0, 0xFC, 0x03, 0xC0, 0xF8, 0x07, 0x01, 0xF8, 0x1C, 0x01,
  0xF0, 0x30, 0x01, 0xF0, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x08, 0x0C, 0x0F,
  0x0F, 0xCF, 0xFB, 0xF0, 0x70, 0x30, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0x83, 0xC3, 0xFB, 0xFE, 0x7C,
  0x1C, 0x04, 0x00, 0x00, 0x04, 0x03, 0x01, 0xE0, 0xFC, 0x7F, 0xCF, 0xC0,
  0xE0, 0x30, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x70, 0x1E, 0x1F, 0xC7, 0xF8, 0x7E, 0x0F, 0x83,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0xF0, 0x7C, 0x0E, 0x01, 0xF0, 0xE0, 0x07, 0xCE, 0x00, 0x1F,
  0x70, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x80, 0x3E, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xDF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x02, 0x03,
  0xC0, 0x10, 0x0E, 0x00, 0x80, 0x78, 0x08, 0x00, 0xE0, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x01, 0xFF, 0x1C, 0x3C, 0x07, 0xFF, 0x1C,
  0x78, 0x0F, 0x3F, 0x1C, 0x78, 0x1E, 0x1F, 0x1C, 0x78, 0x3E, 0x3E, 0x1C,
  0xF0, 0x7C, 0x3E, 0x1C, 0xF0, 0x78, 0x3E, 0x1C, 0xF0, 0xF8, 0x3C, 0x1C,
  0xF0, 0xF0, 0x7C, 0x1C, 0xF1, 0xF0, 0x7C, 0x3C, 0xF1, 0xF0, 0xF8, 0x78,
  0xF1, 0xF0, 0xF8, 0x78, 0xF1, 0xF1, 0xF8, 0xF0, 0xF1, 0xF3, 0xF9, 0xE0,
  0xF1, 0xFF, 0xFF, 0xC7, 0x70, 0xFE, 0x7F, 0x8F, 0x78, 0x78, 0x7E, 0x0E,
  0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xC0, 0x7F,
  0xF0, 0x1F, 0xC0, 0x70, 0x03, 0xFE, 0x0F, 0xF8, 0x0C, 0x00, 0x3F, 0xE3,
  0xFE, 0x03, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x60, 0x00, 0x7F, 0xC3, 0xF8,
  0x08, 0x00, 0x07, 0xF8, 0x7F, 0x03, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x60,
  0x00, 0x0F, 0xE1, 0xFC, 0x0E, 0x00, 0x01, 0xFC, 0x3F, 0x81, 0xC0, 0x00,
  0x3F, 0x87, 0xF0, 0x3C, 0x00, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x00, 0x7E,
  0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0xC0, 0x7C, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0x81, 0xFC, 0x00,
  0x7F, 0x83, 0xE0, 0x3F, 0x80, 0x01, 0xF0, 0x78, 0x07, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0xFE, 0x00, 0x01, 0x83, 0x80, 0x1F, 0xC0, 0x00, 0x60, 0xE0,
  0x03, 0xF8, 0x00, 0x08, 0x38, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x77, 0xFF,
  0x81, 0xBF, 0x88, 0x00, 0x3F, 0xFC, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x18, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x90, 0x3F, 0xC0, 0x3F,
  0x80, 0xFF, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x3C,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x78, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x70,
  0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x70, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x60,
  0x00, 0x07, 0xE0, 0x07, 0xFC, 0x60, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x60,
  0x00, 0x03, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x38,
  0x00, 0x03, 0xC1, 0xFF, 0xF0, 0x1C, 0x00, 0x83, 0xCF, 0xFF, 0xF8, 0x0F,
  0x01, 0x07, 0x8F, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0x00, 0x0F, 0xFC, 0x00,
  0x60, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x47, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x00, 0x07, 0xFE,
  0x07, 0x80, 0x00, 0xF0, 0x20, 0xFE, 0x00, 0x1E, 0x01, 0x3F, 0xFF, 0x03,
  0xC0, 0x1F, 0xFF, 0xE0, 0x7C, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0x38, 0x7F,
  0x00, 0xF8, 0x06, 0x00, 0xE0, 0x1F, 0x01, 0xC0, 0x04, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x07, 0x00,
  0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x07, 0xFE, 0x18, 0x00, 0x00, 0x3F, 0xF3,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0x0E, 0x00,
  0x7F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0x38, 0x3F, 0xF8, 0x0F, 0x80, 0x18,
  0x03, 0xFF, 0x07, 0x80, 0x0E, 0x00, 0x3F, 0xE1, 0xE0, 0x07, 0x00, 0x07,
  0xF8, 0x70, 0x03, 0xE0, 0x00, 0xFF, 0x38, 0x01, 0xF8, 0x00, 0x1F, 0xCE,
  0x00, 0x7F, 0x00, 0x03, 0xFB, 0x80, 0x1F, 0xE0, 0x00, 0x7E, 0xE0, 0x07,
  0xFC, 0x00, 0x1F, 0xB8, 0x01, 0xFF, 0x80, 0x03, 0xE6, 0x00, 0x3F, 0xF0,
  0x00, 0x7D, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x60, 0x01, 0xFF, 0xC0, 0x07,
  0xC8, 0x00, 0x1F, 0xF0, 0x00, 0xF3, 0x00, 0x03, 0xFC, 0x00, 0x3C, 0x60,
  0x00, 0x7F, 0x00, 0x0F, 0x0E, 0x02, 0x0F, 0xC0, 0x03, 0xC0, 0xFF, 0x81,
  0xF0, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF,
  0xF0, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x00, 0x03, 0xFF, 0x03, 0xC0,
  0x00, 0x3C, 0x08, 0x3F, 0x80, 0x03, 0xC0, 0x27, 0xFF, 0xE0, 0x3C, 0x01,
  0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0xFF, 0xE0, 0x3E, 0x00, 0xE1, 0xFC, 0x01,
  0xF0, 0x0C, 0x01, 0xC0, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0xF8,
  0x0F, 0xC1, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xFC, 0x7F, 0xF3, 0xF8, 0x3F,
  0xF7, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0x1F, 0x87,
  0xF0, 0x0F, 0xFC, 0x78, 0x3F, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0xE0,
  0x1C, 0x00, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x07, 0xFE, 0x18, 0x00, 0x00,
  0x1F, 0xF9, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x01, 0xFF, 0xE0,
  0x01, 0xC0, 0x07, 0xFF, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x5C, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE0, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x78, 0x00, 0x05,
  0xFF, 0xC0, 0xE0, 0x00, 0x18, 0xFF, 0x03, 0x80, 0x00, 0x60, 0x7C, 0x07,
  0x00, 0x01, 0xC0, 0x60, 0x0C, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x20,
  0xC0, 0x00, 0xFF, 0x00, 0xE1, 0x80, 0x01, 0xFE, 0x03, 0xE3, 0x00, 0x03,
  0xFE, 0x0F, 0xE7, 0x00, 0x03, 0xFE, 0x1F, 0xE6, 0x00, 0x07, 0xFE, 0x7F,
  0xC6, 0x00, 0x07, 0xFF, 0xFF, 0x0E, 0x00, 0x0F, 0xFE, 0x7C, 0x0E, 0x00,
  0x8F, 0xFC, 0x30, 0x07, 0x8F, 0x8F, 0xF8, 0x60, 0x03, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x0C, 0x00, 0x00, 0x7C, 0x18, 0x3E, 0x00, 0x00, 0xF0,
  0x04, 0x7F, 0x00, 0x01, 0xE0, 0x04, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0x7F,
  0xC0, 0x07, 0xC0, 0x06, 0x3F, 0xE0, 0x0F, 0x80, 0x18, 0x1F, 0xF0, 0x0F,
  0x80, 0x30, 0x0F, 0xFC, 0x1F, 0x80, 0xE0, 0x07, 0xFC, 0x1F, 0x01, 0xE0,
  0x03, 0xF8, 0x3F, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0x07, 0xE0, 0x01, 0xC0,
  0x3F, 0x07, 0xE0, 0x03, 0x00, 0x7F, 0x0F, 0xE0, 0x0E, 0x00, 0x7F, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0xF0, 0x7F, 0x07, 0xF8, 0xFF,
  0xF8, 0x7F, 0x03, 0xFD, 0xFF, 0xF8, 0x7F, 0x03, 0xFE, 0x07, 0xFC, 0x7F,
  0x01, 0xFF, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFF,
  0x80, 0xFE, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0x0F, 0xC0, 0x3F, 0x3F, 0xC0, 0x0F, 0xC0, 0x3E, 0x1F, 0xC0, 0x07, 0x80,
  0x7E, 0x1F, 0xE0, 0x0F, 0x00, 0x7E, 0x0F, 0xE0, 0x0E, 0x00, 0x7C, 0x0F,
  0xF0, 0x1C, 0x00, 0x7C, 0x07, 0xF8, 0x30, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x0E, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0x9F, 0xF0, 0x00, 0x00, 0x18, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x7F, 0xE0,
  0x00, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xE0,
  0x01, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0xE3, 0xFF, 0x80, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0xF0, 0x07, 0x80, 0x0F, 0xC7,
  0xF0, 0x1C, 0x00, 0x3E, 0x7F, 0xE0, 0x70, 0x01, 0xFB, 0xFF, 0xC1, 0x80,
  0x07, 0xC9, 0xFF, 0x8C, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x07,
  0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0x81, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0xF0,
  0x00, 0x7F, 0xFE, 0x1C, 0x00, 0x07, 0xFF, 0x83, 0x80, 0x00, 0x7F, 0xE0,
  0xE0, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x30,
  0x00, 0x1F, 0xC0, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x7F, 0x80,
  0x07, 0x80, 0x27, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x03, 0xE1, 0xFF, 0xC0, 0x00, 0x7C, 0x7F, 0xFC,
  0x00, 0x0F, 0x1F, 0xFF, 0xC0, 0x01, 0xE4, 0x1F, 0xFC, 0x00, 0x38, 0x01,
  0xFF, 0xC0, 0x06, 0x00, 0x1F, 0xFC, 0x01, 0x80, 0x01, 0xFF, 0xE0, 0x60,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xF8, 0x00, 0x3C, 0x00,
  0xFF, 0xE0, 0x03, 0xC0, 0x03, 0xFF, 0xF8, 0x1C, 0x00, 0x0F, 0xFF, 0x81,
  0xC0, 0x00, 0x1F, 0xF8, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x00, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x07, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x09, 0xFE, 0x00,
  0x03, 0xEF, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00,
  0x70, 0x3F, 0xF8, 0x00, 0x07, 0x87, 0xFF, 0xE0, 0x00, 0x38, 0x77, 0xFF,
  0x80, 0x01, 0xC2, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x00, 0xC0,
  0x00, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0xFF, 0xC1, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0xFC, 0x03, 0x80, 0x01, 0xE0, 0x7F, 0xE0, 0x38, 0x00,
  0x7C, 0x3F, 0xFE, 0x03, 0x80, 0x1F, 0x87, 0xFF, 0xE0, 0x70, 0x03, 0xE1,
  0xC3, 0xFE, 0x0E, 0x00, 0x7C, 0x30, 0x3F, 0xC0, 0xE0, 0x1F, 0xCC, 0x03,
  0xFC, 0x1C, 0x03, 0xF9, 0x00, 0x3F, 0x83, 0x80, 0x7F, 0x20, 0x07, 0xF8,
  0x70, 0x0F, 0xF4, 0x00, 0x7F, 0x0E, 0x00, 0xFE, 0x80, 0x0F, 0xF9, 0xC0,
  0x1F, 0xF0, 0x00, 0xFE, 0x30, 0x03, 0xFE, 0x00, 0x0F, 0x0E, 0x00, 0x3F,
  0xE0, 0x01, 0x81, 0x80, 0x07, 0xFE, 0x00, 0xE0, 0x70, 0x00, 0x7F, 0xC0,
  0x38, 0x18, 0x00, 0x0F, 0xFC, 0x1F, 0xC6, 0x00, 0x00, 0xFF, 0x8F, 0xF9,
  0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xC0, 0x3E,
  0x03, 0xFC, 0x00, 0xFE, 0x03, 0xC0, 0x3F, 0x80, 0x3F, 0xE0, 0x70, 0x07,
  0xF8, 0x0F, 0xFC, 0x0C, 0x00, 0x7F, 0x03, 0xFF, 0xC1, 0x80, 0x0F, 0xF0,
  0x07, 0xFE, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF9,
  0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x3E, 0x7F, 0x80, 0x01, 0xF3, 0xFC,
  0x00, 0x0F, 0x9F, 0xF0, 0x00, 0x7C, 0x7F, 0x80, 0x07, 0xC3, 0xFE, 0x00,
  0x3E, 0x0F, 0xF0, 0x03, 0xE0, 0x7F, 0xC8, 0x3E, 0x01, 0xFE, 0x7F, 0xE0,
  0x0F, 0xF0, 0x7C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0x7F, 0xFE, 0x00, 0x80, 0x7F, 0xFC, 0x1C, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xCC, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0x03, 0xF8,
  0x0F, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x01, 0xC0, 0x0F, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x60, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x0C, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xC1, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03,
  0xF8, 0x60, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x8C, 0x00, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF9, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0xB0,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x82, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0xE0, 0x60, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x38, 0x0C, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x0C, 0x00, 0xE7, 0xF0, 0x0F, 0xC0, 0x3E, 0x03, 0x80,
  0x1F, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0xE0, 0x01, 0xFF, 0xE0, 0x3E, 0x00,
  0xF8, 0x1C, 0x00, 0x1F, 0xFE, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x00, 0xF0,
  0xC0, 0xF8, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x18, 0x1F, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x02, 0x03, 0xC0, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE1,
  0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x18, 0x3F, 0x80, 0x00, 0x08, 0x01,
  0xC0, 0x07, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x31, 0xC0, 0xC0, 0x7F, 0x00,
  0x07, 0xFC, 0x0C, 0xFC, 0x10, 0x0F, 0xF0, 0x01, 0xFF, 0xC1, 0x3F, 0xE6,
  0x00, 0xFF, 0x98, 0x7F, 0xFC, 0x6F, 0xFF, 0x80, 0x1F, 0xFE, 0x08, 0xFF,
  0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x90, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x1C, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0xC0, 0xFE,
  0x03, 0xC0, 0x3F, 0xF2, 0x01, 0xFC, 0x1C, 0x00, 0x7F, 0xF8, 0x07, 0xF0,
  0x60, 0x00, 0x7F, 0xC0, 0x1F, 0xC1, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x84,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x30, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0xC0,
  0x00, 0x0F, 0xE0, 0x0F, 0xFB, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xF4, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x10, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x60, 0x00,
  0x03, 0xF0, 0x03, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x18, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0xC0, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0x00, 0x1F, 0xFF, 0x03,
  0xF0, 0x38, 0x00, 0x1F, 0xFC, 0x0F, 0x81, 0xE0, 0x00, 0x10, 0x30, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0xC0, 0x78, 0x3E, 0x00, 0x00, 0x02, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x03, 0x81, 0xFC,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x70, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0x80, 0x3F, 0x80, 0x07, 0xFC, 0x0C, 0x00, 0xFF, 0x08,
  0x3F, 0xF8, 0x30, 0x01, 0xFF, 0xF1, 0xBF, 0xF1, 0x80, 0x07, 0xFF, 0x84,
  0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x3F,
  0xFF, 0xE0, 0x00, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0x01, 0xFF, 0xC0,
  0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0xFF, 0xC1, 0xE0, 0x00,
  0x00, 0xFF, 0x87, 0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0xF9, 0xFF, 0xF8, 0x00, 0x01,
  0xF1, 0xFF, 0xF8, 0x00, 0x03, 0xE1, 0xFF, 0xF8, 0x00, 0x03, 0xC1, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x00,
  0x1E, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x60, 0x00,
  0x03, 0x00, 0xFE, 0x00, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x1F,
  0xFF, 0x00, 0x00, 0x20, 0x7F, 0xFF, 0x80, 0x00, 0xC1, 0x0F, 0xFF, 0x80,
  0x03, 0x00, 0x07, 0xFF, 0xC0, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x00,
  0x07, 0xE3, 0xFF, 0xC7, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xBB, 0xFE, 0x00,
  0x38, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0x80, 0x00, 0xFF, 0x0F, 0xFC, 0x03, 0x00, 0x01, 0xFE, 0x0F, 0xFE, 0x06,
  0x00, 0x01, 0xFC, 0x0F, 0xFE, 0x0C, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x18,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x30, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x60,
  0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x60, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0xC0,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0xE0,
  0x38, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x18,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0x00, 0x00, 0x3B, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0xC0, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x07, 0xFF,
  0xF8, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0x80, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0x3C, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x01, 0xC6, 0x00, 0x1E, 0x30, 0x01, 0xFC, 0x00,
  0x1F, 0xCC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0x83, 0x3F, 0xE0, 0xA1, 0xFF, 0xF0, 0x03, 0xFC, 0x60,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x63, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x60, 0xFF, 0x80, 0x7E, 0x0F, 0xFF, 0x20, 0x3F, 0xC0,
  0x3C, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0x3C, 0x00, 0x3F, 0xF0, 0x07, 0xF8,
  0x1C, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x0E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE7, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xF3, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE1, 0xC0, 0x00, 0x07, 0xE0, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xF8, 0x03,
  0x80, 0x18, 0x00, 0x00, 0x7C, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0x8F,
  0xF0, 0x00, 0x38, 0x06, 0x07, 0xDF, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xE1,
  0xFE, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x03, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x01,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC1, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xF1,
  0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x20, 0x00, 0x7F, 0xFF, 0xE0, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x3F, 0xC0,
  0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0xFF, 0xE0, 0xF0, 0x60,
  0x3F, 0xFF, 0xE1, 0xE0, 0x63, 0xFF, 0xFF, 0xE3, 0xC0, 0x7F, 0xFF, 0xC0,
  0x6F, 0x80, 0x7F, 0xFE, 0x00, 0x5F, 0x00, 0x7F, 0xF0, 0x00, 0xDF, 0x00,
  0x7F, 0xC0, 0x01, 0xBE, 0x00, 0x7E, 0x00, 0x03, 0x7E, 0x00, 0x00, 0x00,
  0x02, 0xFC, 0x00, 0x00, 0x00, 0x0D, 0xFC, 0x00, 0x00, 0x00, 0x19, 0xFC,
  0x00, 0x00, 0x00, 0x33, 0xFC, 0x00, 0x00, 0x00, 0xC3, 0xFC, 0x00, 0x00,
  0x03, 0x87, 0xFE, 0x00, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x07,
  0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x3F,
  0xFF, 0x80, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0x07, 0xFF, 0xC0,
  0x30, 0x00, 0x03, 0xFF, 0xE3, 0x60, 0x00, 0x11, 0xFF, 0xFC, 0x80, 0x00,
  0xE1, 0xFF, 0xE3, 0x00, 0x03, 0x80, 0xFF, 0x86, 0x00, 0x0F, 0x00, 0xFE,
  0x0C, 0x00, 0x3E, 0x00, 0x30, 0x18, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x01,
  0xFE, 0x00, 0x00, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x03, 0xFE, 0x00,
  0x00, 0x60, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x17, 0xFE, 0x00, 0x00, 0x3F,
  0xC7, 0xFE, 0x00, 0x00, 0x0C, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x60, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x0F,
  0x80, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x70, 0x00, 0x0C,
  0xFF, 0xF1, 0x80, 0x00, 0x00, 0x7F, 0xF4, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x60,
  0x00, 0x3F, 0xF8, 0x01, 0x80, 0x00, 0x3F, 0xFE, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x20, 0x0F, 0x0E,
  0x00, 0x0E, 0x00, 0xF0, 0x30, 0x01, 0xF0, 0x0F, 0x00, 0x80, 0x3F, 0x00,
  0xF8, 0x04, 0x07, 0xF0, 0x07, 0xC0, 0x20, 0xFF, 0x80, 0x7E, 0x03, 0x07,
  0xFC, 0x03, 0xF0, 0x30, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00,
  0xF0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x7F,
  0x00, 0x03, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x07, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x6F, 0xE0, 0x67, 0xFF, 0x06,
  0x7F, 0x04, 0x0F, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07,
  0x80, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x20, 0xFF, 0x00, 0x7F, 0xFF, 0xFD, 0x83,
  0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x07, 0xF8, 0x1F, 0x00, 0x3F, 0xF0, 0x1F,
  0xE0, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xC1, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x8E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x30, 0x00, 0x07, 0xF0, 0x03, 0xF0,
  0xC0, 0x00, 0x0F, 0xC0, 0x07, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x7C, 0x00, 0xC0, 0x10, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x1C, 0x01, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x06, 0x00, 0x41, 0xE0, 0x1F, 0xC0, 0x0C, 0x06,
  0x07, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x3C, 0x01, 0xFF, 0x00, 0x04, 0x00,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x38, 0x03, 0x0F, 0xFF, 0x00, 0x00,
  0xE0, 0x08, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x1C, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x1F, 0xC6, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xD8,
  0x74, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x1E, 0x03, 0xFE, 0x01, 0xFE,
  0x7F, 0xFC, 0x06, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x07, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0xFF, 0x07, 0x80, 0x1F, 0xE0, 0x70, 0x00, 0x3F, 0xC3,
  0x80, 0x07, 0xF0, 0x70, 0x00, 0x0F, 0xE3, 0xE0, 0x03, 0xFC, 0x38, 0x00,
  0x07, 0xF1, 0xF0, 0x00, 0xFF, 0x1C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x7F,
  0xCC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x3E, 0x3F,
  0x80, 0x07, 0x01, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x03, 0x00, 0xC0, 0x00,
  0x0F, 0x8F, 0xF0, 0x03, 0x80, 0x60, 0x00, 0x07, 0xC7, 0xFC, 0x03, 0xC0,
  0x18, 0x00, 0x03, 0xE1, 0xFE, 0x03, 0xE0, 0x06, 0x00, 0x41, 0xE0, 0xFF,
  0x83, 0xF8, 0x01, 0x80, 0x60, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xC0,
  0x70, 0x0F, 0xE0, 0xFF, 0x80, 0x0F, 0x80, 0x70, 0x07, 0xF0, 0x7F, 0xE0,
  0x00, 0x00, 0x38, 0x01, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xFC,
  0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x38, 0x0E, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x1C, 0x08,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x3F, 0xFF,
  0xC7, 0xFF, 0x8C, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x07, 0xE2, 0x1F, 0xFF,
  0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xF8,
  0xFE, 0x1F, 0xF1, 0xFF, 0xC7, 0x80, 0x3F, 0x8C, 0xFC, 0x78, 0x00, 0xFE,
  0xC3, 0xC3, 0x80, 0x03, 0xF4, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x00, 0xC0,
  0x00, 0x7F, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x1F, 0x80,
  0x01, 0x80, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00,
  0x3F, 0xFF, 0x80, 0x80, 0x03, 0xFF, 0xFC, 0x07, 0x00, 0x3F, 0xFF, 0xC0,
  0x1E, 0x33, 0xFF, 0xFE, 0x00, 0x1E, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0x7F, 0x00, 0x00, 0x00, 0x09, 0xFC, 0x00,
  0x03, 0xE0, 0xCF, 0xF0, 0x00, 0x3F, 0x84, 0x7F, 0xC0, 0x81, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0xC7, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xE2, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xA0, 0x3F, 0xC0, 0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x0F, 0x00, 0x1F,
  0xF8, 0x07, 0xF0, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xC3, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x38, 0x00, 0x07, 0xF0, 0x07, 0xF9, 0x80, 0x00, 0x3F, 0x80,
  0x3F, 0xCC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x07,
  0xF3, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x08, 0x00, 0x00, 0xF8, 0x00, 0xE0,
  0x60, 0x00, 0x07, 0xC0, 0x0E, 0x03, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x0C,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x30, 0x02, 0x0F, 0x01, 0xF8, 0x00, 0xE0,
  0x60, 0x78, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0C, 0x0F, 0xF0,
  0x00, 0x3F, 0xE1, 0xC0, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0x1F, 0xE0,
  0x0E, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x00, 0x7F, 0x01, 0xC0, 0x00, 0x1F,
  0xC0, 0x70, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x30, 0x00, 0x07, 0xC0, 0x06, 0x00,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x78, 0x7F,
  0xC0, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x07, 0x9F, 0xFF, 0x00, 0x01, 0xC8,
  0x7F, 0xE0, 0x00, 0x60, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0xFF, 0x80, 0x1C,
  0x00, 0x3F, 0xF0, 0x0E, 0x00, 0x07, 0xFF, 0x06, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0x00,
  0x20, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xF9, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0x3C,
  0x3C, 0x01, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0xF8, 0xF8, 0xFC, 0x7C, 0x3C, 0x1E, 0x0E, 0x06, 0x03,
  0x01, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x2F, 0xFC, 0x01, 0x8F, 0xFE, 0x07, 0x07, 0xF8,
  0x1C, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC,
  0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0,
  0x3E, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0xF8, 0x9F, 0xE3, 0xFF, 0x1F, 0xFB,
  0xFC, 0x1F, 0xE7, 0xF0, 0x1F, 0x07, 0xE0, 0x1C, 0x07, 0x80, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x1C, 0x00,
  0x10, 0xE0, 0x00, 0x27, 0x80, 0x00, 0xBE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x08, 0x07, 0xE0,
  0x60, 0x1F, 0x83, 0xC0, 0x7E, 0x1F, 0x81, 0xF9, 0xFE, 0x07, 0xF9, 0xFC,
  0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80,
  0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1E, 0x1F, 0x80, 0x78,
  0x7E, 0x01, 0xC1, 0xF8, 0x0E, 0x07, 0xF0, 0x30, 0x3F, 0xF1, 0x81, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xCF, 0xC0, 0xE3, 0xE0, 0xE1, 0xF8, 0x70, 0xFC, 0x78, 0x3F, 0x3C,
  0x1E, 0x3E, 0x04, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x87,
  0xFF, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x63, 0xFC, 0x13, 0x83, 0xFC, 0x3F, 0x03, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7,
  0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x78, 0x7E,
  0x00, 0xF0, 0xFC, 0x01, 0xE1, 0xF8, 0x03, 0xC3, 0xF0, 0x07, 0x07, 0xE0,
  0x0E, 0x0F, 0xF0, 0x18, 0x7F, 0xF8, 0x60, 0x3F, 0xF9, 0x80, 0x0F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x19, 0xF8, 0x0E, 0x7E,
  0x07, 0x0F, 0xC1, 0xC3, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x9F, 0x07, 0xE7,
  0x80, 0xFD, 0xE0, 0x3C, 0x7C, 0x38, 0x1F, 0x70, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC1, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x08, 0x38, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xCF, 0xFC, 0x03, 0x0F, 0xFE, 0x0E, 0x0F,
  0xF8, 0x3C, 0x07, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0x87, 0xC0, 0x0E,
  0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x8F, 0xF8, 0x3F, 0xE3, 0xF0, 0x7F, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x70,
  0x03, 0xE1, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x30, 0xF0, 0x00, 0x47, 0xC0, 0x00, 0x9E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x40, 0x1F, 0x83, 0x80, 0x7E, 0x3E, 0x01,
  0xF9, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xC7,
  0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xC3, 0xF9, 0x8F, 0x1F, 0xFC, 0x38,
  0x1F, 0xE1, 0xE0, 0x3F, 0x07, 0x00, 0x38, 0x38, 0x00, 0x40, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFC, 0x9F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x88, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E,
  0x01, 0xE0, 0x02, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xFC,
  0x1B, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xEC, 0x03, 0xC4, 0x03, 0x82,
  0x07, 0x03, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x70, 0xC1, 0xE0,
  0x43, 0xC0, 0x27, 0xC7, 0x37, 0x8F, 0x1F, 0x9F, 0x1F, 0xBF, 0x1F, 0xBF,
  0x1F, 0xFA, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC4,
  0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x3F, 0x00, 0xF0, 0xC1, 0xC0, 0x43, 0xC0, 0x27, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC4, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xF0,
  0x03, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0x7F, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0xFF, 0x9F, 0xF0, 0x3F, 0xED, 0xFD, 0xFF, 0xF1, 0x7F, 0x87,
  0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x3F,
  0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x1F, 0x81,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x83, 0xF2, 0x1F, 0xF3, 0xFE,
  0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3E, 0x03, 0xF8, 0x0F,
  0x00, 0xE0, 0x0F, 0x80, 0x30, 0x07, 0x00, 0x3C, 0x00, 0x80, 0x10, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x0F, 0x00, 0xC0, 0x07, 0xC0, 0xF0, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0xFF, 0xC3, 0xFF, 0x9F, 0xFA, 0x3F, 0x87, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0,
  0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x7F, 0x03,
  0xF2, 0x7F, 0xC1, 0xFD, 0x1F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0x81, 0xE0,
  0x0F, 0x80, 0x60, 0x03, 0xC0, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x01, 0xEF, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0x7F,
  0x03, 0xF1, 0xFE, 0x0F, 0xC3, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xE3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F,
  0x0F, 0xC0, 0x3C, 0x3F, 0x00, 0xE1, 0xFF, 0x07, 0x0F, 0xFE, 0x18, 0x0F,
  0xFE, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x7F, 0x00,
  0xC0, 0x7F, 0x83, 0xE0, 0x7F, 0x87, 0xE0, 0x3F, 0x9F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x3C, 0x0F, 0xC0, 0x3C, 0x7F, 0xC0, 0x38, 0x7F, 0xE0,
  0x70, 0xFF, 0xF8, 0x60, 0xFF, 0xFE, 0xC0, 0x87, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xC8, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0D, 0xFF, 0x80, 0xC7,
  0xFF, 0x0C, 0x0F, 0xF0, 0xE0, 0x3F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xE0, 0x3E, 0x3F,
  0x01, 0xF1, 0xFC, 0x0F, 0x8F, 0xF0, 0xFC, 0x3F, 0xCF, 0xE0, 0xFF, 0x9F,
  0x07, 0xF8, 0xF8, 0x1F, 0x87, 0xC0, 0x70, 0x3E, 0x01, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x18, 0x02, 0x07, 0x81, 0xC3, 0xF0, 0xF0, 0xFE, 0x3E, 0x7F, 0x9F,
  0x97, 0xFF, 0xF8, 0xFE, 0xFC, 0x3F, 0x3E, 0x0F, 0xC7, 0x03, 0xF1, 0x80,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x60, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01,
  0x00, 0x60, 0x3E, 0x03, 0x03, 0xF8, 0x38, 0x3F, 0xFF, 0x82, 0x7F, 0xFC,
  0x20, 0xFF, 0xC3, 0x01, 0xFC, 0x38, 0x03, 0x81, 0xC0, 0x08, 0x1F, 0x00,
  0xC0, 0xFC, 0x0E, 0x03, 0xF0, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFD, 0xFE, 0x0F, 0x83, 0xF0, 0x38, 0x0F, 0xC1, 0x80, 0x3E, 0x08, 0x01,
  0xE0, 0xC0, 0x07, 0x0F, 0x80, 0x30, 0xFF, 0x81, 0x0F, 0xFF, 0x10, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x87,
  0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x18, 0x07, 0x80, 0x1C, 0x07, 0xE0, 0x1F, 0x03,
  0xF8, 0x0F, 0xC3, 0xFC, 0x1F, 0xF1, 0x7F, 0x07, 0xF9, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x1F,
  0xC3, 0xF9, 0x3F, 0xF2, 0xFF, 0x8F, 0xFE, 0x7F, 0x80, 0xFE, 0x1F, 0xC0,
  0x3E, 0x07, 0xC0, 0x0E, 0x01, 0xC0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x10, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1E,
  0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x3F, 0xE0, 0xFE, 0x7F, 0xF8, 0x7F, 0xE1,
  0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x06, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xE0, 0x38, 0x03, 0xFC, 0x30, 0x01, 0xFF, 0x10, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0x07,
  0xF0, 0x0E, 0x00, 0xC0, 0x7F, 0x81, 0xF0, 0x1E, 0x07, 0xF8, 0x3F, 0x87,
  0xF0, 0x3F, 0xC7, 0xFC, 0xFF, 0x81, 0xFD, 0x9F, 0xF3, 0xF8, 0x0F, 0xF0,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x38, 0x07, 0xC0, 0xFC, 0x07, 0x00, 0xFC, 0x0F, 0xF0, 0x60, 0x0F, 0xE1,
  0xFF, 0x8C, 0x01, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x70, 0x18, 0x0F,
  0x83, 0x80, 0xFC, 0x3C, 0x1F, 0xE7, 0xE3, 0xFE, 0xFE, 0x27, 0xFF, 0xE0,
  0x3F, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x18, 0x03, 0xE1, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xF1, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0x1F, 0x00, 0x60, 0x60, 0x04, 0x02, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x02, 0x03, 0x00, 0x78,
  0x1C, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0xC0, 0x7F, 0x01, 0xC0, 0x7F, 0x87, 0xE0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3C, 0x0F, 0xC4, 0x7C, 0x1F, 0xC8,
  0x78, 0x3F, 0xF0, 0x78, 0x0F, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x01, 0xC0,
  0xC0, 0x00, 0x81, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x21, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x03, 0x0F, 0x0C, 0x1F, 0xD0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x04, 0xFE, 0x08, 0x7E,
  0x18, 0x7F, 0x30, 0x3F, 0x30, 0x3F, 0x70, 0x3F, 0x60, 0x1F, 0x60, 0x1F,
  0x60, 0x1F, 0x60, 0x1F, 0xE0, 0x1E, 0x60, 0x1E, 0x60, 0x1E, 0x60, 0x1C,
  0x60, 0x1C, 0x30, 0x38, 0x30, 0x30, 0x18, 0x60, 0x07, 0x80, 0x00, 0x06,
  0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 41, 13, 1, -40 },
  { 58, 19, 15, 22, 1, -39 },
  { 94, 24, 31, 28, 2, -35 },
  { 187, 19, 45, 23, 2, -42 },
  { 294, 37, 39, 39, 1, -39 },
  { 475, 28, 35, 32, 2, -34 },
  { 598, 9, 15, 11, 1, -39 },
  { 615, 12, 44, 14, 1, -43 },
  { 681, 12, 45, 14, 1, -43 },
  { 749, 18, 21, 19, 0, -41 },
  { 797, 18, 20, 22, 2, -28 },
  { 842, 9, 15, 10, 0, -8 },
  { 859, 16, 11, 16, 1, -22 },
  { 881, 9, 9, 11, 1, -8 },
  { 892, 27, 43, 29, 1, -41 },
  { 1038, 24, 40, 26, 1, -39 },
  { 1158, 16, 38, 18, 1, -38 },
  { 1234, 23, 37, 25, 1, -37 },
  { 1341, 24, 38, 26, 1, -38 },
  { 1455, 23, 37, 25, 1, -37 },
  { 1562, 24, 39, 26, 1, -39 },
  { 1679, 23, 38, 25, 1, -38 },
  { 1789, 22, 37, 24, 1, -37 },
  { 1891, 24, 39, 26, 1, -39 },
  { 2008, 23, 39, 25, 1, -39 },
  { 2121, 9, 27, 11, 1, -26 },
  { 2152, 10, 33, 9, 0, -26 },
  { 2194, 15, 21, 16, 0, -26 },
  { 2234, 19, 12, 21, 1, -22 },
  { 2263, 15, 21, 16, 0, -26 },
  { 2303, 21, 40, 25, 2, -39 },
  { 2408, 32, 34, 33, 1, -26 },
  { 2544, 43, 40, 45, 1, -39 },
  { 2759, 48, 41, 49, 0, -40 },
  { 3005, 36, 41, 38, 1, -40 },
  { 3190, 42, 42, 45, 1, -40 },
  { 3411, 37, 41, 39, 1, -40 },
  { 3601, 39, 48, 42, 1, -41 },
  { 3835, 40, 42, 42, 1, -40 },
  { 4045, 38, 51, 40, 1, -43 },
  { 4288, 35, 47, 38, 1, -40 },
  { 4494, 37, 54, 39, 1, -40 },
  { 4744, 43, 40, 45, 1, -39 },
  { 4959, 29, 40, 31, 1, -39 },
  { 5104, 59, 42, 61, 1, -39 },
  { 5414, 46, 40, 49, 1, -39 },
  { 5644, 39, 40, 41, 1, -39 },
  { 5839, 47, 48, 49, 1, -39 },
  { 6121, 42, 43, 44, 1, -39 },
  { 6347, 49, 41, 51, 1, -40 },
  { 6599, 39, 40, 42, 1, -39 },
  { 6794, 39, 40, 41, 1, -39 },
  { 6989, 37, 41, 39, 1, -38 },
  { 7179, 46, 41, 49, 1, -40 },
  { 7415, 57, 40, 59, 1, -39 },
  { 7700, 37, 41, 40, 1, -40 },
  { 7890, 45, 49, 47, 1, -40 },
  { 8166, 34, 47, 37, 1, -40 },
  { 8366, 8, 44, 10, 1, -41 },
  { 8410, 33, 39, 6, -10, -36 },
  { 8571, 8, 44, 10, 1, -41 },
  { 8615, 20, 15, 23, 1, -39 },
  { 8653, 26, 4, 25, 0, 6 },
  { 8666, 8, 11, 28, 9, -39 },
  { 8677, 23, 30, 25, 1, -28 },
  { 8764, 22, 40, 24, 1, -38 },
  { 8874, 17, 29, 20, 1, -28 },
  { 8936, 23, 39, 25, 1, -38 },
  { 9049, 18, 29, 20, 1, -28 },
  { 9115, 16, 50, 13, 0, -40 },
  { 9215, 23, 41, 26, 1, -29 },
  { 9333, 22, 49, 24, 1, -39 },
  { 9468, 13, 39, 15, 1, -38 },
  { 9532, 16, 49, 13, -3, -39 },
  { 9630, 16, 39, 18, 1, -38 },
  { 9708, 16, 39, 15, 1, -38 },
  { 9786, 37, 30, 39, 1, -29 },
  { 9925, 25, 29, 28, 1, -28 },
  { 10016, 22, 29, 23, 0, -28 },
  { 10096, 24, 44, 25, 0, -33 },
  { 10228, 21, 40, 24, 1, -29 },
  { 10333, 18, 29, 20, 1, -28 },
  { 10399, 21, 35, 23, 1, -34 },
  { 10491, 15, 36, 17, 1, -35 },
  { 10559, 25, 30, 28, 1, -29 },
  { 10653, 25, 32, 25, -1, -31 },
  { 10753, 36, 33, 38, 1, -32 },
  { 10902, 20, 40, 22, 1, -29 },
  { 11002, 24, 42, 26, 1, -33 },
  { 11128, 16, 39, 18, 1, -29 },
  { 11206, 15, 44, 18, 1, -43 },
  { 11289, 3, 46, 9, 3, -43 },
  { 11307, 15, 44, 18, 1, -43 },
  { 11390, 18, 4, 20, 1, -18 },
};

const GFXfont UnifrakturMaguntia_Regular55pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular55pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular55pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR55PT7B_H_
