#ifndef _UNIFRAKTURMAGUNTIA_REGULAR72PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x1F, 0x01, 0xFC, 0x1F, 0xF3, 0xFF,
  0xEF, 0xFE, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0x80, 0x0E,
  0x00, 0xF8, 0x0F, 0xE1, 0xFF, 0xCF, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xC0,
  0x04, 0x00, 0x40, 0x00, 0x04, 0x00, 0x10, 0x03, 0x00, 0x18, 0x03, 0xC0,
  0x1E, 0x03, 0xF0, 0x1F, 0x83, 0xFC, 0x1F, 0xE7, 0xFF, 0x1F, 0xFD, 0xFF,
  0x87, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xE0,
  0x0C, 0x00, 0x70, 0x04, 0x00, 0x30, 0x06, 0x00, 0x10, 0x02, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xC1, 0xF0,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7F, 0x80, 0x3E, 0x7F, 0xC0, 0x18,
  0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x30, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3E, 0x70, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x38, 0x00, 0x3C,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x18,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x78, 0x00, 0x00, 0x01, 0xC1,
  0xF0, 0xF8, 0x00, 0x00, 0x07, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x1C, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x78, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0x80, 0xFC, 0x0F, 0xE0, 0x00, 0x0E, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x38, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x0E, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x3C, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x1C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x7E,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0xC1, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0E,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x70, 0x0F,
  0xC0, 0xFE, 0x00, 0x01, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1C, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x78, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x0E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x38, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x03, 0x80, 0x00, 0x3F, 0x03,
  0xF8, 0x0F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x7C,
  0x07, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x10, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x01, 0xFC, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x03,
  0xFC, 0x78, 0x00, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1E, 0x00, 0xF3, 0xFE, 0x00, 0x70, 0x0F, 0x0F, 0xF8,
  0x03, 0x00, 0xF8, 0x7F, 0xC0, 0x18, 0x0F, 0xC1, 0xFF, 0x01, 0xC0, 0x7C,
  0x0F, 0xF8, 0x0C, 0x07, 0xE0, 0x7F, 0xE0, 0x60, 0x3F, 0x01, 0xFF, 0x03,
  0x01, 0xF8, 0x0F, 0xFC, 0x30, 0x1F, 0xC0, 0x3F, 0xE1, 0x80, 0xFF, 0x01,
  0xFF, 0x98, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x09, 0xFF, 0x00, 0x7F, 0xE0, 0x67, 0xFC, 0x01, 0xFF, 0x87, 0x3F,
  0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x00, 0x02,
  0x00, 0x60, 0x0F, 0x01, 0xF8, 0x3F, 0xC7, 0xFF, 0x3F, 0xF1, 0xFE, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0E, 0x7E, 0x70, 0xFE, 0x3E, 0x7F,
  0x7E, 0x3C, 0x7E, 0x7F, 0x18, 0xFE, 0x3F, 0x18, 0xFE, 0x3F, 0x99, 0xFC,
  0x3F, 0xFF, 0xFC, 0x20, 0x7E, 0x04, 0x40, 0x3C, 0x04, 0x3B, 0xFF, 0xFC,
  0x3F, 0xDB, 0xFC, 0x7F, 0x99, 0xFE, 0x7F, 0x18, 0xFE, 0x7F, 0x3C, 0xFE,
  0xFE, 0x3C, 0x7F, 0x0E, 0x7E, 0x70, 0x02, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x60, 0x07, 0x00, 0xF8, 0x1F, 0xC7, 0xFF, 0x7F, 0xF1, 0xFF,
  0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x04, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x3F,
  0xC7, 0xFE, 0xFF, 0xF3, 0xF8, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0E, 0x1F, 0xE0, 0x40, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x07, 0x80, 0x1F, 0xFC,
  0x3C, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x7F, 0xE3, 0x80, 0x00, 0xFF, 0x9C,
  0x00, 0x03, 0xFE, 0x60, 0x00, 0x0F, 0xF9, 0x80, 0x00, 0x1F, 0xE6, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x0F, 0x00, 0x03, 0x00, 0x78, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x78, 0x1F, 0xFE, 0x01, 0xC0, 0x0F, 0xFE, 0x07, 0x00, 0x0F,
  0xFE, 0x1C, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x80, 0x01,
  0xFC, 0xFF, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xE0,
  0x03, 0xF8, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1D, 0xFC, 0x00, 0x00, 0x33, 0xF8, 0x00, 0x00, 0xC7, 0xF0, 0x00, 0x03,
  0x8F, 0xE0, 0x00, 0x06, 0x1F, 0xC0, 0x00, 0x1C, 0x3F, 0x80, 0x00, 0x70,
  0x7F, 0x00, 0x00, 0xC0, 0xFE, 0x00, 0x03, 0x81, 0xFC, 0x00, 0x0E, 0x03,
  0xF8, 0x00, 0x18, 0x07, 0xF0, 0x00, 0x70, 0x0F, 0xE0, 0x01, 0xC0, 0x1F,
  0xC0, 0x03, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x7F, 0x00, 0x18, 0x00, 0xFE,
  0x00, 0x60, 0x01, 0xFC, 0x01, 0xC0, 0x03, 0xF8, 0x03, 0x00, 0x07, 0xF0,
  0x0E, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x06, 0x00,
  0x00, 0x60, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x1F, 0xF0, 0x00, 0x1D, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x1F, 0x00, 0x0F, 0xFC, 0x3C,
  0x00, 0x0F, 0xF8, 0x60, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0xFF, 0x80, 0x01,
  0xFC, 0xFF, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xF8, 0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0xFE, 0x00,
  0x03, 0xC0, 0xFE, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x00,
  0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xE0, 0x07, 0xF8, 0x0F,
  0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x18, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF,
  0xF8, 0x1F, 0xF3, 0xFF, 0xF8, 0x3F, 0xEE, 0x0F, 0xF8, 0x7F, 0xD8, 0x0F,
  0xF0, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9,
  0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xF8,
  0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0x7C, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x78, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xF0,
  0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x3C, 0x1F, 0xF0, 0x00, 0xF8, 0x3F, 0xF8,
  0x01, 0xE0, 0x3F, 0xFC, 0x07, 0x80, 0x7F, 0xFC, 0x1E, 0x00, 0x7F, 0xFE,
  0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0x1F, 0xFF, 0x80, 0x1C, 0x0F, 0xFF, 0x80, 0x70, 0x0F, 0xFF,
  0x81, 0xC0, 0x07, 0xFF, 0x07, 0x80, 0x07, 0xFE, 0x1E, 0x00, 0x03, 0xFE,
  0x7C, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC1,
  0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0xF8, 0x03,
  0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F,
  0xC7, 0xF0, 0x00, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0x1F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xCF,
  0xF0, 0x01, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x07, 0xFE, 0x7F,
  0xC0, 0x1F, 0xFC, 0x7F, 0x80, 0x3F, 0xF8, 0xFF, 0x00, 0xDF, 0xF0, 0xFF,
  0x01, 0xBF, 0xE1, 0xFF, 0x06, 0x7F, 0xC1, 0xFF, 0xF8, 0xFF, 0x01, 0xFF,
  0xE1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x80, 0x00, 0xFE, 0x07, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0x3F,
  0x01, 0xFE, 0x00, 0x7C, 0x03, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xE0,
  0x03, 0xF8, 0x07, 0x80, 0x03, 0xF0, 0x1E, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x60, 0x0F,
  0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0xFF, 0xF1, 0xF8, 0x0F, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0xF0, 0x1F,
  0x03, 0xFC, 0x7F, 0xEF, 0xFF, 0x3F, 0x80, 0xF0, 0x0E, 0x00, 0x60, 0x04,
  0x00, 0x02, 0x00, 0x18, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xFF,
  0xE1, 0xF8, 0x07, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x38, 0x03, 0xE0, 0x3F, 0x87, 0xFF,
  0x3F, 0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0x01, 0xF0,
  0x03, 0xF8, 0x3E, 0x00, 0x1F, 0xC3, 0xC0, 0x01, 0xFC, 0x78, 0x00, 0x0F,
  0xE7, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFF,
  0x80, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xE0, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x07, 0xC0, 0x02,
  0x00, 0x7C, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x3F, 0x00, 0xC0, 0x01,
  0xF8, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x1C, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x00, 0xFD, 0xF1, 0xE0,
  0x7C, 0x00, 0xFF, 0xFC, 0x3C, 0x3F, 0x00, 0x7C, 0xFF, 0x0F, 0x0F, 0x80,
  0x7E, 0x3F, 0xC3, 0xC3, 0xE0, 0x3F, 0x07, 0xE0, 0xF1, 0xF0, 0x0F, 0x83,
  0xF8, 0x3C, 0x7C, 0x07, 0xE0, 0xFE, 0x0F, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xCF, 0xC1, 0xFC, 0x0F, 0xC0, 0xF3, 0xE0, 0x7E, 0x03, 0xF0, 0x3C, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0x7E, 0x07, 0x8F, 0x83, 0xF0,
  0x3F, 0x81, 0xE3, 0xE1, 0xFC, 0x0F, 0xE0, 0xF0, 0xF8, 0x7E, 0x07, 0xF0,
  0x3C, 0x3E, 0x1F, 0x83, 0xFC, 0x1E, 0x0F, 0x87, 0xE1, 0xFF, 0x0F, 0x81,
  0xE1, 0xFC, 0xFF, 0xC7, 0xC0, 0x7C, 0x3F, 0xFF, 0xF3, 0xE3, 0xDF, 0x0F,
  0xFC, 0xFF, 0xF0, 0xF3, 0xC1, 0xFE, 0x3F, 0xF8, 0x78, 0xF0, 0x3E, 0x07,
  0xF0, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xF0,
  0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xE0,
  0x1C, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x30, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0x80, 0x00, 0x0F,
  0xFE, 0x07, 0xFC, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x0E, 0x00,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x18, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x30, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x60, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x03,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x6F, 0xFC, 0x30, 0x00, 0x3F, 0xFF, 0x83, 0x9F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x70, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0x80, 0x7F, 0xE0, 0x03,
  0xFE, 0x07, 0xFF, 0xE4, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x1C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x70, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x01, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x30, 0x3F, 0x1F,
  0xFF, 0xFF, 0x80, 0x7C, 0x01, 0x80, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x30, 0x1F,
  0xE0, 0x00, 0x1F, 0x00, 0x60, 0xFF, 0xE2, 0x00, 0xF8, 0x00, 0xCF, 0xFF,
  0xFC, 0x07, 0xE0, 0x03, 0x7F, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x3C, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0x7F, 0x80,
  0x3F, 0x80, 0x1C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x20, 0x07,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x06, 0x03, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0x38, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0xFF,
  0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE1, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC7,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xCE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x9C, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x38, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFE, 0x70, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFD, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFB,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF3, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xE7, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7C,
  0x07, 0xC3, 0xC0, 0x7F, 0x00, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x40, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x03, 0xC3, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFE, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x0E, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x0C, 0x1F,
  0xFC, 0x20, 0x0F, 0x80, 0x0C, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x1B, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x79, 0xFF,
  0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x7F, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x08, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFC, 0x6F, 0xF0, 0x1F, 0xFF, 0x3F, 0xFF, 0xDF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0x3F, 0xFF, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xE3, 0xFF,
  0x00, 0x3F, 0xFF, 0x0F, 0x83, 0xFE, 0x00, 0x3F, 0xFE, 0x04, 0x07, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x3C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x83,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xCC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x06,
  0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xC0, 0x70, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xF0, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0x83, 0x80, 0x00, 0x1F,
  0xFE, 0x07, 0xFE, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF1, 0xC0, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x70,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0x3F, 0x80,
  0x1E, 0x00, 0xF3, 0xFF, 0xE0, 0xF0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x06,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x40, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xE1, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x30, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xBF, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xC7, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x30, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x0E, 0x03,
  0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xC0, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x78,
  0x00, 0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x03, 0xFF, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC,
  0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xE7, 0xFF, 0x00, 0x07,
  0xFC, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE3, 0xFF, 0x00,
  0x03, 0xF8, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC1, 0xFF,
  0x80, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0xFF, 0xE0, 0x0F, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x83, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3C, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xFF, 0x20, 0x00, 0x00, 0x0E, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xE0, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE1,
  0xFF, 0x80, 0x1E, 0x00, 0x03, 0xF8, 0xFF, 0xF0, 0x07, 0x00, 0x01, 0xFE,
  0x7F, 0xFE, 0x01, 0x80, 0x00, 0x7F, 0x3F, 0xFF, 0xC0, 0xE0, 0x00, 0x1F,
  0xC8, 0x7F, 0xFC, 0x60, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFC, 0x10, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x80, 0x04, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x78, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xE1, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0x83, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x08, 0x07,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x04, 0x03,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x04, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x06, 0x1F, 0xFF, 0xC0, 0x00, 0x1E, 0x04,
  0x03, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x78, 0x00,
  0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1F, 0xC1, 0xE1,
  0xFF, 0xE0, 0x3C, 0x00, 0x1F, 0xC3, 0x80, 0x7F, 0xF0, 0x1E, 0x00, 0x3F,
  0xC3, 0x00, 0x3F, 0xF0, 0x1E, 0x00, 0x3F, 0xC2, 0x00, 0x1F, 0xF8, 0x1E,
  0x00, 0x3F, 0xC6, 0x00, 0x1F, 0xF8, 0x1E, 0x00, 0x3F, 0xE6, 0x00, 0x0F,
  0xFC, 0x1E, 0x00, 0x3F, 0xE6, 0x00, 0x0F, 0xFC, 0x1E, 0x00, 0x3F, 0xF6,
  0x00, 0x07, 0xFE, 0x1E, 0x00, 0x3F, 0xF6, 0x00, 0x07, 0xFF, 0x9E, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC,
  0x1C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0x81, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xC3, 0x80, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xE6, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF4, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xC0,
  0x03, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0x80, 0x01, 0xFF, 0xC0, 0xC7, 0xFF, 0x83, 0x00, 0x00, 0xFF, 0xF3, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE1, 0xFF,
  0x00, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xF8, 0x00,
  0x0F, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC7, 0x3F, 0xE0, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x08, 0xFF, 0xFF, 0xE0, 0x00, 0x37, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0x80, 0x07, 0xFF, 0xFE, 0x3E, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xC1, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFB, 0xCF, 0xFF, 0x98, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFC, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x70, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x06, 0x00,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x0C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xEC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x8C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xE0,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1C, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x30, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x7C, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0x8F,
  0xC0, 0x70, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x31, 0xFE, 0x06, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0x3F, 0xF0, 0xC0, 0x03, 0xFF, 0x87,
  0x0F, 0xFF, 0xE0, 0x67, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE1, 0xCF, 0xFF,
  0x0C, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x18, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x30, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x38, 0x1F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x7F,
  0xFE, 0x60, 0x07, 0xFC, 0x07, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x70, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x06, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x0C, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x0C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xEC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x0C, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xC0, 0x07, 0x81, 0xF8, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xF0, 0x03, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x1C, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0x80, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x38, 0x00, 0x7F, 0xF0, 0x20, 0x7F, 0xFE, 0x07, 0x00,
  0x03, 0xFF, 0xCF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x3F, 0xFF, 0xE1, 0x8F,
  0xFF, 0x9C, 0x00, 0x01, 0xFF, 0xF8, 0x10, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE1, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x10, 0x00, 0x00, 0x03, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x08, 0x3F, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0xF3, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE0,
  0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x03,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x0E, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x60,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE1, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xC3, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x06, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x0C, 0x00, 0x10, 0x7F, 0x80, 0x00,
  0x1F, 0xF8, 0x1C, 0x00, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7D,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0x84, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE7, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xDC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x03, 0x9F, 0xFE, 0x03, 0x83, 0xFF, 0xFE, 0x08, 0x1F, 0xFC,
  0x18, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0E, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x18, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0xFE, 0x60, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x80, 0x0F, 0xFC,
  0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xF0, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF9,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE3, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x87,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x3F, 0x1F, 0xFE, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFD, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x1E, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x01,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0x00, 0x00, 0x7F, 0xF8,
  0xC1, 0x9F, 0xFF, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1C, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xC0,
  0x30, 0x07, 0xFF, 0xFF, 0xF0, 0xF8, 0x02, 0x03, 0xFF, 0xFF, 0xFE, 0x1F,
  0x80, 0x71, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0E,
  0x7E, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xCF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x0D, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xBF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x37, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x06, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x19, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x67, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x8F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x17, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x07, 0x3F, 0xFF,
  0xFE, 0xE0, 0x00, 0x03, 0x83, 0xFF, 0xFF, 0x30, 0x00, 0x03, 0xC0, 0x3F,
  0xFF, 0x8C, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x83, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xC0, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x30, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x63, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x06, 0x3F, 0xFF, 0x87, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF1, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x60, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x30, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x08, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x04, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x06, 0x03, 0xFF, 0x80,
  0x07, 0xF0, 0x07, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xBF, 0xE0, 0x1E, 0xFF, 0xFE, 0x03, 0x9F, 0xF8, 0x08, 0x1F,
  0xFF, 0xC7, 0x87, 0xFE, 0x60, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x03,
  0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x60, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xCC, 0x03, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xFE, 0xC0, 0x3F,
  0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xF8, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x0E, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xF8, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x06, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x03, 0x80, 0x01, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38,
  0x3F, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x0E, 0x03, 0xE0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x01, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7C, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0x30, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF9, 0xC1, 0xCC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x07,
  0xF0, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x0F,
  0xFE, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x78,
  0x00, 0x0F, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x1F, 0x00, 0x01, 0xFF,
  0x80, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x1F, 0xF8, 0x1C, 0x00,
  0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x03, 0xFF, 0x83, 0x80, 0x00, 0x01, 0xFF,
  0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x03, 0xFC, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3E, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x07, 0xF1, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x3F,
  0xF0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xF0, 0x03, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x7E, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xC0, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0x81, 0xF0, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x1C, 0x00, 0x60, 0x3E, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xE0, 0x06, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xF8, 0x10, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xB8, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xC0, 0x03, 0xFE, 0x18, 0xFF, 0x07,
  0xC0, 0x00, 0xFF, 0x98, 0x1F, 0x03, 0xC0, 0x00, 0x3F, 0xCC, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xF4, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x43, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x9F, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x61, 0xFF, 0xE0, 0x20, 0x1F, 0xFC, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x86, 0x07,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0x00, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF,
  0xFE, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x07,
  0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC1, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x38, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x8E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE3,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xEC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE0,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0E, 0x00, 0x04, 0x07, 0xC0, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xF0,
  0x03, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x3E, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xC0, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x70, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x38, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x04, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC3, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x38, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE7, 0xE0, 0x03,
  0xF8, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xC1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x33, 0xFF, 0xC0, 0x01, 0x87, 0xFF, 0xE0, 0x0E, 0x0F, 0xFF, 0x00, 0xF0,
  0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0x07, 0xF8, 0xCF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0x3F,
  0xF0, 0x3F, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFC, 0x07, 0xF0,
  0x01, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x01,
  0xE0, 0x00, 0x0C, 0x1F, 0x00, 0x00, 0x31, 0xF0, 0x00, 0x01, 0x9F, 0x80,
  0x00, 0x06, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x30, 0x01, 0xFC, 0x03, 0x80, 0x0F, 0xE0,
  0x3C, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0xC0, 0x1F, 0xCF, 0xFF,
  0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x81,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xC0, 0xFE,
  0x00, 0x3E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x01, 0xFC, 0x00,
  0xF0, 0x1F, 0xE0, 0x0F, 0x00, 0xFF, 0xC0, 0x70, 0x0F, 0xFF, 0x07, 0x00,
  0xFF, 0xFE, 0x30, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0x9F, 0xE0, 0x0C,
  0x7F, 0x80, 0x70, 0xFF, 0x03, 0xC3, 0xFC, 0x1E, 0x07, 0xF8, 0xF8, 0x1F,
  0xE3, 0xE0, 0x3F, 0x9F, 0x80, 0xF8, 0x7E, 0x01, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x01, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x17, 0xFF, 0x80, 0x03, 0x0F,
  0xFE, 0x00, 0x70, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC1, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x7C, 0x1F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x07,
  0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x07, 0x81, 0xFC, 0x00, 0x3C, 0x1F, 0xF0,
  0x01, 0xC0, 0xFF, 0xE0, 0x1C, 0x1F, 0xFF, 0x80, 0xE0, 0x7F, 0xFF, 0x0E,
  0x00, 0x7F, 0xFE, 0x60, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x19, 0xFC, 0x00, 0x63, 0xFC, 0x03, 0xC3, 0xF8, 0x07, 0x07,
  0xF8, 0x1E, 0x07, 0xF0, 0x7C, 0x0F, 0xF0, 0xF8, 0x1F, 0xE3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xF0,
  0xFE, 0x07, 0x81, 0xFC, 0x78, 0x03, 0xFB, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x02, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xF0, 0x40, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xE7, 0xFC, 0x03, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x33, 0xFF, 0xE0, 0x03, 0x87, 0xFF,
  0xF0, 0x1E, 0x07, 0xFF, 0x80, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x0F, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x78, 0x1F,
  0x80, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x7C, 0x0F, 0xE0,
  0x01, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x3F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xC0, 0x7F,
  0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xF0, 0x0C, 0x00,
  0x1F, 0xC0, 0x20, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0xF0, 0x07,
  0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x38, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x60, 0xF8, 0x00,
  0x00, 0xC7, 0xE0, 0x00, 0x01, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x00, 0x7F,
  0x01, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC7,
  0xFC, 0x00, 0x7F, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x7F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x81,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFF, 0x00, 0x3E, 0x03,
  0xFC, 0x21, 0xF8, 0x1F, 0xFF, 0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x00, 0xFF,
  0xC0, 0x78, 0x01, 0xFE, 0x03, 0xC0, 0x01, 0xF0, 0x0E, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC6,
  0x7F, 0xC2, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x30, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x6F, 0xFC, 0x06,
  0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0xC0, 0x07, 0xE2,
  0x00, 0x3E, 0x18, 0x01, 0xE0, 0x60, 0x1E, 0x01, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x80, 0x78, 0x02, 0x07, 0x80, 0x18, 0x7C, 0x0C, 0x67, 0xE1, 0xE3, 0x7F,
  0x1F, 0x0F, 0xF1, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x18, 0x1F, 0xFC, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x80, 0xF8, 0x06, 0x0F, 0x80, 0x18, 0x7C,
  0x00, 0x67, 0xE0, 0x03, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x18, 0x1F, 0xFD, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xFB, 0x9F, 0xF6, 0x7F,
  0xFC, 0xCF, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x8F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF3, 0x1F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x07, 0xC0, 0x07, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xEC, 0xFF,
  0xF8, 0x8F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xC4,
  0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xF8, 0x03, 0xFF,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x04, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFC, 0x3F,
  0xF0, 0x1F, 0xC1, 0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC1,
  0xFC, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0xE1, 0xFC, 0x03, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07,
  0xE1, 0xFC, 0x00, 0x7C, 0x3F, 0xC0, 0x07, 0x83, 0xFE, 0x00, 0xF0, 0x3F,
  0xF8, 0x0E, 0x0F, 0xFF, 0xC1, 0xC0, 0x7F, 0xFF, 0x38, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0x7F, 0xE0, 0x0F,
  0x00, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0x87, 0xFE,
  0x01, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0,
  0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7C, 0x1F, 0xF8, 0x01, 0xF0, 0x7F, 0xF0,
  0x03, 0xE1, 0xFF, 0xF8, 0x07, 0x83, 0xFF, 0xFC, 0x1C, 0x0F, 0xFF, 0xFC,
  0x30, 0x1C, 0xFF, 0xFE, 0xC0, 0x20, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE7, 0x80,
  0x00, 0x0F, 0x82, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0xFF, 0xF0, 0x01,
  0xC7, 0xFF, 0xF0, 0x38, 0x1F, 0xFE, 0x07, 0x80, 0xFF, 0xC0, 0xF0, 0x03,
  0xF8, 0x1F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0x87,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8,
  0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF8,
  0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0x83, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0xCF, 0xF8, 0x0F,
  0xFF, 0x1F, 0x80, 0x7F, 0xE1, 0xF8, 0x03, 0xFC, 0x1F, 0x80, 0x1F, 0x01,
  0xF8, 0x00, 0xE0, 0x1F, 0x80, 0x0C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x07, 0x00, 0x30, 0x0F, 0xC0, 0x38, 0x1F, 0xE0, 0x78, 0x1F, 0xE0, 0xFC,
  0x3F, 0xF1, 0xFC, 0x3F, 0xF3, 0xFE, 0x6F, 0xFF, 0xFE, 0x47, 0xFC, 0xFF,
  0x07, 0xFC, 0xFE, 0x03, 0xF8, 0x7C, 0x03, 0xF8, 0x78, 0x03, 0xF8, 0x30,
  0x03, 0xF8, 0x30, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x20, 0x07, 0xFF, 0x40, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x60, 0x01,
  0xE0, 0x06, 0x00, 0x3F, 0x00, 0x60, 0x07, 0xFC, 0x0E, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x06, 0x3F, 0xFF, 0xC0, 0xC0, 0xFF, 0xF8, 0x18,
  0x03, 0xFF, 0x03, 0x80, 0x0F, 0xE0, 0x38, 0x00, 0x18, 0x07, 0xC0, 0x01,
  0x00, 0x7C, 0x00, 0x30, 0x07, 0xE0, 0x07, 0x00, 0x7F, 0x00, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0x7C, 0x03, 0xFC,
  0x03, 0x80, 0x1F, 0xC0, 0x38, 0x00, 0xFC, 0x03, 0x00, 0x0F, 0xC0, 0x60,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0x81, 0xFE, 0x00, 0x70, 0x3F, 0xF8, 0x06,
  0x07, 0xFF, 0xE0, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x20, 0x7F, 0xE4,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xF1, 0xBF, 0xE0, 0x3F, 0xF0, 0x8F, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x07,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x88,
  0x3F, 0xF0, 0xFF, 0xEC, 0x7F, 0xFD, 0xDF, 0xFC, 0x0F, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0xE0, 0x7F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xE0, 0x01, 0xFF, 0x03,
  0x80, 0x03, 0xFF, 0x83, 0x00, 0x03, 0xFF, 0xE6, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xC0, 0x00,
  0x60, 0x3F, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0xFF, 0xE0, 0x1F, 0x80, 0x1F,
  0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xF3, 0x9F, 0xFC, 0x3F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0x81, 0xFE, 0x01, 0xFC,
  0x00, 0x7E, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x1C,
  0x00, 0x7F, 0x81, 0xFF, 0xF0, 0x60, 0x03, 0xFF, 0x0F, 0xFF, 0xF3, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x04, 0x01, 0xF0, 0x07, 0x00, 0xFE, 0x07, 0x80, 0xFF,
  0x07, 0xE0, 0x7F, 0xC7, 0xF0, 0x7F, 0xF7, 0xFC, 0x7F, 0xFB, 0xFE, 0x23,
  0xFF, 0x7F, 0x81, 0xFF, 0x3F, 0x80, 0x7F, 0x0F, 0x80, 0x3F, 0x87, 0xC0,
  0x1F, 0xC1, 0xC0, 0x0F, 0xE0, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xC0, 0x0F, 0xFC, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0x07, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x03,
  0xE0, 0x38, 0x03, 0xF8, 0x0F, 0x8F, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x40, 0x3F, 0xE0,
  0x03, 0x00, 0xFF, 0xC0, 0x1E, 0x03, 0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x07,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F,
  0xF9, 0x83, 0xE0, 0x7F, 0xFC, 0x0F, 0x83, 0xFF, 0xE0, 0x3C, 0x03, 0xFF,
  0x01, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x20, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x07, 0x80, 0xC0, 0xFE,
  0x30, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0x7F, 0xE0, 0x63, 0xFE, 0x0C, 0x1F, 0xE1,
  0xC1, 0xFF, 0x18, 0x0F, 0xF3, 0x80, 0xFF, 0x30, 0x07, 0xF7, 0x00, 0x7F,
  0x70, 0x07, 0xF7, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xEE, 0x00, 0x3E, 0xE0, 0x03, 0xEE, 0x00,
  0x3C, 0x60, 0x07, 0xC7, 0x00, 0x78, 0x30, 0x07, 0x03, 0x00, 0xE0, 0x18,
  0x0C, 0x00, 0xC3, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0,
};

const GFXglyph UnifrakturMaguntia_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 13, 53, 17, 2, -52 },
  { 88, 25, 19, 29, 2, -51 },
  { 148, 33, 41, 37, 2, -46 },
  { 318, 24, 58, 30, 3, -55 },
  { 492, 47, 50, 51, 2, -51 },
  { 786, 37, 45, 41, 2, -44 },
  { 995, 12, 19, 14, 1, -51 },
  { 1024, 16, 59, 18, 1, -57 },
  { 1142, 16, 59, 18, 1, -57 },
  { 1260, 24, 28, 25, 0, -54 },
  { 1344, 23, 25, 28, 3, -36 },
  { 1416, 12, 20, 13, 0, -11 },
  { 1446, 20, 14, 21, 2, -28 },
  { 1481, 12, 12, 14, 1, -11 },
  { 1499, 35, 57, 38, 2, -54 },
  { 1749, 32, 51, 34, 1, -50 },
  { 1953, 21, 49, 23, 1, -49 },
  { 2082, 30, 49, 32, 1, -49 },
  { 2266, 31, 50, 34, 1, -50 },
  { 2460, 31, 49, 33, 1, -49 },
  { 2650, 31, 50, 34, 1, -50 },
  { 2844, 31, 52, 33, 1, -51 },
  { 3046, 29, 49, 31, 1, -49 },
  { 3224, 31, 51, 34, 1, -51 },
  { 3422, 31, 51, 33, 1, -51 },
  { 3620, 12, 35, 14, 1, -34 },
  { 3673, 13, 43, 12, 0, -34 },
  { 3743, 20, 27, 21, 0, -34 },
  { 3811, 24, 15, 28, 2, -29 },
  { 3856, 20, 27, 21, 0, -34 },
  { 3924, 28, 52, 33, 2, -51 },
  { 4106, 42, 43, 44, 1, -33 },
  { 4332, 55, 53, 59, 2, -51 },
  { 4697, 62, 53, 64, 0, -52 },
  { 5108, 46, 53, 49, 2, -52 },
  { 5413, 55, 56, 58, 2, -53 },
  { 5798, 47, 53, 51, 2, -52 },
  { 6110, 52, 62, 54, 1, -53 },
  { 6513, 52, 54, 55, 2, -52 },
  { 6864, 50, 66, 53, 1, -56 },
  { 7277, 47, 62, 49, 1, -53 },
  { 7642, 49, 71, 51, 1, -53 },
  { 8077, 56, 53, 58, 1, -51 },
  { 8448, 39, 52, 41, 1, -51 },
  { 8702, 76, 55, 80, 2, -51 },
  { 9225, 60, 52, 64, 2, -51 },
  { 9615, 51, 54, 54, 2, -52 },
  { 9960, 62, 63, 64, 1, -51 },
  { 10449, 54, 57, 57, 2, -52 },
  { 10834, 63, 53, 67, 2, -52 },
  { 11252, 51, 53, 55, 2, -52 },
  { 11590, 50, 52, 54, 2, -51 },
  { 11915, 49, 54, 51, 1, -50 },
  { 12246, 60, 55, 64, 2, -53 },
  { 12659, 75, 53, 78, 1, -52 },
  { 13156, 49, 54, 52, 1, -53 },
  { 13487, 58, 64, 62, 2, -53 },
  { 13951, 45, 62, 48, 1, -53 },
  { 14300, 10, 56, 13, 1, -53 },
  { 14370, 45, 50, 8, -14, -47 },
  { 14652, 10, 56, 13, 1, -53 },
  { 14722, 27, 20, 30, 1, -51 },
  { 14790, 34, 5, 33, -1, 8 },
  { 14812, 10, 13, 36, 12, -50 },
  { 14829, 30, 39, 33, 2, -37 },
  { 14976, 29, 52, 32, 2, -50 },
  { 15165, 22, 39, 26, 2, -37 },
  { 15273, 29, 51, 33, 2, -50 },
  { 15458, 23, 39, 26, 2, -37 },
  { 15571, 22, 64, 18, -1, -52 },
  { 15747, 30, 52, 33, 2, -37 },
  { 15942, 30, 63, 32, 1, -50 },
  { 16179, 17, 51, 20, 1, -50 },
  { 16288, 21, 64, 17, -4, -51 },
  { 16456, 21, 52, 23, 1, -50 },
  { 16593, 21, 52, 20, 1, -50 },
  { 16730, 47, 39, 51, 2, -38 },
  { 16960, 33, 39, 36, 2, -37 },
  { 17121, 28, 39, 30, 0, -37 },
  { 17258, 31, 57, 32, 0, -43 },
  { 17479, 28, 52, 31, 1, -37 },
  { 17661, 24, 38, 26, 1, -37 },
  { 17775, 28, 46, 30, 1, -45 },
  { 17936, 20, 48, 22, 1, -46 },
  { 18056, 33, 38, 36, 2, -37 },
  { 18213, 32, 42, 33, -1, -41 },
  { 18381, 46, 44, 50, 2, -42 },
  { 18634, 25, 53, 28, 2, -38 },
  { 18800, 30, 55, 34, 2, -43 },
  { 19007, 20, 51, 24, 2, -38 },
  { 19135, 20, 58, 24, 1, -56 },
  { 19280, 5, 59, 11, 3, -56 },
  { 19317, 20, 58, 24, 1, -56 },
  { 19462, 23, 5, 26, 2, -24 },
};

const GFXfont UnifrakturMaguntia_Regular72pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular72pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular72pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR72PT7B_H_
