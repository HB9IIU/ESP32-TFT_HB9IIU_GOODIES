#ifndef _UNIFRAKTURMAGUNTIA_REGULAR63PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x83, 0xFE, 0x7F, 0xF3,
  0xFE, 0x3F, 0xE3, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0x00,
  0xF8, 0x1F, 0xC3, 0xFE, 0x5F, 0xC0, 0xF8, 0x07, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x40, 0x18, 0x01, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0x7C, 0x3F,
  0xC3, 0xF9, 0xFF, 0x9F, 0xF1, 0xFC, 0x3F, 0xC3, 0xF0, 0x3F, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0C, 0x03, 0x00, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x00, 0x10, 0x0C, 0x00, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x03, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E,
  0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F,
  0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0,
  0x07, 0x83, 0xC0, 0x3C, 0x03, 0x81, 0xE0, 0x0F, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x00,
  0xF9, 0xF8, 0x03, 0xE7, 0xF8, 0x07, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xE3, 0x00, 0x7F, 0xDE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x00,
  0x07, 0x8E, 0x00, 0x3C, 0x18, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x7C,
  0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x83, 0xFE, 0x00,
  0x00, 0x01, 0xC3, 0xC7, 0x80, 0x00, 0x01, 0xC3, 0xE1, 0xE0, 0x00, 0x01,
  0xC3, 0xE0, 0xF8, 0x00, 0x00, 0xC1, 0xF0, 0x7C, 0x00, 0x00, 0xE0, 0xF8,
  0x3F, 0x00, 0x00, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0xE0, 0x7E, 0x0F, 0xC0,
  0x00, 0xE0, 0x3F, 0x07, 0xE0, 0x00, 0xE0, 0x1F, 0x83, 0xF0, 0x00, 0xE0,
  0x0F, 0xC1, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x70, 0x03, 0xF0,
  0x7E, 0x00, 0x70, 0x01, 0xF8, 0x3F, 0x00, 0x70, 0x00, 0xFC, 0x1F, 0x80,
  0x70, 0x00, 0x3E, 0x0F, 0xC0, 0x70, 0x00, 0x1F, 0x07, 0xC0, 0x70, 0x00,
  0x0F, 0x83, 0xE0, 0x70, 0x00, 0x03, 0xE1, 0xE0, 0x30, 0x00, 0x00, 0xF1,
  0xE0, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x38, 0x0F, 0x80, 0x07, 0xC0, 0x38,
  0x1F, 0xF0, 0x00, 0x00, 0x38, 0x1E, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x1F,
  0x00, 0x00, 0x38, 0x1F, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x83, 0xE0, 0x00,
  0x1C, 0x0F, 0xC1, 0xF0, 0x00, 0x1C, 0x07, 0xE0, 0xFC, 0x00, 0x1C, 0x03,
  0xF0, 0x7E, 0x00, 0x1C, 0x03, 0xF8, 0x3F, 0x00, 0x1C, 0x01, 0xFC, 0x1F,
  0x80, 0x1C, 0x00, 0xFE, 0x0F, 0xC0, 0x1C, 0x00, 0x7F, 0x07, 0xE0, 0x0E,
  0x00, 0x1F, 0x83, 0xF0, 0x0E, 0x00, 0x0F, 0xC1, 0xF8, 0x0E, 0x00, 0x07,
  0xE0, 0xF8, 0x0E, 0x00, 0x01, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0xF8, 0x3C,
  0x0E, 0x00, 0x00, 0x3C, 0x3E, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x0E, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x01, 0xF8, 0x1E,
  0x00, 0x01, 0xF8, 0x1E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3C,
  0x00, 0x01, 0xF8, 0x3C, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x01, 0xFC, 0x70,
  0x00, 0x01, 0xFC, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7C, 0x07, 0xFF, 0x80, 0x78, 0x0F, 0x3F, 0xC0, 0x30, 0x1E, 0x3F, 0xC0,
  0x30, 0x3E, 0x3F, 0xE0, 0x30, 0x3C, 0x1F, 0xE0, 0x60, 0x7C, 0x1F, 0xF0,
  0x60, 0x7C, 0x0F, 0xF0, 0x60, 0xFC, 0x0F, 0xF8, 0x40, 0xFC, 0x07, 0xF8,
  0xC0, 0xFC, 0x07, 0xFD, 0xC0, 0xFE, 0x03, 0xFD, 0x80, 0xFE, 0x03, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF,
  0x81, 0x7F, 0x80, 0x7F, 0xC7, 0x3F, 0xC0, 0x7F, 0xFE, 0x3F, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x03,
  0xE0, 0x08, 0x03, 0x00, 0xE0, 0x7C, 0x7F, 0xBF, 0xF3, 0xFC, 0x3F, 0x0F,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0x80, 0x40, 0x30, 0x08, 0x00, 0x00,
  0x08, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x02, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xE0, 0x06, 0x7E, 0xC3, 0xF1, 0xE7, 0xEF, 0x8E, 0x3E, 0x7E, 0x33, 0xF3,
  0xF9, 0x3F, 0x8F, 0xEB, 0xF8, 0x41, 0xF0, 0x44, 0x07, 0x82, 0x3F, 0xDF,
  0xF9, 0xFC, 0x9F, 0xCF, 0xC6, 0x7E, 0x7E, 0x73, 0xF7, 0xE3, 0x8F, 0xC3,
  0x3E, 0x60, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x00, 0xE0, 0x7C, 0x3F, 0x9F, 0xF3, 0xFC, 0x3F, 0x07,
  0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00,
  0x00, 0x03, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x78, 0x7F, 0xBF, 0xF7, 0xF8, 0x78,
  0x0E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF,
  0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF8,
  0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x07, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x0E, 0x7F, 0x82, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF,
  0xF7, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0xFF, 0xC3, 0xC0,
  0x1F, 0xF8, 0xE0, 0x03, 0xFE, 0x70, 0x00, 0x7F, 0x9C, 0x00, 0x1F, 0xE6,
  0x00, 0x03, 0xFD, 0x80, 0x00, 0xFF, 0x40, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x04, 0x03, 0xC0, 0x03, 0x00,
  0xE0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0x83, 0xFF,
  0x81, 0xC0, 0x1F, 0xF0, 0x70, 0x01, 0xFF, 0x0C, 0x00, 0x1F, 0xE3, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFB, 0xFC, 0x00, 0x3F, 0x7F, 0x80, 0x07,
  0xC7, 0xF0, 0x00, 0xF8, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0x80, 0xFC,
  0x01, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x33, 0xF0, 0x00, 0x06, 0x7E, 0x00, 0x01,
  0x8F, 0xC0, 0x00, 0x21, 0xF8, 0x00, 0x0C, 0x3F, 0x00, 0x03, 0x07, 0xE0,
  0x00, 0x60, 0xFC, 0x00, 0x18, 0x1F, 0x80, 0x06, 0x03, 0xF0, 0x00, 0xC0,
  0x7E, 0x00, 0x30, 0x0F, 0xC0, 0x0C, 0x01, 0xF8, 0x01, 0x80, 0x3F, 0x00,
  0x60, 0x07, 0xE0, 0x08, 0x00, 0xFC, 0x03, 0x00, 0x1F, 0x80, 0xC0, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x37, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x1F, 0xE0, 0x00, 0x6F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0x87, 0x80, 0x1F, 0xF0, 0xC0, 0x00, 0xFF,
  0x30, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0x7F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xF8, 0xFE, 0x00, 0x1F, 0x1F,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF0, 0x1F, 0x80, 0x3C, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x07,
  0xF0, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xE0, 0x7C, 0x01, 0xFC, 0x0F,
  0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x07,
  0x83, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x01, 0xC0, 0x0F, 0xE1, 0xFF, 0x01, 0xFC, 0x7F, 0xF0,
  0x3F, 0x98, 0x7F, 0x07, 0xF2, 0x07, 0xF0, 0xFE, 0xC0, 0x7F, 0x1F, 0xD0,
  0x0F, 0xE3, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xDF, 0xF0, 0x03, 0xF9,
  0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3C, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x07, 0x8F, 0xC0, 0x00, 0xF1, 0xF8, 0x00, 0x1E, 0x3F, 0x80, 0x03, 0xC3,
  0xF8, 0x00, 0xF0, 0x7F, 0xC0, 0x1E, 0x0F, 0xFC, 0x07, 0x80, 0xFF, 0xE1,
  0xE0, 0x1F, 0xFF, 0x78, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xE7, 0xFF,
  0xC0, 0x30, 0x3F, 0xF8, 0x0E, 0x01, 0xFF, 0x83, 0x80, 0x1F, 0xF0, 0xF0,
  0x00, 0xFF, 0x3C, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x07, 0xC0, 0x03, 0xC0,
  0x7C, 0x00, 0x78, 0x0F, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xF8, 0x00,
  0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xE7, 0xF0, 0x07, 0xFC, 0xFE,
  0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF1, 0xFC, 0x05, 0xFE, 0x3F, 0xC1, 0xBF,
  0xC3, 0xFC, 0x67, 0xF8, 0x3F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x03, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0x07, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x01,
  0xFC, 0x03, 0xC0, 0x1F, 0x80, 0xF0, 0x01, 0xF8, 0x1C, 0x00, 0x1F, 0x87,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0x03, 0x01, 0xE0,
  0xFC, 0x7F, 0xBF, 0xF3, 0xF0, 0x78, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x78, 0x7F, 0xBF, 0xF7, 0xF8, 0x78, 0x0E, 0x03, 0x00, 0x00, 0x04,
  0x00, 0xC0, 0x3C, 0x0F, 0xC3, 0xFC, 0xFF, 0xC7, 0xE0, 0x78, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0x80, 0xF8, 0x3F, 0x8F, 0xF8, 0xFF,
  0x07, 0xE0, 0x7C, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x3C, 0x00, 0xFC, 0x78, 0x00, 0xFC,
  0x70, 0x00, 0x7E, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x3E, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x0F, 0x00, 0x30, 0x0F, 0x80, 0x30,
  0x07, 0xC0, 0x60, 0x03, 0xE0, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x03, 0xFF,
  0x8E, 0x0F, 0x80, 0x7F, 0xFC, 0x78, 0x78, 0x07, 0xCF, 0xE3, 0xC7, 0xC0,
  0x7C, 0x7E, 0x1E, 0x3C, 0x07, 0xC3, 0xF0, 0xF1, 0xE0, 0x7C, 0x1F, 0x87,
  0x9F, 0x07, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E, 0x07, 0xC1, 0xE7, 0x83, 0xF0,
  0x3E, 0x0F, 0x3C, 0x1F, 0x03, 0xE0, 0x71, 0xE1, 0xF8, 0x1F, 0x07, 0x8F,
  0x0F, 0xC1, 0xF8, 0x3C, 0x78, 0x7C, 0x0F, 0xC3, 0xC3, 0xC3, 0xE0, 0xFC,
  0x3E, 0x1E, 0x1F, 0x0F, 0xE3, 0xE0, 0xF8, 0xFC, 0xFF, 0x3E, 0x03, 0xC7,
  0xFF, 0xFF, 0xE3, 0xDE, 0x1F, 0xE7, 0xFE, 0x1C, 0x70, 0x7C, 0x1F, 0x81,
  0xE3, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x70, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x70, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x70, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x30, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x38, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x18, 0x00, 0x03, 0xFF, 0x07, 0xF8, 0x0C, 0x00, 0x00, 0xFF, 0x83, 0xFC,
  0x06, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x03, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x81, 0xE0, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x70, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x03,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x80,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0x83, 0xC0,
  0x03, 0xFC, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x81, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0x7F, 0xC6, 0x00, 0x07,
  0xFF, 0xC7, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x1E, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x30, 0x3F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x1F, 0xFD, 0x80, 0x7F, 0xC0,
  0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x0E, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x38, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x03, 0x80,
  0x00, 0x07, 0xE0, 0x7F, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xFF, 0xF8,
  0x07, 0x80, 0x0C, 0x1F, 0x1F, 0xFF, 0xFC, 0x07, 0x80, 0x30, 0x3C, 0x7F,
  0xFF, 0xF8, 0x07, 0xF3, 0xC0, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x01,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x3F, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x38, 0x1F, 0xC0, 0x01, 0xF0, 0x0C, 0x3F,
  0xE0, 0x03, 0xE0, 0x04, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xFF, 0xFE, 0x07,
  0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x0E, 0x0F, 0xF0, 0x1F, 0x80, 0x1C,
  0x03, 0xE0, 0x1F, 0x80, 0x70, 0x00, 0xC0, 0x3F, 0x80, 0xF0, 0x00, 0x00,
  0x3F, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x00,
  0x0F, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x03, 0x80, 0x00, 0x07, 0xFF,
  0x06, 0x00, 0x00, 0x03, 0xFF, 0xCC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0x83, 0xFF,
  0xF0, 0x0F, 0xE0, 0x03, 0x80, 0x7F, 0xF8, 0x07, 0xC0, 0x03, 0x80, 0x0F,
  0xFE, 0x07, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0x83, 0xC0, 0x03, 0xC0, 0x00,
  0x7F, 0xC1, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0xE0, 0x01, 0xF8, 0x00,
  0x07, 0xF8, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x70, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x38, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x8C, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xE6, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF3, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3E, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x1C, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0x87, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xE0, 0x78, 0x08, 0x1F, 0xC0, 0x00, 0xF0, 0x0F, 0xFE,
  0x07, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x7C, 0x40, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x03,
  0x83, 0xFF, 0xFF, 0x83, 0xC0, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x0E, 0x07, 0xF0, 0x00, 0x3E, 0x01,
  0x87, 0xFE, 0x20, 0x3E, 0x00, 0x4F, 0xFF, 0xF0, 0x3E, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0x00, 0x1C, 0x1F, 0xE0, 0x1F,
  0x80, 0x1C, 0x03, 0xE0, 0x0F, 0xC0, 0x38, 0x00, 0x60, 0x0F, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xFC, 0x03, 0xC0, 0x7F, 0x83, 0xFF,
  0x03, 0xF0, 0x3F, 0xC1, 0xFF, 0xC3, 0xFE, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xBF, 0xF3, 0xFC,
  0x03, 0xFF, 0xC7, 0xF1, 0xFE, 0x00, 0xFF, 0xF0, 0xF0, 0xFF, 0x00, 0x3F,
  0xFC, 0x10, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x7F,
  0xE0, 0x38, 0x00, 0x00, 0x3F, 0xFC, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0x30,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x19, 0xFF, 0xC0, 0x78, 0x00, 0x01,
  0x83, 0xF8, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xC0,
  0x18, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xFC, 0x00, 0x40, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0x07,
  0x00, 0x00, 0xFF, 0x80, 0x7E, 0x18, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0xC0,
  0x00, 0x3F, 0xF8, 0x7F, 0xE7, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x18, 0x00,
  0x07, 0xFF, 0x3F, 0xF0, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0x80, 0x00,
  0x7F, 0xF0, 0xF8, 0x07, 0x00, 0x73, 0xFF, 0x83, 0x80, 0x1F, 0xFF, 0x0F,
  0xFE, 0x18, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x80, 0x00, 0x00, 0xFC, 0xE0, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x02, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
  0x0B, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x77, 0xFE, 0x00, 0x1F, 0x80, 0x06,
  0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x60, 0xFF, 0xE0, 0x0F, 0xC0, 0x0E, 0x03,
  0xFF, 0xC0, 0xFC, 0x00, 0xE0, 0x07, 0xFF, 0x07, 0xE0, 0x1E, 0x00, 0x1F,
  0xF0, 0x7F, 0x01, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xE0,
  0x3F, 0x81, 0xF8, 0x00, 0x0E, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xC0, 0x0F,
  0xE0, 0xFF, 0x00, 0x1C, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0x07,
  0xFE, 0x7F, 0xFF, 0x0F, 0xF0, 0x1F, 0xF3, 0x7F, 0xFC, 0x7F, 0x80, 0xFF,
  0xC0, 0x3F, 0xF3, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xBF, 0xE0, 0x07, 0xFE, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0xE0, 0x03, 0xFC, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x3F,
  0xE0, 0x01, 0xF0, 0x03, 0xF1, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x87, 0xFC,
  0x00, 0xF0, 0x01, 0xF8, 0x3F, 0xE0, 0x0F, 0x00, 0x0F, 0xC0, 0xFF, 0x80,
  0x70, 0x00, 0x7C, 0x03, 0xFE, 0x06, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x40,
  0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x8F, 0xFC,
  0x00, 0x00, 0x00, 0x60, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xCF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x7C,
  0x01, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0x00, 0x0F, 0xE3, 0xFF, 0x00,
  0xE0, 0x00, 0xFC, 0x7F, 0xF8, 0x0C, 0x00, 0x0F, 0xCF, 0xFF, 0xC1, 0x80,
  0x00, 0xF8, 0x0F, 0xFF, 0x30, 0x00, 0x1F, 0x80, 0x3F, 0xFE, 0x00, 0x01,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xE6, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x07, 0x80,
  0x00, 0x3F, 0xFE, 0x03, 0xC0, 0x00, 0x07, 0xFE, 0x01, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x00,
  0x1C, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x07, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x87,
  0xFF, 0xF0, 0x00, 0x07, 0x87, 0x7F, 0xFC, 0x00, 0x03, 0xC6, 0x0F, 0xFF,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xC1, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE6, 0x07, 0x80, 0x00, 0x7F, 0xFF,
  0x81, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x70, 0x00, 0x00, 0xFF, 0xC0, 0x1C,
  0x00, 0x00, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x03, 0x8F, 0xF0,
  0x00, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x00,
  0x1E, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x81, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x73, 0xFF, 0xE0, 0x00, 0x38, 0x20, 0x7F,
  0xF8, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x1F, 0xFE, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xE1, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x1F, 0x81, 0xFF, 0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xFF, 0xF0, 0x0E, 0x00,
  0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0x80, 0x07, 0xE1, 0xFF, 0xFF, 0x01, 0xC0,
  0x07, 0xF0, 0xE0, 0xFF, 0xC0, 0xF0, 0x03, 0xF8, 0xC0, 0x3F, 0xE0, 0x78,
  0x01, 0xFC, 0x60, 0x0F, 0xF8, 0x1C, 0x00, 0xFE, 0x20, 0x03, 0xFC, 0x0E,
  0x00, 0x7F, 0x10, 0x01, 0xFF, 0x07, 0x00, 0x3F, 0xD8, 0x00, 0x7F, 0x83,
  0x80, 0x1F, 0xEC, 0x00, 0x3F, 0xE1, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF0,
  0x70, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x7F, 0xF0, 0x00, 0xE0,
  0x38, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x38, 0x00, 0x07, 0xFE, 0x01, 0xF8,
  0x30, 0x00, 0x03, 0xFF, 0x83, 0xFE, 0x30, 0x00, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF6, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x70,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x38, 0x00, 0xFF, 0x81, 0xFF, 0xF8, 0x18,
  0x00, 0x7F, 0xE0, 0x8F, 0xFE, 0x38, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFE,
  0x00, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x1F, 0x87,
  0xFC, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0xE0, 0x00, 0x7E,
  0x1F, 0xFC, 0x00, 0x1F, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x07,
  0xE0, 0x1F, 0xF9, 0x07, 0xF0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x83,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xBF, 0xFF, 0xFC, 0x00, 0x60, 0x1F, 0xFF,
  0xC0, 0x70, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xE6, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFB, 0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0x81, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x70, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x38, 0x00, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC2, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x80, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x20, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC8,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C,
  0x30, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1C, 0x0C, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x06, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0x00, 0x78, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x70, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x3C, 0x00, 0x07, 0xFF,
  0x80, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x60, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x00, 0x18, 0x07, 0xC0, 0x07, 0x83, 0xF0, 0x00, 0x00,
  0x06, 0x01, 0xE0, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x38, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x0C, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x06, 0x3C, 0x07, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x01, 0x9F, 0xC1, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xC0,
  0xCF, 0xF8, 0xC0, 0x0F, 0xFC, 0x31, 0xFF, 0xF8, 0x67, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0xC7, 0xFF, 0x33, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x20, 0xFF,
  0xFD, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x67, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0x20, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x83, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x60, 0x3F, 0xC0, 0x7E,
  0x03, 0xFF, 0xE6, 0x01, 0xFE, 0x07, 0x80, 0x0F, 0xFE, 0xC0, 0x1F, 0xE0,
  0x60, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x88, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE8, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1E, 0x0C, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x06,
  0x00, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0xE0,
  0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x1C, 0x00, 0x1F, 0xFF, 0x80, 0x7E, 0x03,
  0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x3C, 0x00, 0x03, 0xFB, 0x80, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x7C, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xFE,
  0x00, 0x00, 0xF8, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1C, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x30,
  0x00, 0xFF, 0xE7, 0x1F, 0xFF, 0x86, 0x00, 0x07, 0xFF, 0xE3, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC3, 0xFF,
  0xFE, 0x00, 0x00, 0x3E, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x3C, 0x00, 0x40, 0x80, 0x00, 0x01, 0xC0, 0x0F, 0xC8, 0x00, 0x00, 0x0E,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0x01, 0x0F,
  0xFF, 0xE0, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x00,
  0x03, 0xE0, 0x1F, 0xFE, 0xF7, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x1F,
  0xF8, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0x80, 0x00, 0x7F,
  0xC1, 0xFF, 0xE0, 0x0E, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x30, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0x80, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x03,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xFE, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xFC, 0x30, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xE1, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC6, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x8C, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x18,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x38, 0x03, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x7E, 0x78, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x18,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x80, 0x00,
  0x01, 0xC0, 0x01, 0xF9, 0x00, 0x03, 0xF1, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xF9, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x73, 0xFF, 0x03, 0xC3, 0xFF, 0xF8, 0x40,
  0xFF, 0x86, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x9F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0xE3, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0x81, 0xFF, 0x80, 0x1F, 0xC7,
  0xFF, 0xF9, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFB, 0x00, 0x7F, 0xC0,
  0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x70, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x60, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x60,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x70, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x0E, 0x00, 0x30,
  0x1F, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xE0, 0x1F, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x70, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x60, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xC0, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE1, 0xC0, 0x00, 0x7F,
  0xF3, 0x04, 0x7F, 0xFB, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x04, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x80, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x0F, 0x81, 0x00, 0x3F, 0xFF, 0xF0, 0xF8, 0x18, 0x0F,
  0xFF, 0xFF, 0x8F, 0x80, 0xC3, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xCF, 0x80, 0x3F, 0xFF, 0xE0, 0x06, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x6F, 0x80, 0x1F, 0xFE, 0x00, 0x02, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x37, 0xF8, 0x00,
  0x00, 0x00, 0x06, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x63, 0xFE, 0x00, 0x00,
  0x00, 0x0E, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xC1, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x1B, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x98, 0x00, 0x01, 0xC7, 0xFF, 0xF8, 0xC0, 0x00,
  0x18, 0x1F, 0xFF, 0x86, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x60, 0x00, 0x3E,
  0x00, 0xFF, 0x03, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x0C, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0xBF, 0xFC, 0x00, 0x00,
  0x1E, 0x1C, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x10, 0x7F, 0xF8, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xE0, 0x0F, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x60, 0x00, 0xF0,
  0x03, 0xE0, 0x08, 0x00, 0xFC, 0x01, 0xF0, 0x02, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x60, 0xFF, 0xE0, 0x0F, 0xE0, 0x30,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xFF, 0x80, 0x37, 0xF8, 0x1D, 0xFF, 0xF0, 0x39, 0xFE, 0x0C, 0x0F,
  0xFF, 0x3C, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x39, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE3, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x98, 0x1F,
  0xF0, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x3E, 0x00, 0x3F, 0xFC,
  0x03, 0xFE, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x1C, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x86, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x83,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x03, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0x80, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x70, 0x01, 0x83, 0xE0, 0x0F, 0xF0, 0x01,
  0xC0, 0x38, 0x1E, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xE0, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1D, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0xC1, 0xFF, 0xF8,
  0x00, 0x01, 0xC0, 0x04, 0x03, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFC,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0xEF, 0x18, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0xC1, 0xD8, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x78, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x18, 0x01, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0xE0, 0x1C, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x1F, 0xF8,
  0x1E, 0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x0F, 0xF8,
  0x1C, 0x00, 0x01, 0xFF, 0x0F, 0x80, 0x03, 0xFC, 0x0E, 0x00, 0x00, 0x7F,
  0x87, 0xC0, 0x01, 0xFF, 0x0E, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7F,
  0xE3, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xF1, 0x80, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xC0, 0xC0, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x7E, 0x3F, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x3F, 0x0F, 0xF8, 0x01,
  0xE0, 0x06, 0x00, 0x00, 0x1F, 0x87, 0xFC, 0x01, 0xF0, 0x03, 0x00, 0x00,
  0x0F, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0xC0, 0x01, 0x07, 0xC0, 0xFF, 0x80,
  0xFE, 0x00, 0x38, 0x03, 0x03, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0x07,
  0x01, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFE, 0x01, 0xE0, 0x07, 0xF8,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x70, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x7F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x07,
  0xC0, 0x03, 0xFE, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x30, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xE0, 0x20, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x60,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x20, 0x00, 0x00, 0x7F, 0xFE, 0xF3, 0xFF, 0xE0, 0x60,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xE1, 0x81, 0xFF, 0xFE,
  0x00, 0xFF, 0x70, 0x7F, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x00, 0x7F, 0x8F, 0xFF, 0x07, 0x80, 0x07, 0xF9, 0x87, 0xC1, 0xE0,
  0x00, 0x7F, 0x20, 0x00, 0x38, 0x00, 0x0F, 0xF4, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x07, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1C, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xE1, 0xCF, 0xFF, 0xFC, 0x00, 0x0F, 0xE3, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x2F, 0xF0,
  0x00, 0x00, 0x00, 0x05, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x9F, 0xE0, 0x00,
  0x03, 0xE0, 0x23, 0xFE, 0x00, 0x00, 0xFF, 0x0C, 0x7F, 0xF0, 0x20, 0x3F,
  0xF3, 0x87, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFE, 0x01, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x39,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xCC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF9,
  0x00, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xA0, 0x1F, 0xF0, 0x3E, 0x00, 0x3F,
  0xFC, 0x01, 0xFE, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE1, 0xC0, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x38, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xCE, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xF9, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xB8,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x60, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0x81, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x7E, 0x00,
  0x78, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x30, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x07, 0x00, 0x18, 0x3E, 0x01, 0xFC, 0x00, 0x38, 0x0C, 0x07,
  0x80, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0x80,
  0x3E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x04,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0x9F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7F,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x07,
  0x80, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x00,
  0x3F, 0x80, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00,
  0xE0, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00,
  0x07, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x3F,
  0xFC, 0x00, 0x00, 0x78, 0xFF, 0xFC, 0x00, 0x01, 0xE7, 0xFF, 0xFC, 0x00,
  0x03, 0xC4, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x1C, 0x00,
  0x3F, 0xFC, 0x00, 0x30, 0x00, 0x3F, 0xFC, 0x00, 0xC0, 0x00, 0x3F, 0xFC,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC3, 0xE0, 0x0F, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x67, 0xFF, 0x00, 0x1C, 0x7F, 0xF8,
  0x07, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x0F, 0x00,
  0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF8, 0x1F,
  0x88, 0xFF, 0x87, 0xF9, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x0F,
  0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0E, 0x01, 0xF0, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x04, 0x0E,
  0x00, 0x01, 0x87, 0x80, 0x00, 0x23, 0xE0, 0x00, 0x0D, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x0F, 0xC0, 0x30, 0x03, 0xF0,
  0x1C, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xF0, 0x0F, 0xCF, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F,
  0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3C,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0x80, 0xFC, 0x01, 0xC0, 0x7F, 0xC0,
  0xE0, 0x1F, 0xF8, 0x30, 0x0F, 0xFF, 0x98, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0x80, 0x1B, 0xF8, 0x03, 0x1F, 0xC0, 0x71, 0xFC, 0x0E, 0x0F,
  0xC1, 0xE0, 0xFE, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x02, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0B, 0xFF, 0x80, 0x0C, 0x3F, 0xE0, 0x7E, 0x03, 0xFC, 0x1F,
  0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00, 0xE0,
  0x7F, 0x00, 0x38, 0x3F, 0xF0, 0x1C, 0x1F, 0xFE, 0x06, 0x03, 0xFF, 0xE3,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1B, 0xF8, 0x07, 0x1F, 0x80, 0xF1, 0xFC,
  0x0E, 0x0F, 0xC1, 0xE0, 0xFE, 0x3E, 0x0F, 0xE3, 0xE0, 0x7E, 0x3E, 0x07,
  0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x38, 0x7C, 0x1C, 0x07, 0xEF,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE3, 0x07, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFE, 0x20, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0x7F, 0x80, 0x60, 0xF0, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x37, 0xFE, 0x00, 0x0C, 0x7F, 0xF8, 0x03, 0x87,
  0xFF, 0x80, 0xE0, 0x7F, 0xE0, 0x3C, 0x03, 0xF8, 0x0F, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x38, 0x1F, 0x80, 0x0F, 0x03, 0xF0, 0x01,
  0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x7F,
  0x01, 0xFF, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x1F, 0x80, 0x60,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x03, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x3F, 0x00,
  0x1C, 0x03, 0xE0, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0xE0, 0x70, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0x07, 0xC0, 0x00, 0x63, 0xE0, 0x00, 0x09,
  0xF8, 0x00, 0x03, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x60, 0x03, 0xF0, 0x38, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x1F, 0xE0, 0x0F,
  0xDF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xFE,
  0x61, 0xE0, 0xFF, 0xF0, 0xF8, 0x3F, 0xF8, 0x3C, 0x03, 0xFC, 0x0E, 0x00,
  0x3E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x80, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xF3, 0x7F, 0xC4, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x83, 0xFD, 0x87, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x67, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0x20, 0x07, 0x8C, 0x03, 0xC1, 0x81, 0xE0, 0x20, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0x83, 0x03,
  0xC0, 0x61, 0xE0, 0x0C, 0xF8, 0x31, 0x3E, 0x3C, 0x7F, 0x9F, 0x0F, 0xEF,
  0xC3, 0xFB, 0xF0, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x41, 0xFF, 0xB0, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x83, 0x03, 0xC0, 0x61, 0xE0, 0x0C,
  0xF8, 0x01, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x41, 0xFF, 0xA0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x07, 0xF0, 0x3F,
  0x83, 0xF0, 0x03, 0xF8, 0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xF3, 0xFF,
  0xE3, 0xFF, 0x63, 0xFF, 0x3F, 0xF9, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x7F,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x27, 0xFE, 0x3F, 0xF0, 0x7F, 0xB3, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x7F,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x80, 0x04, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x70, 0x03, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0xF1, 0xFF,
  0xF3, 0xFF, 0x09, 0xFF, 0x0F, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01,
  0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x07,
  0xFE, 0x07, 0xF2, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x78, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xE0, 0x7F,
  0x0F, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0x0F, 0xE0, 0x7F, 0x87,
  0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFC,
  0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0x8F, 0xE0, 0x07,
  0xC7, 0xF0, 0x03, 0xE3, 0xF8, 0x01, 0xE1, 0xFC, 0x01, 0xF0, 0xFE, 0x00,
  0xF0, 0x7F, 0x00, 0x70, 0x7F, 0xE0, 0x78, 0x7F, 0xF8, 0x38, 0x1F, 0xFF,
  0x30, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x03, 0xFC, 0x01, 0xC0,
  0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF7,
  0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x0F, 0xF0,
  0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xC1, 0xFE, 0x00, 0x78, 0x7F,
  0xC0, 0x1E, 0x1F, 0xFE, 0x03, 0x87, 0xFF, 0xF0, 0xE0, 0xFF, 0xFF, 0x18,
  0x18, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xF8, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0x3F, 0xF8, 0x07, 0x0F, 0xFF, 0x07, 0x83, 0xFF, 0x07, 0x80, 0x7F,
  0x03, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8,
  0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0xC0, 0x7E, 0x0F,
  0xF0, 0x7F, 0x07, 0xFC, 0x3F, 0x81, 0xFF, 0xEF, 0xC0, 0x7F, 0xC7, 0xE0,
  0x3F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xC0, 0xFC, 0x00, 0x80, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x80, 0xF8, 0x06, 0x07, 0xE0, 0x70, 0x7F, 0x87,
  0xC3, 0xFC, 0x7E, 0x3F, 0xF7, 0xF9, 0x3F, 0xFF, 0xD1, 0xFE, 0x7F, 0x07,
  0xE3, 0xE0, 0x3F, 0x0F, 0x01, 0xF8, 0x70, 0x0F, 0xC1, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x8C, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x30, 0x03, 0x00, 0x78, 0x03, 0x00, 0xFE, 0x07, 0x03,
  0xFF, 0xDE, 0x07, 0xFF, 0xFE, 0x0C, 0x7F, 0xFE, 0x18, 0x1F, 0xFC, 0x30,
  0x07, 0xF0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0x40, 0x78, 0x00, 0x80, 0x7C,
  0x01, 0x80, 0x7E, 0x03, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0x80, 0xFE, 0x07,
  0x00, 0x7E, 0x06, 0x00, 0x7E, 0x04, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1F,
  0x80, 0x38, 0x3F, 0xE0, 0x30, 0x7F, 0xF8, 0x60, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0xC3, 0xFE, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x03, 0xC0, 0x03, 0x80, 0x3F, 0x00,
  0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF,
  0x89, 0xFC, 0x0F, 0xF8, 0x87, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x1F,
  0xE2, 0x1F, 0xF1, 0xFF, 0xB1, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0x8F, 0xF8,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x80, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x18, 0x03, 0xC0, 0x07, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x87, 0xFF, 0x07, 0xF9,
  0xCF, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x01, 0xC0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x01, 0xF0, 0x0E, 0x00, 0x3F, 0xC0, 0xC0,
  0x07, 0xFF, 0x18, 0x00, 0x7F, 0xFB, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x40, 0xFF, 0x00, 0x70, 0x00, 0xC0,
  0xFF, 0x80, 0xFC, 0x03, 0xC0, 0xFF, 0xC1, 0xFE, 0x07, 0xE0, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0x3F, 0xC7, 0xFF, 0x7F, 0xF8, 0x1F, 0xEC, 0x7F, 0xC3,
  0xFC, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F,
  0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x3F,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x80, 0x3E, 0x07, 0xE0, 0x3F, 0x80,
  0x3E, 0x07, 0xE0, 0x3F, 0x80, 0x3E, 0x07, 0xE0, 0x3F, 0x80, 0x3C, 0x0F,
  0xE0, 0x3F, 0x80, 0x7C, 0x0F, 0xE0, 0x3F, 0x80, 0x78, 0x0F, 0xE0, 0x3F,
  0x80, 0x70, 0x0F, 0xE0, 0x7F, 0xC0, 0xE0, 0x0F, 0xE0, 0xFF, 0xF0, 0xC0,
  0x1F, 0xF0, 0xFF, 0xFD, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xF0,
  0x07, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x00, 0x60, 0x1F, 0x81,
  0xC0, 0x7F, 0x07, 0xC0, 0xFF, 0x1F, 0x83, 0xFF, 0x7F, 0x85, 0xFF, 0xFF,
  0x11, 0xFE, 0xFF, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xF0, 0x07, 0xE1, 0xC0,
  0x0F, 0xC1, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0xC0, 0x0F, 0xFB, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x18, 0x3E, 0x00,
  0x60, 0x38, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x60, 0x18,
  0x03, 0xE0, 0x1C, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x04, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0xC0, 0xF8, 0x0F,
  0xFC, 0x7F, 0x80, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFE, 0x07,
  0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8,
  0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x0F, 0xF3, 0x0F, 0x83, 0xFF, 0xC1, 0xE0,
  0x3F, 0xF0, 0x78, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0C, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x18, 0x0C, 0x0F, 0xC6, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x9F, 0xE0, 0x21, 0xFC,
  0x0C, 0x1F, 0xC3, 0x03, 0xF8, 0x60, 0x3F, 0x18, 0x07, 0xE3, 0x00, 0xFC,
  0x60, 0x1F, 0x9C, 0x01, 0xF3, 0x80, 0x3E, 0x60, 0x07, 0xCC, 0x00, 0xF9,
  0x80, 0x1F, 0x30, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x03, 0xC1,
  0x80, 0x70, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x3F, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 12, 47, 15, 1, -46 },
  { 72, 22, 17, 25, 1, -45 },
  { 119, 28, 35, 32, 2, -40 },
  { 242, 22, 51, 26, 2, -48 },
  { 383, 41, 44, 45, 2, -45 },
  { 609, 32, 40, 36, 2, -39 },
  { 769, 10, 17, 13, 1, -45 },
  { 791, 14, 52, 16, 1, -50 },
  { 882, 14, 51, 16, 1, -49 },
  { 972, 21, 24, 22, 0, -47 },
  { 1035, 21, 22, 25, 2, -32 },
  { 1093, 10, 18, 12, 0, -10 },
  { 1116, 17, 12, 19, 2, -25 },
  { 1142, 10, 11, 13, 1, -10 },
  { 1156, 30, 50, 33, 2, -47 },
  { 1344, 28, 45, 30, 1, -44 },
  { 1502, 18, 43, 20, 1, -43 },
  { 1599, 26, 43, 28, 1, -43 },
  { 1739, 27, 43, 29, 1, -43 },
  { 1885, 27, 43, 29, 1, -43 },
  { 2031, 27, 44, 29, 1, -44 },
  { 2180, 27, 45, 29, 1, -45 },
  { 2332, 25, 43, 27, 1, -43 },
  { 2467, 27, 44, 29, 1, -44 },
  { 2616, 27, 45, 29, 1, -45 },
  { 2768, 10, 31, 13, 1, -30 },
  { 2807, 11, 38, 11, 0, -30 },
  { 2860, 17, 23, 18, 0, -29 },
  { 2909, 22, 14, 24, 1, -26 },
  { 2948, 17, 23, 18, 0, -29 },
  { 2997, 24, 46, 29, 2, -45 },
  { 3135, 37, 38, 38, 1, -29 },
  { 3311, 49, 46, 51, 1, -45 },
  { 3593, 55, 47, 56, 0, -46 },
  { 3917, 40, 47, 43, 2, -46 },
  { 4152, 49, 48, 51, 1, -46 },
  { 4446, 41, 47, 44, 2, -46 },
  { 4687, 45, 54, 48, 1, -46 },
  { 4991, 45, 47, 49, 2, -45 },
  { 5256, 44, 58, 46, 1, -49 },
  { 5575, 41, 54, 43, 1, -46 },
  { 5852, 42, 62, 45, 1, -46 },
  { 6178, 49, 46, 51, 1, -45 },
  { 6460, 34, 45, 36, 1, -44 },
  { 6652, 66, 47, 70, 2, -44 },
  { 7040, 52, 45, 56, 2, -44 },
  { 7333, 45, 46, 48, 1, -45 },
  { 7592, 54, 55, 56, 1, -44 },
  { 7964, 48, 49, 50, 1, -45 },
  { 8258, 56, 47, 59, 1, -46 },
  { 8587, 44, 46, 48, 2, -45 },
  { 8840, 45, 46, 47, 1, -45 },
  { 9099, 42, 48, 45, 1, -44 },
  { 9351, 53, 47, 56, 1, -46 },
  { 9663, 65, 46, 68, 1, -45 },
  { 10037, 43, 47, 45, 1, -46 },
  { 10290, 51, 56, 54, 1, -46 },
  { 10647, 39, 54, 42, 1, -46 },
  { 10911, 9, 50, 12, 1, -47 },
  { 10968, 39, 44, 7, -12, -41 },
  { 11183, 9, 50, 12, 1, -47 },
  { 11240, 24, 17, 26, 1, -44 },
  { 11291, 30, 5, 29, -1, 7 },
  { 11310, 10, 12, 32, 10, -44 },
  { 11325, 27, 34, 29, 1, -32 },
  { 11440, 26, 45, 28, 1, -43 },
  { 11587, 20, 33, 22, 1, -32 },
  { 11670, 26, 45, 29, 2, -44 },
  { 11817, 20, 33, 23, 1, -32 },
  { 11900, 20, 57, 15, -1, -46 },
  { 12043, 27, 46, 29, 1, -33 },
  { 12199, 26, 55, 28, 1, -44 },
  { 12378, 15, 45, 17, 1, -44 },
  { 12463, 18, 57, 15, -3, -45 },
  { 12592, 18, 46, 20, 1, -44 },
  { 12696, 18, 45, 17, 1, -44 },
  { 12798, 41, 34, 45, 2, -33 },
  { 12973, 29, 33, 32, 1, -32 },
  { 13093, 25, 33, 26, 0, -32 },
  { 13197, 27, 51, 28, 0, -38 },
  { 13370, 25, 46, 27, 1, -33 },
  { 13514, 21, 33, 23, 1, -32 },
  { 13601, 24, 40, 26, 1, -39 },
  { 13721, 17, 42, 19, 1, -40 },
  { 13811, 29, 34, 32, 1, -33 },
  { 13935, 28, 37, 28, -1, -36 },
  { 14065, 40, 39, 43, 2, -37 },
  { 14260, 23, 46, 25, 1, -33 },
  { 14393, 27, 49, 30, 1, -38 },
  { 14559, 19, 44, 21, 1, -32 },
  { 14664, 17, 50, 21, 1, -49 },
  { 14771, 4, 52, 10, 3, -49 },
  { 14797, 17, 50, 21, 1, -49 },
  { 14904, 21, 5, 23, 1, -21 },
};

const GFXfont UnifrakturMaguntia_Regular63pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular63pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular63pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR63PT7B_H_
