#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/UnifrakturMaguntia_Regular
// Headers: 67

#include "UnifrakturMaguntia_Regular6pt7b.h"
#include "UnifrakturMaguntia_Regular7pt7b.h"
#include "UnifrakturMaguntia_Regular8pt7b.h"
#include "UnifrakturMaguntia_Regular9pt7b.h"
#include "UnifrakturMaguntia_Regular10pt7b.h"
#include "UnifrakturMaguntia_Regular11pt7b.h"
#include "UnifrakturMaguntia_Regular12pt7b.h"
#include "UnifrakturMaguntia_Regular13pt7b.h"
#include "UnifrakturMaguntia_Regular14pt7b.h"
#include "UnifrakturMaguntia_Regular15pt7b.h"
#include "UnifrakturMaguntia_Regular16pt7b.h"
#include "UnifrakturMaguntia_Regular17pt7b.h"
#include "UnifrakturMaguntia_Regular18pt7b.h"
#include "UnifrakturMaguntia_Regular19pt7b.h"
#include "UnifrakturMaguntia_Regular20pt7b.h"
#include "UnifrakturMaguntia_Regular21pt7b.h"
#include "UnifrakturMaguntia_Regular22pt7b.h"
#include "UnifrakturMaguntia_Regular23pt7b.h"
#include "UnifrakturMaguntia_Regular24pt7b.h"
#include "UnifrakturMaguntia_Regular25pt7b.h"
#include "UnifrakturMaguntia_Regular26pt7b.h"
#include "UnifrakturMaguntia_Regular27pt7b.h"
#include "UnifrakturMaguntia_Regular28pt7b.h"
#include "UnifrakturMaguntia_Regular29pt7b.h"
#include "UnifrakturMaguntia_Regular30pt7b.h"
#include "UnifrakturMaguntia_Regular31pt7b.h"
#include "UnifrakturMaguntia_Regular32pt7b.h"
#include "UnifrakturMaguntia_Regular33pt7b.h"
#include "UnifrakturMaguntia_Regular34pt7b.h"
#include "UnifrakturMaguntia_Regular35pt7b.h"
#include "UnifrakturMaguntia_Regular36pt7b.h"
#include "UnifrakturMaguntia_Regular37pt7b.h"
#include "UnifrakturMaguntia_Regular38pt7b.h"
#include "UnifrakturMaguntia_Regular39pt7b.h"
#include "UnifrakturMaguntia_Regular40pt7b.h"
#include "UnifrakturMaguntia_Regular41pt7b.h"
#include "UnifrakturMaguntia_Regular42pt7b.h"
#include "UnifrakturMaguntia_Regular43pt7b.h"
#include "UnifrakturMaguntia_Regular44pt7b.h"
#include "UnifrakturMaguntia_Regular45pt7b.h"
#include "UnifrakturMaguntia_Regular46pt7b.h"
#include "UnifrakturMaguntia_Regular47pt7b.h"
#include "UnifrakturMaguntia_Regular48pt7b.h"
#include "UnifrakturMaguntia_Regular49pt7b.h"
#include "UnifrakturMaguntia_Regular50pt7b.h"
#include "UnifrakturMaguntia_Regular51pt7b.h"
#include "UnifrakturMaguntia_Regular52pt7b.h"
#include "UnifrakturMaguntia_Regular53pt7b.h"
#include "UnifrakturMaguntia_Regular54pt7b.h"
#include "UnifrakturMaguntia_Regular55pt7b.h"
#include "UnifrakturMaguntia_Regular56pt7b.h"
#include "UnifrakturMaguntia_Regular57pt7b.h"
#include "UnifrakturMaguntia_Regular58pt7b.h"
#include "UnifrakturMaguntia_Regular59pt7b.h"
#include "UnifrakturMaguntia_Regular60pt7b.h"
#include "UnifrakturMaguntia_Regular61pt7b.h"
#include "UnifrakturMaguntia_Regular62pt7b.h"
#include "UnifrakturMaguntia_Regular63pt7b.h"
#include "UnifrakturMaguntia_Regular64pt7b.h"
#include "UnifrakturMaguntia_Regular65pt7b.h"
#include "UnifrakturMaguntia_Regular66pt7b.h"
#include "UnifrakturMaguntia_Regular67pt7b.h"
#include "UnifrakturMaguntia_Regular68pt7b.h"
#include "UnifrakturMaguntia_Regular69pt7b.h"
#include "UnifrakturMaguntia_Regular70pt7b.h"
#include "UnifrakturMaguntia_Regular71pt7b.h"
#include "UnifrakturMaguntia_Regular72pt7b.h"
