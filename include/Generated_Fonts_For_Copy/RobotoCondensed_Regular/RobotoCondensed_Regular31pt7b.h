#ifndef _ROBOTOCONDENSED_REGULAR31PT7B_H_
#define _ROBOTOCONDENSED_REGULAR31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x3E, 0xC0, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x01, 0x8C, 0x06,
  0x30, 0x18, 0xC7, 0xFF, 0xDF, 0xFF, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03,
  0x18, 0x1C, 0x60, 0x63, 0x8F, 0xFF, 0xBF, 0xFE, 0x18, 0xC0, 0x63, 0x03,
  0x8C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x00, 0x06, 0x00, 0x60, 0x06, 0x01,
  0xF0, 0x3F, 0xC7, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0x6E, 0x06, 0x60, 0x07,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x06, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x0E, 0x7B, 0xE3, 0xFC, 0x1F, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x38, 0x00, 0xFC, 0x00, 0xC6, 0x00, 0xC6, 0x18, 0xC6, 0x38, 0xC6,
  0x30, 0xC6, 0x60, 0xC6, 0x60, 0x7C, 0xC0, 0x38, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x1C, 0x03, 0x7E, 0x06, 0x63, 0x0E, 0x63, 0x0C, 0x43, 0x18,
  0x43, 0x18, 0x63, 0x10, 0x63, 0x00, 0x7E, 0x00, 0x1C, 0x0F, 0x00, 0x7F,
  0x00, 0xE7, 0x03, 0x86, 0x07, 0x0C, 0x0E, 0x18, 0x1C, 0x70, 0x1D, 0xC0,
  0x3F, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x71, 0x9C, 0x73, 0x38,
  0xE6, 0x60, 0xFC, 0xC0, 0xF9, 0x81, 0xE3, 0x81, 0xC3, 0x8F, 0xC7, 0xFF,
  0xC3, 0xE3, 0x80, 0xFF, 0xFC, 0x02, 0x0C, 0x30, 0xE1, 0x87, 0x0C, 0x38,
  0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x18, 0x30, 0x70, 0x60, 0xE0, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x83, 0x83,
  0x03, 0x07, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0x86, 0x0C, 0x30,
  0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x07, 0x33, 0x3F, 0xFC, 0xFF,
  0x80, 0xE0, 0x0F, 0x80, 0xEE, 0x06, 0x38, 0x71, 0xC1, 0x04, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x39, 0xCE, 0x73, 0x39, 0x8C, 0xFF, 0xF0, 0xEF, 0x60, 0x00, 0xC0,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0x1F, 0x03, 0xFC, 0x79, 0xC6, 0x0E, 0xE0, 0xEE,
  0x06, 0xE0, 0x6C, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0x60, 0xE7, 0xBC, 0x3F, 0x81,
  0xF0, 0x03, 0x0F, 0x3F, 0xFF, 0xE7, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x81, 0xFF, 0x0E, 0x38, 0xE0, 0xE7, 0x07, 0x30, 0x1B, 0x80, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x0F,
  0x83, 0xFC, 0x3D, 0xE7, 0x07, 0x60, 0x76, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x1E, 0x0F, 0xC0, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xE0,
  0x36, 0x07, 0x70, 0x77, 0xDE, 0x3F, 0xC0, 0xF8, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1B, 0x81, 0xDC, 0x0C, 0xE0, 0xE7,
  0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9F, 0xFF, 0xFF, 0xF8,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE3, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x87, 0xFC, 0x7F,
  0xE6, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x7E, 0x07, 0x70,
  0xE7, 0x9E, 0x3F, 0xC0, 0xF8, 0x03, 0x80, 0xF8, 0x1F, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0xF8, 0xFF, 0xCF, 0x9E, 0xF0, 0xEE, 0x06, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70, 0xE7, 0x9E, 0x3F,
  0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x1F, 0x03, 0xFC, 0x7B, 0xC7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0x60, 0xE7, 0xBC, 0x3F, 0x83, 0xF8, 0x71, 0xCE, 0x0E, 0xE0,
  0x6C, 0x07, 0xC0, 0x7E, 0x06, 0xE0, 0xE7, 0xBE, 0x7F, 0xC1, 0xF0, 0x1F,
  0x07, 0xF1, 0xEF, 0x70, 0xEE, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78,
  0x0F, 0x83, 0xF0, 0x77, 0xBE, 0xFE, 0xC7, 0xB8, 0x07, 0x00, 0xC0, 0x38,
  0x0F, 0x07, 0xC3, 0xF0, 0x78, 0x00, 0xEF, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xF6, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x77, 0x77, 0xEE,
  0x40, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3C, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0E, 0x00, 0x40, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C,
  0x0E, 0x01, 0x00, 0x00, 0x1F, 0x07, 0xF1, 0xEF, 0x70, 0x6E, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x18, 0x00, 0xC3,
  0x00, 0x06, 0x30, 0x00, 0x66, 0x07, 0x83, 0x60, 0xFC, 0x3E, 0x1C, 0xC3,
  0xC3, 0x8C, 0x3C, 0x30, 0xC3, 0xC3, 0x0C, 0x3C, 0x70, 0xC3, 0xC7, 0x0C,
  0x3C, 0x70, 0xC3, 0xC6, 0x0C, 0x3C, 0x70, 0xC3, 0xC7, 0x1C, 0x2C, 0x33,
  0xC6, 0xC3, 0xEF, 0xCE, 0x1C, 0x78, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x04, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0xE0,
  0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38,
  0x18, 0x18, 0x38, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x70, 0x0C, 0x70, 0x0E,
  0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x38,
  0x7D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x0F,
  0x3F, 0xF1, 0xFF, 0xCE, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC3, 0xEF, 0xFE, 0x7F, 0xE0, 0x07, 0xC0, 0x7F, 0xC3,
  0xEF, 0x9C, 0x0E, 0x70, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x07,
  0xE0, 0x1D, 0xC0, 0x77, 0x03, 0x8F, 0x3E, 0x1F, 0xF0, 0x3F, 0x00, 0xFF,
  0x83, 0xFF, 0x8E, 0x3F, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x7C, 0xFF, 0xE3,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0xFF, 0xC3,
  0xEF, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x7F, 0xE1, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1D, 0xC0, 0x77, 0x01, 0xCF, 0x9F, 0x1F, 0xF8, 0x1F, 0x80, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0xBE, 0x3F, 0xC1, 0xF0, 0xE0,
  0x1D, 0xC0, 0x73, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xE0,
  0x73, 0xC0, 0xE7, 0x01, 0xDC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xB8, 0x1E,
  0x70, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE1, 0xC0, 0xE3, 0x81, 0xE7, 0x01,
  0xCE, 0x01, 0xDC, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x60, 0x3F, 0xEE, 0x06, 0xFD,
  0xC1, 0xDF, 0x98, 0x3B, 0xF3, 0x86, 0x7E, 0x71, 0xCF, 0xC6, 0x39, 0xF8,
  0xE6, 0x3F, 0x1D, 0xC7, 0xE1, 0xB8, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xF0,
  0x78, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xC0, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFB, 0x83, 0xF7, 0x07, 0xE7, 0x0F,
  0xCE, 0x1F, 0x8E, 0x3F, 0x0C, 0x7E, 0x1C, 0xFC, 0x19, 0xF8, 0x3B, 0xF0,
  0x37, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0x81, 0xE7, 0x01, 0xDC, 0x03,
  0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1C, 0xE0, 0x39, 0xC0,
  0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0xCE, 0x0F,
  0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xEE, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0x81, 0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x06, 0xE0, 0x1C, 0xC0, 0x39, 0xC0, 0xE1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x10, 0xFF,
  0xC3, 0xFF, 0x8E, 0x1F, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0x87, 0x0E,
  0x0E, 0x38, 0x38, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x0E, 0xE0, 0x3B,
  0x80, 0x70, 0x0F, 0xC0, 0x7F, 0x83, 0xEF, 0x1C, 0x0E, 0x70, 0x19, 0xC0,
  0x77, 0x01, 0xDC, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x03, 0x8F,
  0xBE, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1B, 0x80, 0xEF, 0x03, 0x9F, 0x7C, 0x3F, 0xE0, 0x3F, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x38,
  0x1C, 0x38, 0x18, 0x38, 0x38, 0x18, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0C,
  0x70, 0x0C, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x30, 0x1F, 0x80, 0xC0,
  0x76, 0x07, 0x81, 0x98, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC1, 0xE0, 0xE7,
  0x0F, 0xC3, 0x8C, 0x33, 0x0C, 0x30, 0xCC, 0x70, 0xE3, 0x31, 0xC3, 0x9C,
  0xC7, 0x0E, 0x61, 0x9C, 0x19, 0x86, 0x60, 0x66, 0x19, 0x81, 0x98, 0x6E,
  0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0xE0, 0x39,
  0xE0, 0xF1, 0xC1, 0xC1, 0xC3, 0x83, 0x8E, 0x03, 0x9C, 0x07, 0x70, 0x07,
  0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xB8,
  0x0F, 0x38, 0x1C, 0x70, 0x78, 0x70, 0xE0, 0xE3, 0xC0, 0xE7, 0x01, 0xDE,
  0x01, 0xC0, 0x70, 0x0F, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C,
  0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFC, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60,
  0x1C, 0x07, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF,
  0xF0, 0x0C, 0x0E, 0x07, 0x83, 0xC3, 0xE1, 0xB8, 0xCC, 0xE6, 0x63, 0xB0,
  0xF8, 0x60, 0xFF, 0xFF, 0xFF, 0xF1, 0xC3, 0x87, 0x1F, 0x07, 0xF9, 0xEF,
  0x70, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0xFF, 0x7F, 0xEE, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0xC3, 0xFF, 0xFB, 0xFF, 0x3C, 0xE0, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x8F, 0xFC, 0xFB, 0xEE, 0x0E, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0E, 0xFB, 0xEF, 0xFC, 0xEF, 0x80, 0x0F, 0x83, 0xFE, 0x3D, 0xE7,
  0x07, 0x70, 0x76, 0x03, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x37, 0x07, 0x3C, 0xE3, 0xFE, 0x0F, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0x33, 0xFB, 0x3D, 0xF7, 0x07,
  0x70, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03,
  0x70, 0x37, 0x07, 0x3C, 0xF3, 0xFB, 0x0F, 0x30, 0x0F, 0x81, 0xFE, 0x3C,
  0xE7, 0x07, 0x70, 0x76, 0x03, 0x60, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x02, 0x3C, 0xF3, 0xFE, 0x0F, 0xC0, 0x07, 0x0F,
  0x87, 0x87, 0x03, 0x81, 0xC3, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x0F, 0x33, 0xFB, 0x3D, 0xF7, 0x07, 0x70, 0x36, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0x60, 0x36, 0x03, 0x70, 0x37, 0x07, 0x3C, 0xF3, 0xFB,
  0x0F, 0x30, 0x03, 0x00, 0x72, 0x07, 0x39, 0xE3, 0xFE, 0x0F, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0xFE, 0xFB, 0xDE,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xCE, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xDD, 0xEE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x1C, 0xE3,
  0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xE7,
  0x0E, 0x70, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF, 0x8F, 0x9F, 0xFB, 0xFB,
  0xEF, 0xEF, 0xF0, 0x78, 0x7E, 0x0E, 0x0F, 0xC1, 0xC0, 0xF8, 0x38, 0x1F,
  0x07, 0x03, 0xE0, 0xE0, 0x7C, 0x1C, 0x0F, 0x83, 0x81, 0xF0, 0x70, 0x3E,
  0x0E, 0x07, 0xC1, 0xC0, 0xF8, 0x38, 0x1F, 0x07, 0x03, 0xE0, 0xE0, 0x60,
  0xE7, 0x9F, 0xFB, 0xEF, 0x78, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0,
  0x0F, 0x80, 0xFF, 0x0F, 0x3C, 0xE0, 0xE7, 0x03, 0xB0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77, 0x03, 0xB8, 0x38, 0xF3,
  0xC3, 0xFC, 0x0F, 0x80, 0xCF, 0x8F, 0xFC, 0xFB, 0xEE, 0x0E, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0xF1, 0xEF, 0xFC, 0xEF, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x0F, 0x33, 0xFB, 0x7D, 0xF7, 0x07, 0x70, 0x36, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x37, 0x07,
  0x3C, 0xF3, 0xFB, 0x0F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0xEF, 0xFF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x1F, 0x0F, 0xF3, 0xCF, 0x70, 0xEE, 0x0D,
  0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0x00, 0x7C, 0x0F, 0xC1,
  0xBC, 0xF3, 0xFC, 0x1F, 0x00, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F,
  0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xDC, 0xFB, 0xFF, 0x3E,
  0xE0, 0xE0, 0x7C, 0x1F, 0x83, 0xB0, 0x77, 0x0C, 0xE3, 0x8C, 0x71, 0x8C,
  0x39, 0x87, 0x70, 0x6E, 0x0D, 0x81, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0xC0, 0xF8, 0x30, 0x7E, 0x1E, 0x1D, 0x87, 0x87, 0x61, 0xE1,
  0x9C, 0x7C, 0x67, 0x3F, 0x38, 0xCC, 0xCE, 0x33, 0x33, 0x0C, 0xCE, 0xC3,
  0xF3, 0xB0, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xE0, 0x70,
  0x38, 0x0C, 0x0C, 0x00, 0xE0, 0xE7, 0x0E, 0x71, 0xC3, 0x9C, 0x3B, 0x81,
  0xB8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1F, 0x01, 0xB8, 0x39, 0x83,
  0x1C, 0x70, 0xC7, 0x0E, 0xE0, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xB0, 0x67,
  0x1C, 0xE3, 0x9C, 0x61, 0x8C, 0x3B, 0x87, 0x70, 0x6C, 0x0D, 0x81, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x07, 0x81, 0xF0,
  0x3C, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0xFF,
  0xFF, 0xE0, 0x02, 0x07, 0x0E, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x78, 0xF0, 0xF0, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x1C, 0x1C, 0x0E, 0x07, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x81, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x83, 0x83, 0x87, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x61, 0xC3, 0x8E, 0x10, 0x00, 0x3C, 0x0D, 0xF8, 0x3F, 0xF0, 0xF8,
  0xFF, 0xC1, 0xF8, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 22, 8, 2, -22 },
  { 10, 6, 7, 10, 2, -23 },
  { 16, 14, 22, 17, 2, -22 },
  { 55, 12, 28, 15, 2, -25 },
  { 97, 16, 22, 20, 2, -22 },
  { 141, 15, 22, 17, 2, -22 },
  { 183, 2, 7, 5, 2, -23 },
  { 185, 7, 32, 10, 2, -25 },
  { 213, 7, 32, 10, 1, -25 },
  { 241, 13, 13, 13, 0, -22 },
  { 263, 13, 16, 15, 1, -18 },
  { 289, 5, 8, 6, 0, -3 },
  { 294, 6, 2, 8, 1, -10 },
  { 296, 4, 3, 8, 2, -3 },
  { 298, 10, 24, 12, 0, -22 },
  { 328, 12, 22, 15, 2, -22 },
  { 361, 8, 22, 15, 2, -22 },
  { 383, 13, 22, 15, 1, -22 },
  { 419, 12, 22, 15, 1, -22 },
  { 452, 13, 22, 15, 1, -22 },
  { 488, 12, 22, 15, 2, -22 },
  { 521, 12, 22, 15, 2, -22 },
  { 554, 13, 22, 15, 1, -22 },
  { 590, 12, 22, 15, 2, -22 },
  { 623, 11, 22, 15, 2, -22 },
  { 654, 4, 16, 7, 2, -16 },
  { 662, 4, 21, 6, 1, -16 },
  { 673, 11, 14, 14, 1, -17 },
  { 693, 11, 8, 15, 2, -14 },
  { 704, 11, 14, 14, 2, -17 },
  { 724, 11, 22, 13, 1, -22 },
  { 755, 20, 29, 24, 2, -22 },
  { 828, 16, 22, 18, 1, -22 },
  { 872, 13, 22, 17, 2, -22 },
  { 908, 14, 22, 18, 2, -22 },
  { 947, 14, 22, 18, 2, -22 },
  { 986, 12, 22, 15, 2, -22 },
  { 1019, 12, 22, 15, 2, -22 },
  { 1052, 14, 22, 18, 2, -22 },
  { 1091, 15, 22, 19, 2, -22 },
  { 1133, 3, 22, 8, 2, -22 },
  { 1142, 12, 22, 15, 1, -22 },
  { 1175, 15, 22, 17, 2, -22 },
  { 1217, 12, 22, 15, 2, -22 },
  { 1250, 19, 22, 23, 2, -22 },
  { 1303, 15, 22, 19, 2, -22 },
  { 1345, 15, 22, 19, 2, -22 },
  { 1387, 14, 22, 17, 2, -22 },
  { 1426, 15, 26, 19, 2, -22 },
  { 1475, 14, 22, 16, 2, -22 },
  { 1514, 14, 22, 16, 1, -22 },
  { 1553, 14, 22, 16, 1, -22 },
  { 1592, 14, 22, 17, 2, -22 },
  { 1631, 16, 22, 17, 1, -22 },
  { 1675, 22, 22, 24, 1, -22 },
  { 1736, 15, 22, 17, 1, -22 },
  { 1778, 16, 22, 16, 0, -22 },
  { 1822, 14, 22, 16, 1, -22 },
  { 1861, 5, 30, 8, 2, -25 },
  { 1880, 10, 24, 11, 1, -22 },
  { 1910, 6, 30, 8, 0, -25 },
  { 1933, 9, 11, 12, 1, -22 },
  { 1946, 12, 2, 13, 0, 0 },
  { 1949, 6, 4, 10, 1, -23 },
  { 1952, 11, 17, 15, 2, -17 },
  { 1976, 12, 23, 15, 2, -23 },
  { 2011, 12, 17, 14, 1, -17 },
  { 2037, 12, 23, 15, 1, -23 },
  { 2072, 12, 17, 15, 1, -17 },
  { 2098, 9, 23, 10, 1, -23 },
  { 2124, 12, 23, 15, 1, -17 },
  { 2159, 11, 23, 15, 2, -23 },
  { 2191, 3, 23, 7, 2, -23 },
  { 2200, 5, 29, 7, 0, -23 },
  { 2219, 12, 23, 14, 2, -23 },
  { 2254, 3, 23, 7, 2, -23 },
  { 2263, 19, 17, 23, 2, -17 },
  { 2304, 11, 17, 15, 2, -17 },
  { 2328, 13, 17, 16, 1, -17 },
  { 2356, 12, 23, 15, 2, -17 },
  { 2391, 12, 23, 16, 1, -17 },
  { 2426, 7, 17, 9, 2, -17 },
  { 2441, 11, 17, 14, 2, -17 },
  { 2465, 8, 20, 9, 0, -20 },
  { 2485, 11, 17, 15, 2, -17 },
  { 2509, 11, 17, 13, 1, -17 },
  { 2533, 18, 17, 20, 1, -17 },
  { 2572, 12, 17, 14, 1, -17 },
  { 2598, 11, 23, 13, 1, -17 },
  { 2630, 11, 17, 14, 1, -17 },
  { 2654, 8, 30, 10, 1, -24 },
  { 2684, 2, 26, 8, 3, -22 },
  { 2691, 7, 30, 10, 1, -24 },
  { 2718, 14, 6, 18, 2, -12 },
};

const GFXfont RobotoCondensed_Regular31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_REGULAR31PT7B_H_
