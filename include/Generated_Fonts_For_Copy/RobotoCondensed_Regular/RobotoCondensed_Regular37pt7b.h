#ifndef _ROBOTOCONDENSED_REGULAR37PT7B_H_
#define _ROBOTOCONDENSED_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0x01, 0x87, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x70, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x38, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC1, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0,
  0x30, 0xC0, 0x18, 0x60, 0x1C, 0x30, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC1, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18,
  0x70, 0x0C, 0x30, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x8E, 0x1E, 0x78, 0x3D, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0xF7, 0x87, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x80, 0x0E, 0x38, 0x20,
  0xC1, 0x87, 0x0C, 0x18, 0x60, 0xC1, 0x8E, 0x0C, 0x18, 0xC0, 0xE3, 0x9C,
  0x07, 0x79, 0x80, 0x7F, 0x30, 0x03, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC7, 0x80, 0x1C, 0xFC, 0x01, 0x9C, 0xE0, 0x39, 0x87, 0x03,
  0x18, 0x70, 0x71, 0x87, 0x06, 0x18, 0x70, 0xC1, 0x87, 0x1C, 0x18, 0x70,
  0x01, 0xCE, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xF1, 0xC0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE1,
  0xC0, 0x3C, 0xF0, 0x07, 0x78, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0xC7, 0xBC, 0x71, 0xC7, 0x1C, 0xF1, 0xE7, 0x38, 0x3D, 0xCE,
  0x07, 0xF3, 0x81, 0xF8, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x87, 0xE1, 0xFF,
  0xFC, 0x3F, 0xF7, 0x83, 0xF0, 0xE0, 0xFF, 0xFD, 0xB6, 0xC0, 0x01, 0x01,
  0x81, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x08, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0xE0, 0xC0, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x06, 0x18, 0x2F, 0x33, 0xDF, 0xFF, 0x8F, 0xFE, 0x03, 0xC0,
  0x0F, 0xC0, 0x3B, 0x80, 0x73, 0x81, 0xC3, 0x83, 0x87, 0x02, 0x04, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0x40, 0xFF, 0xFF, 0xF8, 0xEF, 0xFE, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0,
  0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC,
  0x07, 0x70, 0x3D, 0xC0, 0xE7, 0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0x1F, 0x00,
  0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xC3, 0xCF, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0x70, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1E, 0x1E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xE7, 0x07, 0x9F,
  0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xB8, 0x03, 0xB8, 0x07, 0x38, 0x07,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x78,
  0x38, 0x70, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xDF, 0x07, 0xFE, 0x1F, 0xFC, 0xF0, 0xF8, 0x81, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x80, 0xE7,
  0x07, 0x9F, 0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFE,
  0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xCF,
  0x87, 0xFF, 0x3F, 0xFE, 0xFC, 0x3B, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xE0, 0xF3, 0xC3, 0x87,
  0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E,
  0x1E, 0x70, 0x39, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x39, 0xC0, 0xE3,
  0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x87, 0x8F, 0xFE,
  0x1F, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x70,
  0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xF7, 0x0F, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x07, 0xF8, 0x1F, 0x80,
  0x78, 0x00, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x73, 0xDE, 0xE0, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x39, 0xCE, 0xF7, 0xB9, 0xDC, 0x40, 0x00, 0x08, 0x01, 0xC0, 0x3E,
  0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x03, 0x80, 0x10, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x07,
  0xB8, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xF0, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C,
  0x30, 0x1F, 0x07, 0x38, 0x1F, 0xC1, 0x9C, 0x1E, 0xF0, 0xCC, 0x1C, 0x38,
  0x66, 0x0E, 0x18, 0x37, 0x06, 0x0C, 0x1F, 0x87, 0x06, 0x0F, 0xC3, 0x83,
  0x07, 0xE1, 0xC1, 0x83, 0xF0, 0xC0, 0xC1, 0xF8, 0x60, 0xE0, 0xDC, 0x30,
  0x70, 0x6E, 0x18, 0x38, 0x37, 0x0E, 0x1C, 0x3B, 0x87, 0x1E, 0x18, 0xC3,
  0xFB, 0x9C, 0x60, 0xFD, 0xFC, 0x38, 0x38, 0x7C, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x87, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3B,
  0x80, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x1E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0x80, 0x38,
  0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1E, 0xF0, 0x00,
  0xEE, 0x00, 0x0E, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7,
  0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0x38, 0x0F, 0x70, 0x0E, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC1,
  0xE3, 0x80, 0x73, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x80,
  0x79, 0xC0, 0x38, 0xF0, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1C, 0xE0, 0x1E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x7C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x7B, 0x80,
  0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x1C, 0xF8,
  0x1E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x87, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00,
  0xE0, 0x0F, 0x70, 0x0F, 0x38, 0x07, 0x9C, 0x07, 0x8E, 0x07, 0x87, 0x07,
  0x83, 0x83, 0xC1, 0xC3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x39, 0xE0, 0x1D,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xEF, 0x01, 0xF3, 0x80, 0xF1, 0xE0,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0F, 0x0E, 0x03, 0xC7, 0x01, 0xE3, 0x80,
  0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x7F, 0xEE, 0x01, 0xDF, 0xB8, 0x07, 0x7E, 0xE0, 0x3D, 0xF9, 0xC0, 0xE7,
  0xE7, 0x03, 0x9F, 0x9C, 0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE3,
  0x8E, 0x1F, 0x87, 0x38, 0x7E, 0x1C, 0xE1, 0xF8, 0x73, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F,
  0x80, 0xC0, 0x70, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDC, 0x07, 0xEF, 0x03, 0xF3, 0x81,
  0xF8, 0xE0, 0xFC, 0x70, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x83, 0x8F, 0xC1,
  0xC7, 0xE0, 0x73, 0xF0, 0x39, 0xF8, 0x0E, 0xFC, 0x07, 0x7E, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x3C, 0x38, 0x07, 0x9E, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x03, 0x8E, 0x01,
  0xE3, 0xE0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78,
  0x07, 0x9C, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0E, 0x70,
  0x03, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78,
  0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3C, 0x70, 0x1E,
  0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x79, 0xF0, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x80, 0x3C, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C,
  0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE7, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0xF0, 0x0E, 0x01, 0xDC, 0x03, 0x80, 0x77, 0x01, 0xE0, 0x3D, 0xC0, 0x78,
  0x0F, 0x70, 0x1F, 0x03, 0x9E, 0x07, 0xC0, 0xE3, 0x83, 0xB0, 0x38, 0xE0,
  0xEC, 0x0E, 0x38, 0x3B, 0x87, 0x8E, 0x0E, 0xE1, 0xC3, 0xC7, 0x38, 0x70,
  0x71, 0xC6, 0x1C, 0x1C, 0x71, 0xC7, 0x07, 0x1C, 0x73, 0xC1, 0xC6, 0x1C,
  0xE0, 0x73, 0x83, 0x38, 0x0E, 0xE0, 0xCE, 0x03, 0xB8, 0x3B, 0x80, 0xEC,
  0x0E, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0E,
  0x00, 0x78, 0x03, 0xDE, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x07, 0xB8, 0x01, 0xCF, 0x00, 0xF1, 0xC0, 0x38, 0x78, 0x1E, 0x0E,
  0x07, 0x03, 0xC3, 0xC0, 0x70, 0xE0, 0x1E, 0x78, 0x03, 0x9C, 0x00, 0xF0,
  0xF0, 0x03, 0xFC, 0x01, 0xE7, 0x00, 0x79, 0xE0, 0x1C, 0x38, 0x0F, 0x0F,
  0x03, 0x81, 0xC1, 0xE0, 0x70, 0x70, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xF3,
  0x80, 0x1D, 0xE0, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xFF, 0x06, 0x01, 0xC0, 0x3C, 0x07, 0x81, 0xF8, 0x3F, 0x06,
  0x61, 0xCE, 0x39, 0xCE, 0x39, 0xC3, 0xB8, 0x7E, 0x0E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xF8,
  0xFF, 0xE7, 0xE3, 0x9C, 0x0E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E,
  0xF0, 0xF9, 0xFF, 0xE3, 0xFB, 0x87, 0xCF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xE1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xC1, 0xEF, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78,
  0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xBC, 0x07, 0x78, 0x1E, 0xF8, 0x3D, 0xFF, 0xF3, 0xBF, 0xC7, 0x1F, 0x00,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0xF0, 0x3B, 0x80, 0x7E, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x7E, 0x01, 0xFC, 0x0E, 0x78, 0x79, 0xFF, 0xC3, 0xFE, 0x03, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x0F, 0x9C, 0xFF, 0x77, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFD, 0xC3, 0xE7,
  0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x39, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x03,
  0xC3, 0xF0, 0xFC, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xBF, 0xEF,
  0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0x9C,
  0xFF, 0x77, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFD, 0xC3, 0xE7, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x70, 0x79, 0xFF, 0xC3, 0xFF, 0x03, 0xF0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF3, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3B, 0xC0, 0xEF,
  0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0x67, 0xF7, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x70, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x0F, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCE, 0xFB, 0xEE, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F,
  0x3C, 0x78, 0xF3, 0xC3, 0xCE, 0x0F, 0x78, 0x3F, 0xC0, 0xFE, 0x03, 0xFC,
  0x0F, 0xF8, 0x3E, 0xE0, 0xF3, 0xC3, 0xC7, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0,
  0x73, 0xC1, 0xEF, 0x03, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xE1, 0xF1, 0xDF, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0xFF, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0F,
  0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0xF0,
  0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x03,
  0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3F,
  0x81, 0xE0, 0x70, 0xE3, 0xE3, 0xBF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3B,
  0xC0, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x03, 0xDE,
  0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0x38, 0x0E, 0x78, 0x3C, 0x7F, 0xF0,
  0x7F, 0xC0, 0x7E, 0x00, 0xE3, 0xE1, 0xDF, 0xE3, 0xFF, 0xE7, 0xC3, 0xEF,
  0x03, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xF8, 0x3D,
  0xFF, 0xF3, 0xFF, 0xC7, 0x9F, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x9C, 0xFF,
  0x77, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC,
  0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFD, 0xC3, 0xE7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF7, 0xFF,
  0xFF, 0xFC, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE0,
  0xEF, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x7B, 0xFF, 0x8F,
  0xF8, 0x1F, 0x80, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xF0, 0xFC, 0x1F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x78,
  0x7B, 0xFF, 0xCF, 0xFE, 0x3E, 0x70, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x39, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x0C, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xC0, 0xE0, 0x30, 0x1F, 0x81, 0xE0, 0x7F, 0x07,
  0x83, 0xDC, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC3, 0xF0, 0xE7, 0x0F, 0xC3,
  0x8E, 0x37, 0x1C, 0x39, 0xCC, 0x70, 0xE7, 0x39, 0xC3, 0x9C, 0xE7, 0x07,
  0x63, 0x98, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0x80, 0x60,
  0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x8E, 0x1C, 0x1C, 0xF0, 0x73, 0x80, 0xFE,
  0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7B,
  0x81, 0xCE, 0x0F, 0x3C, 0x38, 0x71, 0xE1, 0xE7, 0x03, 0xBC, 0x0F, 0xE0,
  0x3F, 0xC0, 0xEF, 0x03, 0x9C, 0x1E, 0x70, 0x71, 0xE1, 0xC3, 0x87, 0x0E,
  0x3C, 0x38, 0xE0, 0xF3, 0x81, 0xCE, 0x07, 0x70, 0x1D, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0xE0,
  0x78, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0xF8, 0x3C, 0x0F, 0x80, 0xF0, 0x1C, 0x07,
  0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x38, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x81,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C,
  0x0F, 0x83, 0xC3, 0xE1, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x78, 0x38, 0x18, 0x00, 0x1E,
  0x01, 0xCF, 0xE0, 0x67, 0xFC, 0x39, 0xC7, 0x8E, 0xE0, 0xFF, 0x38, 0x1F,
  0xC0, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 26, 9, 3, -26 },
  { 11, 8, 9, 12, 2, -28 },
  { 20, 17, 26, 20, 2, -26 },
  { 76, 14, 33, 18, 2, -30 },
  { 134, 20, 26, 23, 2, -26 },
  { 199, 18, 26, 20, 2, -26 },
  { 258, 3, 9, 6, 2, -28 },
  { 262, 9, 38, 12, 2, -30 },
  { 305, 8, 38, 12, 1, -30 },
  { 343, 15, 15, 16, 0, -26 },
  { 372, 15, 19, 18, 2, -22 },
  { 408, 5, 9, 7, 1, -4 },
  { 414, 7, 3, 9, 1, -13 },
  { 417, 4, 4, 10, 3, -4 },
  { 419, 11, 28, 14, 1, -26 },
  { 458, 14, 26, 18, 2, -26 },
  { 504, 9, 26, 18, 3, -26 },
  { 534, 15, 26, 18, 2, -26 },
  { 583, 14, 26, 18, 2, -26 },
  { 629, 16, 26, 18, 1, -26 },
  { 681, 14, 26, 18, 3, -26 },
  { 727, 14, 26, 18, 2, -26 },
  { 773, 15, 26, 18, 2, -26 },
  { 822, 14, 26, 18, 2, -26 },
  { 868, 14, 26, 18, 2, -26 },
  { 914, 5, 20, 9, 2, -20 },
  { 927, 5, 25, 8, 1, -20 },
  { 943, 13, 16, 17, 1, -20 },
  { 969, 12, 11, 18, 3, -18 },
  { 986, 13, 16, 17, 2, -20 },
  { 1012, 13, 26, 16, 1, -26 },
  { 1055, 25, 34, 28, 2, -26 },
  { 1162, 20, 26, 21, 1, -26 },
  { 1227, 15, 26, 20, 3, -26 },
  { 1276, 17, 26, 21, 2, -26 },
  { 1332, 16, 26, 21, 3, -26 },
  { 1384, 14, 26, 18, 3, -26 },
  { 1430, 14, 26, 18, 3, -26 },
  { 1476, 17, 26, 22, 2, -26 },
  { 1532, 17, 26, 23, 3, -26 },
  { 1588, 3, 26, 9, 3, -26 },
  { 1598, 14, 26, 18, 1, -26 },
  { 1644, 17, 26, 20, 3, -26 },
  { 1700, 13, 26, 18, 3, -26 },
  { 1743, 22, 26, 28, 3, -26 },
  { 1815, 17, 26, 23, 3, -26 },
  { 1871, 18, 26, 22, 2, -26 },
  { 1930, 16, 26, 21, 3, -26 },
  { 1982, 18, 30, 22, 2, -26 },
  { 2050, 16, 26, 20, 3, -26 },
  { 2102, 16, 26, 19, 2, -26 },
  { 2154, 17, 26, 19, 1, -26 },
  { 2210, 17, 26, 21, 2, -26 },
  { 2266, 19, 26, 21, 1, -26 },
  { 2328, 26, 26, 28, 1, -26 },
  { 2413, 18, 26, 20, 1, -26 },
  { 2472, 18, 26, 19, 1, -26 },
  { 2531, 16, 26, 19, 2, -26 },
  { 2583, 6, 36, 9, 2, -30 },
  { 2610, 12, 28, 14, 1, -26 },
  { 2652, 6, 36, 9, 1, -30 },
  { 2679, 11, 13, 14, 1, -26 },
  { 2697, 15, 3, 15, 0, 0 },
  { 2703, 8, 5, 11, 1, -27 },
  { 2708, 14, 20, 18, 2, -20 },
  { 2743, 15, 28, 18, 2, -28 },
  { 2796, 14, 20, 17, 2, -20 },
  { 2831, 14, 28, 18, 2, -28 },
  { 2880, 14, 20, 17, 2, -20 },
  { 2915, 10, 28, 12, 1, -28 },
  { 2950, 14, 28, 18, 2, -20 },
  { 2999, 14, 28, 18, 2, -28 },
  { 3048, 4, 27, 8, 2, -27 },
  { 3062, 6, 35, 8, 0, -27 },
  { 3089, 14, 28, 17, 2, -28 },
  { 3138, 3, 28, 8, 3, -28 },
  { 3149, 23, 20, 28, 2, -20 },
  { 3207, 14, 20, 18, 2, -20 },
  { 3242, 15, 20, 19, 2, -20 },
  { 3280, 15, 28, 18, 2, -20 },
  { 3333, 14, 28, 19, 2, -20 },
  { 3382, 8, 20, 11, 2, -20 },
  { 3402, 13, 20, 17, 2, -20 },
  { 3435, 10, 24, 11, 0, -24 },
  { 3465, 13, 20, 18, 2, -20 },
  { 3498, 14, 20, 16, 1, -20 },
  { 3533, 22, 20, 24, 1, -20 },
  { 3588, 14, 20, 16, 1, -20 },
  { 3623, 14, 28, 15, 1, -20 },
  { 3672, 13, 20, 16, 2, -20 },
  { 3705, 10, 36, 11, 1, -29 },
  { 3750, 3, 31, 9, 3, -26 },
  { 3762, 9, 36, 11, 1, -29 },
  { 3803, 18, 7, 22, 2, -14 },
};

const GFXfont RobotoCondensed_Regular37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_REGULAR37PT7B_H_
