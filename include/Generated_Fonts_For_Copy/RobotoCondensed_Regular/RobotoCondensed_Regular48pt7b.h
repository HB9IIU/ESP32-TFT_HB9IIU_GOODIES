#ifndef _ROBOTOCONDENSED_REGULAR48PT7B_H_
#define _ROBOTOCONDENSED_REGULAR48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xB8, 0x6E, 0x1B, 0x86, 0x00, 0x70, 0x70,
  0x03, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x0F, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x07, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x87,
  0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x0F, 0x87, 0xE7, 0xC0, 0xF9, 0xE0, 0x1E, 0x78, 0x07,
  0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xF7,
  0xC0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x0E, 0x02, 0x07,
  0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0,
  0x70, 0x70, 0xE0, 0x38, 0x38, 0xF0, 0x1C, 0x1C, 0x70, 0x0F, 0x1E, 0x70,
  0x03, 0xFE, 0x38, 0x00, 0xFE, 0x38, 0x00, 0x3E, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F, 0x00, 0x0F, 0x3F, 0xC0, 0x07,
  0x1F, 0xF0, 0x07, 0x9E, 0x3C, 0x03, 0x8E, 0x0E, 0x03, 0x8F, 0x07, 0x01,
  0xC7, 0x03, 0x81, 0xC3, 0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x78, 0x38, 0x70, 0x1C, 0x1C, 0x08, 0x0F, 0x1E, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x3E,
  0x3C, 0x78, 0x1F, 0x3C, 0xF8, 0x0F, 0x78, 0xF8, 0x0F, 0xF8, 0xF8, 0x07,
  0xF8, 0x78, 0x03, 0xF0, 0x78, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x07,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0x3E, 0x03, 0xF8,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x18, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xC0, 0x08, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0x60, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x38, 0x37, 0xE7, 0x3E, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xCF,
  0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x04, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x7B, 0xCF,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xDF, 0x78, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x1E, 0x03, 0xE7, 0x80, 0x7B,
  0xE0, 0x1E, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x0F, 0x9F, 0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x60, 0x3C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x0F,
  0xC7, 0xC0, 0x7C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xEF, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0,
  0xF8, 0xF8, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7B, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F,
  0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xDF, 0x80, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0,
  0x7C, 0x78, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x79, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF,
  0xFC, 0xFE, 0x0F, 0xBF, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x3D, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E, 0x03, 0xE7, 0x80, 0x7B, 0xE0,
  0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F,
  0x8F, 0x07, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x83,
  0xE1, 0xF1, 0xE0, 0x3E, 0xF8, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07,
  0x9F, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xF8,
  0x78, 0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x7B,
  0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB,
  0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0xFC, 0xF8, 0x3F, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xF7, 0x80, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x7B, 0xEF, 0xFE,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xBF, 0xF9, 0xE0, 0x3C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x20, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x01, 0xF0, 0x1C, 0x38,
  0x07, 0xF8, 0x0C, 0x78, 0x0F, 0xFE, 0x0E, 0x70, 0x1E, 0x1C, 0x0E, 0x70,
  0x1C, 0x1C, 0x0E, 0x70, 0x3C, 0x1C, 0x0E, 0xF0, 0x38, 0x1C, 0x06, 0xE0,
  0x78, 0x1C, 0x06, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0,
  0x70, 0x1C, 0x07, 0xE0, 0xF0, 0x1C, 0x07, 0xE0, 0xF0, 0x3C, 0x06, 0xE0,
  0xF0, 0x3C, 0x06, 0xE0, 0xF0, 0x3C, 0x0E, 0xE0, 0xF0, 0x3C, 0x0E, 0xE0,
  0xF0, 0x38, 0x0E, 0xE0, 0xF0, 0x38, 0x0E, 0xE0, 0xF0, 0x7C, 0x1C, 0xE0,
  0x78, 0x7C, 0x1C, 0xE0, 0x7D, 0xDC, 0x38, 0xF0, 0x7F, 0xDF, 0xF8, 0x70,
  0x3F, 0x8F, 0xF0, 0x70, 0x1E, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x04, 0x00, 0x03,
  0xE0, 0x1C, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x01, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00,
  0x7D, 0xE0, 0x1F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF3, 0xC0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00,
  0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3D,
  0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0xFC,
  0x07, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0,
  0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0,
  0x07, 0xCF, 0x00, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x01, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00,
  0x0F, 0x3E, 0x00, 0x7C, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0,
  0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF,
  0x00, 0x3E, 0x3C, 0x01, 0xF8, 0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80,
  0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3D,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x3E,
  0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF0,
  0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x00,
  0xFB, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0x7F, 0xF8, 0x00, 0x7B, 0xFD, 0xE0, 0x03, 0xDF, 0xEF, 0x00, 0x3C,
  0xFF, 0x78, 0x01, 0xEF, 0xF9, 0xE0, 0x0F, 0x7F, 0xCF, 0x00, 0xF3, 0xFE,
  0x78, 0x07, 0x9F, 0xF1, 0xE0, 0x3C, 0xFF, 0x8F, 0x03, 0xC7, 0xFC, 0x78,
  0x1E, 0x3F, 0xE1, 0xC0, 0xF1, 0xFF, 0x0F, 0x0F, 0x0F, 0xF8, 0x78, 0x78,
  0x7F, 0xC1, 0xC3, 0xC3, 0xFE, 0x0F, 0x3C, 0x1F, 0xF0, 0x79, 0xE0, 0xFF,
  0x81, 0xCF, 0x07, 0xFC, 0x0F, 0x70, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x01,
  0xFC, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0x7E, 0x03, 0xFE, 0x01, 0xF0,
  0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xC0, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xDE, 0x00,
  0xFF, 0x78, 0x03, 0xFC, 0xF0, 0x0F, 0xF3, 0xE0, 0x3F, 0xC7, 0x80, 0xFF,
  0x1F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x03,
  0xC3, 0xFC, 0x0F, 0x0F, 0xF0, 0x1E, 0x3F, 0xC0, 0x78, 0xFF, 0x00, 0xF3,
  0xFC, 0x03, 0xCF, 0xF0, 0x07, 0xBF, 0xC0, 0x1E, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x1F,
  0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x3E, 0x78, 0x00,
  0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xC3,
  0xE0, 0x0F, 0x87, 0xE0, 0x7E, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7C, 0x78,
  0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0,
  0x0F, 0x9E, 0x01, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0x80, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xE0, 0x3E, 0x1E, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00,
  0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x1F, 0x01, 0xF8, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0x1E, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xF8, 0x01, 0xF0,
  0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x01, 0xF7, 0x80, 0x3E,
  0x00, 0xF3, 0xC0, 0x1F, 0x80, 0x79, 0xE0, 0x1F, 0xC0, 0x3C, 0xF0, 0x0F,
  0xE0, 0x1E, 0x7C, 0x07, 0x70, 0x1F, 0x1E, 0x03, 0xB8, 0x0F, 0x0F, 0x03,
  0xDE, 0x07, 0x87, 0x81, 0xEF, 0x03, 0xC3, 0xC0, 0xE3, 0x81, 0xE1, 0xE0,
  0x71, 0xC0, 0xF0, 0x78, 0x78, 0xF0, 0xF0, 0x3C, 0x3C, 0x78, 0x78, 0x1E,
  0x1E, 0x1C, 0x3C, 0x0F, 0x0E, 0x0E, 0x1E, 0x07, 0x87, 0x07, 0x8F, 0x01,
  0xE7, 0x83, 0xCF, 0x00, 0xF3, 0xC0, 0xE7, 0x80, 0x79, 0xC0, 0x73, 0xC0,
  0x3C, 0xE0, 0x39, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x07, 0x78, 0x0F, 0x70,
  0x03, 0xB8, 0x03, 0xB8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x87, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x07, 0x80, 0x3C,
  0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3E, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF9, 0xE0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0x78,
  0x1C, 0xE0, 0xF3, 0xC3, 0x8F, 0x0E, 0x1C, 0x78, 0x79, 0xE1, 0xEF, 0x03,
  0xBC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3F, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xFB, 0xF0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFD, 0xFF, 0xFE, 0xFF,
  0xEF, 0x3F, 0xE7, 0x87, 0xC3, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0xE0, 0x79, 0xFF, 0x0F, 0x7F,
  0xF1, 0xFF, 0xFF, 0x3F, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3D, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xE0, 0x7C, 0xFF, 0xFF,
  0x9E, 0xFF, 0xE3, 0xCF, 0xF8, 0x78, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x07, 0xDF, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x1D, 0xE0, 0x0F, 0x7C, 0x03, 0xCF, 0x81, 0xF3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xCF, 0x87, 0xFD, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x81, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xEF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x00, 0xF9, 0xF0, 0x3F, 0x3F,
  0xFF, 0xE3, 0xFF, 0xBC, 0x3F, 0xE7, 0x81, 0xF8, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0x78, 0xF8, 0x0F, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x18, 0x7C,
  0x07, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xF1,
  0xE1, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF3, 0xE0, 0x7E, 0xF8, 0x07,
  0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x3E,
  0x7C, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFB, 0xE0, 0x7E, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x84, 0x01, 0xF1,
  0xE0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x3E, 0x1E,
  0x7F, 0xCF, 0x7F, 0xF7, 0xFF, 0xFB, 0xF8, 0x3D, 0xF0, 0x1F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x07, 0x83, 0xE1, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x7F, 0xBF, 0x9F, 0xCF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFB, 0xC0, 0x7C, 0xF0, 0x3E, 0x3C,
  0x0F, 0x8F, 0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x3E,
  0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFD, 0xE0, 0x3E, 0x7C, 0x0F, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0x7C, 0x3C,
  0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00,
  0xFB, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF1, 0xF8, 0x0F, 0xC3, 0xDF, 0xF8, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0xE0, 0xFB, 0xE0, 0x3F, 0x01,
  0xFF, 0x00, 0x7C, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00,
  0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0xF8, 0x79, 0xFF, 0x3D, 0xFF, 0xDF, 0xFF,
  0xEF, 0xE0, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3E, 0x07,
  0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0xF1, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3,
  0xFF, 0xFE, 0xFC, 0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xEF, 0xFF, 0xFB, 0xDF, 0xFC, 0xF3,
  0xFE, 0x3C, 0x7E, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF3,
  0xE0, 0x7E, 0xF8, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC,
  0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFB, 0xE0, 0x7E, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3C, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xEF, 0x80, 0x7F, 0xE0,
  0x1F, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0x1F, 0xF7, 0x87, 0xE3, 0xC0, 0xF0, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0,
  0x3C, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x1C, 0xF0, 0x07, 0xBC, 0x01, 0xEE, 0x00,
  0x7B, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x7B, 0xC0, 0x3C,
  0x03, 0xDE, 0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x0F,
  0x3C, 0x0F, 0xE0, 0x78, 0xF0, 0x7F, 0x03, 0x87, 0x83, 0xB8, 0x3C, 0x3C,
  0x1D, 0xC1, 0xE1, 0xE1, 0xEF, 0x0F, 0x07, 0x8F, 0x78, 0x70, 0x3C, 0x71,
  0xC7, 0x81, 0xE3, 0x8E, 0x3C, 0x0F, 0x3C, 0x79, 0xE0, 0x39, 0xE3, 0xCF,
  0x01, 0xEE, 0x0E, 0x70, 0x0F, 0x70, 0x77, 0x80, 0x7F, 0x83, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x1E,
  0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x7D, 0xF0,
  0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xE1,
  0xE0, 0x3C, 0x7C, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xFE, 0x01, 0xF7,
  0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1F, 0x1E,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0xB8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x0E, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xE0, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x04, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x73, 0xFF, 0x01, 0xDF, 0xFE,
  0x0F, 0x78, 0xFC, 0x3F, 0xC1, 0xFF, 0xEF, 0x03, 0xFF, 0xBC, 0x03, 0xFC,
  0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 34, 12, 4, -34 },
  { 18, 10, 12, 15, 3, -36 },
  { 33, 22, 34, 26, 3, -34 },
  { 127, 18, 43, 24, 3, -39 },
  { 224, 25, 34, 30, 3, -34 },
  { 331, 24, 34, 26, 2, -34 },
  { 433, 4, 11, 8, 2, -36 },
  { 439, 11, 50, 15, 3, -39 },
  { 508, 11, 50, 15, 1, -39 },
  { 577, 19, 20, 21, 1, -34 },
  { 625, 20, 25, 24, 2, -28 },
  { 688, 6, 12, 9, 1, -5 },
  { 697, 10, 4, 12, 1, -17 },
  { 702, 6, 5, 13, 3, -5 },
  { 706, 15, 37, 18, 1, -34 },
  { 776, 18, 34, 24, 3, -34 },
  { 853, 11, 34, 24, 4, -34 },
  { 900, 20, 34, 24, 2, -34 },
  { 985, 19, 34, 24, 2, -34 },
  { 1066, 21, 34, 24, 1, -34 },
  { 1156, 19, 34, 24, 3, -34 },
  { 1237, 18, 34, 24, 3, -34 },
  { 1314, 20, 34, 24, 2, -34 },
  { 1399, 18, 34, 24, 3, -34 },
  { 1476, 19, 34, 24, 2, -34 },
  { 1557, 6, 26, 11, 3, -26 },
  { 1577, 7, 33, 10, 1, -26 },
  { 1606, 16, 21, 21, 2, -26 },
  { 1648, 17, 14, 23, 3, -23 },
  { 1678, 17, 21, 22, 3, -26 },
  { 1723, 16, 34, 20, 2, -34 },
  { 1791, 32, 45, 37, 3, -34 },
  { 1971, 26, 34, 28, 1, -34 },
  { 2082, 19, 34, 26, 4, -34 },
  { 2163, 22, 34, 27, 3, -34 },
  { 2257, 20, 34, 27, 4, -34 },
  { 2342, 18, 34, 24, 4, -34 },
  { 2419, 17, 34, 23, 4, -34 },
  { 2492, 22, 34, 28, 3, -34 },
  { 2586, 22, 34, 30, 4, -34 },
  { 2680, 4, 34, 12, 4, -34 },
  { 2697, 19, 34, 23, 1, -34 },
  { 2778, 22, 34, 26, 4, -34 },
  { 2872, 17, 34, 23, 4, -34 },
  { 2945, 29, 34, 36, 4, -34 },
  { 3069, 22, 34, 30, 4, -34 },
  { 3163, 23, 34, 29, 3, -34 },
  { 3261, 21, 34, 27, 4, -34 },
  { 3351, 23, 40, 29, 3, -34 },
  { 3466, 21, 34, 25, 4, -34 },
  { 3556, 21, 34, 25, 2, -34 },
  { 3646, 23, 34, 25, 1, -34 },
  { 3744, 21, 34, 27, 3, -34 },
  { 3834, 25, 34, 27, 1, -34 },
  { 3941, 33, 34, 37, 2, -34 },
  { 4082, 23, 34, 26, 2, -34 },
  { 4180, 23, 34, 25, 1, -34 },
  { 4278, 21, 34, 25, 2, -34 },
  { 4368, 8, 46, 12, 3, -39 },
  { 4414, 16, 37, 18, 1, -34 },
  { 4488, 8, 46, 12, 1, -39 },
  { 4534, 14, 17, 18, 2, -34 },
  { 4564, 18, 4, 19, 1, 0 },
  { 4573, 10, 7, 15, 1, -36 },
  { 4582, 17, 26, 23, 3, -26 },
  { 4638, 19, 36, 24, 3, -36 },
  { 4724, 18, 26, 22, 2, -26 },
  { 4783, 19, 36, 24, 2, -36 },
  { 4869, 19, 26, 23, 2, -26 },
  { 4931, 13, 36, 15, 2, -36 },
  { 4990, 19, 36, 24, 2, -26 },
  { 5076, 17, 36, 23, 3, -36 },
  { 5153, 5, 35, 11, 3, -35 },
  { 5175, 9, 45, 11, -1, -35 },
  { 5226, 18, 36, 22, 3, -36 },
  { 5307, 5, 36, 11, 3, -36 },
  { 5330, 30, 26, 36, 3, -26 },
  { 5428, 17, 26, 23, 3, -26 },
  { 5484, 20, 26, 24, 2, -26 },
  { 5549, 18, 36, 24, 3, -26 },
  { 5630, 19, 36, 24, 2, -26 },
  { 5716, 11, 26, 15, 3, -26 },
  { 5752, 18, 26, 22, 2, -26 },
  { 5811, 11, 32, 14, 1, -32 },
  { 5855, 17, 26, 23, 3, -26 },
  { 5911, 18, 26, 21, 1, -26 },
  { 5970, 29, 26, 31, 1, -26 },
  { 6065, 19, 26, 21, 1, -26 },
  { 6127, 18, 36, 20, 1, -26 },
  { 6208, 17, 26, 21, 2, -26 },
  { 6264, 12, 46, 15, 2, -37 },
  { 6333, 4, 40, 12, 4, -34 },
  { 6353, 12, 46, 15, 1, -37 },
  { 6422, 22, 9, 28, 3, -18 },
};

const GFXfont RobotoCondensed_Regular48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_REGULAR48PT7B_H_
