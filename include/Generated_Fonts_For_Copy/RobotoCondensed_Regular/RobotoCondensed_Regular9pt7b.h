#ifndef _ROBOTOCONDENSED_REGULAR9PT7B_H_
#define _ROBOTOCONDENSED_REGULAR9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xC0, 0x66, 0xFA, 0xEA, 0xC0, 0x26, 0x54, 0x61, 0x96, 0x20,
  0x45, 0x9C, 0x43, 0xAC, 0x60, 0x62, 0x98, 0xCA, 0xC9, 0xC0, 0xC0, 0x6A,
  0xAA, 0x40, 0x95, 0x55, 0x80, 0x4D, 0x6A, 0x22, 0xF2, 0x20, 0xC0, 0xC0,
  0x80, 0x24, 0xA4, 0xA4, 0x65, 0x99, 0x95, 0x60, 0xD5, 0x54, 0x69, 0x12,
  0x24, 0x70, 0x69, 0x12, 0x19, 0x60, 0x22, 0x55, 0xF1, 0x10, 0xF3, 0x93,
  0x70, 0x53, 0x5B, 0x70, 0xF1, 0x22, 0x24, 0x40, 0xD6, 0xEB, 0x70, 0x69,
  0x99, 0x71, 0x60, 0x88, 0x40, 0x60, 0x29, 0x10, 0xE0, 0x70, 0x89, 0x40,
  0x74, 0x94, 0x10, 0x38, 0x89, 0x6D, 0x5A, 0xB7, 0x90, 0x1C, 0x21, 0x14,
  0xA7, 0x26, 0x20, 0xF6, 0xFB, 0x78, 0xE9, 0x88, 0x89, 0xE0, 0xEA, 0x99,
  0x9A, 0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0xE9, 0x8B, 0x99, 0xE0,
  0x99, 0x9F, 0x99, 0x90, 0xFE, 0x11, 0x11, 0x19, 0x60, 0xAA, 0xCC, 0xCA,
  0x90, 0x92, 0x49, 0x38, 0x8C, 0x67, 0xBD, 0xD6, 0xA0, 0x99, 0xDD, 0xBB,
  0x90, 0xE9, 0x99, 0x99, 0xE0, 0xE9, 0x9E, 0x88, 0x80, 0xE9, 0x99, 0x99,
  0xE1, 0xEA, 0xAE, 0xAA, 0x90, 0x79, 0x46, 0x19, 0x70, 0xF2, 0x22, 0x22,
  0x20, 0x99, 0x99, 0x99, 0xE0, 0x8A, 0x54, 0xA5, 0x10, 0x80, 0x93, 0x29,
  0xD3, 0x66, 0xCD, 0x92, 0x00, 0x52, 0x98, 0x45, 0x29, 0x40, 0x92, 0x94,
  0x42, 0x10, 0x80, 0xF1, 0x22, 0x44, 0xF0, 0xFF, 0x89, 0x24, 0x49, 0xD5,
  0x57, 0x4A, 0x80, 0xF0, 0x90, 0x61, 0x79, 0x70, 0x93, 0xDB, 0x78, 0x69,
  0x89, 0x60, 0x11, 0x79, 0x99, 0x70, 0x69, 0xF8, 0x70, 0x6B, 0xA4, 0x90,
  0x79, 0x99, 0x71, 0x60, 0x93, 0x5B, 0x68, 0x3E, 0x3F, 0x80, 0x93, 0x6D,
  0xA8, 0xFE, 0xDD, 0x6B, 0x5A, 0x80, 0xD6, 0xDA, 0x69, 0x99, 0x60, 0xF6,
  0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x68, 0x69, 0x60, 0x75,
  0x50, 0xB6, 0xDE, 0x9A, 0x66, 0x40, 0xA6, 0xE7, 0x96, 0x48, 0xA6, 0x46,
  0x90, 0x9A, 0x66, 0x44, 0xC0, 0xF2, 0x44, 0xF0, 0x29, 0x28, 0x92, 0x20,
  0xFF, 0x95, 0x55, 0x80, 0xDA,
};

const GFXglyph RobotoCondensed_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 1, 2, 3, 1, -7 },
  { 3, 4, 7, 5, 1, -7 },
  { 7, 4, 9, 4, 0, -8 },
  { 12, 5, 7, 6, 0, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 0, -7 },
  { 23, 2, 9, 3, 1, -7 },
  { 26, 2, 9, 3, 0, -7 },
  { 29, 4, 4, 4, 0, -7 },
  { 31, 4, 5, 4, 0, -6 },
  { 34, 1, 2, 2, 0, -1 },
  { 35, 2, 1, 2, 0, -3 },
  { 36, 1, 1, 2, 1, -1 },
  { 37, 3, 8, 3, 0, -7 },
  { 40, 4, 7, 4, 0, -7 },
  { 44, 2, 7, 4, 1, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 3, 7, 4, 1, -7 },
  { 61, 3, 7, 4, 1, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 3, 7, 4, 1, -7 },
  { 71, 4, 7, 4, 0, -7 },
  { 75, 1, 5, 2, 1, -5 },
  { 76, 2, 6, 2, 0, -5 },
  { 78, 3, 4, 4, 0, -5 },
  { 80, 3, 4, 4, 1, -5 },
  { 82, 3, 4, 4, 1, -5 },
  { 84, 3, 7, 4, 0, -7 },
  { 87, 7, 8, 7, 0, -6 },
  { 94, 5, 7, 5, 0, -7 },
  { 99, 3, 7, 5, 1, -7 },
  { 102, 4, 7, 5, 1, -7 },
  { 106, 4, 7, 5, 1, -7 },
  { 110, 3, 7, 4, 1, -7 },
  { 113, 3, 7, 4, 1, -7 },
  { 116, 4, 7, 5, 1, -7 },
  { 120, 4, 7, 6, 1, -7 },
  { 124, 1, 7, 2, 1, -7 },
  { 125, 4, 7, 4, 0, -7 },
  { 129, 4, 7, 5, 1, -7 },
  { 133, 3, 7, 4, 1, -7 },
  { 136, 5, 7, 7, 1, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 4, 7, 5, 1, -7 },
  { 149, 4, 7, 5, 1, -7 },
  { 153, 4, 8, 5, 1, -7 },
  { 157, 4, 7, 5, 1, -7 },
  { 161, 4, 7, 5, 0, -7 },
  { 165, 4, 7, 5, 0, -7 },
  { 169, 4, 7, 5, 1, -7 },
  { 173, 5, 7, 5, 0, -7 },
  { 178, 7, 7, 7, 0, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 4, 7, 5, 0, -7 },
  { 199, 1, 8, 2, 1, -7 },
  { 200, 3, 8, 3, 0, -7 },
  { 203, 2, 8, 2, 0, -7 },
  { 205, 3, 3, 3, 0, -7 },
  { 207, 4, 1, 4, 0, 0 },
  { 208, 2, 2, 3, 0, -7 },
  { 209, 4, 5, 4, 0, -5 },
  { 212, 3, 7, 4, 1, -7 },
  { 215, 4, 5, 4, 0, -5 },
  { 218, 4, 7, 4, 0, -7 },
  { 222, 4, 5, 4, 0, -5 },
  { 225, 3, 7, 3, 0, -7 },
  { 228, 4, 7, 4, 0, -5 },
  { 232, 3, 7, 4, 1, -7 },
  { 235, 1, 7, 2, 1, -7 },
  { 236, 1, 9, 2, 0, -7 },
  { 238, 3, 7, 4, 1, -7 },
  { 241, 1, 7, 2, 1, -7 },
  { 242, 5, 5, 7, 1, -5 },
  { 246, 3, 5, 4, 1, -5 },
  { 248, 4, 5, 5, 0, -5 },
  { 251, 3, 7, 4, 1, -5 },
  { 254, 4, 7, 5, 0, -5 },
  { 258, 2, 5, 3, 1, -5 },
  { 260, 4, 5, 4, 0, -5 },
  { 263, 2, 6, 3, 0, -6 },
  { 265, 3, 5, 4, 1, -5 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 6, 5, 6, 0, -5 },
  { 274, 4, 5, 4, 0, -5 },
  { 277, 4, 7, 4, 0, -5 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 3, 9, 3, 0, -7 },
  { 288, 1, 8, 2, 1, -7 },
  { 289, 2, 9, 3, 0, -7 },
  { 292, 4, 2, 5, 1, -4 },
};

const GFXfont RobotoCondensed_Regular9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_REGULAR9PT7B_H_
