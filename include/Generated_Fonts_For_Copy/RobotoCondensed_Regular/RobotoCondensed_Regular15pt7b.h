#ifndef _ROBOTOCONDENSED_REGULAR15PT7B_H_
#define _ROBOTOCONDENSED_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xA8, 0x3C, 0xB6, 0xD0, 0x14, 0x48, 0x97, 0xF2, 0x85, 0x0A,
  0x7E, 0x48, 0x91, 0x40, 0x20, 0x87, 0xB2, 0x8B, 0x04, 0x1C, 0x18, 0x38,
  0xF2, 0x70, 0x80, 0xE0, 0xA4, 0x94, 0xA8, 0xE8, 0x10, 0x16, 0x29, 0x29,
  0x49, 0x06, 0x70, 0x93, 0x22, 0xC7, 0x0C, 0x35, 0x4E, 0x8D, 0x99, 0xD8,
  0xF0, 0x25, 0x2D, 0x24, 0x93, 0x24, 0x48, 0x84, 0x62, 0x23, 0x33, 0x33,
  0x22, 0x24, 0x80, 0x10, 0x4F, 0xCC, 0x29, 0x20, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x00, 0x56, 0xE0, 0xB0, 0x08, 0x44, 0x21, 0x10, 0x84, 0x42, 0x11,
  0x00, 0x73, 0x28, 0xA3, 0x8E, 0x38, 0xE3, 0x8B, 0x27, 0x00, 0x3F, 0xB3,
  0x33, 0x33, 0x33, 0x30, 0x73, 0x28, 0x82, 0x08, 0x63, 0x08, 0x43, 0x0F,
  0xC0, 0x76, 0x62, 0x11, 0x98, 0x21, 0x8E, 0x5C, 0x0C, 0x18, 0x71, 0xE2,
  0xCD, 0x93, 0x7F, 0x0C, 0x18, 0x30, 0x79, 0x04, 0x10, 0xFB, 0x20, 0xC3,
  0x8F, 0x27, 0x80, 0x31, 0x84, 0x20, 0xBB, 0x28, 0xE3, 0x8D, 0x27, 0x00,
  0xFC, 0x20, 0x82, 0x10, 0x43, 0x08, 0x21, 0x84, 0x00, 0x73, 0x28, 0xA2,
  0xC9, 0xCC, 0xA3, 0x8F, 0x27, 0x00, 0x76, 0xE3, 0x18, 0xED, 0xE1, 0x08,
  0x98, 0xB0, 0x0B, 0x48, 0x00, 0x12, 0x58, 0x09, 0xF9, 0x0E, 0x1C, 0x20,
  0xF8, 0x01, 0xF0, 0x87, 0x0C, 0x13, 0x72, 0x00, 0x74, 0xA6, 0x31, 0x19,
  0x8C, 0x00, 0x18, 0x1E, 0x08, 0x44, 0x0A, 0x39, 0x92, 0x64, 0x99, 0x26,
  0xC9, 0x96, 0xA6, 0xE4, 0x01, 0x80, 0x3E, 0x00, 0x08, 0x18, 0x1C, 0x14,
  0x34, 0x26, 0x22, 0x7E, 0x43, 0x41, 0xC1, 0xFB, 0x3C, 0x71, 0xCF, 0xEC,
  0x71, 0xC7, 0x3F, 0x80, 0x38, 0x8B, 0x1C, 0x38, 0x10, 0x20, 0x43, 0xC6,
  0x88, 0xE0, 0xF9, 0x9B, 0x16, 0x3C, 0x78, 0xF1, 0xE3, 0xC5, 0x9B, 0xE0,
  0xFF, 0x0C, 0x30, 0xC3, 0xEC, 0x30, 0xC3, 0x0F, 0xC0, 0xFF, 0x0C, 0x30,
  0xC3, 0xEC, 0x30, 0xC3, 0x0C, 0x00, 0x3C, 0x8B, 0x1C, 0x08, 0x10, 0x23,
  0xC3, 0xC6, 0x8C, 0xF0, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0xE1, 0xC3,
  0x87, 0x08, 0xFF, 0xFF, 0xFC, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xC5,
  0x33, 0x80, 0xC7, 0x9B, 0x26, 0x8F, 0x1E, 0x34, 0x6C, 0xCD, 0x8B, 0x18,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xC1, 0xE0, 0xF8,
  0x74, 0x7A, 0x2D, 0x96, 0x5B, 0x29, 0x9C, 0xC6, 0x62, 0x20, 0xC3, 0x87,
  0x8F, 0x1F, 0x3A, 0x72, 0xE5, 0xC7, 0x8F, 0x08, 0x38, 0x8B, 0x1C, 0x18,
  0x30, 0x60, 0xC1, 0xC6, 0x88, 0xE0, 0xF9, 0x8B, 0x1E, 0x3C, 0x78, 0xBE,
  0x60, 0xC1, 0x83, 0x00, 0x38, 0x8B, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC6,
  0x88, 0xF0, 0x30, 0x20, 0xF9, 0x9B, 0x16, 0x2C, 0x59, 0xBE, 0x64, 0xCD,
  0x8B, 0x18, 0x7B, 0x38, 0x60, 0xC0, 0xE0, 0xC1, 0x87, 0x37, 0x80, 0xFE,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x85, 0x89, 0xE0, 0xC1, 0x43, 0x42, 0x62, 0x26,
  0x24, 0x34, 0x14, 0x1C, 0x18, 0x18, 0x88, 0x63, 0x38, 0xCE, 0x72, 0xD4,
  0x95, 0xA5, 0x29, 0x4E, 0x63, 0x18, 0xC2, 0x10, 0x42, 0x66, 0x24, 0x3C,
  0x18, 0x18, 0x18, 0x34, 0x26, 0x66, 0x43, 0xC2, 0x42, 0x66, 0x24, 0x3C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x30, 0x86, 0x10, 0xC2, 0x10,
  0xC2, 0x0F, 0xC0, 0xEA, 0xAA, 0xAA, 0xB0, 0x42, 0x10, 0xC2, 0x10, 0xC2,
  0x10, 0xC2, 0x10, 0xED, 0xB6, 0xDB, 0x6D, 0xB7, 0xC0, 0x21, 0x9C, 0xA4,
  0x80, 0xFC, 0x44, 0x76, 0x42, 0xFC, 0xC6, 0x6D, 0x82, 0x08, 0x20, 0xBB,
  0x28, 0xE3, 0x8E, 0x3C, 0xAE, 0x76, 0x63, 0x08, 0x47, 0x2E, 0x08, 0x42,
  0x17, 0xE6, 0x31, 0x8C, 0x72, 0xF0, 0x76, 0x63, 0xF8, 0x43, 0x2F, 0x74,
  0x44, 0xE4, 0x44, 0x44, 0x44, 0x7E, 0x63, 0x18, 0xC7, 0x2F, 0x0C, 0x5C,
  0x84, 0x21, 0x0B, 0xE6, 0x31, 0x8C, 0x63, 0x10, 0xDF, 0xE0, 0x51, 0x55,
  0x55, 0x70, 0x82, 0x08, 0x20, 0x9A, 0x4A, 0x38, 0xE2, 0x49, 0xA2, 0xFF,
  0xF0, 0xBB, 0xE6, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0xBE, 0x63,
  0x18, 0xC6, 0x31, 0x73, 0x28, 0xE1, 0x86, 0x3C, 0x9C, 0xBB, 0x28, 0xE3,
  0x8E, 0x3C, 0xAE, 0x82, 0x08, 0x00, 0x7E, 0x63, 0x18, 0xC7, 0x2F, 0x08,
  0x42, 0xBA, 0x49, 0x24, 0x74, 0xE1, 0xC3, 0xC6, 0x2E, 0x66, 0xF6, 0x66,
  0x66, 0x63, 0x8C, 0x63, 0x18, 0xC7, 0x6F, 0xC5, 0x34, 0x9A, 0x28, 0xC3,
  0x04, 0xCC, 0xA6, 0x53, 0x2B, 0xB7, 0x71, 0x98, 0xCC, 0x46, 0x4D, 0xA3,
  0x8C, 0x30, 0xA6, 0x93, 0xCD, 0x34, 0x9A, 0x38, 0xC3, 0x04, 0x30, 0x86,
  0x00, 0xF8, 0xCC, 0x46, 0x22, 0x1F, 0x2D, 0x24, 0xB4, 0xC9, 0x24, 0xC8,
  0xFF, 0xF8, 0xC4, 0x66, 0x62, 0x21, 0x22, 0x66, 0x64, 0xC0, 0x63, 0x2E,
  0x30,
};

const GFXglyph RobotoCondensed_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 3, 4, 5, 1, -11 },
  { 6, 7, 11, 8, 1, -11 },
  { 16, 6, 14, 7, 1, -13 },
  { 27, 8, 11, 10, 1, -11 },
  { 38, 7, 11, 8, 1, -11 },
  { 48, 1, 4, 3, 1, -11 },
  { 49, 3, 15, 5, 1, -12 },
  { 55, 4, 15, 5, 0, -12 },
  { 63, 6, 6, 6, 0, -11 },
  { 68, 6, 7, 7, 1, -8 },
  { 74, 2, 4, 3, 0, -2 },
  { 75, 3, 1, 4, 0, -5 },
  { 76, 2, 2, 4, 1, -2 },
  { 77, 5, 12, 6, 0, -11 },
  { 85, 6, 11, 7, 1, -11 },
  { 94, 4, 11, 7, 1, -11 },
  { 100, 6, 11, 7, 1, -11 },
  { 109, 5, 11, 7, 1, -11 },
  { 116, 7, 11, 7, 0, -11 },
  { 126, 6, 11, 7, 1, -11 },
  { 135, 6, 11, 7, 1, -11 },
  { 144, 6, 11, 7, 1, -11 },
  { 153, 6, 11, 7, 1, -11 },
  { 162, 5, 11, 7, 1, -11 },
  { 169, 2, 8, 4, 1, -8 },
  { 171, 3, 10, 3, 0, -8 },
  { 175, 5, 7, 7, 1, -8 },
  { 180, 5, 4, 7, 1, -7 },
  { 183, 5, 7, 7, 1, -8 },
  { 188, 5, 11, 6, 1, -11 },
  { 195, 10, 13, 12, 1, -10 },
  { 212, 8, 11, 9, 0, -11 },
  { 223, 6, 11, 8, 1, -11 },
  { 232, 7, 11, 9, 1, -11 },
  { 242, 7, 11, 9, 1, -11 },
  { 252, 6, 11, 7, 1, -11 },
  { 261, 6, 11, 7, 1, -11 },
  { 270, 7, 11, 9, 1, -11 },
  { 280, 7, 11, 9, 1, -11 },
  { 290, 2, 11, 4, 1, -11 },
  { 293, 6, 11, 7, 0, -11 },
  { 302, 7, 11, 8, 1, -11 },
  { 312, 6, 11, 7, 1, -11 },
  { 321, 9, 11, 11, 1, -11 },
  { 334, 7, 11, 9, 1, -11 },
  { 344, 7, 11, 9, 1, -11 },
  { 354, 7, 11, 8, 1, -11 },
  { 364, 7, 13, 9, 1, -11 },
  { 376, 7, 11, 8, 1, -11 },
  { 386, 6, 11, 8, 1, -11 },
  { 395, 7, 11, 8, 0, -11 },
  { 405, 7, 11, 8, 1, -11 },
  { 415, 8, 11, 8, 0, -11 },
  { 426, 10, 11, 11, 1, -11 },
  { 440, 8, 11, 8, 0, -11 },
  { 451, 8, 11, 8, 0, -11 },
  { 462, 6, 11, 8, 1, -11 },
  { 471, 2, 14, 4, 1, -12 },
  { 475, 5, 12, 6, 0, -11 },
  { 483, 3, 14, 4, 0, -12 },
  { 489, 5, 5, 6, 0, -11 },
  { 493, 6, 1, 6, 0, 0 },
  { 494, 3, 2, 5, 0, -11 },
  { 495, 5, 8, 7, 1, -8 },
  { 500, 6, 12, 7, 1, -12 },
  { 509, 5, 8, 7, 1, -8 },
  { 514, 5, 12, 7, 1, -12 },
  { 522, 5, 8, 7, 1, -8 },
  { 527, 4, 12, 5, 1, -12 },
  { 533, 5, 11, 7, 1, -8 },
  { 540, 5, 12, 7, 1, -12 },
  { 548, 1, 11, 3, 1, -11 },
  { 550, 2, 14, 3, 0, -11 },
  { 554, 6, 12, 7, 1, -12 },
  { 563, 1, 12, 3, 1, -12 },
  { 565, 9, 8, 11, 1, -8 },
  { 574, 5, 8, 7, 1, -8 },
  { 579, 6, 8, 8, 1, -8 },
  { 585, 6, 11, 7, 1, -8 },
  { 594, 5, 11, 8, 1, -8 },
  { 601, 3, 8, 5, 1, -8 },
  { 604, 5, 8, 7, 1, -8 },
  { 609, 4, 10, 4, 0, -10 },
  { 614, 5, 8, 7, 1, -8 },
  { 619, 6, 8, 6, 0, -8 },
  { 625, 9, 8, 10, 0, -8 },
  { 634, 6, 8, 7, 0, -8 },
  { 640, 6, 11, 6, 0, -8 },
  { 649, 5, 8, 7, 1, -8 },
  { 654, 3, 15, 5, 1, -12 },
  { 660, 1, 13, 4, 1, -11 },
  { 662, 4, 15, 5, 0, -12 },
  { 670, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_Regular15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_REGULAR15PT7B_H_
