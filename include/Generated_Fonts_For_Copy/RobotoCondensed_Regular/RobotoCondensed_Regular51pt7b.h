#ifndef _ROBOTOCONDENSED_REGULAR51PT7B_H_
#define _ROBOTOCONDENSED_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xE0,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xBC, 0x77, 0x8E, 0xE1,
  0xDC, 0x3B, 0x87, 0x70, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00,
  0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00,
  0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x00,
  0xE0, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01,
  0xC1, 0xE0, 0x01, 0xC1, 0xE0, 0x01, 0xC1, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0x80, 0x07,
  0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x3E,
  0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0F, 0x01, 0x01,
  0xC0, 0xE0, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0x70,
  0x70, 0x1C, 0x0E, 0x1E, 0x03, 0x81, 0xC3, 0x80, 0x70, 0x38, 0xF0, 0x0F,
  0x0F, 0x1C, 0x00, 0xE1, 0xC7, 0x80, 0x1F, 0xF8, 0xE0, 0x01, 0xFE, 0x38,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x1F, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x71, 0xFF, 0x80, 0x1E, 0x78,
  0xF0, 0x03, 0x8E, 0x0F, 0x00, 0xE3, 0xC1, 0xE0, 0x1C, 0x78, 0x1C, 0x07,
  0x0F, 0x03, 0x80, 0xE1, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x0F, 0x07, 0x81,
  0xC1, 0xC0, 0x70, 0x78, 0x38, 0x0E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x0F, 0x80,
  0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x3C, 0x3E, 0xF8, 0x3C,
  0x7C, 0x7C, 0x3C, 0xF8, 0x3E, 0x3C, 0xF8, 0x3E, 0x3C, 0xF0, 0x1F, 0x3C,
  0xF0, 0x0F, 0xFC, 0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF8, 0xF0, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xF8, 0x7F, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0x3E, 0x07, 0xFC, 0x1F, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x06, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0x00,
  0x20, 0x40, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x60, 0xF0, 0x2F, 0xCF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF9,
  0xE0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x81, 0xC0, 0x70, 0x04,
  0x02, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF3, 0xE7, 0x82, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x27, 0xFF, 0xFF, 0xB8, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3C, 0xF8,
  0x07, 0x9F, 0x01, 0xF1, 0xF0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x3E,
  0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xC3, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E,
  0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x07,
  0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1,
  0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x9F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7E, 0x1F, 0x8F, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x9E, 0x01,
  0xF3, 0xF0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0xFC, 0x07, 0xBF, 0xF0,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0x07, 0xCF, 0xE0, 0x3E, 0xFC, 0x03,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x7C,
  0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC1, 0xF0, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0,
  0x3C, 0xF8, 0x0F, 0x8F, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0xBE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x3E, 0x01,
  0xF7, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFD, 0xF0, 0x3F, 0xBF, 0x0F, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC3, 0xFE, 0xF0, 0x3F, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF7, 0xDE, 0x08, 0x3E, 0x3E, 0x3F, 0x3E,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x78, 0xF8, 0x70, 0x20, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE1,
  0xFB, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x03, 0xE0, 0x1C, 0x38, 0x03,
  0xFE, 0x03, 0x8E, 0x01, 0xFF, 0xC0, 0xE7, 0x80, 0xF8, 0xF0, 0x39, 0xC0,
  0x3C, 0x1C, 0x0E, 0x70, 0x1E, 0x0F, 0x03, 0x9C, 0x07, 0x03, 0xC0, 0xEF,
  0x03, 0xC0, 0xF0, 0x1F, 0xC0, 0xF0, 0x3C, 0x07, 0xE0, 0x38, 0x0F, 0x01,
  0xF8, 0x1E, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0xE0, 0x1F, 0x81, 0xE0, 0x38,
  0x07, 0xE0, 0x78, 0x0E, 0x01, 0xF8, 0x1E, 0x03, 0x80, 0x7E, 0x07, 0x80,
  0xE0, 0x3B, 0x81, 0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x1E, 0x03, 0xB8, 0x1E,
  0x07, 0x80, 0xEF, 0x07, 0x81, 0xE0, 0x73, 0xC1, 0xE0, 0xF8, 0x1C, 0xF0,
  0x3C, 0x7F, 0x0E, 0x1C, 0x0F, 0xFB, 0xEF, 0x87, 0x01, 0xFC, 0x7F, 0xC1,
  0xE0, 0x3E, 0x0F, 0xE0, 0x38, 0x02, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x0F, 0xE0,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x7E, 0x78, 0x01, 0xFB, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03,
  0xEF, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xC0, 0x1F, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x1F,
  0x78, 0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB,
  0xC0, 0x07, 0xDE, 0x00, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x7C, 0x1F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xF0, 0x0F, 0xE3, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0x3C,
  0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xFB,
  0xC0, 0x07, 0xCF, 0x00, 0x3F, 0x3C, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0x81, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x7E, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0, 0x01,
  0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x3E,
  0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF8, 0x00, 0xF1, 0xF0,
  0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xEF, 0x00, 0x07, 0xFF, 0xDE, 0x00, 0x1F,
  0xFF, 0xBC, 0x00, 0x3D, 0xFF, 0x3C, 0x00, 0x7B, 0xFE, 0x78, 0x01, 0xF7,
  0xFC, 0xF0, 0x03, 0xCF, 0xF8, 0xF0, 0x07, 0x9F, 0xF1, 0xE0, 0x1F, 0x3F,
  0xE3, 0xC0, 0x3C, 0x7F, 0xC3, 0xC0, 0x78, 0xFF, 0x87, 0x81, 0xF1, 0xFF,
  0x0F, 0x03, 0xC3, 0xFE, 0x0F, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0x0F, 0xF8,
  0x3C, 0x3C, 0x1F, 0xF0, 0x3C, 0x78, 0x3F, 0xE0, 0x79, 0xF0, 0x7F, 0xC0,
  0xF3, 0xC0, 0xFF, 0x80, 0xF7, 0x81, 0xFF, 0x01, 0xEF, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x0F,
  0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0x1F, 0x00, 0xFF, 0x80, 0x3C,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xF7, 0x80, 0x1F, 0xF7, 0x80, 0x1F, 0xF3, 0xC0, 0x1F, 0xF3,
  0xE0, 0x1F, 0xF1, 0xE0, 0x1F, 0xF1, 0xF0, 0x1F, 0xF0, 0xF0, 0x1F, 0xF0,
  0xF8, 0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0,
  0x3E, 0x1F, 0xF0, 0x1E, 0x1F, 0xF0, 0x1F, 0x1F, 0xF0, 0x0F, 0x1F, 0xF0,
  0x0F, 0x9F, 0xF0, 0x07, 0x9F, 0xF0, 0x03, 0xDF, 0xF0, 0x03, 0xDF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0,
  0xFC, 0x01, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF0, 0x03, 0xFB, 0xC0, 0x03, 0xEF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC,
  0x1F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x3F,
  0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x07, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0x83, 0xF0, 0xF8, 0x03, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xE0, 0x0F, 0xCF, 0xE0, 0x7E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x1E,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x7C, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x00, 0x1E, 0xF8, 0x01, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x00, 0x3E, 0x78, 0x01, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x80,
  0x3C, 0x7C, 0x03, 0xF8, 0x03, 0xC7, 0xC0, 0x3F, 0x80, 0x3C, 0x7C, 0x03,
  0xFC, 0x07, 0xC3, 0xC0, 0x3B, 0xC0, 0x7C, 0x3C, 0x07, 0xBC, 0x07, 0x83,
  0xC0, 0x79, 0xC0, 0x78, 0x3E, 0x07, 0x9C, 0x07, 0x83, 0xE0, 0x79, 0xE0,
  0xF8, 0x1E, 0x0F, 0x1E, 0x0F, 0x81, 0xE0, 0xF1, 0xE0, 0xF0, 0x1E, 0x0F,
  0x0E, 0x0F, 0x01, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x0E, 0x0F, 0x0F, 0x00,
  0xF1, 0xE0, 0xF1, 0xF0, 0x0F, 0x1E, 0x07, 0x1E, 0x00, 0xF1, 0xE0, 0x71,
  0xE0, 0x0F, 0x1C, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x79, 0xE0, 0x07, 0xBC,
  0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x3B, 0xC0, 0x07, 0xB8, 0x03, 0xFC, 0x00,
  0x7B, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01,
  0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xB8, 0x0F, 0x78, 0x1E, 0xF0, 0x38, 0xE0, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x1F, 0xE0, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xE0, 0xF3, 0xE0, 0x1E, 0xF8, 0x03, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0xBF,
  0x07, 0xF3, 0xFF, 0xFE, 0x7F, 0xFB, 0xC7, 0xFE, 0x78, 0x3F, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0xFB, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xE0, 0x7C, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xE0,
  0x7C, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xF3, 0xFF, 0x0F, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xC3,
  0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x0F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF7, 0x80,
  0x1F, 0x7C, 0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x07, 0xE1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x3F,
  0x1F, 0x0F, 0xFD, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF0, 0x7F, 0x7C,
  0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFF, 0xF1, 0xFF,
  0xEF, 0x0F, 0xFC, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xC3, 0xC0, 0x3E, 0x7C, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x43, 0xE0,
  0x0C, 0x3F, 0x01, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xE8, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xFF, 0xFF, 0x3F, 0x07, 0xF7,
  0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xDF, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE1, 0x80, 0x3E, 0x1E, 0x07, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0xFB,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x7B, 0xFE,
  0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x07, 0x07,
  0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xDF, 0xEF,
  0xF7, 0xF3, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0xF8, 0x0F, 0x8F,
  0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0xBC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0xF0, 0x0F, 0x8F,
  0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xEF,
  0x80, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07,
  0xF0, 0xFB, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xFE, 0xFE, 0x0F, 0xF8, 0x3E, 0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x03, 0xE0,
  0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0xFC, 0x3E,
  0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E, 0x1F,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0xF0, 0xFC, 0x0F,
  0x3F, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8,
  0x03, 0xEF, 0xC0, 0x3E, 0xFE, 0x07, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xBF, 0xF0, 0xF8, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xF0, 0xFF, 0xCF, 0x1F,
  0xFE, 0xF3, 0xFF, 0xFF, 0x3F, 0x07, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x3F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xDF, 0x03,
  0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1E,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xDF, 0x01, 0xF7, 0xC1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFE, 0xF0,
  0x7E, 0x00, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xC0, 0x03,
  0xBC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x03,
  0x80, 0x3E, 0xF0, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x3E,
  0x01, 0xE7, 0xC0, 0x7C, 0x03, 0xC7, 0x81, 0xFC, 0x0F, 0x8F, 0x03, 0xF8,
  0x1E, 0x1E, 0x07, 0xF0, 0x3C, 0x3E, 0x0E, 0xF0, 0x78, 0x3C, 0x3D, 0xE1,
  0xF0, 0x78, 0x7B, 0xC3, 0xC0, 0xF0, 0xE3, 0x87, 0x81, 0xE3, 0xC7, 0x8F,
  0x01, 0xE7, 0x8F, 0x1E, 0x03, 0xCF, 0x1E, 0x78, 0x07, 0x9C, 0x1C, 0xF0,
  0x0F, 0x78, 0x3D, 0xE0, 0x1F, 0xF0, 0x7B, 0xC0, 0x1F, 0xE0, 0xF7, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x7C, 0x03, 0xF7, 0xC0, 0x3E,
  0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x8F,
  0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01,
  0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x0E, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x40, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0xC0, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x40, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xE0, 0x0F, 0x3F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0F, 0x7C, 0x7C,
  0x1E, 0x78, 0x3E, 0x3E, 0xF0, 0x1F, 0xFE, 0xF0, 0x0F, 0xFC, 0xF0, 0x07,
  0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 36, 13, 4, -36 },
  { 24, 11, 12, 16, 3, -38 },
  { 41, 24, 36, 28, 3, -36 },
  { 149, 19, 46, 25, 3, -41 },
  { 259, 27, 36, 32, 3, -36 },
  { 381, 24, 37, 28, 3, -36 },
  { 492, 3, 12, 9, 3, -38 },
  { 497, 12, 53, 16, 3, -41 },
  { 577, 12, 53, 16, 1, -41 },
  { 657, 20, 21, 22, 1, -36 },
  { 710, 21, 26, 25, 2, -30 },
  { 779, 7, 13, 10, 1, -5 },
  { 791, 10, 4, 13, 1, -18 },
  { 796, 5, 6, 13, 4, -6 },
  { 800, 16, 39, 19, 1, -36 },
  { 878, 19, 36, 25, 3, -36 },
  { 964, 12, 36, 25, 4, -36 },
  { 1018, 21, 36, 25, 2, -36 },
  { 1113, 20, 36, 25, 2, -36 },
  { 1203, 23, 36, 25, 1, -36 },
  { 1307, 19, 36, 25, 4, -36 },
  { 1393, 20, 36, 25, 3, -36 },
  { 1483, 21, 36, 25, 2, -36 },
  { 1578, 19, 36, 25, 3, -36 },
  { 1664, 19, 36, 25, 3, -36 },
  { 1750, 6, 28, 12, 3, -28 },
  { 1771, 8, 36, 10, 1, -28 },
  { 1807, 17, 22, 23, 2, -27 },
  { 1854, 17, 14, 24, 4, -24 },
  { 1884, 18, 22, 23, 3, -27 },
  { 1934, 17, 36, 22, 2, -36 },
  { 2011, 34, 47, 39, 3, -36 },
  { 2211, 27, 36, 29, 1, -36 },
  { 2333, 21, 36, 28, 4, -36 },
  { 2428, 24, 36, 29, 3, -36 },
  { 2536, 22, 36, 29, 4, -36 },
  { 2635, 19, 36, 25, 4, -36 },
  { 2721, 19, 36, 25, 4, -36 },
  { 2807, 24, 36, 30, 3, -36 },
  { 2915, 24, 36, 32, 4, -36 },
  { 3023, 5, 36, 13, 4, -36 },
  { 3046, 20, 36, 25, 1, -36 },
  { 3136, 24, 36, 28, 4, -36 },
  { 3244, 19, 36, 24, 4, -36 },
  { 3330, 31, 36, 39, 4, -36 },
  { 3470, 24, 36, 32, 4, -36 },
  { 3578, 25, 36, 31, 3, -36 },
  { 3691, 22, 36, 28, 4, -36 },
  { 3790, 25, 42, 31, 3, -36 },
  { 3922, 22, 36, 27, 4, -36 },
  { 4021, 22, 36, 26, 2, -36 },
  { 4120, 23, 36, 27, 2, -36 },
  { 4224, 23, 36, 29, 3, -36 },
  { 4328, 27, 36, 29, 1, -36 },
  { 4450, 36, 36, 39, 2, -36 },
  { 4612, 24, 36, 28, 2, -36 },
  { 4720, 25, 36, 27, 1, -36 },
  { 4833, 23, 36, 27, 2, -36 },
  { 4937, 9, 49, 13, 3, -41 },
  { 4993, 17, 39, 19, 1, -36 },
  { 5076, 8, 49, 13, 1, -41 },
  { 5125, 15, 18, 19, 2, -36 },
  { 5159, 19, 4, 21, 1, 0 },
  { 5169, 11, 7, 16, 1, -38 },
  { 5179, 19, 27, 24, 3, -27 },
  { 5244, 20, 38, 25, 3, -38 },
  { 5339, 20, 27, 24, 2, -27 },
  { 5407, 20, 38, 25, 2, -38 },
  { 5502, 20, 27, 24, 2, -27 },
  { 5570, 14, 39, 16, 2, -39 },
  { 5639, 20, 37, 25, 2, -27 },
  { 5732, 18, 38, 25, 3, -38 },
  { 5818, 5, 37, 12, 3, -37 },
  { 5842, 9, 47, 11, -1, -37 },
  { 5895, 20, 38, 23, 3, -38 },
  { 5990, 4, 38, 12, 4, -38 },
  { 6009, 32, 27, 38, 3, -27 },
  { 6117, 18, 27, 25, 3, -27 },
  { 6178, 21, 27, 26, 2, -27 },
  { 6249, 20, 37, 25, 3, -27 },
  { 6342, 20, 37, 26, 2, -27 },
  { 6435, 11, 27, 16, 3, -27 },
  { 6473, 19, 27, 23, 2, -27 },
  { 6538, 12, 34, 15, 1, -34 },
  { 6589, 18, 27, 25, 3, -27 },
  { 6650, 20, 27, 22, 1, -27 },
  { 6718, 31, 27, 33, 1, -27 },
  { 6823, 20, 27, 22, 1, -27 },
  { 6891, 19, 37, 21, 1, -27 },
  { 6979, 18, 27, 22, 2, -27 },
  { 7040, 13, 49, 16, 2, -40 },
  { 7120, 4, 43, 12, 4, -36 },
  { 7142, 13, 49, 16, 1, -40 },
  { 7222, 24, 10, 30, 3, -20 },
};

const GFXfont RobotoCondensed_Regular51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_REGULAR51PT7B_H_
