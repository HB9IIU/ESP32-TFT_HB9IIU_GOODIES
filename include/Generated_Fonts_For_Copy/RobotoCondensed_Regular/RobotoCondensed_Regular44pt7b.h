#ifndef _ROBOTOCONDENSED_REGULAR44PT7B_H_
#define _ROBOTOCONDENSED_REGULAR44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xBD, 0xC0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC6, 0xE3, 0x61, 0xB0, 0xC0, 0x00, 0xE1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x83, 0x87, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x03, 0x87, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x1E,
  0x07, 0x8F, 0x03, 0xE7, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x1F,
  0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE0, 0xE1, 0x80, 0xE0, 0xE3, 0x80, 0x60,
  0xE7, 0x00, 0x70, 0xE7, 0x00, 0x7F, 0xCE, 0x00, 0x3F, 0x8E, 0x00, 0x1F,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x31, 0xFC, 0x00,
  0x73, 0xFE, 0x00, 0xE3, 0x8E, 0x00, 0xE7, 0x07, 0x01, 0xC7, 0x07, 0x01,
  0xC7, 0x07, 0x03, 0x87, 0x07, 0x03, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x02, 0x03, 0x8E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xCF,
  0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80,
  0x3C, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x03, 0xDF, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0xF0, 0xF3, 0xC3, 0xC7, 0xCF, 0x8F, 0x1E, 0x1E, 0x3C, 0xF0, 0x3C, 0xE3,
  0xC0, 0xFB, 0x8F, 0x01, 0xFE, 0x3C, 0x03, 0xF8, 0xF0, 0x07, 0xC1, 0xE0,
  0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0x8F, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xF3,
  0xE0, 0x3F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x60, 0x3C,
  0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0,
  0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x06, 0x00, 0x80, 0x40, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x80,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x06, 0x0E, 0x0F, 0xE7, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xFC, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x73, 0xC0, 0x78, 0xF0, 0x78, 0x3C,
  0x18, 0x1C, 0x04, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xCF,
  0x3D, 0xE7, 0x9E, 0xF3, 0x84, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE7, 0xC3, 0xC0,
  0xF3, 0xC0, 0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0xDC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0x80,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x1C, 0x07, 0x8F, 0x03, 0xC7,
  0xE7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x60, 0x3C, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFB, 0xF8, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0xFC,
  0x7C, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xC7, 0xC7, 0xC1, 0xF3,
  0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xC7, 0xC7,
  0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0x78, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80,
  0x78, 0xF0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x7E, 0x07, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0x3C, 0x07, 0x9E, 0x07, 0xC7, 0xCF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x7E, 0x0F, 0x7F, 0x87, 0xFF, 0xE3, 0xF8, 0xF9, 0xF8,
  0x3E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1D, 0xE0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x07,
  0x87, 0xCF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7E, 0x7C, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x3E, 0x7C, 0x1F,
  0xF8, 0x0F, 0xF0, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1E, 0x7C, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xCF, 0xC7, 0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3C,
  0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x7C, 0x1F, 0x9F, 0x3F, 0xCF,
  0xFF, 0xE3, 0xFE, 0xF0, 0x7C, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3C, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xEF, 0xFF, 0xEE, 0x18, 0xF7, 0xCF, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0xF3, 0xCF,
  0x3D, 0xE7, 0x9C, 0xF1, 0x80, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F,
  0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xF0, 0x03, 0x80,
  0x04, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83,
  0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x70, 0x0F, 0x80, 0xC3, 0x80, 0x7F, 0x03, 0x8E, 0x03, 0xFE, 0x0E, 0x38,
  0x1E, 0x38, 0x19, 0xC0, 0xF0, 0xE0, 0x67, 0x03, 0x83, 0x81, 0x9C, 0x1E,
  0x0E, 0x07, 0x70, 0x70, 0x38, 0x1D, 0xC1, 0xC0, 0xE0, 0x77, 0x07, 0x03,
  0x81, 0xD8, 0x3C, 0x0E, 0x07, 0xE0, 0xF0, 0x38, 0x1F, 0x83, 0xC0, 0xE0,
  0x7E, 0x0E, 0x03, 0x81, 0xB8, 0x38, 0x1C, 0x06, 0x60, 0xF0, 0x70, 0x39,
  0xC3, 0xC1, 0xC0, 0xE7, 0x07, 0x0F, 0x87, 0x1C, 0x1E, 0x7E, 0x1C, 0x70,
  0x7F, 0xBF, 0xE1, 0xC0, 0xFC, 0x7F, 0x03, 0x81, 0xE0, 0xF8, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x60,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x80, 0x01,
  0xE7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xE0, 0x07, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xC0, 0xFE, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x1F, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7E, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83,
  0xF9, 0xFC, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xE3,
  0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x3F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F,
  0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xFB,
  0xC0, 0x3E, 0x78, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x7C, 0x03,
  0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x3E, 0x01, 0xF3, 0xF8, 0xFE, 0x1F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xBC, 0x07, 0xDF, 0x03, 0xC7, 0xE7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xC0, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0,
  0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00,
  0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF7,
  0x80, 0x3F, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01,
  0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xE0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFE, 0xF0, 0x03, 0xBF, 0xDE, 0x00, 0xF7, 0xF9, 0xC0, 0x1E, 0xFF, 0x38,
  0x03, 0x9F, 0xE7, 0x80, 0xF3, 0xFC, 0x70, 0x1E, 0x7F, 0x8E, 0x03, 0x8F,
  0xF1, 0xE0, 0xF1, 0xFE, 0x1C, 0x1E, 0x3F, 0xC3, 0x83, 0x87, 0xF8, 0x78,
  0xF0, 0xFF, 0x07, 0x1E, 0x1F, 0xE0, 0xE3, 0x83, 0xFC, 0x1E, 0x70, 0x7F,
  0x81, 0xDE, 0x0F, 0xF0, 0x3B, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7E,
  0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC,
  0x03, 0x80, 0x78, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0xE0, 0x0F,
  0xF7, 0x80, 0x7F, 0x9C, 0x03, 0xFC, 0xF0, 0x1F, 0xE3, 0x80, 0xFF, 0x1E,
  0x07, 0xF8, 0x70, 0x3F, 0xC3, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x78, 0x7F,
  0x81, 0xE3, 0xFC, 0x0F, 0x1F, 0xE0, 0x3C, 0xFF, 0x01, 0xE7, 0xF8, 0x07,
  0xBF, 0xC0, 0x3D, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x0F, 0x80, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x01, 0xFC, 0xF0, 0x03, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03,
  0xEF, 0x01, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0,
  0x0F, 0x1F, 0x80, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x40, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0x03, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x78, 0xF0, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0xC7, 0xC0, 0x7C, 0xF0, 0x07,
  0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x7D,
  0xF0, 0x0F, 0x1F, 0xCF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x79,
  0xE0, 0x1F, 0x3F, 0x8F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7,
  0x80, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x70, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70,
  0x00, 0x39, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E,
  0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x39, 0xC0, 0x3F, 0x01, 0xE7, 0x80, 0xFC, 0x07, 0x9E, 0x03, 0xF0, 0x1E,
  0x78, 0x1F, 0xE0, 0x79, 0xE0, 0x73, 0x81, 0xC3, 0x81, 0xCE, 0x07, 0x0F,
  0x07, 0x38, 0x3C, 0x3C, 0x1C, 0xE0, 0xF0, 0xF0, 0xF1, 0xC3, 0xC3, 0xC3,
  0x87, 0x0E, 0x07, 0x0E, 0x1C, 0x38, 0x1E, 0x38, 0x71, 0xE0, 0x79, 0xE1,
  0xE7, 0x81, 0xE7, 0x03, 0x9E, 0x07, 0x9C, 0x0E, 0x70, 0x0E, 0x70, 0x39,
  0xC0, 0x3B, 0xC0, 0xF7, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x07,
  0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xE1,
  0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xC0,
  0x7C, 0x0F, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x3C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00,
  0x3C, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0xFF,
  0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF,
  0xF8, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0x73, 0xC3, 0xC7, 0x0E, 0x1C, 0x38, 0x79,
  0xE0, 0xE7, 0x03, 0x9C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xC7, 0xC7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x01, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0xF3, 0xC0, 0x79,
  0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x9E, 0x07, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0x78, 0x3F, 0x1E, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0xFC, 0x1E, 0xFF, 0x8F, 0xFF, 0xE7, 0xF3,
  0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x81, 0xF7, 0xF3, 0xF3, 0xFF,
  0xF9, 0xCF, 0xF8, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0xC7, 0xE7, 0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xC7, 0xE7,
  0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC1, 0xF9, 0xE3, 0xFE, 0xF3, 0xFF, 0xF9, 0xF9,
  0xFD, 0xF0, 0x3E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0xF9, 0xF9, 0xFC, 0xFF,
  0xFE, 0x3F, 0xEF, 0x07, 0xC7, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xC7, 0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0x1F, 0x01, 0xC7, 0xE3,
  0xF3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0x81, 0xFC,
  0x1F, 0x80, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0xE7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0xE7, 0xF7, 0xC0, 0xFB,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xBC, 0x03, 0xDF, 0x03, 0xE7, 0xE7, 0xF3, 0xFF, 0xF8, 0xFF, 0xBC,
  0x1F, 0x9E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC6, 0x01,
  0xE3, 0xE3, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xE0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xC7, 0xBF, 0xCF, 0xFF, 0xDF, 0xCF, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0E, 0x0F,
  0xFF, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x04, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0xBE, 0xFE, 0xFC, 0xF8, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8,
  0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xF0, 0x3F, 0x1E, 0xFF,
  0x1F, 0xF3, 0xFF, 0xF7, 0xFF, 0x7E, 0x3F, 0xF7, 0xEF, 0x81, 0xF8, 0x3F,
  0xE0, 0x3E, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x78, 0x0F, 0xF0, 0x0E,
  0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8, 0x07, 0x00, 0xFF,
  0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0x70,
  0x0F, 0xF0, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8,
  0x07, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0x80,
  0x78, 0xE1, 0xF1, 0xEF, 0xF3, 0xFF, 0xF7, 0xF3, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0x80, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xDE,
  0x01, 0xE7, 0xC0, 0xF8, 0xFC, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0xE3, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9F, 0xCF, 0xCF, 0x81, 0xF7,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0xF0,
  0x0F, 0x78, 0x07, 0xBE, 0x07, 0xDF, 0x8F, 0xCF, 0xFF, 0xE7, 0xBF, 0xE3,
  0xCF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0xE7, 0x8F,
  0xFB, 0xCF, 0xFF, 0xEF, 0xE7, 0xF7, 0xC0, 0xFB, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0xDF,
  0x03, 0xEF, 0xE3, 0xF3, 0xFF, 0xF8, 0xFF, 0xBC, 0x1F, 0x9E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7E, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7E, 0x3E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE7, 0xF7, 0xFF,
  0xE7, 0xFD, 0xC3, 0xE3, 0x80, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x1C, 0x1C,
  0x0E, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x3D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xFC, 0x07, 0x80,
  0xF7, 0x01, 0xE0, 0x3D, 0xE0, 0x7C, 0x0F, 0x78, 0x1F, 0x03, 0x9E, 0x0F,
  0xC0, 0xE3, 0x83, 0xF8, 0x78, 0xF0, 0xFE, 0x1E, 0x3C, 0x7B, 0x87, 0x0F,
  0x1C, 0xE1, 0xC1, 0xC7, 0x3C, 0xF0, 0x71, 0xC7, 0x3C, 0x1E, 0xF1, 0xCE,
  0x07, 0xB8, 0x73, 0x80, 0xEE, 0x1E, 0xE0, 0x3B, 0x83, 0xF8, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x78, 0x0F, 0xBC,
  0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x0F, 0x1E, 0x07,
  0x87, 0x87, 0x83, 0xC3, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78,
  0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x40, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x07, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xC0, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x7E, 0x03, 0xC1, 0xF8, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x18, 0x00, 0x0F, 0x00,
  0x03, 0xF8, 0x07, 0x7F, 0xC0, 0x77, 0xFE, 0x07, 0xF0, 0xF0, 0xFE, 0x07,
  0xFE, 0xE0, 0x3F, 0xEE, 0x01, 0xFC, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 9, 11, 14, 3, -33 },
  { 34, 20, 31, 24, 3, -31 },
  { 112, 17, 40, 22, 2, -36 },
  { 197, 24, 31, 28, 2, -31 },
  { 290, 22, 31, 24, 2, -31 },
  { 376, 3, 10, 8, 2, -33 },
  { 380, 10, 45, 14, 3, -35 },
  { 437, 10, 45, 14, 1, -35 },
  { 494, 17, 18, 19, 1, -31 },
  { 533, 18, 23, 22, 2, -26 },
  { 585, 6, 11, 9, 1, -5 },
  { 594, 9, 3, 11, 1, -15 },
  { 598, 5, 5, 12, 3, -5 },
  { 602, 14, 34, 16, 1, -31 },
  { 662, 17, 31, 22, 2, -31 },
  { 728, 11, 31, 22, 3, -31 },
  { 771, 18, 31, 22, 2, -31 },
  { 841, 17, 31, 22, 2, -31 },
  { 907, 19, 31, 22, 1, -31 },
  { 981, 17, 31, 22, 3, -31 },
  { 1047, 17, 31, 22, 3, -31 },
  { 1113, 18, 31, 22, 2, -31 },
  { 1183, 16, 31, 22, 3, -31 },
  { 1245, 17, 31, 22, 2, -31 },
  { 1311, 5, 24, 10, 3, -24 },
  { 1326, 6, 30, 9, 1, -24 },
  { 1349, 14, 20, 20, 2, -24 },
  { 1384, 15, 11, 21, 3, -20 },
  { 1405, 15, 20, 20, 3, -24 },
  { 1443, 15, 31, 19, 2, -31 },
  { 1502, 30, 41, 34, 2, -31 },
  { 1656, 23, 31, 25, 1, -31 },
  { 1746, 18, 31, 24, 3, -31 },
  { 1816, 20, 31, 25, 3, -31 },
  { 1894, 19, 31, 25, 3, -31 },
  { 1968, 17, 31, 22, 3, -31 },
  { 2034, 17, 31, 21, 3, -31 },
  { 2100, 20, 31, 26, 3, -31 },
  { 2178, 21, 31, 27, 3, -31 },
  { 2260, 4, 31, 11, 4, -31 },
  { 2276, 17, 31, 21, 1, -31 },
  { 2342, 21, 31, 24, 3, -31 },
  { 2424, 17, 31, 21, 3, -31 },
  { 2490, 27, 31, 33, 3, -31 },
  { 2595, 21, 31, 27, 3, -31 },
  { 2677, 21, 31, 26, 3, -31 },
  { 2759, 20, 31, 24, 3, -31 },
  { 2837, 21, 36, 26, 3, -31 },
  { 2932, 20, 31, 23, 3, -31 },
  { 3010, 19, 31, 23, 2, -31 },
  { 3084, 21, 31, 23, 1, -31 },
  { 3166, 19, 31, 25, 3, -31 },
  { 3240, 23, 31, 25, 1, -31 },
  { 3330, 30, 31, 34, 2, -31 },
  { 3447, 22, 31, 24, 1, -31 },
  { 3533, 21, 31, 23, 1, -31 },
  { 3615, 19, 31, 23, 2, -31 },
  { 3689, 7, 43, 11, 3, -36 },
  { 3727, 15, 34, 16, 1, -31 },
  { 3791, 7, 43, 11, 1, -36 },
  { 3829, 14, 16, 16, 1, -31 },
  { 3857, 16, 3, 18, 1, 0 },
  { 3863, 9, 6, 14, 1, -33 },
  { 3870, 17, 23, 21, 2, -23 },
  { 3919, 17, 33, 22, 3, -33 },
  { 3990, 17, 23, 20, 2, -23 },
  { 4039, 17, 33, 22, 2, -33 },
  { 4110, 17, 23, 21, 2, -23 },
  { 4159, 13, 33, 14, 1, -33 },
  { 4213, 17, 32, 22, 2, -23 },
  { 4281, 15, 33, 21, 3, -33 },
  { 4343, 4, 32, 10, 3, -32 },
  { 4359, 8, 41, 10, -1, -32 },
  { 4400, 16, 33, 20, 3, -33 },
  { 4466, 4, 33, 10, 3, -33 },
  { 4483, 27, 23, 33, 3, -23 },
  { 4561, 15, 23, 21, 3, -23 },
  { 4605, 18, 23, 22, 2, -23 },
  { 4657, 17, 32, 22, 3, -23 },
  { 4725, 17, 32, 22, 2, -23 },
  { 4793, 9, 23, 13, 3, -23 },
  { 4819, 16, 23, 20, 2, -23 },
  { 4865, 11, 29, 13, 0, -29 },
  { 4905, 15, 23, 21, 3, -23 },
  { 4949, 17, 23, 19, 1, -23 },
  { 4998, 26, 23, 29, 1, -23 },
  { 5073, 17, 23, 19, 1, -23 },
  { 5122, 16, 32, 18, 1, -23 },
  { 5186, 16, 23, 19, 2, -23 },
  { 5232, 11, 42, 14, 2, -34 },
  { 5290, 3, 37, 11, 4, -31 },
  { 5304, 11, 42, 14, 1, -34 },
  { 5362, 20, 9, 26, 3, -18 },
};

const GFXfont RobotoCondensed_Regular44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_REGULAR44PT7B_H_
