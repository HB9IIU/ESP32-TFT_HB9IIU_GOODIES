#ifndef _ROBOTOCONDENSED_REGULAR16PT7B_H_
#define _ROBOTOCONDENSED_REGULAR16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xB6, 0xD0, 0x16, 0x28, 0x51, 0x27, 0xE4, 0x89,
  0x7F, 0x28, 0x91, 0x22, 0x40, 0x10, 0x47, 0x92, 0xCF, 0x1C, 0x1C, 0x18,
  0x38, 0x61, 0xCD, 0xE3, 0x00, 0x60, 0x90, 0x94, 0x94, 0x68, 0x08, 0x10,
  0x17, 0x25, 0x29, 0x45, 0x07, 0x70, 0x48, 0x48, 0x48, 0x78, 0x30, 0x70,
  0xDA, 0x8A, 0x8C, 0xCE, 0x7A, 0xF0, 0x12, 0x64, 0x4C, 0xC8, 0x88, 0xCC,
  0x44, 0x62, 0x10, 0x84, 0x62, 0x23, 0x11, 0x11, 0x13, 0x22, 0x64, 0x80,
  0x10, 0x23, 0x53, 0xE3, 0x8D, 0x11, 0x00, 0x30, 0xC3, 0x3F, 0x30, 0xC3,
  0x0C, 0x57, 0xF0, 0xF0, 0x08, 0x46, 0x21, 0x08, 0x84, 0x22, 0x10, 0x8C,
  0x00, 0x79, 0x2C, 0xE1, 0x86, 0x18, 0x61, 0x87, 0x34, 0x9E, 0x17, 0x91,
  0x11, 0x11, 0x11, 0x11, 0x7B, 0x38, 0xC3, 0x0C, 0x21, 0x8C, 0x21, 0x8C,
  0x3F, 0x7B, 0x28, 0xC3, 0x08, 0xE0, 0x83, 0x0E, 0x3C, 0x9C, 0x0C, 0x18,
  0x70, 0xA3, 0x44, 0x99, 0x22, 0xFE, 0x08, 0x10, 0x20, 0x7D, 0x04, 0x10,
  0x79, 0x30, 0x41, 0x07, 0x14, 0xDE, 0x39, 0x84, 0x30, 0xBB, 0x3C, 0x61,
  0x87, 0x14, 0xCE, 0xFC, 0x10, 0xC2, 0x08, 0x61, 0x0C, 0x30, 0x86, 0x10,
  0x7B, 0x2C, 0xF3, 0x49, 0xEC, 0xA1, 0x86, 0x3C, 0xDE, 0x73, 0x28, 0xE3,
  0x8E, 0x3C, 0xDF, 0x0C, 0x21, 0x9C, 0xF0, 0x03, 0xC0, 0x4C, 0x00, 0x03,
  0x6B, 0x00, 0x09, 0xF9, 0x0E, 0x1C, 0x20, 0xFC, 0x00, 0x3F, 0x83, 0x83,
  0x83, 0x3B, 0x88, 0x00, 0x76, 0xE2, 0x11, 0x88, 0xC4, 0x60, 0x08, 0xC0,
  0x1F, 0x06, 0x31, 0x01, 0x27, 0x28, 0xA5, 0x24, 0x64, 0x8C, 0x91, 0x92,
  0x52, 0x4A, 0x76, 0x60, 0x04, 0x00, 0x40, 0x07, 0x80, 0x08, 0x06, 0x07,
  0x02, 0x81, 0x61, 0x90, 0x88, 0x46, 0x7F, 0x30, 0x90, 0x58, 0x30, 0xFD,
  0x8B, 0x1E, 0x3C, 0xDF, 0x31, 0x63, 0xC7, 0x8F, 0x17, 0xC0, 0x3C, 0xCF,
  0x0E, 0x18, 0x10, 0x20, 0x40, 0xC3, 0x85, 0x99, 0xE0, 0xF9, 0x9B, 0x1E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x37, 0xC0, 0xFF, 0x0C, 0x30, 0xC3,
  0xFC, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0xC3,
  0x0C, 0x30, 0x3C, 0xCF, 0x0E, 0x08, 0x10, 0x23, 0xC1, 0xC3, 0x85, 0x99,
  0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0x89, 0xB1, 0xC0, 0xC6, 0xC4, 0xCC, 0xD8, 0xD0, 0xF0, 0xF0, 0xD8, 0xCC,
  0xC4, 0xC6, 0xC2, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0xC0, 0xF8, 0x3E, 0x1F, 0x85, 0xE1, 0x7C, 0xFD, 0x2F, 0x4B, 0xDE, 0xF3,
  0x3C, 0xCF, 0x33, 0xC3, 0xC3, 0xE3, 0xE3, 0xD3, 0xD3, 0xCB, 0xCB, 0xCF,
  0xC7, 0xC7, 0xC3, 0x3C, 0x66, 0xC2, 0xC3, 0x83, 0x83, 0x83, 0x83, 0xC3,
  0xC2, 0x66, 0x3C, 0xFD, 0x8F, 0x0E, 0x1C, 0x38, 0xFF, 0x60, 0xC1, 0x83,
  0x06, 0x00, 0x3C, 0x66, 0xC2, 0x82, 0x83, 0x83, 0x83, 0x83, 0x82, 0xC2,
  0x66, 0x3C, 0x06, 0x02, 0xF9, 0x8B, 0x1E, 0x3C, 0x79, 0xBE, 0x64, 0xCD,
  0x8B, 0x1E, 0x30, 0x79, 0x9A, 0x1C, 0x0C, 0x0E, 0x07, 0x02, 0x07, 0x0F,
  0x33, 0xC0, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x8F, 0x1B,
  0xE0, 0xC1, 0xA0, 0x98, 0xCC, 0x62, 0x21, 0x10, 0xD8, 0x28, 0x14, 0x0A,
  0x07, 0x01, 0x00, 0x8C, 0x71, 0x8A, 0x31, 0x67, 0x2C, 0xA4, 0xB5, 0x94,
  0xB2, 0x94, 0x53, 0x8E, 0x30, 0x86, 0x10, 0xC0, 0xC7, 0x8D, 0x33, 0x63,
  0x87, 0x0E, 0x14, 0x6C, 0x9B, 0x1C, 0x30, 0xC3, 0x42, 0x62, 0x26, 0x34,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x41, 0x82, 0x07, 0xF0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x38,
  0x41, 0x04, 0x18, 0x20, 0x83, 0x04, 0x10, 0x60, 0x82, 0x0C, 0xED, 0xB6,
  0xDB, 0x6D, 0xB6, 0xF8, 0x66, 0x6F, 0x99, 0xFC, 0x62, 0x7B, 0x28, 0xC3,
  0x7F, 0x38, 0xF3, 0x7C, 0x82, 0x08, 0x2E, 0xCE, 0x18, 0x61, 0x86, 0x1C,
  0xEE, 0x7B, 0x38, 0xE0, 0x82, 0x08, 0xF2, 0x78, 0x0C, 0x30, 0xDF, 0xCE,
  0x38, 0xE3, 0x8E, 0x3C, 0xDD, 0x7B, 0x28, 0xE3, 0xFE, 0x08, 0x33, 0x78,
  0x34, 0x4E, 0x44, 0x44, 0x44, 0x44, 0x77, 0x38, 0xE3, 0x8E, 0x38, 0xF3,
  0x7C, 0x3C, 0xDE, 0x82, 0x08, 0x2E, 0xCA, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0xB3, 0xFF, 0xFF, 0x48, 0x24, 0x92, 0x49, 0x24, 0xB0, 0x82, 0x08, 0x22,
  0x9A, 0xCA, 0x38, 0xD2, 0x68, 0xA3, 0xFF, 0xFF, 0xFF, 0xBB, 0xB3, 0x38,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x40, 0xBB, 0x28, 0xE3,
  0x8E, 0x38, 0xE3, 0x8C, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0xBB,
  0x38, 0x61, 0x86, 0x18, 0x73, 0xBA, 0x08, 0x20, 0x77, 0x38, 0xE3, 0x8E,
  0x38, 0xF3, 0x7C, 0x30, 0xC3, 0xBC, 0x88, 0x88, 0x88, 0x80, 0x73, 0x28,
  0xB0, 0x70, 0x68, 0xF2, 0x78, 0x66, 0xF6, 0x66, 0x66, 0x62, 0x30, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xF3, 0x7C, 0x45, 0x14, 0xDA, 0x28, 0xA3, 0x8C,
  0x10, 0x44, 0x53, 0x34, 0xC9, 0x3A, 0x6A, 0x8C, 0xA3, 0x30, 0xCC, 0x31,
  0x00, 0x44, 0xD8, 0xA1, 0xC1, 0x07, 0x0A, 0x36, 0x44, 0xC5, 0x14, 0xDA,
  0x28, 0xA3, 0x8C, 0x10, 0xC2, 0x18, 0xF8, 0xC4, 0x62, 0x31, 0x10, 0xF8,
  0x26, 0x44, 0x44, 0x48, 0x44, 0x44, 0x46, 0x20, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC6, 0x22, 0x22, 0x21, 0x22, 0x22, 0x26, 0xC0, 0x73, 0xB6, 0x38,
};

const GFXglyph RobotoCondensed_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 3, 4, 5, 1, -12 },
  { 6, 7, 12, 9, 1, -12 },
  { 17, 6, 15, 8, 1, -14 },
  { 29, 8, 12, 10, 1, -12 },
  { 41, 8, 12, 9, 1, -12 },
  { 53, 1, 4, 3, 1, -12 },
  { 54, 4, 17, 5, 1, -13 },
  { 63, 4, 17, 5, 0, -13 },
  { 72, 7, 7, 7, 0, -12 },
  { 79, 6, 8, 8, 1, -9 },
  { 85, 2, 4, 3, 0, -2 },
  { 86, 4, 1, 4, 0, -5 },
  { 87, 2, 2, 4, 1, -2 },
  { 88, 5, 13, 6, 0, -12 },
  { 97, 6, 12, 8, 1, -12 },
  { 106, 4, 12, 8, 1, -12 },
  { 112, 6, 12, 8, 1, -12 },
  { 121, 6, 12, 8, 1, -12 },
  { 130, 7, 12, 8, 0, -12 },
  { 141, 6, 12, 8, 1, -12 },
  { 150, 6, 12, 8, 1, -12 },
  { 159, 6, 12, 8, 1, -12 },
  { 168, 6, 12, 8, 1, -12 },
  { 177, 6, 12, 8, 1, -12 },
  { 186, 2, 9, 4, 1, -9 },
  { 189, 3, 11, 3, 0, -9 },
  { 194, 5, 7, 7, 1, -9 },
  { 199, 6, 4, 8, 1, -7 },
  { 202, 6, 7, 7, 1, -9 },
  { 208, 5, 12, 7, 1, -12 },
  { 216, 11, 15, 12, 1, -11 },
  { 237, 9, 12, 9, 0, -12 },
  { 251, 7, 12, 9, 1, -12 },
  { 262, 7, 12, 9, 1, -12 },
  { 273, 7, 12, 9, 1, -12 },
  { 284, 6, 12, 8, 1, -12 },
  { 293, 6, 12, 8, 1, -12 },
  { 302, 7, 12, 9, 1, -12 },
  { 313, 8, 12, 10, 1, -12 },
  { 325, 2, 12, 4, 1, -12 },
  { 328, 7, 12, 8, 0, -12 },
  { 339, 8, 12, 9, 1, -12 },
  { 351, 6, 12, 8, 1, -12 },
  { 360, 10, 12, 12, 1, -12 },
  { 375, 8, 12, 10, 1, -12 },
  { 387, 8, 12, 10, 1, -12 },
  { 399, 7, 12, 9, 1, -12 },
  { 410, 8, 14, 10, 1, -12 },
  { 424, 7, 12, 9, 1, -12 },
  { 435, 7, 12, 8, 1, -12 },
  { 446, 8, 12, 8, 0, -12 },
  { 458, 7, 12, 9, 1, -12 },
  { 469, 9, 12, 9, 0, -12 },
  { 483, 11, 12, 12, 1, -12 },
  { 500, 7, 12, 9, 1, -12 },
  { 511, 8, 12, 8, 0, -12 },
  { 523, 7, 12, 8, 1, -12 },
  { 534, 3, 15, 4, 1, -13 },
  { 540, 6, 13, 6, 0, -12 },
  { 550, 3, 15, 4, 0, -13 },
  { 556, 4, 6, 6, 1, -12 },
  { 559, 6, 1, 6, 0, 0 },
  { 560, 4, 2, 5, 0, -12 },
  { 561, 6, 9, 8, 1, -9 },
  { 568, 6, 12, 8, 1, -12 },
  { 577, 6, 9, 7, 1, -9 },
  { 584, 6, 12, 8, 1, -12 },
  { 593, 6, 9, 8, 1, -9 },
  { 600, 4, 12, 5, 1, -12 },
  { 606, 6, 12, 8, 1, -9 },
  { 615, 6, 12, 8, 1, -12 },
  { 624, 2, 12, 4, 1, -12 },
  { 627, 3, 15, 4, 0, -12 },
  { 633, 6, 12, 7, 1, -12 },
  { 642, 2, 12, 4, 1, -12 },
  { 645, 10, 9, 12, 1, -9 },
  { 657, 6, 9, 8, 1, -9 },
  { 664, 6, 9, 8, 1, -9 },
  { 671, 6, 12, 8, 1, -9 },
  { 680, 6, 12, 8, 1, -9 },
  { 689, 4, 9, 5, 1, -9 },
  { 694, 6, 9, 7, 1, -9 },
  { 701, 4, 11, 5, 0, -11 },
  { 707, 6, 9, 8, 1, -9 },
  { 714, 6, 9, 7, 0, -9 },
  { 721, 10, 9, 10, 0, -9 },
  { 733, 7, 9, 7, 0, -9 },
  { 741, 6, 12, 7, 0, -9 },
  { 750, 5, 9, 7, 1, -9 },
  { 756, 4, 15, 5, 1, -12 },
  { 764, 2, 14, 4, 1, -12 },
  { 768, 4, 15, 5, 0, -12 },
  { 776, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_Regular16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_REGULAR16PT7B_H_
