#ifndef _ROBOTOCONDENSED_REGULAR7PT7B_H_
#define _ROBOTOCONDENSED_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0xC0, 0x07, 0x6E, 0x20, 0x0E, 0xA2, 0xD0, 0xCE, 0x27, 0x30,
  0x66, 0x4A, 0x60, 0x80, 0x1A, 0xA4, 0x25, 0x58, 0x4A, 0x00, 0x5D, 0x20,
  0xC0, 0x00, 0x00, 0x16, 0x80, 0x76, 0xD6, 0xF8, 0x64, 0xAE, 0x65, 0x1E,
  0x2E, 0xF2, 0x68, 0x96, 0x73, 0xD6, 0xE4, 0xA4, 0x75, 0x56, 0x76, 0xB4,
  0x80, 0x98, 0x39, 0x00, 0xB0, 0x8D, 0x00, 0xC5, 0x24, 0x32, 0x6F, 0xBB,
  0xA0, 0x80, 0x46, 0x66, 0x90, 0xFF, 0xC0, 0x69, 0x89, 0x60, 0xD6, 0xDC,
  0xEE, 0xC0, 0xEE, 0x80, 0x68, 0x89, 0x70, 0x37, 0xDA, 0x78, 0x24, 0x9E,
  0x1A, 0x6A, 0x2A, 0xC0, 0x1B, 0xBB, 0xD0, 0x36, 0xFA, 0x69, 0x99, 0x60,
  0xD7, 0x48, 0x69, 0x99, 0x61, 0xD7, 0x6A, 0x71, 0x96, 0xE9, 0x24, 0x99,
  0x99, 0x60, 0x9A, 0x66, 0x40, 0xAD, 0x56, 0xA5, 0x00, 0x06, 0x46, 0x90,
  0x86, 0x44, 0x40, 0xE5, 0x2E, 0xEA, 0xA8, 0xA5, 0x40, 0xFE, 0x58, 0xE0,
  0x00, 0x66, 0xF0, 0x9E, 0xDE, 0x76, 0x30, 0x2E, 0xD6, 0x77, 0x30, 0x75,
  0x40, 0x76, 0xB6, 0x9E, 0xDA, 0x78, 0xFC, 0x97, 0x6A, 0xF8, 0xF5, 0x6B,
  0x50, 0xF6, 0xD0, 0x76, 0xB0, 0xF6, 0xF8, 0x76, 0xF2, 0xEA, 0x51, 0xF0,
  0x3A, 0x40, 0xB6, 0xF0, 0xB5, 0x20, 0xAB, 0x55, 0xA9, 0x50, 0xB5, 0x24,
  0x00, 0xE9, 0x70, 0x59, 0x50, 0x78, 0xA5, 0xA0, 0x5A,
};

const GFXglyph RobotoCondensed_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 1, 2, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 3, 0, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 1, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 1, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 2, 5, 3, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 1, 5, 3, 1, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 1, 4, 2, 0, -4 },
  { 49, 1, 5, 1, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 2, 2, 3, 1, -3 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 5, 3, 0, -5 },
  { 57, 5, 7, 5, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 2, 5, 4, 1, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 2, 5, 3, 1, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 1, 5, 2, 0, -5 },
  { 82, 3, 5, 3, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 2, 5, 3, 1, -5 },
  { 88, 4, 5, 5, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 4, 6, 4, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 3, 5, 4, 0, -5 },
  { 105, 3, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 5, 5, 5, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 3, 5, 4, 0, -5 },
  { 125, 2, 7, 2, 0, -6 },
  { 127, 2, 5, 3, 0, -5 },
  { 129, 1, 7, 2, 0, -6 },
  { 130, 2, 3, 3, 0, -5 },
  { 131, 3, 1, 3, 0, 0 },
  { 132, 2, 1, 2, 0, -5 },
  { 133, 3, 4, 3, 0, -4 },
  { 135, 3, 5, 3, 0, -5 },
  { 137, 3, 4, 3, 0, -4 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 3, 4, 3, 0, -4 },
  { 143, 2, 5, 2, 0, -5 },
  { 145, 3, 5, 3, 0, -4 },
  { 147, 3, 5, 3, 0, -5 },
  { 149, 1, 5, 2, 0, -5 },
  { 150, 1, 7, 2, 0, -5 },
  { 151, 3, 5, 3, 0, -5 },
  { 153, 1, 5, 2, 0, -5 },
  { 154, 5, 4, 5, 0, -4 },
  { 157, 3, 4, 3, 0, -4 },
  { 159, 3, 4, 4, 0, -4 },
  { 161, 3, 5, 3, 0, -4 },
  { 163, 3, 5, 4, 0, -4 },
  { 165, 2, 4, 2, 0, -4 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 2, 5, 2, 0, -5 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 4, 4, 5, 0, -4 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 3, 6, 3, 0, -4 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 2, 6, 2, 0, -5 },
  { 185, 1, 6, 2, 0, -5 },
  { 186, 2, 6, 2, 0, -5 },
  { 188, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Regular7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_REGULAR7PT7B_H_
