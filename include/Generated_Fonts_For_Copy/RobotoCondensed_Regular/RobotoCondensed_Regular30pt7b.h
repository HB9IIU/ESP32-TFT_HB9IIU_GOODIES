#ifndef _ROBOTOCONDENSED_REGULAR30PT7B_H_
#define _ROBOTOCONDENSED_REGULAR30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0xDB, 0x00, 0x3E, 0xC0, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06,
  0x30, 0x31, 0x87, 0xFF, 0xDF, 0xFF, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x06,
  0x30, 0x18, 0xC0, 0x63, 0x0F, 0xFF, 0xBF, 0xFE, 0x18, 0xC0, 0x46, 0x03,
  0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F,
  0x83, 0xF8, 0xF7, 0x98, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x38, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x0F,
  0xC1, 0xDE, 0xF3, 0xFE, 0x1F, 0x01, 0x80, 0x30, 0x06, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0xC6, 0x00, 0xC6, 0x18, 0x86, 0x30, 0x86, 0x30, 0xC6, 0x60,
  0xC6, 0xC0, 0xFC, 0xC0, 0x39, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x3C,
  0x06, 0x7E, 0x06, 0xE6, 0x0C, 0xC3, 0x0C, 0xC3, 0x18, 0xC3, 0x18, 0xC3,
  0x10, 0xE6, 0x00, 0x7E, 0x00, 0x3C, 0x1F, 0x00, 0xFE, 0x07, 0x9C, 0x1C,
  0x70, 0x70, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0x3F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x80, 0x77, 0x1B, 0x9C, 0x6C, 0x3B, 0xB0, 0x7E, 0xC1, 0xF3,
  0x03, 0xCE, 0x0F, 0x3C, 0x7C, 0x7F, 0xB8, 0x7C, 0x70, 0xFF, 0xF8, 0x04,
  0x1C, 0x30, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xE0, 0xC0,
  0xC1, 0xC1, 0x00, 0x81, 0x83, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x1C, 0x38,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C,
  0x18, 0x60, 0xC3, 0x06, 0x18, 0x20, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x8E, 0x27, 0xE7, 0x3F, 0xFC, 0x3E, 0x01, 0xF0, 0x1D, 0x80, 0xCE, 0x0E,
  0x38, 0x20, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x39, 0xCE, 0x67, 0x31, 0x80, 0xFF, 0xF0,
  0xFD, 0x80, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x1F, 0x07, 0xF1, 0xC7,
  0x70, 0x6E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1D, 0x83, 0x39, 0xE3,
  0xF8, 0x3E, 0x00, 0x02, 0x1D, 0xFF, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x0F,
  0x81, 0xFE, 0x0E, 0x78, 0xE0, 0xC6, 0x07, 0x70, 0x3B, 0x81, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x0F,
  0x83, 0xFC, 0x79, 0xE7, 0x0E, 0x60, 0x66, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x1C, 0x0F, 0x80, 0xFC, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0xE0,
  0x76, 0x07, 0x70, 0x67, 0x9E, 0x3F, 0xC0, 0xF8, 0x00, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE0, 0xC7,
  0x0E, 0x38, 0x61, 0xC7, 0x0E, 0x30, 0x73, 0x83, 0x9F, 0xFF, 0xFF, 0xF8,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3F, 0xE3, 0xFE, 0x7F,
  0xE7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x6F, 0x07, 0xFC, 0x7B,
  0xE2, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0xE0, 0x6E, 0x06, 0x60,
  0xE7, 0x9C, 0x3F, 0xC1, 0xF0, 0x07, 0x83, 0xF0, 0xF8, 0x1C, 0x07, 0x00,
  0xC0, 0x18, 0x07, 0x78, 0xFF, 0xDF, 0x3B, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1D, 0xC3, 0xBC, 0xE3, 0xF8, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x1F, 0x07, 0xF1,
  0xEF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xCE, 0x78, 0xFE,
  0x1F, 0xC7, 0x1D, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xB9,
  0xE7, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0xF1, 0xCE, 0x70, 0xEE, 0x0D, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0xF7, 0x3E, 0xFF, 0xCF,
  0xB8, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x07, 0xC3, 0xF0, 0x78, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x77, 0x76, 0xEC, 0x00, 0x40, 0x70, 0x3C, 0x3E, 0x3E, 0x3E, 0x0E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x38, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08, 0x00,
  0x1F, 0x1F, 0xE7, 0xBF, 0x87, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01,
  0xC0, 0x18, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x78, 0x66, 0x1F, 0xC6,
  0x61, 0x8C, 0x6C, 0x30, 0xC2, 0xC3, 0x0C, 0x3C, 0x70, 0xC3, 0xC6, 0x0C,
  0x3C, 0x61, 0xC3, 0xC6, 0x18, 0x3C, 0x61, 0x82, 0xC6, 0x18, 0x6C, 0x61,
  0x86, 0xC7, 0x3C, 0xCC, 0x3E, 0xFC, 0xC1, 0xC7, 0x86, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x40, 0x0F, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x70, 0x1C, 0x30,
  0x18, 0x30, 0x18, 0x38, 0x38, 0x38, 0x3F, 0xF8, 0x3F, 0xFC, 0x70, 0x1C,
  0x70, 0x0C, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0x87,
  0xFF, 0x38, 0x79, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xDC, 0x0E, 0xE0,
  0x77, 0x0F, 0x3F, 0xF1, 0xFF, 0xCE, 0x07, 0x70, 0x3B, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC3, 0xEF, 0xFE, 0x7F, 0xC0, 0x0F, 0xC0,
  0x7F, 0xC3, 0xCF, 0x1C, 0x0E, 0x60, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x07, 0xE0, 0x1D, 0x80, 0xE7, 0x03, 0x8F, 0x3C, 0x1F, 0xE0, 0x3F,
  0x00, 0xFF, 0x07, 0xFE, 0x38, 0xF9, 0xC0, 0xEE, 0x03, 0x70, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x1D, 0xC3, 0xCF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xCF, 0x1C, 0x0E,
  0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x7F, 0xE1, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80,
  0x77, 0x01, 0xCF, 0x1E, 0x1F, 0xF0, 0x3F, 0x00, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xBD, 0xE7,
  0xFC, 0x3E, 0x00, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x38, 0x38, 0xE1, 0xE3,
  0x87, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xCE, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE3, 0x83, 0xCE, 0x07,
  0x38, 0x0E, 0xE0, 0x3B, 0x80, 0x70, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF,
  0xC0, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x6F, 0xB0, 0x1B, 0xEC, 0x0E, 0xFB, 0x83, 0x3E,
  0x60, 0xCF, 0x98, 0x73, 0xE7, 0x18, 0xF8, 0xC6, 0x3E, 0x33, 0x8F, 0x8E,
  0xC3, 0xE1, 0xB0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE0, 0xE0,
  0xF8, 0x38, 0x30, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x3E, 0xC0, 0xFB, 0x83, 0xE6, 0x0F, 0x9C, 0x3E, 0x30, 0xF8, 0xE3,
  0xE1, 0x8F, 0x87, 0x3E, 0x0C, 0xF8, 0x3B, 0xE0, 0x6F, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1C,
  0x0E, 0x60, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D,
  0x80, 0x67, 0x03, 0x8F, 0xBC, 0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0xC7, 0xFF,
  0x38, 0x3D, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x3D, 0xFF, 0xEF, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0xFF,
  0x83, 0xDF, 0x1C, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x67, 0x03, 0x8F, 0x7C, 0x3F, 0xE0, 0x3F, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0x87, 0xFF, 0x38, 0x3D,
  0xC0, 0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x37, 0x03, 0xB8,
  0x3D, 0xFF, 0xCF, 0xF8, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE7, 0x03,
  0xB8, 0x1D, 0xC0, 0xEE, 0x03, 0xF0, 0x1C, 0x0F, 0xC0, 0xFF, 0x0F, 0x3C,
  0xE0, 0x77, 0x03, 0xB8, 0x0D, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xE0, 0x1F, 0x01,
  0xDC, 0x0E, 0xF9, 0xE3, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1C, 0xF1, 0xE3, 0xFE, 0x07, 0xC0, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x8C, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0x60, 0x61, 0xC0, 0xE3, 0x81, 0xC6, 0x01, 0x8C,
  0x03, 0xB8, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xD8, 0x1C, 0x0E,
  0xC0, 0xE0, 0x67, 0x0F, 0x83, 0x38, 0x7C, 0x39, 0xC3, 0x61, 0xCE, 0x1B,
  0x0E, 0x30, 0xDC, 0x61, 0x8E, 0x63, 0x0E, 0x63, 0x18, 0x73, 0x19, 0xC3,
  0x98, 0xCE, 0x0D, 0xC3, 0x60, 0x6C, 0x1B, 0x03, 0x60, 0xD8, 0x1F, 0x06,
  0xC0, 0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0xF0, 0x1C, 0xE0, 0x39, 0xC0, 0xE1, 0xC1, 0xC3, 0x87, 0x03,
  0x8E, 0x07, 0x38, 0x07, 0x70, 0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0x70, 0x70, 0xE0,
  0xE0, 0xE3, 0x81, 0xC7, 0x01, 0xDC, 0x03, 0x80, 0x70, 0x0E, 0xE0, 0x1C,
  0xC0, 0x71, 0xC0, 0xE3, 0x83, 0x83, 0x87, 0x07, 0x0C, 0x06, 0x38, 0x0E,
  0x70, 0x0D, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0x80, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x0C, 0x0E,
  0x07, 0x03, 0xC3, 0x61, 0xB0, 0xDC, 0xC6, 0x63, 0x31, 0xF8, 0x60, 0xFF,
  0xFF, 0xFF, 0xE1, 0xC3, 0x87, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0xEE, 0x0C,
  0x01, 0x87, 0xF3, 0xFE, 0xF0, 0xDC, 0x1B, 0x03, 0x60, 0x6E, 0x1D, 0xEF,
  0x9F, 0xB1, 0xE7, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x7C, 0xFF, 0xDF, 0x3F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7F, 0x1D, 0xBF, 0xB3, 0xE0, 0x0F,
  0x83, 0xFC, 0x79, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x07, 0x70, 0x77, 0x8E, 0x3F, 0xC0, 0xF8, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xF7, 0x3F,
  0xF7, 0x9F, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x60, 0x77, 0x07, 0x79, 0xF3, 0xFF, 0x1F, 0x70, 0x0F, 0x83,
  0xFC, 0x38, 0xE7, 0x06, 0x60, 0x76, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x27, 0x8F, 0x3F, 0xE0, 0xF8, 0x0F, 0x1F,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x73, 0xFF,
  0x79, 0xF7, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x60, 0x76, 0x07, 0x70, 0x77, 0x9F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07,
  0x20, 0x63, 0x9E, 0x3F, 0xC0, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x78, 0xFF, 0xDF, 0x7B, 0x83, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x38, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x31,
  0xCC, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x3B, 0xBD, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x0E, 0xE3, 0x9C, 0x73, 0x9C, 0x77, 0x0E, 0xC1, 0xF8,
  0x3F, 0x07, 0xF0, 0xEE, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xCF, 0x0F,
  0x1B, 0xF3, 0xFB, 0xCF, 0xEF, 0x70, 0x70, 0x6E, 0x0E, 0x0F, 0xC1, 0xC1,
  0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83,
  0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07,
  0xCF, 0x1B, 0xFB, 0xEF, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x0F, 0x80,
  0xFF, 0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x30, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xD8, 0x0E, 0xC0, 0x67, 0x07, 0x1C, 0x70, 0xFF, 0x81, 0xF0,
  0xCF, 0x9B, 0xFB, 0xCF, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xE3, 0xBF, 0xF7, 0x7C, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x1F, 0x73, 0xFF, 0x78, 0xF7,
  0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76,
  0x07, 0x70, 0x77, 0x8F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xCD, 0xFB, 0xF7, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x1F, 0x07, 0xF9, 0xE7, 0xB8, 0x77,
  0x0E, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0x3C, 0x03, 0xF0, 0x36, 0x0E,
  0xF3, 0xCF, 0xF0, 0xFC, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0xE7, 0xDF, 0xF9, 0xF7, 0xC0, 0xFC,
  0x1F, 0x83, 0x30, 0x66, 0x1C, 0xE3, 0x0C, 0x61, 0x8C, 0x3B, 0x87, 0x60,
  0x6C, 0x0D, 0x81, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xC0, 0xC1, 0xF8, 0x70,
  0x6E, 0x1C, 0x19, 0x87, 0x8E, 0x63, 0xE3, 0x9C, 0xD8, 0xC7, 0x36, 0x30,
  0xCD, 0xCC, 0x37, 0x37, 0x0D, 0x8D, 0x83, 0xE3, 0xE0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x30, 0xE0, 0xEE, 0x19, 0xC7,
  0x18, 0xC3, 0xB8, 0x36, 0x07, 0xC0, 0x70, 0x0E, 0x03, 0xE0, 0x6C, 0x1D,
  0xC3, 0x18, 0xE3, 0x98, 0x3F, 0x07, 0xC0, 0xFC, 0x1B, 0x83, 0x30, 0xE7,
  0x1C, 0xE3, 0x1C, 0x61, 0x9C, 0x3B, 0x07, 0x60, 0x6C, 0x0F, 0x81, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x0F, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0x02,
  0x0F, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x70,
  0xF0, 0xF0, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x0C, 0x0F, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x81, 0xC1,
  0xC3, 0x83, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xC1, 0xC7, 0x8E,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE3, 0x84, 0x00, 0x3C,
  0x0D, 0xF8, 0x3F, 0xF1, 0xF0, 0xEE, 0xC1, 0xF8, 0x03, 0x80,
};

const GFXglyph RobotoCondensed_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 22, 7, 2, -22 },
  { 10, 6, 7, 10, 2, -23 },
  { 16, 14, 22, 16, 2, -22 },
  { 55, 11, 28, 15, 2, -25 },
  { 94, 16, 22, 19, 2, -22 },
  { 138, 14, 22, 16, 2, -22 },
  { 177, 2, 7, 5, 2, -23 },
  { 179, 7, 31, 9, 2, -24 },
  { 207, 7, 31, 10, 1, -24 },
  { 235, 13, 12, 13, 0, -22 },
  { 255, 13, 16, 15, 1, -18 },
  { 281, 5, 7, 6, 0, -3 },
  { 286, 6, 2, 7, 1, -10 },
  { 288, 3, 3, 8, 2, -3 },
  { 290, 10, 24, 11, 0, -22 },
  { 320, 11, 22, 15, 2, -22 },
  { 351, 7, 22, 15, 2, -22 },
  { 371, 13, 22, 15, 1, -22 },
  { 407, 12, 22, 15, 1, -22 },
  { 440, 13, 22, 15, 1, -22 },
  { 476, 12, 22, 15, 2, -22 },
  { 509, 11, 22, 15, 2, -22 },
  { 540, 12, 22, 15, 1, -22 },
  { 573, 11, 22, 15, 2, -22 },
  { 604, 11, 22, 15, 2, -22 },
  { 635, 3, 16, 7, 2, -16 },
  { 641, 4, 20, 6, 1, -16 },
  { 651, 10, 13, 13, 1, -16 },
  { 668, 10, 8, 14, 2, -14 },
  { 678, 11, 13, 14, 2, -16 },
  { 696, 10, 22, 13, 1, -22 },
  { 724, 20, 28, 23, 2, -21 },
  { 794, 16, 22, 17, 1, -22 },
  { 838, 13, 22, 16, 2, -22 },
  { 874, 14, 22, 17, 2, -22 },
  { 913, 13, 22, 17, 2, -22 },
  { 949, 12, 22, 15, 2, -22 },
  { 982, 11, 22, 14, 2, -22 },
  { 1013, 14, 22, 18, 2, -22 },
  { 1052, 14, 22, 19, 2, -22 },
  { 1091, 3, 22, 8, 2, -22 },
  { 1100, 11, 22, 15, 1, -22 },
  { 1131, 14, 22, 16, 2, -22 },
  { 1170, 11, 22, 14, 2, -22 },
  { 1201, 18, 22, 23, 2, -22 },
  { 1251, 14, 22, 19, 2, -22 },
  { 1290, 14, 22, 18, 2, -22 },
  { 1329, 13, 22, 17, 2, -22 },
  { 1365, 14, 26, 18, 2, -22 },
  { 1411, 13, 22, 16, 2, -22 },
  { 1447, 13, 22, 16, 1, -22 },
  { 1483, 14, 22, 16, 1, -22 },
  { 1522, 13, 22, 17, 2, -22 },
  { 1558, 15, 22, 17, 1, -22 },
  { 1600, 21, 22, 23, 1, -22 },
  { 1658, 15, 22, 17, 1, -22 },
  { 1700, 15, 22, 16, 0, -22 },
  { 1742, 13, 22, 16, 1, -22 },
  { 1778, 5, 29, 8, 2, -24 },
  { 1797, 10, 24, 11, 1, -22 },
  { 1827, 5, 29, 8, 0, -24 },
  { 1846, 9, 11, 11, 1, -22 },
  { 1859, 12, 2, 12, 0, 0 },
  { 1862, 6, 4, 9, 1, -22 },
  { 1865, 11, 16, 14, 2, -16 },
  { 1887, 11, 23, 15, 2, -23 },
  { 1919, 12, 16, 14, 1, -16 },
  { 1943, 12, 23, 15, 1, -23 },
  { 1978, 12, 16, 14, 1, -16 },
  { 2002, 8, 23, 10, 1, -23 },
  { 2025, 12, 22, 15, 1, -16 },
  { 2058, 11, 23, 14, 2, -23 },
  { 2090, 3, 22, 7, 2, -22 },
  { 2099, 5, 28, 7, 0, -22 },
  { 2117, 11, 23, 14, 2, -23 },
  { 2149, 3, 23, 7, 2, -23 },
  { 2158, 19, 16, 23, 2, -16 },
  { 2196, 11, 16, 15, 2, -16 },
  { 2218, 13, 16, 15, 1, -16 },
  { 2244, 11, 22, 15, 2, -16 },
  { 2275, 12, 22, 15, 1, -16 },
  { 2308, 7, 16, 9, 2, -16 },
  { 2322, 11, 16, 14, 1, -16 },
  { 2344, 8, 20, 9, 0, -20 },
  { 2364, 11, 16, 15, 2, -16 },
  { 2386, 11, 16, 13, 1, -16 },
  { 2408, 18, 16, 20, 1, -16 },
  { 2444, 11, 16, 13, 1, -16 },
  { 2466, 11, 22, 13, 1, -16 },
  { 2497, 11, 16, 13, 1, -16 },
  { 2519, 8, 28, 9, 1, -23 },
  { 2547, 2, 26, 7, 3, -22 },
  { 2554, 7, 28, 9, 1, -23 },
  { 2579, 14, 6, 18, 2, -12 },
};

const GFXfont RobotoCondensed_Regular30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_REGULAR30PT7B_H_
