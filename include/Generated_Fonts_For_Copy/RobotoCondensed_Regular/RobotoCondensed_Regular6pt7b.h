#ifndef _ROBOTOCONDENSED_REGULAR6PT7B_H_
#define _ROBOTOCONDENSED_REGULAR6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xC0, 0xF0, 0x6F, 0x80, 0x55, 0x1A, 0x80, 0xE4, 0x62, 0xEA, 0xF0,
  0xC0, 0x6A, 0x80, 0xA5, 0x40, 0x48, 0x49, 0x20, 0xC0, 0x00, 0x80, 0x5A,
  0xF6, 0xF0, 0xD5, 0xE5, 0x60, 0xE4, 0xF0, 0x4B, 0x90, 0x48, 0xF0, 0xDA,
  0xF0, 0x69, 0x20, 0xFE, 0xF0, 0xF5, 0xA0, 0x20, 0x30, 0x50, 0xF0, 0x48,
  0xD0, 0x7B, 0xFF, 0x40, 0x4D, 0xD0, 0xF6, 0xD0, 0xF2, 0x30, 0xB6, 0xD0,
  0x92, 0x40, 0x92, 0x40, 0xF2, 0xB0, 0xB6, 0xD0, 0xF0, 0x57, 0xBB, 0x50,
  0x92, 0x40, 0x9D, 0xBB, 0xBE, 0xD0, 0xF6, 0xB0, 0xF6, 0x40, 0xF6, 0xB0,
  0xF6, 0x50, 0xF8, 0xF0, 0x49, 0x20, 0xB6, 0xF0, 0xB5, 0x20, 0xBF, 0x55,
  0xA9, 0x50, 0xA9, 0x20, 0x69, 0x60, 0xFC, 0xA5, 0xFC, 0x70, 0x00, 0x80,
  0xE6, 0x80, 0x93, 0xDE, 0xD3, 0x80, 0x27, 0xDE, 0xFF, 0x00, 0x6A, 0x80,
  0xF6, 0xB0, 0x92, 0xDA, 0x70, 0x78, 0x93, 0x6A, 0xF8, 0xBB, 0xB0, 0xB6,
  0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xA8, 0x9C, 0x2A, 0xB6, 0x80,
  0xD4, 0x96, 0x20, 0xDC, 0xD4, 0x58, 0x68, 0x90, 0x70, 0xA8, 0xA0, 0xE0,
};

const GFXglyph RobotoCondensed_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 3, 2, 3, 0, -4 },
  { 18, 3, 4, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 1, 1, 1, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 1, 0, -3 },
  { 44, 1, 4, 1, 0, -3 },
  { 45, 2, 2, 3, 0, -3 },
  { 46, 2, 2, 3, 0, -3 },
  { 47, 3, 2, 3, 0, -3 },
  { 48, 2, 4, 3, 0, -4 },
  { 49, 4, 5, 5, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 1, 4, 2, 0, -4 },
  { 69, 2, 4, 3, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 4, 4, 5, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 3, 5, 4, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 4, 4, 5, 0, -4 },
  { 96, 3, 4, 3, 0, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 3, 4, 3, 0, -4 },
  { 102, 1, 6, 2, 0, -5 },
  { 103, 2, 4, 2, 0, -4 },
  { 104, 1, 6, 2, 0, -5 },
  { 105, 2, 2, 2, 0, -4 },
  { 106, 2, 1, 2, 0, 0 },
  { 107, 1, 1, 2, 0, -5 },
  { 108, 3, 3, 3, 0, -3 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 3, 3, 3, 0, -3 },
  { 118, 2, 5, 2, 0, -5 },
  { 120, 3, 4, 3, 0, -3 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 1, 4, 1, 0, -4 },
  { 125, 1, 5, 1, 0, -4 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 1, 5, 1, 0, -5 },
  { 129, 4, 3, 5, 0, -3 },
  { 131, 3, 3, 3, 0, -3 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 4, 3, 0, -3 },
  { 137, 3, 4, 3, 0, -3 },
  { 139, 2, 3, 2, 0, -3 },
  { 140, 2, 3, 3, 0, -3 },
  { 141, 2, 4, 2, 0, -4 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 2, 3, 3, 0, -3 },
  { 145, 4, 3, 4, 0, -3 },
  { 147, 2, 3, 3, 0, -3 },
  { 148, 2, 4, 3, 0, -3 },
  { 149, 2, 3, 3, 0, -3 },
  { 150, 2, 6, 2, 0, -5 },
  { 152, 1, 5, 1, 0, -4 },
  { 153, 2, 6, 2, 0, -5 },
  { 155, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoCondensed_Regular6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_REGULAR6PT7B_H_
