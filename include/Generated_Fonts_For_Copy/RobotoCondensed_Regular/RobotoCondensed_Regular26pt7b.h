#ifndef _ROBOTOCONDENSED_REGULAR26PT7B_H_
#define _ROBOTOCONDENSED_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0xDF, 0x00, 0xDE, 0xE7, 0x39,
  0xCC, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0xCC, 0x08, 0xCF, 0xFF, 0xFF, 0xF1,
  0x98, 0x19, 0x81, 0x98, 0x11, 0x83, 0x18, 0xFF, 0xEF, 0xFE, 0x33, 0x03,
  0x30, 0x23, 0x02, 0x30, 0x62, 0x00, 0x06, 0x01, 0x80, 0x60, 0x7C, 0x3F,
  0x9C, 0x77, 0x0D, 0x83, 0x60, 0xDC, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1C, 0x03, 0xE0, 0xF8, 0x36, 0x0D, 0xC7, 0x3F, 0x87, 0xC0, 0x40, 0x10,
  0x38, 0x01, 0xF0, 0x04, 0x62, 0x31, 0x88, 0xC6, 0x63, 0x19, 0x04, 0x6C,
  0x1F, 0x20, 0x39, 0x80, 0x0C, 0x00, 0x37, 0x81, 0xBF, 0x06, 0xCC, 0x33,
  0x10, 0xC8, 0x46, 0x21, 0x18, 0xCC, 0x03, 0xF0, 0x07, 0x80, 0x1F, 0x01,
  0xFC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xCE, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x0D, 0x8C, 0xCE, 0x6E, 0x3B, 0x70, 0xFB, 0x87, 0x8C, 0x1C,
  0x71, 0xE1, 0xFF, 0x87, 0xCE, 0xFF, 0xF0, 0x08, 0xC6, 0x63, 0x31, 0x9C,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xC6, 0x30, 0xC6, 0x18, 0xC2,
  0x83, 0x0C, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x61, 0x86, 0x18, 0x71, 0xC6,
  0x18, 0x61, 0x86, 0x30, 0xC3, 0x18, 0x43, 0x08, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x23, 0x2F, 0xDE, 0x7F, 0x83, 0x80, 0xD8, 0x1B, 0x86, 0x30, 0x42,
  0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x33, 0x37, 0x64, 0xFF, 0xC0,
  0xDF, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x04, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x83, 0x60, 0xD8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xD8, 0x36, 0x0D, 0x83, 0x71, 0x8F,
  0xE1, 0xF0, 0x04, 0xFF, 0xFB, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0D,
  0x81, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x1F, 0xFF, 0xFF, 0x80, 0x1E, 0x0F, 0xE7, 0x19,
  0x87, 0xE0, 0xC0, 0x30, 0x1C, 0x06, 0x1F, 0x07, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x3E, 0x0F, 0x83, 0x61, 0x9F, 0xE1, 0xE0, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0xD8, 0x1B, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x31, 0xC6, 0x30,
  0xCE, 0x19, 0xFF, 0xFF, 0xF8, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x7F,
  0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x07, 0xE1, 0xFC, 0xE3, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0xC0, 0x7C, 0x1F, 0x06, 0x63, 0x9F, 0xC1, 0xE0, 0x0E,
  0x0F, 0x83, 0x81, 0x80, 0x60, 0x30, 0x0D, 0xE3, 0xFC, 0xE3, 0xB0, 0x6C,
  0x1B, 0x07, 0xC1, 0xF0, 0x7C, 0x1B, 0x86, 0x63, 0x9F, 0xC1, 0xE0, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xE0, 0x00, 0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0x60, 0xD8, 0x36, 0x0D, 0xC6,
  0x3F, 0x8F, 0xC7, 0x19, 0x83, 0x60, 0xF8, 0x36, 0x0D, 0x83, 0x71, 0xCF,
  0xE1, 0xF0, 0x1E, 0x0F, 0xC7, 0x39, 0x87, 0x60, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xD8, 0x77, 0x1C, 0xFF, 0x1E, 0xC0, 0x30, 0x18, 0x06, 0x07, 0x07,
  0x81, 0xC0, 0xDF, 0x00, 0x00, 0x00, 0x6F, 0x80, 0x7D, 0x80, 0x00, 0x00,
  0x36, 0xFE, 0x80, 0x00, 0x81, 0xC3, 0xE3, 0xC7, 0x87, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xE0, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8, 0x0C, 0x3E, 0x7C, 0xF8, 0x70,
  0x20, 0x00, 0x3E, 0x3F, 0x98, 0xDC, 0x7C, 0x18, 0x0C, 0x0E, 0x06, 0x07,
  0x07, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x00, 0x08, 0x0C, 0x06, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0x66, 0x0F, 0x09, 0x87, 0xE2, 0x63, 0x18, 0xD0, 0xC6, 0x34, 0x61,
  0x8F, 0x18, 0x43, 0xC6, 0x10, 0xF1, 0x84, 0x2C, 0x63, 0x09, 0x18, 0xC6,
  0x43, 0xDF, 0x18, 0xE3, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1B,
  0x00, 0xD8, 0x06, 0xC0, 0x77, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x0C, 0x18,
  0x60, 0xC3, 0xFE, 0x3F, 0xF9, 0x80, 0xCC, 0x06, 0xE0, 0x3E, 0x00, 0xF0,
  0x06, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0E,
  0xFF, 0x9F, 0xF3, 0x07, 0x60, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC1,
  0xDF, 0xF3, 0xFC, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x6C,
  0x07, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x07, 0xC0, 0x6E, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x00, 0xFE, 0x1F, 0xF3,
  0x07, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x06, 0xC1, 0xDF, 0xF3, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF,
  0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xEF, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x1F, 0x03, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC3, 0xFC, 0x3F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07,
  0x70, 0xF3, 0xFE, 0x1F, 0x80, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x1F, 0x06, 0xE3,
  0x9F, 0xC3, 0xE0, 0xC0, 0xEC, 0x0E, 0xC1, 0xCC, 0x38, 0xC3, 0x0C, 0x70,
  0xCE, 0x0C, 0xC0, 0xDC, 0x0F, 0xC0, 0xFE, 0x0E, 0x70, 0xC7, 0x0C, 0x38,
  0xC1, 0x8C, 0x1C, 0xC0, 0xEC, 0x0E, 0xC0, 0x70, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1B, 0xD8, 0x1F, 0xD8, 0x1F, 0xD8, 0x37,
  0xDC, 0x37, 0xCC, 0x37, 0xCC, 0x77, 0xCE, 0x67, 0xC6, 0x67, 0xC6, 0xE7,
  0xC7, 0xC7, 0xC3, 0xC7, 0xC3, 0xC7, 0xC3, 0x87, 0xC1, 0x87, 0xE0, 0x3E,
  0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3D, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C,
  0x63, 0xC7, 0x3C, 0x33, 0xC3, 0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x70, 0x1F, 0x03, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7E, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x00, 0xFF, 0x1F, 0xFB, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0xFF, 0x7F,
  0xCC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x0F,
  0x80, 0xFF, 0x0E, 0x3C, 0xE0, 0x66, 0x03, 0x30, 0x1D, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x01, 0xB0, 0x1D, 0x80, 0xEE,
  0x06, 0x38, 0x70, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x08, 0xFF,
  0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0xDF,
  0xF3, 0xFC, 0x61, 0x8C, 0x39, 0x83, 0x30, 0x76, 0x0E, 0xC0, 0xD8, 0x1F,
  0x01, 0x80, 0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x76, 0x06, 0xC0, 0xD8, 0x03,
  0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xF8, 0x1B, 0x03,
  0x70, 0xE7, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xE1, 0xCF, 0xF8, 0x7C,
  0x00, 0xC0, 0x3E, 0x01, 0xF8, 0x0C, 0xC0, 0x66, 0x07, 0x38, 0x30, 0xC1,
  0x86, 0x1C, 0x30, 0xC1, 0xC6, 0x06, 0x30, 0x33, 0x81, 0xD8, 0x06, 0xC0,
  0x36, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0xC0, 0xC0, 0xF0, 0x30,
  0x3E, 0x0E, 0x1D, 0x87, 0x86, 0x61, 0xE1, 0x98, 0x78, 0x66, 0x1A, 0x19,
  0xCC, 0xCE, 0x33, 0x33, 0x8C, 0xCC, 0xC3, 0x33, 0x30, 0xC8, 0x6C, 0x36,
  0x1B, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xE0, 0x73, 0x03, 0x9C, 0x38, 0x61, 0xC3, 0x8C, 0x0C,
  0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x01, 0xD8,
  0x0C, 0xE0, 0xE3, 0x06, 0x1C, 0x70, 0x63, 0x03, 0xB8, 0x0C, 0x60, 0x3B,
  0x81, 0xDC, 0x0C, 0x60, 0xE3, 0x86, 0x0C, 0x70, 0x73, 0x01, 0x98, 0x0D,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0,
  0xC0, 0xE0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C,
  0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x03, 0x03, 0xFF, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8,
  0x18, 0x18, 0x38, 0x3C, 0x6C, 0x66, 0x66, 0xC6, 0xC3, 0xFF, 0xFF, 0xF0,
  0xE3, 0x0C, 0x30, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0x01, 0xC0, 0x71, 0xFD,
  0xFF, 0x61, 0xD8, 0x7E, 0x1D, 0x8F, 0x7F, 0xCF, 0x30, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0D, 0xE3, 0xFC, 0xE3, 0xB0, 0x6C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0xEF, 0xF3, 0x78, 0x1F, 0x0F,
  0xE7, 0x1D, 0x83, 0xE0, 0xF8, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x36, 0x0D,
  0xC6, 0x3F, 0x87, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x31,
  0xED, 0xFF, 0x71, 0xD8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0x60, 0xDC, 0x73, 0xFC, 0x7B, 0x1F, 0x0F, 0xE7, 0x19, 0x83, 0xE0, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0x38, 0x06, 0x01, 0xC3, 0x3F, 0xC7, 0xC0, 0x0E,
  0x7C, 0xE1, 0x83, 0x06, 0x3F, 0x7E, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x1E, 0xDF, 0xF7, 0x1D, 0x83, 0xE0, 0xF8,
  0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x36, 0x0D, 0xC7, 0x3F, 0xC7, 0xB0, 0x0C,
  0x03, 0x61, 0xDF, 0xE1, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x79, 0xFE, 0xE3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x30, 0x3C, 0x3F, 0xFF, 0xFF, 0xFC, 0x23, 0x30, 0x03,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x37, 0xFE, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x0F, 0x8E, 0xCE, 0x66, 0x37, 0x1F, 0x0F, 0x87,
  0xE3, 0x31, 0x9C, 0xC6, 0x63, 0xB0, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDE, 0x3C, 0xFF, 0x7E, 0xE3, 0xC7, 0xC3, 0x87, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xDE, 0x7F, 0xB8, 0xF8, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x1F, 0x07, 0xF1,
  0xC7, 0x30, 0x6E, 0x0F, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x1D, 0x83,
  0x38, 0xE3, 0xF8, 0x3E, 0x00, 0xDE, 0x3F, 0xCE, 0x3B, 0x06, 0xC1, 0xB0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x8E, 0xFF, 0x37, 0x8C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1E, 0xDF, 0xF7, 0x1D, 0x83, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x36, 0x0D, 0xC7, 0x7F, 0xC7, 0xB0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x60, 0x1E, 0x1F, 0xE6, 0x39, 0x86, 0x60, 0x1C, 0x03, 0xE0, 0x3C,
  0x03, 0x80, 0x7E, 0x1D, 0x86, 0x7F, 0x87, 0xC0, 0x38, 0x70, 0xE7, 0xFF,
  0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0F, 0x0E, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFC,
  0x7F, 0xF9, 0xEC, 0xC1, 0xE0, 0xF8, 0x6C, 0x66, 0x33, 0x19, 0xCC, 0x6C,
  0x36, 0x1B, 0x07, 0x03, 0x81, 0xC0, 0x60, 0xC3, 0x07, 0x87, 0x0F, 0x0E,
  0x3F, 0x1C, 0x66, 0x68, 0xCC, 0xD9, 0x99, 0xB3, 0x3B, 0x6C, 0x3C, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xC3, 0x81, 0x83, 0x03, 0x06, 0x00, 0xE1, 0x98,
  0xE6, 0x30, 0xDC, 0x36, 0x07, 0x81, 0xC0, 0x70, 0x1E, 0x0D, 0x83, 0x31,
  0x8C, 0xE3, 0xB8, 0x60, 0x60, 0xD8, 0x37, 0x1D, 0xC6, 0x31, 0x8C, 0x63,
  0xB0, 0x6C, 0x1B, 0x06, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x1E, 0x07, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30,
  0x38, 0x38, 0x18, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0x04, 0x71, 0x8E, 0x30,
  0xC3, 0x0C, 0x30, 0xC7, 0x38, 0xE1, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xE1, 0x83, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0x06, 0x1C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x07, 0x1C, 0xE3, 0x0C, 0x30, 0xC3, 0x0C,
  0x71, 0x86, 0x30, 0x80, 0x38, 0x37, 0xC3, 0xCE, 0x6C, 0x7E, 0xC3, 0xC0,
};

const GFXglyph RobotoCondensed_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 6, 2, -19 },
  { 9, 5, 6, 8, 2, -20 },
  { 13, 12, 19, 14, 2, -19 },
  { 42, 10, 24, 13, 1, -22 },
  { 72, 14, 19, 16, 1, -19 },
  { 106, 13, 19, 14, 1, -19 },
  { 137, 2, 6, 5, 1, -20 },
  { 139, 5, 27, 8, 2, -21 },
  { 156, 6, 27, 8, 1, -21 },
  { 177, 11, 11, 11, 0, -19 },
  { 193, 11, 13, 13, 1, -15 },
  { 211, 4, 6, 5, 0, -3 },
  { 214, 5, 2, 6, 1, -9 },
  { 216, 3, 3, 7, 2, -3 },
  { 218, 9, 21, 10, 0, -19 },
  { 242, 10, 19, 13, 1, -19 },
  { 266, 6, 19, 13, 2, -19 },
  { 281, 11, 19, 13, 1, -19 },
  { 308, 10, 19, 13, 1, -19 },
  { 332, 11, 19, 13, 1, -19 },
  { 359, 10, 19, 13, 2, -19 },
  { 383, 10, 19, 13, 2, -19 },
  { 407, 11, 19, 13, 1, -19 },
  { 434, 10, 19, 13, 1, -19 },
  { 458, 10, 19, 13, 1, -19 },
  { 482, 3, 14, 6, 2, -14 },
  { 488, 3, 17, 5, 1, -14 },
  { 495, 9, 12, 12, 1, -14 },
  { 509, 9, 7, 12, 2, -12 },
  { 517, 9, 11, 12, 2, -14 },
  { 530, 9, 19, 11, 1, -19 },
  { 552, 18, 24, 20, 1, -18 },
  { 606, 13, 19, 15, 1, -19 },
  { 637, 11, 19, 14, 2, -19 },
  { 664, 12, 19, 15, 2, -19 },
  { 693, 11, 19, 15, 2, -19 },
  { 720, 10, 19, 13, 2, -19 },
  { 744, 10, 19, 13, 2, -19 },
  { 768, 12, 19, 15, 2, -19 },
  { 797, 12, 19, 16, 2, -19 },
  { 826, 2, 19, 7, 2, -19 },
  { 831, 10, 19, 13, 1, -19 },
  { 855, 12, 19, 14, 2, -19 },
  { 884, 10, 19, 12, 2, -19 },
  { 908, 16, 19, 20, 2, -19 },
  { 946, 12, 19, 16, 2, -19 },
  { 975, 12, 19, 16, 2, -19 },
  { 1004, 11, 19, 14, 2, -19 },
  { 1031, 13, 22, 16, 1, -19 },
  { 1067, 11, 19, 14, 2, -19 },
  { 1094, 11, 19, 13, 1, -19 },
  { 1121, 12, 19, 14, 1, -19 },
  { 1150, 11, 19, 15, 2, -19 },
  { 1177, 13, 19, 15, 1, -19 },
  { 1208, 18, 19, 20, 1, -19 },
  { 1251, 13, 19, 14, 1, -19 },
  { 1282, 13, 19, 14, 0, -19 },
  { 1313, 12, 19, 14, 1, -19 },
  { 1342, 4, 25, 7, 2, -21 },
  { 1355, 8, 21, 10, 1, -19 },
  { 1376, 5, 25, 7, 0, -21 },
  { 1392, 8, 9, 10, 1, -19 },
  { 1401, 10, 2, 11, 0, 0 },
  { 1404, 5, 4, 8, 1, -20 },
  { 1407, 10, 14, 12, 1, -14 },
  { 1425, 10, 20, 13, 2, -20 },
  { 1450, 10, 14, 12, 1, -14 },
  { 1468, 10, 20, 13, 1, -20 },
  { 1493, 10, 14, 12, 1, -14 },
  { 1511, 7, 20, 8, 1, -20 },
  { 1529, 10, 19, 13, 1, -14 },
  { 1553, 9, 20, 13, 2, -20 },
  { 1576, 2, 19, 6, 2, -19 },
  { 1581, 4, 24, 6, 0, -19 },
  { 1593, 9, 20, 12, 2, -20 },
  { 1616, 2, 20, 6, 2, -20 },
  { 1621, 16, 14, 20, 2, -14 },
  { 1649, 9, 14, 13, 2, -14 },
  { 1665, 11, 14, 13, 1, -14 },
  { 1685, 10, 19, 13, 2, -14 },
  { 1709, 10, 19, 13, 1, -14 },
  { 1733, 5, 14, 8, 2, -14 },
  { 1742, 10, 14, 12, 1, -14 },
  { 1760, 7, 17, 8, 0, -17 },
  { 1775, 9, 14, 13, 2, -14 },
  { 1791, 9, 14, 11, 1, -14 },
  { 1807, 15, 14, 17, 1, -14 },
  { 1834, 10, 14, 11, 1, -14 },
  { 1852, 10, 19, 11, 0, -14 },
  { 1876, 9, 14, 11, 1, -14 },
  { 1892, 6, 25, 8, 1, -20 },
  { 1911, 2, 22, 6, 2, -19 },
  { 1917, 6, 25, 8, 1, -20 },
  { 1936, 12, 5, 15, 2, -10 },
};

const GFXfont RobotoCondensed_Regular26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_REGULAR26PT7B_H_
