#ifndef _ROBOTOCONDENSED_REGULAR56PT7B_H_
#define _ROBOTOCONDENSED_REGULAR56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x00, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3B, 0x87, 0x70,
  0xEE, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xF0,
  0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70,
  0x3C, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x3C, 0x1E, 0x00,
  0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x9F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x10, 0x0F, 0x03, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xF0, 0x78, 0x0E, 0x03,
  0xC1, 0xC0, 0x38, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x38, 0x03, 0xC0, 0xF1,
  0xE0, 0x0F, 0x03, 0x87, 0x00, 0x1E, 0x1E, 0x3C, 0x00, 0x7F, 0xF0, 0xE0,
  0x00, 0xFF, 0xC7, 0x80, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0x80, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC7, 0xF8, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x71, 0xFF, 0xC0, 0x03,
  0xC7, 0x87, 0x80, 0x0E, 0x1C, 0x0E, 0x00, 0x78, 0xF0, 0x3C, 0x01, 0xC3,
  0xC0, 0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x38, 0x3C, 0x0F, 0x01, 0xE0, 0xF0,
  0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x3C, 0x0F,
  0x03, 0x80, 0x70, 0x38, 0x04, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80,
  0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x3C, 0x7E, 0x3F, 0x07, 0x8F,
  0x83, 0xE1, 0xF3, 0xF0, 0x7E, 0x3E, 0x7C, 0x07, 0xE7, 0xCF, 0x80, 0x7C,
  0xF1, 0xF0, 0x0F, 0xFE, 0x3E, 0x00, 0xFF, 0xC7, 0xC0, 0x0F, 0xF0, 0xF8,
  0x01, 0xFE, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7F,
  0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFC, 0x7E, 0x03, 0xFF, 0x07, 0xE0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x02, 0x40, 0x03, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07,
  0x80, 0x1C, 0x1E, 0x0E, 0xFE, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xCF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x7C, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0xF9, 0xF7, 0xC7,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x11, 0xFF, 0xFF, 0xFD,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x81, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xE0, 0x03,
  0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xF0, 0x3E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC1,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00,
  0x3E, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x03,
  0xF1, 0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x7E, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF9, 0xF0,
  0x00, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xE1, 0xF0,
  0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF3, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFC, 0x0F, 0xE1, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0x78, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0x7E, 0x0F, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE3, 0xF0, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xE3, 0xF9, 0xFC, 0x07, 0xCF, 0xC0, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x07, 0xC7, 0xC0,
  0x3E, 0x3F, 0x03, 0xE0, 0xFC, 0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x87, 0xC0, 0x7E, 0x7C, 0x01,
  0xF3, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xFD, 0xF8, 0x1F, 0xE7, 0xF1,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xF7, 0xC3, 0xFF, 0x3E, 0x07, 0xE1, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x23, 0xEF,
  0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x23, 0xEF, 0xFF, 0xFF, 0xE2, 0x00, 0x0C, 0x1F,
  0x3F, 0x3F, 0x3F, 0x1F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x78, 0x78, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFE, 0x1F, 0x9F, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x01, 0xC1,
  0xE0, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0x7F, 0xC0, 0x38, 0xF0, 0x07, 0xFF,
  0x01, 0xC7, 0x80, 0x7F, 0xFC, 0x0F, 0x78, 0x07, 0xC1, 0xE0, 0x7B, 0xC0,
  0x3C, 0x0F, 0x01, 0xDE, 0x03, 0xC0, 0x78, 0x0E, 0xF0, 0x1E, 0x03, 0x80,
  0x77, 0x01, 0xE0, 0x1C, 0x03, 0xF8, 0x0F, 0x01, 0xE0, 0x1F, 0xC0, 0x78,
  0x0F, 0x00, 0xFE, 0x03, 0xC0, 0x78, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0x3F,
  0x81, 0xE0, 0x1E, 0x01, 0xFC, 0x0F, 0x00, 0xF0, 0x0F, 0xE0, 0x78, 0x07,
  0x80, 0x7F, 0x03, 0xC0, 0x3C, 0x03, 0xF8, 0x1E, 0x01, 0xE0, 0x1F, 0xC0,
  0xF0, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0xF8, 0x0E, 0xF0, 0x3C, 0x07, 0xC0,
  0x73, 0x81, 0xF0, 0x7E, 0x07, 0x9C, 0x07, 0x83, 0xF0, 0x78, 0xF0, 0x3F,
  0x7F, 0xC7, 0xC7, 0x81, 0xFF, 0x9F, 0xFC, 0x3C, 0x07, 0xF8, 0xFF, 0xC0,
  0xF0, 0x1F, 0x83, 0xFC, 0x07, 0x80, 0x10, 0x02, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0x00, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x78, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0x9F, 0x00, 0x1F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x3F, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x1F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x7F, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0xFF, 0x87, 0xC0, 0x0F,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x7F, 0x1F, 0x03, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFE, 0x0F,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xF3, 0xE0, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F,
  0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xF8,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xEF, 0x00, 0x03, 0xFF,
  0xFB, 0xE0, 0x00, 0xF7, 0xFE, 0xF8, 0x00, 0x7D, 0xFF, 0x9E, 0x00, 0x1F,
  0x7F, 0xE7, 0xC0, 0x07, 0x9F, 0xF9, 0xF0, 0x03, 0xE7, 0xFE, 0x3C, 0x00,
  0xF9, 0xFF, 0x8F, 0x80, 0x3C, 0x7F, 0xE3, 0xE0, 0x1F, 0x1F, 0xF8, 0x78,
  0x07, 0xC7, 0xFE, 0x1F, 0x01, 0xE1, 0xFF, 0x87, 0xC0, 0xF8, 0x7F, 0xE0,
  0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x0F, 0x07, 0xFE, 0x0F, 0x87, 0xC1, 0xFF,
  0x81, 0xE1, 0xF0, 0x7F, 0xE0, 0x7C, 0x78, 0x1F, 0xF8, 0x1F, 0x3E, 0x07,
  0xFE, 0x03, 0xCF, 0x81, 0xFF, 0x80, 0xFB, 0xC0, 0x7F, 0xE0, 0x3E, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x7F, 0xE7,
  0x80, 0x1F, 0xF9, 0xF0, 0x07, 0xFE, 0x3C, 0x01, 0xFF, 0x8F, 0x80, 0x7F,
  0xE1, 0xE0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x0F, 0x01, 0xFF, 0x83, 0xE0,
  0x7F, 0xE0, 0x78, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x03, 0xC1, 0xFF, 0x80,
  0xF8, 0x7F, 0xE0, 0x1F, 0x1F, 0xF8, 0x07, 0xC7, 0xFE, 0x00, 0xF9, 0xFF,
  0x80, 0x3E, 0x7F, 0xE0, 0x07, 0xDF, 0xF8, 0x01, 0xF7, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0xE7, 0xC0,
  0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0xDF, 0x00, 0x3F, 0xCF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3F,
  0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x47, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0x80, 0x7F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x1F,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x07, 0xE1, 0xFC, 0x07,
  0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xFB, 0xE0, 0x03,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0x0F,
  0x9F, 0x00, 0x3F, 0x80, 0x1F, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x3C, 0x00,
  0xFF, 0x00, 0x7C, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x03,
  0xE1, 0xF0, 0x0F, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0x78, 0x0F, 0x83, 0xC0,
  0x3C, 0xF0, 0x1F, 0x07, 0xC0, 0xF1, 0xE0, 0x3C, 0x0F, 0x81, 0xE3, 0xC0,
  0xF8, 0x1F, 0x03, 0xC7, 0x81, 0xF0, 0x3E, 0x07, 0x87, 0x83, 0xE0, 0x3C,
  0x1E, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x3C,
  0x1E, 0x01, 0xF0, 0xF0, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0xF1, 0xF0, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x0F, 0x9E, 0x03,
  0xC7, 0x80, 0x1F, 0x3C, 0x03, 0xDF, 0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00,
  0x3D, 0xE0, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x1D, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E,
  0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1,
  0xE1, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1F, 0x3C, 0x07, 0xBE, 0x03,
  0xDF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF8, 0x0F,
  0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0x83, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC, 0x3F, 0xC3, 0xE0, 0x10,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x20, 0x0F, 0x1F, 0xF0, 0x79,
  0xFF, 0xC3, 0xDF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x1F,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0xC0, 0x3F, 0x7F, 0x03, 0xF3, 0xFF, 0xFF, 0x9E, 0xFF, 0xF8, 0xF3, 0xFF,
  0x87, 0x8F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x7F, 0xCF, 0x87, 0xFF, 0x7C, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF,
  0x7F, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x81, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xE3, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0x81, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x00, 0xF7, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x23, 0xF0, 0x03, 0x8F, 0xC0, 0x7C, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1F,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x81, 0xFD,
  0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0x7C, 0x1F, 0xF3, 0xE0, 0x08, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x20, 0x03, 0xE3, 0x80, 0x3F, 0x1F, 0x87, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x1F, 0xF1, 0xE7, 0xFF, 0x3D, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3C, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x01, 0xE0, 0xFC, 0x3F, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xFA, 0x7E, 0xFF, 0xBF, 0xCF, 0xE3, 0xF0, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x03, 0xF0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81,
  0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x20, 0x1E, 0x3F, 0xC0, 0x7F,
  0x83, 0xCF, 0xFE, 0x3F, 0xFC, 0x7B, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xFD,
  0xFF, 0xF9, 0xFC, 0x1F, 0xF8, 0x1F, 0xBF, 0x01, 0xFE, 0x01, 0xF7, 0xC0,
  0x1F, 0x80, 0x3E, 0xF0, 0x03, 0xF0, 0x07, 0xDE, 0x00, 0x3E, 0x00, 0x7B,
  0xC0, 0x07, 0xC0, 0x0F, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0x00,
  0x3F, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x0F,
  0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x07, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x3F,
  0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0x00,
  0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x07,
  0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xE0,
  0x03, 0xC0, 0x07, 0xFC, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x3F,
  0xE3, 0xCF, 0xFE, 0x7B, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xFC, 0x01,
  0xF0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x10, 0x07, 0x8F, 0xF8, 0x3C,
  0xFF, 0xE1, 0xEF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x0F,
  0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xE0, 0x1F, 0xBF, 0x81, 0xF9, 0xFF, 0xFF, 0xCF, 0x7F, 0xFC, 0x79, 0xFF,
  0xC3, 0xC7, 0xFC, 0x1E, 0x06, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x81,
  0xFD, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x87, 0xFF, 0x7C, 0x1F, 0xF3, 0xE0, 0x08, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x1F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x30, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xDE, 0x1F, 0xE3, 0xC0, 0x40, 0x00, 0xF8,
  0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3C, 0x00,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x1E, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3E,
  0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xDE, 0x00, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x79, 0xF0,
  0x0F, 0xC0, 0x3E, 0x7C, 0x03, 0xF0, 0x0F, 0x8F, 0x00, 0xFE, 0x03, 0xE3,
  0xE0, 0x3F, 0x80, 0xF0, 0xF8, 0x1F, 0xE0, 0x3C, 0x3E, 0x07, 0xF8, 0x1F,
  0x07, 0x81, 0xFF, 0x07, 0xC1, 0xE0, 0xFB, 0xC1, 0xE0, 0x7C, 0x3C, 0xF0,
  0x78, 0x1F, 0x0F, 0x3C, 0x1E, 0x03, 0xC3, 0xCF, 0x8F, 0x80, 0xF1, 0xF1,
  0xE3, 0xC0, 0x3E, 0x78, 0x78, 0xF0, 0x0F, 0x9E, 0x1E, 0x3C, 0x01, 0xE7,
  0x87, 0xCF, 0x00, 0x7B, 0xC0, 0xF7, 0xC0, 0x1E, 0xF0, 0x3D, 0xE0, 0x07,
  0xFC, 0x0F, 0x78, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFB,
  0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x1E, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF8,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7E, 0x7E,
  0x00, 0xF9, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x80, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x07,
  0xCF, 0x00, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x05, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xE0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x3C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x01, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x70,
  0x01, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3C, 0x7F, 0xF0,
  0x07, 0x9F, 0xFF, 0x01, 0xE3, 0xFF, 0xF0, 0x3C, 0xF8, 0x7F, 0x0F, 0x9E,
  0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xFC, 0x78, 0x07, 0xFF, 0x1F, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 41, 14, 4, -40 },
  { 32, 11, 13, 18, 4, -42 },
  { 50, 25, 40, 31, 4, -40 },
  { 175, 22, 53, 28, 3, -47 },
  { 321, 30, 42, 35, 3, -41 },
  { 479, 27, 42, 30, 3, -41 },
  { 621, 4, 13, 10, 3, -42 },
  { 628, 12, 58, 18, 4, -45 },
  { 715, 13, 58, 18, 1, -45 },
  { 810, 22, 23, 24, 1, -40 },
  { 874, 23, 30, 28, 2, -34 },
  { 961, 7, 14, 11, 1, -6 },
  { 974, 12, 4, 14, 1, -19 },
  { 980, 6, 7, 15, 4, -6 },
  { 986, 18, 43, 21, 1, -40 },
  { 1083, 21, 42, 28, 3, -41 },
  { 1194, 14, 40, 28, 4, -40 },
  { 1264, 22, 41, 28, 3, -41 },
  { 1377, 21, 42, 28, 3, -41 },
  { 1488, 24, 40, 28, 2, -40 },
  { 1608, 21, 41, 28, 4, -40 },
  { 1716, 21, 41, 28, 4, -40 },
  { 1824, 23, 40, 28, 2, -40 },
  { 1939, 21, 42, 28, 3, -41 },
  { 2050, 21, 41, 28, 3, -41 },
  { 2158, 6, 31, 13, 4, -30 },
  { 2182, 8, 38, 11, 1, -30 },
  { 2220, 19, 25, 25, 2, -30 },
  { 2280, 19, 15, 27, 4, -26 },
  { 2316, 19, 25, 26, 4, -30 },
  { 2376, 19, 42, 24, 2, -41 },
  { 2476, 37, 51, 43, 3, -39 },
  { 2712, 30, 40, 32, 1, -40 },
  { 2862, 23, 40, 31, 4, -40 },
  { 2977, 26, 42, 32, 3, -41 },
  { 3114, 25, 40, 32, 4, -40 },
  { 3239, 22, 40, 28, 4, -40 },
  { 3349, 21, 40, 27, 4, -40 },
  { 3454, 26, 42, 33, 3, -41 },
  { 3591, 26, 40, 35, 4, -40 },
  { 3721, 5, 40, 14, 5, -40 },
  { 3746, 21, 41, 27, 2, -40 },
  { 3854, 26, 40, 31, 4, -40 },
  { 3984, 21, 40, 27, 4, -40 },
  { 4089, 34, 40, 42, 4, -40 },
  { 4259, 26, 40, 35, 4, -40 },
  { 4389, 27, 42, 34, 3, -41 },
  { 4531, 25, 40, 31, 4, -40 },
  { 4656, 28, 48, 34, 3, -41 },
  { 4824, 25, 40, 30, 4, -40 },
  { 4949, 25, 42, 29, 2, -41 },
  { 5081, 26, 40, 29, 2, -40 },
  { 5211, 24, 41, 31, 4, -40 },
  { 5334, 29, 40, 31, 1, -40 },
  { 5479, 39, 40, 43, 2, -40 },
  { 5674, 27, 40, 31, 2, -40 },
  { 5809, 28, 40, 29, 1, -40 },
  { 5949, 24, 40, 29, 3, -40 },
  { 6069, 9, 55, 14, 4, -46 },
  { 6131, 19, 43, 21, 1, -40 },
  { 6234, 9, 55, 14, 1, -46 },
  { 6296, 17, 20, 21, 2, -40 },
  { 6339, 21, 4, 23, 1, 0 },
  { 6350, 11, 8, 17, 2, -42 },
  { 6361, 21, 32, 27, 3, -31 },
  { 6445, 21, 43, 28, 4, -42 },
  { 6558, 21, 32, 26, 3, -31 },
  { 6642, 21, 43, 28, 3, -42 },
  { 6755, 21, 32, 26, 3, -31 },
  { 6839, 15, 43, 18, 2, -43 },
  { 6920, 21, 42, 28, 3, -31 },
  { 7031, 19, 42, 27, 4, -42 },
  { 7131, 5, 41, 13, 4, -41 },
  { 7157, 10, 52, 13, -1, -41 },
  { 7222, 21, 42, 25, 4, -42 },
  { 7333, 5, 42, 13, 4, -42 },
  { 7360, 35, 31, 42, 4, -31 },
  { 7496, 19, 31, 27, 4, -31 },
  { 7570, 23, 32, 28, 3, -31 },
  { 7662, 21, 42, 28, 4, -31 },
  { 7773, 21, 42, 28, 3, -31 },
  { 7884, 12, 31, 17, 4, -31 },
  { 7931, 20, 32, 26, 3, -31 },
  { 8011, 13, 38, 17, 1, -37 },
  { 8073, 19, 31, 27, 4, -30 },
  { 8147, 22, 30, 24, 1, -30 },
  { 8230, 34, 30, 36, 1, -30 },
  { 8358, 22, 30, 25, 1, -30 },
  { 8441, 21, 41, 23, 1, -30 },
  { 8549, 19, 30, 25, 3, -30 },
  { 8621, 14, 54, 17, 2, -44 },
  { 8716, 4, 47, 14, 5, -40 },
  { 8740, 14, 54, 17, 1, -44 },
  { 8835, 27, 11, 33, 3, -22 },
};

const GFXfont RobotoCondensed_Regular56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_REGULAR56PT7B_H_
