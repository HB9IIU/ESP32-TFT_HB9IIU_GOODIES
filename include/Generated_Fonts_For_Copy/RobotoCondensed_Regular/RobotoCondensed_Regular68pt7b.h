#ifndef _ROBOTOCONDENSED_REGULAR68PT7B_H_
#define _ROBOTOCONDENSED_REGULAR68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF3, 0xEF, 0xFF, 0xFF, 0xBE, 0x38, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x78, 0x00, 0xF8,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0xF0, 0x00, 0x7F, 0xFE, 0x1E, 0x00,
  0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x00, 0xFF, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0x00, 0x7C,
  0x3F, 0xFC, 0x00, 0x07, 0x87, 0xFF, 0xC0, 0x00, 0xF8, 0xF8, 0x3E, 0x00,
  0x0F, 0x0F, 0x81, 0xE0, 0x01, 0xF1, 0xF0, 0x1F, 0x00, 0x1E, 0x1F, 0x01,
  0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x01,
  0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0xC0, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFD, 0xF8, 0x07, 0xC1, 0xFC, 0xFE, 0x03, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC1, 0xF8, 0xFE, 0x07, 0xF0, 0xFC, 0x7E, 0x01, 0xFC, 0x7C,
  0x3F, 0x00, 0x7F, 0x3E, 0x3F, 0x00, 0x3F, 0x9F, 0x1F, 0x80, 0x0F, 0xFF,
  0x8F, 0xC0, 0x03, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0xC1, 0xF8, 0x00, 0x7F,
  0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF8, 0x0F, 0xC0, 0x07, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF9, 0xFC, 0x07, 0xFF,
  0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x70, 0x1F, 0x00, 0xCF, 0x83, 0xE0, 0xF9, 0xFE, 0x7C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x0C, 0x00, 0x70, 0x00, 0x80, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7,
  0xE7, 0xE3, 0xF3, 0xF0, 0xF0, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x9F, 0x00,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xE3, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x01,
  0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x07, 0xFC, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80,
  0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0xF1, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x8F, 0xE0, 0x03, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFC, 0x03, 0xFC, 0x3E, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE7, 0xFF, 0x01, 0xF3, 0xFF,
  0xE0, 0x7D, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xF3, 0xFF,
  0x01, 0xFC, 0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0x07, 0xEF, 0xE0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0xC7, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x7F, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFC, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0x7F,
  0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xF0, 0x7F, 0xFC, 0xFC,
  0x07, 0xFE, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x11,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0x80, 0x02, 0x03, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE3, 0xF0, 0x38, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0xFE, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0xFC, 0x01, 0xE1, 0xF0, 0x01, 0xFF,
  0xF0, 0x07, 0x8F, 0x80, 0x1F, 0xFF, 0xC0, 0x3C, 0x78, 0x00, 0xFC, 0x7E,
  0x01, 0xE7, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0x79, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xFE,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xFF, 0x80,
  0x7C, 0x01, 0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0x3E,
  0x00, 0x78, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x7F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0x7B, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xDF, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xE7,
  0xC0, 0x7E, 0x07, 0xF0, 0x0F, 0x3E, 0x03, 0xF0, 0x3F, 0x80, 0xF0, 0xF0,
  0x0F, 0xC7, 0xBE, 0x0F, 0x87, 0x80, 0x7F, 0xFD, 0xF8, 0xF8, 0x3E, 0x01,
  0xFF, 0xCF, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0x80, 0x1F,
  0xC0, 0xFF, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFE, 0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xD0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFF, 0xBF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0x87,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7D, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0xEF, 0x80, 0x00, 0x3F, 0x7F,
  0xF7, 0xE0, 0x00, 0x1F, 0x7F, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0xFC, 0xF8,
  0x00, 0x0F, 0xDF, 0xFE, 0x7E, 0x00, 0x07, 0xCF, 0xFF, 0x3F, 0x00, 0x07,
  0xE7, 0xFF, 0x8F, 0x80, 0x03, 0xF3, 0xFF, 0xC7, 0xE0, 0x01, 0xF1, 0xFF,
  0xE3, 0xF0, 0x01, 0xF8, 0xFF, 0xF0, 0xF8, 0x00, 0xFC, 0x7F, 0xF8, 0x7E,
  0x00, 0x7C, 0x3F, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xFE, 0x0F, 0x80, 0x3F,
  0x0F, 0xFF, 0x07, 0xE0, 0x1F, 0x07, 0xFF, 0x83, 0xF0, 0x1F, 0x83, 0xFF,
  0xC0, 0xF8, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x07, 0xC0, 0xFF, 0xF0, 0x3F,
  0x07, 0xE0, 0x7F, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0xFC, 0x07, 0xE1, 0xF0,
  0x1F, 0xFE, 0x03, 0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0xFC, 0x07, 0xFF,
  0x80, 0x7E, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0x3E, 0x01, 0xFF, 0xE0, 0x0F,
  0xBF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFD, 0xF0, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0xF8,
  0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0x7C, 0x00, 0x3F, 0xFC, 0x7E,
  0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x1F,
  0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x03,
  0xF0, 0x3F, 0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x01, 0xF8, 0x3F, 0xFC, 0x01,
  0xF8, 0x3F, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x7C, 0x3F, 0xFC, 0x00,
  0x7E, 0x3F, 0xFC, 0x00, 0x3E, 0x3F, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0x00,
  0x1F, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x0F, 0xBF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xCF, 0xC0, 0x00, 0xFF, 0x3F,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F,
  0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83,
  0xF0, 0x03, 0xFF, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0xEF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x78, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x7C, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x1E, 0x03, 0xF0, 0x07,
  0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x0F, 0x07, 0xE0, 0x07,
  0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x03,
  0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x03,
  0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x01,
  0xF1, 0xE0, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x01,
  0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x01,
  0xFB, 0xC0, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC7, 0xE0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7,
  0xFF, 0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xEF, 0xC3, 0xFF, 0xE7, 0xF0, 0x7F, 0xE1, 0xF8, 0x07, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0xFF, 0xC0, 0xFC, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0x00,
  0x3F, 0xBF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0xF8, 0xFD,
  0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0x0F, 0xC3, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFC,
  0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x07, 0xFE, 0x3F, 0x07, 0xFF, 0xEF, 0xC3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0x3F, 0xC0, 0x7F,
  0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xF0, 0x1F, 0xF1, 0xFF, 0xBF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xE7, 0xC1, 0xFF, 0xF9, 0xF0, 0x1F,
  0xF8, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC3, 0xF8, 0x00, 0x70, 0xFF, 0x00,
  0x3E, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x7F, 0xFE, 0x7C, 0x3F,
  0xFF, 0xDF, 0x1F, 0xFF, 0xF7, 0xC7, 0xFE, 0xFF, 0xF3, 0xFC, 0x07, 0xFC,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFF, 0x01, 0xFF, 0x1F, 0xFB, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0x01, 0xFF,
  0x8F, 0xC0, 0x0F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x30, 0x00, 0x7E,
  0x1E, 0x00, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1E, 0x01, 0xF8, 0x7F,
  0xE0, 0xFC, 0xFF, 0xF8, 0x7E, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0x7F, 0xCF, 0xFC, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0xFD, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xE0, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE1, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F,
  0xF0, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F,
  0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0xFE, 0x00,
  0xFF, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x8F, 0xFE,
  0x03, 0xFF, 0x83, 0xF3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xF7, 0xF8, 0x03, 0xFF, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xDF, 0x80, 0x07, 0xF0, 0x01, 0xFB, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x7E, 0x1F, 0xF8, 0x3F, 0x3F, 0xFE, 0x1F, 0xBF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xDF, 0xF3, 0xFF, 0x01, 0xFD, 0xFE, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0x1F, 0xFC, 0x0F, 0xCF, 0xFF, 0xC3, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFD, 0xFF, 0xCF, 0xF8, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xF0, 0x03,
  0xFB, 0xFE, 0x01, 0xFC, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xDF,
  0xFF, 0xE3, 0xF3, 0xFF, 0xF0, 0xFC, 0x7F, 0xF0, 0x3F, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xE1,
  0xF0, 0x7F, 0xFE, 0x7C, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFC,
  0x3F, 0xF3, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFF,
  0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xBF, 0x01, 0xFF, 0x8F, 0xC0, 0x0F, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x01, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F,
  0x07, 0xFF, 0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0xFF, 0x00, 0x3E,
  0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00,
  0xFF, 0x00, 0x7E, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x3F, 0x01, 0xFF, 0x80,
  0x7C, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x1F,
  0x03, 0xE7, 0xC0, 0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x1F, 0x83, 0xE7,
  0xC0, 0xF8, 0x1F, 0x83, 0xE7, 0xE1, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFE,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07,
  0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x0F, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0xC0,
  0x1F, 0x3F, 0xBF, 0xE0, 0x3E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7C, 0x07, 0xFD,
  0xFE, 0x7C, 0x03, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0xFF,
  0xF0, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 49, 17, 5, -48 },
  { 44, 13, 16, 22, 5, -51 },
  { 70, 32, 48, 37, 4, -48 },
  { 262, 26, 63, 34, 4, -56 },
  { 467, 36, 50, 43, 4, -49 },
  { 692, 33, 50, 37, 3, -49 },
  { 899, 5, 16, 12, 3, -51 },
  { 909, 16, 71, 21, 4, -55 },
  { 1051, 15, 71, 22, 2, -55 },
  { 1185, 27, 28, 29, 1, -48 },
  { 1280, 28, 35, 34, 3, -40 },
  { 1403, 9, 17, 13, 1, -7 },
  { 1423, 13, 5, 17, 2, -23 },
  { 1432, 7, 8, 18, 5, -7 },
  { 1439, 22, 52, 25, 1, -48 },
  { 1582, 26, 50, 34, 4, -49 },
  { 1745, 16, 48, 34, 5, -48 },
  { 1841, 28, 49, 34, 3, -49 },
  { 2013, 26, 50, 34, 3, -49 },
  { 2176, 30, 48, 34, 2, -48 },
  { 2356, 26, 49, 34, 5, -48 },
  { 2516, 26, 49, 34, 4, -48 },
  { 2676, 28, 48, 34, 3, -48 },
  { 2844, 26, 50, 34, 4, -49 },
  { 3007, 26, 49, 34, 3, -49 },
  { 3167, 7, 37, 16, 5, -36 },
  { 3200, 10, 46, 14, 1, -36 },
  { 3258, 22, 29, 30, 3, -36 },
  { 3338, 23, 18, 33, 5, -32 },
  { 3390, 23, 30, 31, 5, -37 },
  { 3477, 23, 50, 29, 3, -49 },
  { 3621, 45, 63, 52, 4, -48 },
  { 3976, 37, 48, 39, 1, -48 },
  { 4198, 28, 48, 37, 5, -48 },
  { 4366, 32, 50, 39, 4, -49 },
  { 4566, 30, 48, 39, 5, -48 },
  { 4746, 26, 48, 34, 5, -48 },
  { 4902, 25, 48, 33, 5, -48 },
  { 5052, 32, 50, 40, 4, -49 },
  { 5252, 32, 48, 42, 5, -48 },
  { 5444, 7, 48, 17, 5, -48 },
  { 5486, 26, 49, 33, 2, -48 },
  { 5646, 32, 48, 37, 5, -48 },
  { 5838, 25, 48, 32, 5, -48 },
  { 5988, 41, 48, 51, 5, -48 },
  { 6234, 32, 48, 42, 5, -48 },
  { 6426, 33, 50, 41, 4, -49 },
  { 6633, 30, 48, 38, 5, -48 },
  { 6813, 33, 57, 41, 4, -49 },
  { 7049, 30, 48, 36, 5, -48 },
  { 7229, 29, 50, 35, 3, -49 },
  { 7411, 31, 48, 35, 2, -48 },
  { 7597, 30, 49, 38, 4, -48 },
  { 7781, 36, 48, 38, 1, -48 },
  { 7997, 48, 48, 52, 2, -48 },
  { 8285, 33, 48, 37, 2, -48 },
  { 8483, 34, 48, 36, 1, -48 },
  { 8687, 30, 48, 36, 3, -48 },
  { 8867, 11, 65, 17, 5, -55 },
  { 8957, 22, 52, 25, 2, -48 },
  { 9100, 11, 65, 17, 1, -55 },
  { 9190, 21, 24, 25, 2, -48 },
  { 9253, 26, 5, 28, 1, 0 },
  { 9270, 14, 10, 21, 2, -51 },
  { 9288, 25, 38, 33, 4, -37 },
  { 9407, 26, 52, 34, 4, -51 },
  { 9576, 26, 38, 31, 3, -37 },
  { 9700, 26, 52, 34, 3, -51 },
  { 9869, 26, 38, 32, 3, -37 },
  { 9993, 19, 52, 22, 2, -52 },
  { 10117, 26, 51, 34, 3, -37 },
  { 10283, 25, 51, 33, 4, -51 },
  { 10443, 6, 49, 16, 5, -49 },
  { 10480, 12, 63, 15, -1, -49 },
  { 10575, 26, 51, 31, 4, -51 },
  { 10741, 6, 51, 16, 5, -51 },
  { 10780, 43, 37, 51, 4, -37 },
  { 10979, 25, 37, 33, 4, -37 },
  { 11095, 28, 38, 34, 3, -37 },
  { 11228, 26, 51, 34, 4, -37 },
  { 11394, 26, 51, 34, 3, -37 },
  { 11560, 15, 37, 21, 4, -37 },
  { 11630, 25, 38, 31, 3, -37 },
  { 11749, 17, 46, 20, 1, -45 },
  { 11847, 24, 37, 33, 4, -36 },
  { 11958, 25, 36, 29, 2, -36 },
  { 12071, 40, 36, 44, 2, -36 },
  { 12251, 26, 36, 30, 2, -36 },
  { 12368, 26, 50, 28, 1, -36 },
  { 12531, 24, 36, 30, 3, -36 },
  { 12639, 17, 65, 21, 2, -53 },
  { 12778, 5, 57, 17, 6, -48 },
  { 12814, 17, 65, 21, 1, -53 },
  { 12953, 32, 13, 40, 4, -26 },
};

const GFXfont RobotoCondensed_Regular68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_REGULAR68PT7B_H_
