#ifndef _ROBOTOCONDENSED_REGULAR13PT7B_H_
#define _ROBOTOCONDENSED_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x28, 0xAF, 0xD2, 0x51, 0x4F, 0x94, 0x50, 0x23,
  0xA5, 0x1C, 0x38, 0x71, 0x9B, 0x88, 0xC1, 0x52, 0xA6, 0x81, 0x05, 0x8C,
  0xA9, 0x0C, 0x73, 0x49, 0x18, 0x62, 0xA9, 0xA6, 0x7C, 0xE0, 0x29, 0x49,
  0x24, 0x91, 0x22, 0x89, 0x12, 0x49, 0x25, 0x28, 0x25, 0x1E, 0x64, 0x80,
  0x21, 0x09, 0xF2, 0x10, 0x80, 0x58, 0xE0, 0x80, 0x11, 0x12, 0x22, 0x44,
  0x48, 0x74, 0xA7, 0x18, 0xC6, 0x72, 0x70, 0x3C, 0x92, 0x49, 0x20, 0x74,
  0xA6, 0x21, 0x11, 0x18, 0xF8, 0x74, 0xA4, 0x26, 0x0A, 0x72, 0x70, 0x08,
  0x62, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0x7E, 0x21, 0xE1, 0x86, 0x33, 0x70,
  0x32, 0x21, 0xE9, 0xC6, 0x33, 0x70, 0xF8, 0xC4, 0x22, 0x11, 0x88, 0x40,
  0x74, 0xA7, 0x26, 0x4A, 0x33, 0x70, 0x74, 0xA5, 0x39, 0xB8, 0x42, 0x60,
  0x82, 0x40, 0x05, 0x80, 0x09, 0x98, 0xC3, 0x04, 0xF0, 0xF0, 0x8E, 0x33,
  0xE8, 0xE9, 0x12, 0x64, 0x00, 0x40, 0x3C, 0x42, 0x41, 0x9D, 0xA5, 0xA5,
  0xA5, 0xAD, 0xB6, 0x80, 0x40, 0x3C, 0x10, 0x30, 0xA1, 0x42, 0x4C, 0x9F,
  0x21, 0xC2, 0xF4, 0x63, 0x1F, 0x46, 0x31, 0xF0, 0x7B, 0x28, 0x60, 0x82,
  0x08, 0x72, 0x78, 0xF2, 0x28, 0xA3, 0x8E, 0x38, 0xA2, 0xF0, 0xFC, 0x21,
  0x0F, 0x42, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x80, 0x7B, 0x28,
  0x60, 0x9E, 0x18, 0x73, 0x78, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84,
  0xFF, 0x80, 0x08, 0x42, 0x10, 0x87, 0x29, 0x70, 0x8A, 0x69, 0x28, 0xE3,
  0xC9, 0x22, 0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xC3, 0xC3, 0xC3,
  0xA5, 0xA5, 0xA5, 0x99, 0x99, 0x99, 0x87, 0x1E, 0x69, 0xB6, 0x58, 0xE3,
  0x84, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0xFA, 0x38, 0x63, 0xFA,
  0x08, 0x20, 0x80, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0x30, 0x40,
  0xF2, 0x28, 0xA2, 0xF2, 0x49, 0xA2, 0x8C, 0x74, 0x63, 0x87, 0x06, 0x31,
  0x70, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE2, 0x70, 0xC2, 0x8D, 0x13, 0x22, 0xC5, 0x0A, 0x0C, 0x10, 0x4C,
  0x93, 0x24, 0xC9, 0x32, 0x52, 0x8C, 0xC3, 0x30, 0xCC, 0x21, 0x00, 0x44,
  0xC8, 0xA1, 0xC1, 0x07, 0x0A, 0x32, 0x44, 0xC4, 0x89, 0xA1, 0x43, 0x82,
  0x04, 0x08, 0x10, 0xF8, 0xC4, 0x62, 0x21, 0x10, 0xF8, 0xEA, 0xAA, 0xAA,
  0xC0, 0xC2, 0x10, 0xC2, 0x10, 0x82, 0x10, 0x80, 0xD5, 0x55, 0x55, 0xC0,
  0x22, 0x55, 0x50, 0xF8, 0x44, 0x74, 0x84, 0xE9, 0x4B, 0xC0, 0x84, 0x21,
  0xE9, 0xC6, 0x31, 0x9F, 0x80, 0x74, 0xA1, 0x08, 0x49, 0xC0, 0x18, 0xC7,
  0xF9, 0xCE, 0x73, 0x9B, 0xC0, 0x74, 0xA7, 0xF8, 0x41, 0xC0, 0x36, 0x4F,
  0x44, 0x44, 0x44, 0xEC, 0xE7, 0x39, 0xCD, 0xE3, 0x97, 0x80, 0x88, 0x8F,
  0x99, 0x99, 0x99, 0xBF, 0x80, 0x45, 0x55, 0x57, 0x84, 0x21, 0x2A, 0x73,
  0x94, 0x94, 0x80, 0xFF, 0xC0, 0xF6, 0x99, 0x91, 0x91, 0x91, 0x91, 0x91,
  0xF9, 0x99, 0x99, 0x90, 0x74, 0xE3, 0x18, 0xCD, 0xC0, 0xF4, 0xE3, 0x18,
  0xCF, 0xD0, 0x84, 0x00, 0xFC, 0xE7, 0x39, 0xCF, 0xE3, 0x18, 0xC0, 0xF2,
  0x49, 0x20, 0xF9, 0x86, 0x19, 0xF0, 0x4B, 0xA4, 0x92, 0x20, 0x99, 0x99,
  0x99, 0xF0, 0xCA, 0x56, 0xA3, 0x18, 0x80, 0xC9, 0x59, 0x5B, 0x56, 0x56,
  0x26, 0x26, 0x4A, 0x8C, 0x43, 0x2D, 0x20, 0xCA, 0x54, 0xA3, 0x18, 0x84,
  0x22, 0x00, 0xF3, 0x24, 0x48, 0xF0, 0x32, 0x22, 0x6C, 0x42, 0x22, 0x21,
  0xFF, 0xE0, 0xC4, 0x44, 0x63, 0x64, 0x44, 0x48, 0x66, 0x99, 0x80,
};

const GFXglyph RobotoCondensed_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -10 },
  { 4, 6, 9, 7, 1, -9 },
  { 11, 5, 11, 6, 1, -10 },
  { 18, 7, 9, 8, 1, -9 },
  { 26, 6, 9, 7, 1, -9 },
  { 33, 1, 3, 2, 1, -10 },
  { 34, 3, 13, 4, 1, -10 },
  { 39, 3, 13, 4, 0, -10 },
  { 44, 5, 5, 6, 0, -9 },
  { 48, 5, 7, 6, 1, -8 },
  { 53, 2, 3, 3, 0, -1 },
  { 54, 3, 1, 3, 0, -4 },
  { 55, 1, 1, 3, 1, -1 },
  { 56, 4, 10, 5, 0, -9 },
  { 61, 5, 9, 6, 1, -9 },
  { 67, 3, 9, 6, 1, -9 },
  { 71, 5, 9, 6, 1, -9 },
  { 77, 5, 9, 6, 1, -9 },
  { 83, 6, 9, 6, 0, -9 },
  { 90, 5, 9, 6, 1, -9 },
  { 96, 5, 9, 6, 1, -9 },
  { 102, 5, 9, 6, 1, -9 },
  { 108, 5, 9, 6, 1, -9 },
  { 114, 5, 9, 6, 1, -9 },
  { 120, 1, 7, 3, 1, -7 },
  { 121, 2, 9, 3, 0, -7 },
  { 124, 5, 6, 6, 0, -7 },
  { 128, 4, 3, 6, 1, -6 },
  { 130, 4, 6, 6, 1, -7 },
  { 133, 4, 9, 5, 1, -9 },
  { 138, 8, 12, 10, 1, -9 },
  { 150, 7, 9, 8, 0, -9 },
  { 158, 5, 9, 7, 1, -9 },
  { 164, 6, 9, 7, 1, -9 },
  { 171, 6, 9, 7, 1, -9 },
  { 178, 5, 9, 6, 1, -9 },
  { 184, 5, 9, 6, 1, -9 },
  { 190, 6, 9, 8, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 1, 9, 3, 1, -9 },
  { 206, 5, 9, 6, 0, -9 },
  { 212, 6, 9, 7, 1, -9 },
  { 219, 5, 9, 6, 1, -9 },
  { 225, 8, 9, 10, 1, -9 },
  { 234, 6, 9, 8, 1, -9 },
  { 241, 6, 9, 8, 1, -9 },
  { 248, 6, 9, 7, 1, -9 },
  { 255, 6, 11, 8, 1, -9 },
  { 264, 6, 9, 7, 1, -9 },
  { 271, 5, 9, 7, 1, -9 },
  { 277, 6, 9, 7, 0, -9 },
  { 284, 6, 9, 7, 1, -9 },
  { 291, 7, 9, 7, 0, -9 },
  { 299, 10, 9, 10, 0, -9 },
  { 311, 7, 9, 7, 0, -9 },
  { 319, 7, 9, 7, 0, -9 },
  { 327, 5, 9, 7, 1, -9 },
  { 333, 2, 13, 3, 1, -11 },
  { 337, 5, 10, 5, 0, -9 },
  { 344, 2, 13, 3, 0, -11 },
  { 348, 4, 5, 5, 0, -9 },
  { 351, 5, 1, 5, 0, 0 },
  { 352, 3, 2, 4, 0, -10 },
  { 353, 5, 7, 6, 1, -7 },
  { 358, 5, 10, 6, 1, -10 },
  { 365, 5, 7, 6, 1, -7 },
  { 370, 5, 10, 6, 1, -10 },
  { 377, 5, 7, 6, 1, -7 },
  { 382, 4, 10, 4, 0, -10 },
  { 387, 5, 10, 6, 1, -7 },
  { 394, 4, 10, 6, 1, -10 },
  { 399, 1, 9, 3, 1, -9 },
  { 401, 2, 12, 3, 0, -9 },
  { 404, 5, 10, 6, 1, -10 },
  { 411, 1, 10, 3, 1, -10 },
  { 413, 8, 7, 10, 1, -7 },
  { 420, 4, 7, 6, 1, -7 },
  { 424, 5, 7, 7, 1, -7 },
  { 429, 5, 10, 6, 1, -7 },
  { 436, 5, 10, 7, 1, -7 },
  { 443, 3, 7, 4, 1, -7 },
  { 446, 4, 7, 6, 1, -7 },
  { 450, 3, 9, 4, 0, -9 },
  { 454, 4, 7, 6, 1, -7 },
  { 458, 5, 7, 6, 0, -7 },
  { 463, 8, 7, 8, 0, -7 },
  { 470, 5, 7, 6, 0, -7 },
  { 475, 5, 10, 5, 0, -7 },
  { 482, 4, 7, 6, 1, -7 },
  { 486, 4, 12, 4, 0, -10 },
  { 492, 1, 11, 3, 1, -9 },
  { 494, 4, 12, 4, 0, -10 },
  { 500, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Regular13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_REGULAR13PT7B_H_
