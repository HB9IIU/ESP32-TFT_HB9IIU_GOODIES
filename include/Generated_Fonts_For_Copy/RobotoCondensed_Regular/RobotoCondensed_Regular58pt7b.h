#ifndef _ROBOTOCONDENSED_REGULAR58PT7B_H_
#define _ROBOTOCONDENSED_REGULAR58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x79, 0xFF, 0xDF, 0x7C, 0x40, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00,
  0x1C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x1E, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF1,
  0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x40, 0x3C, 0x0F, 0x00, 0xE0, 0x78,
  0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x1E, 0x03, 0xC0,
  0x70, 0x38, 0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x01, 0xC1, 0xC0, 0x1E, 0x07,
  0x87, 0x80, 0x1E, 0x0F, 0x1E, 0x00, 0x3C, 0x3E, 0x3C, 0x00, 0x3F, 0xF8,
  0xF0, 0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x08, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x1C, 0x3F,
  0xF0, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0xE1, 0xE1, 0xE0, 0x03, 0xC7, 0x81,
  0xE0, 0x0F, 0x0F, 0x03, 0xC0, 0x1E, 0x1C, 0x07, 0x80, 0x78, 0x38, 0x0F,
  0x00, 0xF0, 0x70, 0x1E, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x81, 0xC0, 0x78,
  0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x70, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x7C, 0x3F, 0x3F, 0x07, 0xC7, 0xE1,
  0xF8, 0x7C, 0x7C, 0x1F, 0x87, 0xCF, 0xC0, 0xFC, 0x7C, 0xF8, 0x07, 0xE7,
  0x8F, 0x80, 0x7E, 0xF8, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xF8,
  0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xC7, 0xE0, 0x3F, 0xF0, 0x3F, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01,
  0x80, 0x1C, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x20, 0x80,
  0x06, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x38, 0x1E, 0x06,
  0x7C, 0x38, 0x7D, 0xFF, 0x73, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x80, 0x38, 0x00, 0x00, 0x40, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x38, 0xFB, 0xF7, 0xFF, 0xCF, 0x84, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x1F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x1F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0xF8,
  0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0xFC,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xBF, 0x00, 0x3E, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE7, 0xE0, 0x0F, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x1F, 0x80, 0xFE, 0x3C, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E,
  0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x3E, 0x7F,
  0xE0, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0x3F, 0xC0, 0xFC,
  0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x87, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F,
  0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xFC, 0x7E, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3F, 0x01,
  0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xF8, 0xFC, 0x0F,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00,
  0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0xCF, 0xF3, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFD, 0xF0, 0x7F, 0xC7, 0x80, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3B,
  0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xFF, 0xF7, 0xC4, 0x0E,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7E,
  0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x03, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0xF8, 0x07, 0x07, 0x80, 0x3F, 0xF8, 0x0F, 0x1E, 0x00, 0xFF,
  0xF8, 0x1E, 0x3C, 0x03, 0xE0, 0xF0, 0x1C, 0x78, 0x07, 0x81, 0xE0, 0x39,
  0xE0, 0x1E, 0x03, 0xC0, 0x73, 0xC0, 0x3C, 0x07, 0x80, 0xE7, 0x80, 0xF0,
  0x1E, 0x01, 0xEF, 0x01, 0xE0, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x78, 0x07,
  0xB8, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x01, 0xE0, 0x1F, 0xE0, 0x3C,
  0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F, 0x00,
  0xFF, 0x01, 0xE0, 0x1E, 0x01, 0xFE, 0x07, 0xC0, 0x3C, 0x03, 0xBC, 0x0F,
  0x80, 0x78, 0x07, 0x78, 0x1F, 0x00, 0xF0, 0x0E, 0xF0, 0x3E, 0x01, 0xE0,
  0x3D, 0xE0, 0x3C, 0x07, 0xC0, 0x79, 0xC0, 0x78, 0x0F, 0x80, 0xE3, 0xC0,
  0xF8, 0x3F, 0x03, 0xC7, 0x81, 0xF0, 0xFE, 0x07, 0x0F, 0x01, 0xFF, 0xFE,
  0x3E, 0x1E, 0x03, 0xFF, 0x3F, 0xF8, 0x3C, 0x03, 0xFC, 0x7F, 0xE0, 0x3C,
  0x03, 0xF0, 0x7F, 0x80, 0x78, 0x01, 0x00, 0x10, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC,
  0x07, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF0,
  0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x3F, 0x80, 0x0F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F,
  0x07, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xC0, 0x07, 0xFC, 0xF8,
  0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xEF, 0x80, 0x01, 0xF7, 0xFD, 0xF0, 0x00, 0x3E, 0xFF, 0xBE, 0x00, 0x07,
  0xDF, 0xF3, 0xC0, 0x01, 0xF7, 0xFE, 0x7C, 0x00, 0x3E, 0xFF, 0xCF, 0x80,
  0x07, 0x9F, 0xF8, 0xF0, 0x01, 0xF3, 0xFF, 0x1F, 0x00, 0x3E, 0x7F, 0xE3,
  0xE0, 0x07, 0x8F, 0xFC, 0x3C, 0x01, 0xF1, 0xFF, 0x87, 0xC0, 0x3E, 0x3F,
  0xF8, 0xF8, 0x07, 0x87, 0xFF, 0x0F, 0x01, 0xF0, 0xFF, 0xE1, 0xF0, 0x3E,
  0x1F, 0xFC, 0x3E, 0x07, 0x83, 0xFF, 0x83, 0xC1, 0xF0, 0x7F, 0xF0, 0x7C,
  0x3E, 0x0F, 0xFE, 0x0F, 0x87, 0x81, 0xFF, 0xC0, 0xF1, 0xF0, 0x3F, 0xF8,
  0x1F, 0x3E, 0x07, 0xFF, 0x03, 0xE7, 0x80, 0xFF, 0xE0, 0x3C, 0xF0, 0x1F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xFC,
  0x00, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0xF8, 0x01, 0xFF, 0xDF, 0x00, 0x3F,
  0xF9, 0xF0, 0x07, 0xFF, 0x3E, 0x00, 0xFF, 0xE3, 0xE0, 0x1F, 0xFC, 0x7C,
  0x03, 0xFF, 0x87, 0xC0, 0x7F, 0xF0, 0xF8, 0x0F, 0xFE, 0x0F, 0x81, 0xFF,
  0xC1, 0xF0, 0x3F, 0xF8, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0xFF, 0xE0, 0x3E,
  0x1F, 0xFC, 0x03, 0xC3, 0xFF, 0x80, 0x7C, 0x7F, 0xF0, 0x07, 0xCF, 0xFE,
  0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0xBF, 0xF8, 0x01, 0xF7, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x7E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0,
  0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xC0, 0x03,
  0xE7, 0xC0, 0x07, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xF8, 0x01, 0xF9, 0xF0,
  0x01, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0xFF,
  0x80, 0x3E, 0x1F, 0x00, 0x7B, 0xC0, 0x1F, 0x0F, 0x80, 0x3D, 0xE0, 0x0F,
  0x87, 0xC0, 0x1E, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x78, 0x07, 0xC0, 0xF8,
  0x0F, 0xBE, 0x03, 0xE0, 0x7C, 0x07, 0x8F, 0x01, 0xF0, 0x3E, 0x03, 0xC7,
  0x80, 0xF8, 0x1F, 0x03, 0xE3, 0xC0, 0xF8, 0x07, 0x81, 0xF1, 0xF0, 0x7C,
  0x03, 0xE0, 0xF0, 0x78, 0x3E, 0x01, 0xF0, 0x78, 0x3C, 0x1F, 0x00, 0xF8,
  0x3C, 0x1E, 0x0F, 0x80, 0x7C, 0x3E, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x03,
  0xC7, 0xC0, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0xF1, 0xF0,
  0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x03,
  0xDF, 0x00, 0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x7C,
  0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x03, 0xE7,
  0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xC0, 0x3F,
  0x9F, 0x83, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFB, 0xE1, 0xFF, 0xCF, 0x81,
  0xFE, 0x3F, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0xFC, 0x0F, 0xBF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x1F, 0xBF, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0,
  0x03, 0xEF, 0xE0, 0x1F, 0xBF, 0xC1, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0x3F, 0xFC, 0x3C, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F,
  0xC0, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF,
  0x3F, 0xFF, 0xFC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x03,
  0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF0,
  0xFF, 0xE7, 0xC0, 0xFF, 0x1F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xC7, 0xE0, 0x07, 0x8F, 0xE0,
  0x3E, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF1, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xDF, 0x3F, 0xFF, 0xFC, 0xFC,
  0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF,
  0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC0, 0xFF,
  0x1F, 0x00, 0x60, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x60, 0x03, 0xE3, 0xC0, 0x1F, 0x8F, 0xE3, 0xFC, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x08, 0x0F, 0x8F, 0xF0, 0xFB, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0x7E, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x03, 0x81, 0xF0, 0xFC,
  0x3F, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xF7, 0xEF, 0xFB,
  0xFC, 0xFF, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x01, 0xF0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xFB, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xEF, 0x80, 0x3F, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF,
  0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x8F, 0xF0, 0x1F, 0xF0, 0xFB, 0xFF, 0x87, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xE0, 0xFE,
  0xFC, 0x03, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0x80, 0x3E, 0xF8, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x08, 0x0F,
  0x8F, 0xF0, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0x7E,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0x80,
  0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xFC,
  0x0F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xFC, 0x0F, 0x3F, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xCF, 0xC0, 0x1F, 0xBE,
  0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x81, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xBF, 0xFC, 0x3E, 0x3F, 0xC0, 0xF8, 0x10, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xF0, 0xFF,
  0xF7, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F,
  0xDF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xF7, 0xC1, 0xFF, 0x1F, 0x00, 0x60, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x2F, 0x9F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF0, 0x0F,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0xC1, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x02, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x7E,
  0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x0F, 0xF9, 0xF0,
  0x10, 0x00, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0x80, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x00,
  0x7D, 0xF0, 0x07, 0xC0, 0x0F, 0xBE, 0x00, 0xFC, 0x01, 0xE3, 0xC0, 0x1F,
  0x80, 0x7C, 0x7C, 0x07, 0xF0, 0x0F, 0x8F, 0x80, 0xFF, 0x01, 0xF1, 0xF0,
  0x1F, 0xE0, 0x3C, 0x3E, 0x03, 0xFC, 0x0F, 0x83, 0xC0, 0xFF, 0x81, 0xF0,
  0x7C, 0x1E, 0xF8, 0x3E, 0x0F, 0x83, 0xDF, 0x07, 0x81, 0xF0, 0xF9, 0xE0,
  0xF0, 0x1E, 0x1F, 0x3C, 0x3E, 0x03, 0xE3, 0xC7, 0xC7, 0xC0, 0x7C, 0x78,
  0x78, 0xF0, 0x0F, 0x9F, 0x0F, 0x1E, 0x00, 0xF3, 0xC1, 0xE3, 0xC0, 0x1E,
  0x78, 0x3E, 0xF8, 0x03, 0xEF, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x7B, 0xC0,
  0x07, 0xF8, 0x0F, 0x78, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7C, 0x7C,
  0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x01, 0xF0,
  0x7E, 0x03, 0xE0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x03, 0xE0, 0x7C,
  0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0xFF, 0xE0, 0x0F, 0xBF, 0xFE,
  0x01, 0xE7, 0xFF, 0xE0, 0x3D, 0xF0, 0x7E, 0x0F, 0xBE, 0x07, 0xFF, 0xE7,
  0x80, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xE0, 0x00,
};

const GFXglyph RobotoCondensed_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 42, 14, 4, -41 },
  { 33, 12, 14, 19, 4, -44 },
  { 54, 26, 41, 32, 4, -41 },
  { 188, 23, 54, 29, 3, -48 },
  { 344, 31, 43, 37, 3, -42 },
  { 511, 28, 43, 32, 3, -42 },
  { 662, 4, 14, 10, 3, -44 },
  { 669, 13, 60, 18, 4, -47 },
  { 767, 13, 60, 19, 2, -47 },
  { 865, 23, 24, 25, 1, -41 },
  { 934, 24, 30, 29, 2, -34 },
  { 1024, 8, 14, 11, 1, -6 },
  { 1038, 12, 4, 14, 1, -19 },
  { 1044, 7, 7, 15, 4, -6 },
  { 1051, 19, 45, 22, 1, -41 },
  { 1158, 22, 43, 29, 3, -42 },
  { 1277, 13, 41, 29, 5, -41 },
  { 1344, 23, 42, 29, 3, -42 },
  { 1465, 22, 43, 29, 3, -42 },
  { 1584, 25, 41, 29, 2, -41 },
  { 1713, 22, 42, 29, 4, -41 },
  { 1829, 22, 42, 29, 4, -41 },
  { 1945, 24, 41, 29, 2, -41 },
  { 2068, 22, 43, 29, 3, -42 },
  { 2187, 22, 42, 29, 3, -42 },
  { 2303, 6, 32, 14, 4, -31 },
  { 2327, 9, 39, 12, 1, -31 },
  { 2371, 20, 25, 26, 2, -31 },
  { 2434, 20, 17, 28, 4, -28 },
  { 2477, 20, 25, 27, 4, -31 },
  { 2540, 20, 43, 25, 2, -42 },
  { 2648, 39, 54, 45, 3, -41 },
  { 2912, 31, 41, 33, 1, -41 },
  { 3071, 24, 41, 32, 4, -41 },
  { 3194, 26, 43, 33, 4, -42 },
  { 3334, 26, 41, 33, 4, -41 },
  { 3468, 23, 41, 29, 4, -41 },
  { 3586, 22, 41, 28, 4, -41 },
  { 3699, 26, 43, 34, 4, -42 },
  { 3839, 27, 41, 36, 4, -41 },
  { 3978, 5, 41, 15, 5, -41 },
  { 4004, 22, 42, 28, 2, -41 },
  { 4120, 27, 41, 32, 4, -41 },
  { 4259, 22, 41, 28, 4, -41 },
  { 4372, 35, 41, 44, 4, -41 },
  { 4552, 27, 41, 36, 4, -41 },
  { 4691, 27, 43, 35, 4, -42 },
  { 4837, 26, 41, 32, 4, -41 },
  { 4971, 29, 49, 35, 3, -42 },
  { 5149, 26, 41, 31, 4, -41 },
  { 5283, 26, 43, 30, 2, -42 },
  { 5423, 27, 41, 30, 2, -41 },
  { 5562, 25, 42, 33, 4, -41 },
  { 5694, 30, 41, 33, 1, -41 },
  { 5848, 41, 41, 44, 2, -41 },
  { 6059, 28, 41, 32, 2, -41 },
  { 6203, 29, 41, 30, 1, -41 },
  { 6352, 25, 41, 30, 3, -41 },
  { 6481, 9, 56, 15, 4, -47 },
  { 6544, 20, 45, 21, 1, -41 },
  { 6657, 9, 56, 15, 1, -47 },
  { 6720, 18, 21, 22, 2, -41 },
  { 6768, 22, 4, 23, 1, 0 },
  { 6779, 11, 8, 18, 2, -43 },
  { 6790, 22, 33, 28, 3, -32 },
  { 6881, 22, 45, 29, 4, -44 },
  { 7005, 22, 33, 27, 3, -32 },
  { 7096, 22, 45, 29, 3, -44 },
  { 7220, 22, 33, 27, 3, -32 },
  { 7311, 16, 45, 18, 2, -45 },
  { 7401, 22, 44, 29, 3, -32 },
  { 7522, 20, 44, 28, 4, -44 },
  { 7632, 6, 42, 13, 4, -42 },
  { 7664, 10, 54, 13, -1, -42 },
  { 7732, 22, 44, 26, 4, -44 },
  { 7853, 5, 44, 13, 4, -44 },
  { 7881, 36, 32, 44, 4, -32 },
  { 8025, 20, 32, 28, 4, -32 },
  { 8105, 23, 33, 29, 3, -32 },
  { 8200, 22, 44, 29, 4, -32 },
  { 8321, 22, 44, 29, 3, -32 },
  { 8442, 12, 32, 18, 4, -32 },
  { 8490, 21, 33, 26, 3, -32 },
  { 8577, 14, 39, 17, 1, -38 },
  { 8646, 20, 32, 28, 4, -31 },
  { 8726, 22, 31, 25, 1, -31 },
  { 8812, 35, 31, 38, 1, -31 },
  { 8948, 23, 31, 25, 1, -31 },
  { 9038, 22, 43, 24, 1, -31 },
  { 9157, 20, 31, 25, 3, -31 },
  { 9235, 15, 55, 18, 2, -45 },
  { 9339, 4, 49, 14, 5, -41 },
  { 9364, 15, 55, 18, 1, -45 },
  { 9468, 27, 11, 34, 4, -22 },
};

const GFXfont RobotoCondensed_Regular58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_REGULAR58PT7B_H_
