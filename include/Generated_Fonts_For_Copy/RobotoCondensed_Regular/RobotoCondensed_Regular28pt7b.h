#ifndef _ROBOTOCONDENSED_REGULAR28PT7B_H_
#define _ROBOTOCONDENSED_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xCF, 0x3C, 0xB2,
  0xCB, 0x28, 0x80, 0x06, 0x60, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x21, 0xFF, 0xEF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x0F, 0xFF,
  0x7F, 0xF8, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0x46, 0x00,
  0x0C, 0x03, 0x00, 0xC0, 0x78, 0x7F, 0x9C, 0xEE, 0x1F, 0x83, 0xE0, 0xF8,
  0x06, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x3C, 0x0F,
  0x07, 0xF3, 0xDF, 0xE3, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x3C, 0x00, 0xFC,
  0x01, 0x98, 0x46, 0x10, 0x8C, 0x23, 0x18, 0x44, 0x19, 0x98, 0x3F, 0x60,
  0x3C, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x19, 0xE0, 0x37, 0xE0, 0xCC, 0xC1,
  0x30, 0x86, 0x61, 0x08, 0x42, 0x30, 0xCC, 0x01, 0xF8, 0x01, 0xE0, 0x0F,
  0x00, 0x7E, 0x03, 0x9C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x9C, 0x06,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1D, 0xC6, 0x63, 0x9B, 0x86, 0xEE,
  0x1F, 0x38, 0x3C, 0x60, 0x71, 0xC7, 0xC3, 0xFF, 0x87, 0xC7, 0xFF, 0xFC,
  0x04, 0x31, 0x8E, 0x31, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0xC3, 0x86, 0x18, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0xC6,
  0x18, 0x63, 0x0C, 0x61, 0x8C, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x76, 0xE7, 0xFF, 0x0F, 0x80, 0xF0, 0x1F, 0x81, 0x98, 0x30, 0xC1, 0x08,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x33, 0x33, 0x76,
  0x40, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xC1,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0xE1, 0xDC, 0xE7, 0xF0, 0x78, 0x06, 0x3D, 0xFF, 0xF8, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0x1F, 0x03, 0xFC, 0x71, 0xC6, 0x0E, 0xE0, 0xEE, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0x7F, 0xF7, 0xFF, 0x1F, 0x07, 0xF1, 0xC7, 0x30,
  0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC1, 0xF0, 0x3E, 0x00, 0xE0,
  0x0E, 0x01, 0xF8, 0x1F, 0x07, 0x60, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xDC, 0x0D, 0xC1, 0x9C, 0x19,
  0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xE1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0xCF, 0xF9, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x78, 0x7F, 0x8E, 0x78, 0x87, 0x00, 0x60, 0x0E, 0x01,
  0xF0, 0x3F, 0x06, 0xE0, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x07, 0x07, 0xC3,
  0xC1, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x3C, 0xFF, 0xBC, 0x7E, 0x1F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x61, 0xDC, 0x63, 0xF8, 0x78, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xC1, 0xF0, 0x7C,
  0x1F, 0x86, 0x73, 0x8F, 0xC7, 0xF1, 0x8E, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xF8, 0xF7, 0xF8, 0x78, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0x60, 0xEC, 0x1D, 0xC7, 0x9F, 0xB1, 0xEE, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0xF0, 0x7C, 0x0E, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x67, 0x60, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0xEC,
  0xC0, 0x00, 0x80, 0xC1, 0xE3, 0xE7, 0xC7, 0x83, 0x80, 0xF8, 0x1F, 0x03,
  0xC0, 0x60, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x80, 0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3C, 0x3E, 0x3E, 0x3E,
  0x0E, 0x02, 0x00, 0x1E, 0x1F, 0xE7, 0x3B, 0x86, 0xE1, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x30, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x38, 0x0C, 0x06,
  0x00, 0xC1, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x1E, 0x11, 0x07, 0xE3, 0x61,
  0x8C, 0x6C, 0x31, 0x8D, 0x8C, 0x31, 0xB1, 0x86, 0x34, 0x30, 0xC6, 0x86,
  0x10, 0xD1, 0xC6, 0x1A, 0x38, 0xC3, 0x63, 0x18, 0x4C, 0x67, 0x19, 0x8F,
  0xBE, 0x30, 0xE3, 0x83, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x01, 0xD8, 0x03, 0x30, 0x06, 0x70, 0x1C, 0x60, 0x30,
  0xC0, 0x61, 0xC1, 0xC3, 0x83, 0x03, 0x07, 0xFE, 0x1F, 0xFE, 0x38, 0x0C,
  0x60, 0x19, 0xC0, 0x3B, 0x80, 0x36, 0x00, 0x60, 0xFF, 0x8F, 0xFC, 0xE1,
  0xEE, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xE1, 0xCF, 0xF8, 0xFF,
  0xCE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x1E, 0xFF,
  0xCF, 0xF8, 0x0F, 0x81, 0xFF, 0x1E, 0x38, 0xC0, 0xEE, 0x03, 0x70, 0x1B,
  0x00, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x1F, 0x80, 0xDC, 0x06, 0x60, 0x73, 0xC7, 0x0F, 0xF8, 0x1F, 0x00, 0xFF,
  0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0xEE, 0x1E, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xF3, 0xFE,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xFF, 0x87, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0x70, 0x3B, 0xC3, 0x8F, 0xF8, 0x1F, 0x80, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xF0, 0x3E,
  0x06, 0xE1, 0xCE, 0x79, 0xFE, 0x0F, 0x80, 0xE0, 0x77, 0x03, 0xB8, 0x39,
  0xC3, 0x8E, 0x38, 0x71, 0xC3, 0x9C, 0x1D, 0xC0, 0xEC, 0x07, 0xF0, 0x3F,
  0x81, 0xEE, 0x0E, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0xE0, 0xE7, 0x03,
  0xB8, 0x1D, 0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFE, 0xC0, 0x6F, 0x60, 0x37, 0xF8, 0x3B, 0xEC, 0x19,
  0xF6, 0x0C, 0xFB, 0x8E, 0x7C, 0xC6, 0x7E, 0x63, 0x3F, 0x3B, 0x9F, 0x8D,
  0x8F, 0xC6, 0xC7, 0xE3, 0xE3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x70,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xB0, 0x7D,
  0xC3, 0xE6, 0x1F, 0x38, 0xF8, 0xC7, 0xC7, 0x3E, 0x19, 0xF0, 0xEF, 0x83,
  0x7C, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x70, 0x0F, 0x81, 0xFF,
  0x1E, 0x3C, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0x60,
  0x73, 0xC7, 0x8F, 0xF8, 0x1F, 0x00, 0xFF, 0x8F, 0xFE, 0xE0, 0xFE, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xF8,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x0F, 0x81, 0xFF, 0x1E, 0x38, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x06, 0x60, 0x73, 0xC7, 0x8F, 0xF8, 0x1F, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x40, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xE3, 0x8E, 0x18, 0xE1,
  0xCE, 0x0C, 0xE0, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0x0F, 0x83, 0xFE, 0x78,
  0xE7, 0x07, 0x60, 0x36, 0x03, 0x60, 0x07, 0x00, 0x3C, 0x01, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x77, 0x8F, 0x3F,
  0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xE0,
  0x77, 0x0E, 0x7F, 0xC1, 0xF8, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0x98, 0x0E,
  0x70, 0x39, 0xC0, 0xC3, 0x03, 0x0C, 0x1C, 0x38, 0x70, 0x61, 0x81, 0x8E,
  0x07, 0x38, 0x1C, 0xC0, 0x33, 0x00, 0xDC, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0xE0, 0x60, 0x7E, 0x0E, 0x06, 0xE0, 0xE0, 0x66,
  0x0F, 0x0E, 0x60, 0xF0, 0xE6, 0x0F, 0x0E, 0x71, 0xB0, 0xC7, 0x19, 0x8C,
  0x31, 0x98, 0xC3, 0x19, 0x9C, 0x33, 0x19, 0xC3, 0xB1, 0x98, 0x3B, 0x0D,
  0x81, 0xB0, 0xD8, 0x1F, 0x0D, 0x81, 0xE0, 0xF8, 0x1E, 0x07, 0x01, 0xE0,
  0x70, 0x0E, 0x07, 0x00, 0xC0, 0x70, 0xE0, 0x39, 0xC0, 0xE7, 0x07, 0x0E,
  0x1C, 0x38, 0xE0, 0x73, 0x81, 0xDC, 0x03, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xCE, 0x0E, 0x38, 0x38, 0x71,
  0xC1, 0xC7, 0x03, 0xB8, 0x0E, 0x60, 0x1D, 0xC0, 0x73, 0x03, 0x8E, 0x0E,
  0x38, 0x30, 0x61, 0xC1, 0xC6, 0x03, 0x38, 0x0E, 0xC0, 0x1B, 0x00, 0x7C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x30,
  0x0C, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xFE, 0x18, 0x1C, 0x1C, 0x3C, 0x36, 0x76,
  0x66, 0x67, 0xE3, 0xC3, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x30, 0x3E, 0x1F,
  0xEE, 0x3B, 0x06, 0x01, 0x80, 0x63, 0xF9, 0xFE, 0xE1, 0xB0, 0x6C, 0x1B,
  0x06, 0xE7, 0xBF, 0xF3, 0xDC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x33, 0xC7, 0xFC, 0xF1, 0xDC, 0x1B, 0x03, 0x60, 0x6C, 0x0F, 0x81,
  0xF0, 0x3E, 0x06, 0xC0, 0xDC, 0x1B, 0xC7, 0x7F, 0xCC, 0xF0, 0x1F, 0x07,
  0xF9, 0xC7, 0x30, 0x76, 0x07, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0x81, 0xB0, 0x77, 0x1C, 0x7F, 0x87, 0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC7, 0x99, 0xFB, 0x71, 0xEC, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x1D, 0xC7, 0x9F, 0xB1, 0xE6,
  0x0F, 0x07, 0xF9, 0xC7, 0x30, 0x76, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1C, 0x01, 0x80, 0x30, 0x27, 0x0E, 0x7F, 0x87, 0xE0, 0x0F, 0x1F, 0x38,
  0x38, 0x30, 0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1E, 0x67, 0xED, 0xC7, 0xB0, 0x7E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x81, 0xB0, 0x77, 0x1E,
  0x7E, 0xC7, 0x98, 0x03, 0x00, 0xE0, 0x1C, 0xC7, 0x1F, 0xE1, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xF3, 0xFE, 0xF3, 0xB8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xC0, 0xDF, 0x00, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x33, 0x30,
  0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x7F, 0xE0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3B, 0x0E, 0xC7, 0x33,
  0x8C, 0xC3, 0x70, 0xF8, 0x3F, 0x0E, 0xC3, 0x38, 0xC7, 0x30, 0xCC, 0x3B,
  0x06, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCF, 0x1E, 0x7F,
  0xDF, 0xB8, 0xF8, 0xF8, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07,
  0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C,
  0x1E, 0x0E, 0x0F, 0x07, 0x06, 0xCF, 0x3F, 0xEF, 0x3B, 0x87, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1C,
  0x0F, 0x03, 0xFC, 0x78, 0xE7, 0x06, 0x60, 0x6E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x60, 0x77, 0x06, 0x78, 0xE3, 0xFC, 0x0F, 0x00, 0xCF,
  0x1F, 0xF3, 0x8F, 0x60, 0xEC, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1B, 0x03, 0x60, 0xEE, 0x1D, 0xFF, 0x33, 0xC6, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x1E, 0x67, 0xFD, 0xC7, 0xB0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xB0, 0x77, 0x1E, 0x7F, 0xC7,
  0x98, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xDF, 0xFF, 0xB8,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x1F, 0x0F, 0xE7,
  0x1D, 0x83, 0x60, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x0D, 0x83,
  0x71, 0xCF, 0xE1, 0xF0, 0x18, 0x30, 0x67, 0xFF, 0xE3, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1E, 0x1C, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE3,
  0xDF, 0xF3, 0xDC, 0xC0, 0xF0, 0x7E, 0x1D, 0x86, 0x61, 0x9C, 0xE3, 0x30,
  0xCC, 0x33, 0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0xC1, 0x83,
  0xC1, 0x83, 0xE3, 0xC3, 0x63, 0xC7, 0x63, 0xC6, 0x63, 0xC6, 0x76, 0x66,
  0x76, 0x66, 0x36, 0x6C, 0x36, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38,
  0x1C, 0x18, 0x18, 0x18, 0xE1, 0xCC, 0x39, 0xCE, 0x19, 0xC3, 0xB0, 0x3C,
  0x07, 0x80, 0x60, 0x1E, 0x03, 0xE0, 0xEC, 0x19, 0xC7, 0x18, 0xC3, 0xB8,
  0x30, 0x60, 0xEE, 0x1D, 0xC3, 0x18, 0x63, 0x1C, 0x73, 0x8E, 0x60, 0xCC,
  0x1B, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x70, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x3F, 0xFF,
  0xFC, 0x06, 0x1C, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x8E,
  0x1C, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x06, 0x0C, 0x1C, 0x1C,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC1, 0x83, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0xE3, 0xCE, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x38, 0x61, 0x82, 0x00, 0x38, 0x1B, 0xF0, 0xFB, 0xCD,
  0x87, 0xEC, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 6, 7, 9, 2, -21 },
  { 15, 13, 20, 15, 2, -20 },
  { 48, 10, 26, 14, 2, -23 },
  { 81, 15, 20, 18, 1, -20 },
  { 119, 14, 20, 15, 1, -20 },
  { 154, 2, 7, 5, 1, -21 },
  { 156, 6, 28, 9, 2, -22 },
  { 177, 6, 28, 9, 1, -22 },
  { 198, 12, 12, 12, 0, -20 },
  { 216, 12, 14, 14, 1, -16 },
  { 237, 4, 7, 6, 0, -3 },
  { 241, 5, 2, 7, 1, -9 },
  { 243, 3, 3, 7, 2, -3 },
  { 245, 9, 22, 10, 0, -20 },
  { 270, 10, 20, 14, 2, -20 },
  { 295, 7, 20, 14, 2, -20 },
  { 313, 12, 20, 14, 1, -20 },
  { 343, 11, 20, 14, 1, -20 },
  { 371, 12, 20, 14, 1, -20 },
  { 401, 11, 20, 14, 2, -20 },
  { 429, 10, 20, 14, 2, -20 },
  { 454, 12, 20, 14, 1, -20 },
  { 484, 10, 20, 14, 2, -20 },
  { 509, 11, 20, 14, 1, -20 },
  { 537, 3, 15, 7, 2, -15 },
  { 543, 4, 19, 6, 1, -15 },
  { 553, 9, 12, 12, 1, -15 },
  { 567, 10, 7, 13, 2, -13 },
  { 576, 10, 12, 13, 2, -15 },
  { 591, 10, 20, 12, 1, -20 },
  { 616, 19, 26, 22, 1, -20 },
  { 678, 15, 20, 16, 1, -20 },
  { 716, 12, 20, 15, 2, -20 },
  { 746, 13, 20, 16, 2, -20 },
  { 779, 12, 20, 16, 2, -20 },
  { 809, 11, 20, 14, 2, -20 },
  { 837, 11, 20, 13, 2, -20 },
  { 865, 13, 20, 17, 2, -20 },
  { 898, 13, 20, 17, 2, -20 },
  { 931, 3, 20, 7, 2, -20 },
  { 939, 11, 20, 14, 1, -20 },
  { 967, 13, 20, 15, 2, -20 },
  { 1000, 10, 20, 13, 2, -20 },
  { 1025, 17, 20, 21, 2, -20 },
  { 1068, 13, 20, 17, 2, -20 },
  { 1101, 13, 20, 17, 2, -20 },
  { 1134, 12, 20, 16, 2, -20 },
  { 1164, 13, 23, 17, 2, -20 },
  { 1202, 12, 20, 15, 2, -20 },
  { 1232, 12, 20, 15, 1, -20 },
  { 1262, 13, 20, 15, 1, -20 },
  { 1295, 12, 20, 16, 2, -20 },
  { 1325, 14, 20, 16, 1, -20 },
  { 1360, 20, 20, 21, 1, -20 },
  { 1410, 14, 20, 15, 1, -20 },
  { 1445, 14, 20, 15, 0, -20 },
  { 1480, 12, 20, 15, 1, -20 },
  { 1510, 4, 27, 7, 2, -23 },
  { 1524, 9, 22, 10, 1, -20 },
  { 1549, 5, 27, 7, 0, -23 },
  { 1566, 8, 10, 10, 1, -20 },
  { 1576, 11, 2, 11, 0, 0 },
  { 1579, 5, 4, 9, 1, -21 },
  { 1582, 10, 15, 13, 2, -15 },
  { 1601, 11, 21, 14, 2, -21 },
  { 1630, 11, 15, 13, 1, -15 },
  { 1651, 11, 21, 14, 1, -21 },
  { 1680, 11, 15, 13, 1, -15 },
  { 1701, 8, 21, 9, 1, -21 },
  { 1722, 11, 21, 14, 1, -15 },
  { 1751, 10, 21, 14, 2, -21 },
  { 1778, 3, 21, 6, 2, -21 },
  { 1786, 4, 27, 6, 0, -21 },
  { 1800, 10, 21, 13, 2, -21 },
  { 1827, 2, 21, 6, 2, -21 },
  { 1833, 17, 15, 21, 2, -15 },
  { 1865, 10, 15, 14, 2, -15 },
  { 1884, 12, 15, 14, 1, -15 },
  { 1907, 11, 21, 14, 2, -15 },
  { 1936, 11, 21, 14, 1, -15 },
  { 1965, 6, 15, 9, 2, -15 },
  { 1977, 10, 15, 13, 1, -15 },
  { 1996, 7, 18, 8, 0, -18 },
  { 2012, 10, 15, 14, 2, -15 },
  { 2031, 10, 15, 12, 1, -15 },
  { 2050, 16, 15, 18, 1, -15 },
  { 2080, 11, 15, 12, 1, -15 },
  { 2101, 11, 21, 12, 0, -15 },
  { 2130, 10, 15, 12, 1, -15 },
  { 2149, 7, 27, 9, 1, -22 },
  { 2173, 2, 24, 7, 2, -20 },
  { 2179, 7, 27, 9, 1, -22 },
  { 2203, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_Regular28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_REGULAR28PT7B_H_
