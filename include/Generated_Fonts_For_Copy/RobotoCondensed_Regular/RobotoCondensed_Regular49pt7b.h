#ifndef _ROBOTOCONDENSED_REGULAR49PT7B_H_
#define _ROBOTOCONDENSED_REGULAR49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0xFF, 0x9C, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x86, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x83, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0xF0, 0x70, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0,
  0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xC1, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xDF, 0x00, 0x79, 0xE0, 0x1F, 0x3F, 0x07, 0xE3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xE0, 0xE0, 0x20, 0x38, 0x3C, 0x0E, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x1C, 0x78,
  0x0E, 0x0F, 0x1C, 0x03, 0x83, 0x8F, 0x00, 0xF1, 0xE3, 0x80, 0x1F, 0xF1,
  0xE0, 0x03, 0xFC, 0x70, 0x00, 0x7C, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x38, 0xFF,
  0x00, 0x1C, 0x7F, 0xE0, 0x0F, 0x3C, 0x78, 0x03, 0x8E, 0x0E, 0x01, 0xE3,
  0x81, 0xC0, 0x70, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x38, 0x08, 0x0F, 0x1E,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x9F,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1C, 0x3E, 0x7C,
  0x1C, 0x7C, 0x3E, 0x3C, 0x7C, 0x1E, 0x3C, 0x78, 0x1F, 0x3C, 0x78, 0x0F,
  0xBC, 0xF8, 0x07, 0xFC, 0xF8, 0x07, 0xF8, 0x78, 0x03, 0xF8, 0x78, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF8, 0x3F, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0x3E, 0x07, 0xFC, 0x1F, 0x00, 0x60, 0x00, 0x77, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x1C, 0x03, 0x80, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x08, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0x60, 0x08, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x3C, 0x38, 0x3F, 0xE7, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x78, 0xF0,
  0x1E, 0x0F, 0x07, 0xC1, 0xF0, 0x70, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDF, 0x7B, 0xCF, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3C, 0x0F, 0x9F, 0x01,
  0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D,
  0xE0, 0x1F, 0x78, 0x07, 0x9F, 0x01, 0xE3, 0xE0, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03,
  0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8,
  0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xEF, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0x8F, 0x81,
  0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x0F,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x07,
  0xC0, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xCF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3E, 0x0F, 0xC7, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F,
  0x83, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0xF7, 0xFC, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFE, 0x0F, 0x9F, 0x80, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x3C, 0x78, 0x0F, 0x8F,
  0x83, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0x9F, 0x03, 0xE3,
  0xE0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8,
  0x7C, 0x7C, 0x07, 0x9E, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7,
  0xC0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0xF8, 0x78,
  0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x7D, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFC, 0xF8, 0x3F, 0x9F, 0xFF, 0xF1, 0xFF,
  0xDE, 0x1F, 0xF3, 0xC0, 0xF8, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x7B,
  0xFF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0xFF, 0x7D, 0xE0, 0x3E, 0x7C, 0xF9, 0xF1, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x20,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x01, 0xF0,
  0x0E, 0x38, 0x07, 0xFC, 0x0E, 0x78, 0x0F, 0xFE, 0x07, 0x70, 0x0F, 0x1E,
  0x07, 0x70, 0x1E, 0x0E, 0x07, 0xF0, 0x3C, 0x1E, 0x07, 0xF0, 0x38, 0x1E,
  0x07, 0xE0, 0x38, 0x1E, 0x07, 0xE0, 0x78, 0x1E, 0x07, 0xE0, 0x78, 0x1E,
  0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0xF0, 0x1C,
  0x07, 0xE0, 0xF0, 0x1C, 0x07, 0xE0, 0xF0, 0x1C, 0x07, 0xE0, 0xF0, 0x1C,
  0x07, 0xE0, 0xF0, 0x3C, 0x0E, 0xE0, 0x70, 0x3C, 0x0E, 0xE0, 0x78, 0x7C,
  0x0E, 0xF0, 0x78, 0xFE, 0x1C, 0xF0, 0x7F, 0xDF, 0x7C, 0x70, 0x3F, 0xCF,
  0xF8, 0x70, 0x1F, 0x87, 0xF0, 0x78, 0x04, 0x01, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x1E,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x07,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8,
  0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0,
  0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0x00, 0xFC, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x78, 0x03, 0xF3, 0xC0,
  0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3C, 0x00,
  0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x3F, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x01,
  0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0x8F, 0x83, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xF3,
  0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x00, 0x7C, 0x1E, 0x01, 0xF8, 0x3C,
  0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xC1,
  0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x1F, 0x80, 0x1E, 0x3E, 0x00, 0x3C, 0xF8,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xF7, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x78, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x78,
  0x00, 0xF8, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xFB, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xE0, 0x03, 0xDF, 0xEF, 0x00,
  0x1E, 0xFF, 0x78, 0x00, 0xF7, 0xF9, 0xE0, 0x0F, 0x3F, 0xCF, 0x00, 0x79,
  0xFE, 0x78, 0x03, 0xCF, 0xF1, 0xE0, 0x3C, 0x7F, 0x8F, 0x01, 0xE3, 0xFC,
  0x78, 0x0F, 0x1F, 0xE1, 0xE0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8, 0x78,
  0x3C, 0x3F, 0xC1, 0xE3, 0xC1, 0xFE, 0x0F, 0x1E, 0x0F, 0xF0, 0x78, 0xF0,
  0x7F, 0x81, 0xEF, 0x03, 0xFC, 0x0F, 0x78, 0x1F, 0xE0, 0x7B, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x01,
  0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC, 0x01, 0xC0,
  0x1E, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xEF, 0x00, 0x7F, 0xDF, 0x00, 0xFF, 0x9E, 0x01, 0xFF,
  0x3E, 0x03, 0xFE, 0x3C, 0x07, 0xFC, 0x3C, 0x0F, 0xF8, 0x78, 0x1F, 0xF0,
  0x78, 0x3F, 0xE0, 0xF0, 0x7F, 0xC0, 0xF0, 0xFF, 0x81, 0xE1, 0xFF, 0x01,
  0xE3, 0xFE, 0x03, 0xC7, 0xFC, 0x03, 0xCF, 0xF8, 0x07, 0x9F, 0xF0, 0x07,
  0xBF, 0xE0, 0x0F, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x3F,
  0x78, 0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x03, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3E, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7E, 0x78,
  0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F,
  0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0,
  0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x07, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x03,
  0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x7C, 0xFC, 0x07, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x1E,
  0x78, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0, 0x3F, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x3E,
  0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xE0,
  0x0F, 0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x9E, 0x00, 0xFC, 0x01, 0xE7,
  0x80, 0x3F, 0x00, 0xF9, 0xE0, 0x1F, 0xC0, 0x3E, 0x7C, 0x07, 0xF8, 0x0F,
  0x0F, 0x01, 0xFE, 0x03, 0xC3, 0xC0, 0x73, 0x80, 0xF0, 0xF0, 0x1C, 0xE0,
  0x3C, 0x3C, 0x0F, 0x3C, 0x1F, 0x0F, 0x83, 0xCF, 0x07, 0x81, 0xE0, 0xE3,
  0xC1, 0xE0, 0x78, 0x38, 0x70, 0x78, 0x1E, 0x1E, 0x1C, 0x1E, 0x07, 0x87,
  0x87, 0x87, 0x81, 0xE1, 0xE1, 0xE3, 0xC0, 0x3C, 0x70, 0x38, 0xF0, 0x0F,
  0x3C, 0x0E, 0x3C, 0x03, 0xCF, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0xF3, 0xC0,
  0x3C, 0xE0, 0x1D, 0xE0, 0x07, 0xB8, 0x07, 0x78, 0x01, 0xFE, 0x01, 0xDE,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF3, 0xC0,
  0x07, 0xC7, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x7C,
  0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x03,
  0xC7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0x70, 0x1C,
  0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7, 0x87, 0x8F, 0x07, 0x1C, 0x0F,
  0x78, 0x1E, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x03, 0xEF,
  0x80, 0x7B, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xF8, 0x3F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xC1, 0xE7, 0xC0, 0x7B, 0xE0, 0x1E, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0xBE, 0x07, 0xE7,
  0xFF, 0xF9, 0xFF, 0xDE, 0x3F, 0xE7, 0xC3, 0xF1, 0xF0, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x7E, 0x0F, 0x3F, 0xE1, 0xEF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0xF8,
  0x07, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xF7, 0xC0,
  0x3E, 0xFE, 0x0F, 0xDF, 0xFF, 0xF3, 0xDF, 0xFC, 0x79, 0xFF, 0x0F, 0x0F,
  0x80, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0,
  0x7C, 0xF8, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01,
  0xF7, 0xC0, 0x3C, 0x7C, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xF8, 0xF0, 0xFF, 0x9E, 0x3F, 0xFB,
  0xCF, 0xFF, 0xF9, 0xF0, 0x3F, 0x7C, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x1F, 0x3E, 0x07, 0xE7, 0xFF, 0xFC,
  0x7F, 0xF7, 0x87, 0xFC, 0xF0, 0x3F, 0x1E, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0C, 0x7C, 0x07, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x1F,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xC3, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x03,
  0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF3, 0xE0, 0x7E, 0xF8,
  0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0,
  0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xEF, 0x0F, 0xF9, 0xE0, 0x7E,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC4, 0x00,
  0xF0, 0xE0, 0x3E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC3, 0xE0, 0xF3, 0xFE, 0x3D, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8,
  0x3E, 0xFC, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xC0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x07,
  0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x7F, 0xBF, 0x9F,
  0xCF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x3E, 0x3C,
  0x0F, 0x87, 0x83, 0xE0, 0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xC7, 0xC0, 0x79,
  0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xBE, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F, 0x07, 0x81, 0xE0,
  0xF8, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x1F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3E, 0x78, 0x03, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF8, 0x0F, 0xC1, 0xE7, 0xFC, 0x3F, 0xE3, 0xDF, 0xFD, 0xFF,
  0xE7, 0xFF, 0xFB, 0xFF, 0xEF, 0xC0, 0xFF, 0x07, 0xDF, 0x01, 0xFC, 0x07,
  0xBE, 0x01, 0xF0, 0x0F, 0x78, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xC0, 0x3F,
  0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0x1F, 0x00, 0xFF, 0x80, 0x3E, 0x01, 0xFF,
  0x00, 0x7C, 0x03, 0xFE, 0x00, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x0F, 0xF8,
  0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0x7F, 0xC0,
  0x1F, 0x00, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0x00, 0x7C, 0x03, 0xFE, 0x00,
  0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x0F, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0x07,
  0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0x7C, 0xF0, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F,
  0xF3, 0xFF, 0xFE, 0xFE, 0x0F, 0xBF, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3E, 0x07, 0xE3, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80,
  0x1F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x3C, 0x03, 0xE3, 0xE0, 0x7E,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xF0, 0xFC,
  0x1E, 0x7F, 0xC3, 0xDF, 0xFC, 0x7F, 0xFF, 0xCF, 0xC0, 0xFD, 0xF0, 0x0F,
  0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x7D,
  0xF8, 0x1F, 0xBF, 0xFF, 0xE7, 0xBF, 0xF8, 0xF3, 0xFE, 0x1E, 0x3F, 0x83,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF1, 0xE1, 0xFF, 0xBC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xE0, 0x7E,
  0xF8, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFD, 0xE0,
  0x7E, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xF1, 0xF8, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3C,
  0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x78,
  0x07, 0xDF, 0x01, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x0F,
  0xDF, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xF7, 0xC3, 0xF1, 0xF0,
  0xF8, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x07, 0x07, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00,
  0x38, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x78,
  0x07, 0x9E, 0x03, 0xE0, 0x1E, 0x78, 0x0F, 0xC0, 0xF0, 0xF0, 0x3F, 0x03,
  0xC3, 0xC1, 0xFC, 0x0F, 0x0F, 0x07, 0xF8, 0x3C, 0x3C, 0x1F, 0xE0, 0xF0,
  0x70, 0x77, 0x87, 0x81, 0xE3, 0xCE, 0x1E, 0x07, 0x8F, 0x3C, 0x78, 0x1E,
  0x38, 0xF1, 0xE0, 0x78, 0xE3, 0xC7, 0x00, 0xF7, 0x87, 0x3C, 0x03, 0xDE,
  0x1E, 0xF0, 0x0F, 0x70, 0x7B, 0xC0, 0x3D, 0xC0, 0xEE, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1F, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x07,
  0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xF7, 0xC0, 0x3E,
  0x78, 0x07, 0x8F, 0x81, 0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x81, 0xE1, 0xE0,
  0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x7C, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80,
  0x7D, 0xE0, 0x1E, 0x7C, 0x07, 0x9F, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C,
  0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x20, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x03, 0xF0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xC0, 0x3C, 0xFF, 0xC0, 0x7B, 0xFF, 0xC0, 0xF7, 0x8F, 0x81, 0xDE,
  0x0F, 0xC7, 0xBC, 0x0F, 0xFF, 0x78, 0x0F, 0xFC, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 35, 12, 4, -35 },
  { 23, 10, 12, 16, 3, -37 },
  { 38, 23, 35, 27, 3, -35 },
  { 139, 19, 44, 24, 3, -40 },
  { 244, 26, 35, 31, 3, -35 },
  { 358, 24, 36, 27, 2, -35 },
  { 466, 4, 11, 9, 2, -37 },
  { 472, 11, 50, 15, 3, -39 },
  { 541, 11, 50, 16, 1, -39 },
  { 610, 19, 20, 21, 1, -35 },
  { 658, 20, 25, 24, 2, -29 },
  { 721, 6, 12, 10, 1, -5 },
  { 730, 10, 4, 12, 1, -17 },
  { 735, 6, 5, 13, 3, -5 },
  { 739, 16, 38, 18, 1, -35 },
  { 815, 18, 35, 24, 3, -35 },
  { 894, 11, 35, 24, 4, -35 },
  { 943, 20, 35, 24, 2, -35 },
  { 1031, 19, 35, 24, 2, -35 },
  { 1115, 22, 35, 24, 1, -35 },
  { 1212, 19, 35, 24, 3, -35 },
  { 1296, 19, 35, 24, 3, -35 },
  { 1380, 20, 35, 24, 2, -35 },
  { 1468, 18, 35, 24, 3, -35 },
  { 1547, 19, 35, 24, 2, -35 },
  { 1631, 6, 26, 11, 3, -26 },
  { 1651, 7, 33, 10, 1, -26 },
  { 1680, 16, 21, 22, 2, -26 },
  { 1722, 16, 14, 23, 4, -23 },
  { 1750, 18, 21, 23, 3, -26 },
  { 1798, 17, 35, 21, 2, -35 },
  { 1873, 32, 45, 38, 3, -34 },
  { 2053, 26, 35, 28, 1, -35 },
  { 2167, 20, 35, 27, 4, -35 },
  { 2255, 23, 35, 28, 3, -35 },
  { 2356, 21, 35, 28, 4, -35 },
  { 2448, 18, 35, 24, 4, -35 },
  { 2527, 18, 35, 24, 4, -35 },
  { 2606, 23, 35, 29, 3, -35 },
  { 2707, 23, 35, 30, 4, -35 },
  { 2808, 4, 35, 12, 4, -35 },
  { 2826, 19, 35, 24, 1, -35 },
  { 2910, 23, 35, 27, 4, -35 },
  { 3011, 18, 35, 23, 4, -35 },
  { 3090, 29, 35, 37, 4, -35 },
  { 3217, 23, 35, 30, 4, -35 },
  { 3318, 23, 35, 29, 3, -35 },
  { 3419, 21, 35, 27, 4, -35 },
  { 3511, 24, 41, 29, 3, -35 },
  { 3634, 21, 35, 26, 4, -35 },
  { 3726, 21, 35, 25, 2, -35 },
  { 3818, 23, 35, 26, 1, -35 },
  { 3919, 22, 35, 28, 3, -35 },
  { 4016, 25, 35, 27, 1, -35 },
  { 4126, 34, 35, 37, 2, -35 },
  { 4275, 23, 35, 27, 2, -35 },
  { 4376, 24, 35, 26, 1, -35 },
  { 4481, 22, 35, 26, 2, -35 },
  { 4578, 8, 47, 12, 3, -40 },
  { 4625, 16, 38, 18, 1, -35 },
  { 4701, 8, 47, 12, 1, -40 },
  { 4748, 15, 17, 18, 2, -35 },
  { 4780, 18, 4, 20, 1, 0 },
  { 4789, 10, 7, 15, 1, -37 },
  { 4798, 18, 26, 23, 3, -26 },
  { 4857, 19, 37, 24, 3, -37 },
  { 4945, 19, 26, 23, 2, -26 },
  { 5007, 19, 37, 24, 2, -37 },
  { 5095, 19, 26, 23, 2, -26 },
  { 5157, 13, 38, 16, 2, -38 },
  { 5219, 19, 36, 24, 2, -26 },
  { 5305, 18, 37, 24, 3, -37 },
  { 5389, 5, 35, 11, 3, -35 },
  { 5411, 9, 45, 11, -1, -35 },
  { 5462, 19, 37, 22, 3, -37 },
  { 5550, 4, 37, 11, 4, -37 },
  { 5569, 31, 26, 37, 3, -26 },
  { 5670, 18, 26, 24, 3, -26 },
  { 5729, 20, 26, 25, 2, -26 },
  { 5794, 19, 36, 24, 3, -26 },
  { 5880, 19, 36, 25, 2, -26 },
  { 5966, 11, 26, 15, 3, -26 },
  { 6002, 18, 26, 22, 2, -26 },
  { 6061, 12, 32, 15, 1, -32 },
  { 6109, 18, 26, 24, 3, -26 },
  { 6168, 19, 26, 21, 1, -26 },
  { 6230, 30, 26, 32, 1, -26 },
  { 6328, 19, 26, 22, 1, -26 },
  { 6390, 18, 36, 20, 1, -26 },
  { 6471, 18, 26, 22, 2, -26 },
  { 6530, 12, 47, 15, 2, -38 },
  { 6601, 4, 41, 12, 4, -35 },
  { 6622, 12, 47, 15, 1, -38 },
  { 6693, 23, 10, 29, 3, -20 },
};

const GFXfont RobotoCondensed_Regular49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_REGULAR49PT7B_H_
