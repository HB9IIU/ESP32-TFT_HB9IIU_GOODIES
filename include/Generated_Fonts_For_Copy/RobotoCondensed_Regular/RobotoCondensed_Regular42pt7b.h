#ifndef _ROBOTOCONDENSED_REGULAR42PT7B_H_
#define _ROBOTOCONDENSED_REGULAR42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77,
  0x00, 0x00, 0x7F, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x30, 0x60, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x06, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x3E, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x07, 0x78, 0x07, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x0F,
  0x78, 0x0F, 0x3E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xEF, 0x00, 0x03, 0x8E, 0x04, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x60, 0x70, 0x71, 0xC0, 0xE0, 0xE3, 0x01, 0xC1, 0x8E, 0x01, 0xC7,
  0x18, 0x03, 0xDE, 0x70, 0x03, 0xF9, 0xC0, 0x03, 0xE3, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x71, 0xF0, 0x00, 0xE7, 0xF0, 0x03, 0x9E,
  0xF0, 0x06, 0x38, 0xE0, 0x1C, 0xE0, 0xE0, 0x31, 0xC1, 0xC0, 0xE3, 0x83,
  0x81, 0x87, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x18, 0x1C, 0x70,
  0x00, 0x3D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xE3, 0xC0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0,
  0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1C, 0x03, 0xC3, 0xC0, 0x1E, 0x78,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0xE7, 0xCF, 0x0E, 0x78, 0xF9, 0xEF, 0x07, 0x9E, 0xF0,
  0x3D, 0xCF, 0x03, 0xFC, 0xF0, 0x1F, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x87,
  0x80, 0xF8, 0x7C, 0x3F, 0xC3, 0xFF, 0xFE, 0x1F, 0xF9, 0xE0, 0x7E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F,
  0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x10, 0x40, 0x38, 0x0E, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07,
  0x0E, 0x1B, 0xF6, 0x7D, 0xFF, 0xFE, 0x3F, 0xFC, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xE7, 0x00, 0xE3, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x00,
  0x10, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x39, 0xCE, 0x77, 0xBD, 0xDE, 0xE2, 0x00, 0xFF, 0xFF, 0xFF, 0x27,
  0xBF, 0xF7, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70,
  0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x3C,
  0x1E, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0xC0, 0xF0,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7E, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x07,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xC7, 0x81, 0xE7, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00,
  0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xE0,
  0xE0, 0x78, 0x38, 0x3C, 0x0E, 0x0F, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7B, 0xE0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x7E, 0xFC, 0x78, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1E, 0x78, 0x1E, 0x7C, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF3, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFC, 0x7C, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x78,
  0x1E, 0x78, 0x1E, 0x3C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x3C,
  0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x3C, 0x1E, 0x3E, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFC, 0x3C,
  0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C, 0x78,
  0x3E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x3C,
  0x7F, 0x3F, 0xFF, 0x1F, 0xEF, 0x07, 0xCF, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x0F,
  0xC0, 0x0F, 0x00, 0x27, 0xBF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x09, 0xEF, 0xF9, 0xC0, 0x10, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x3C, 0xF3, 0x8E,
  0x79, 0xCF, 0x18, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x03, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0xBF, 0x3E, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x7C, 0x06, 0x38, 0x0F, 0xF0, 0x63, 0x01, 0xFF, 0x07, 0x70, 0x3C, 0x70,
  0x77, 0x03, 0x87, 0x03, 0x70, 0x70, 0x70, 0x36, 0x07, 0x07, 0x03, 0x60,
  0xE0, 0x70, 0x3E, 0x0E, 0x07, 0x03, 0xE0, 0xE0, 0x70, 0x3E, 0x0E, 0x07,
  0x03, 0xE0, 0xE0, 0x70, 0x3E, 0x0E, 0x06, 0x07, 0xE0, 0xE0, 0xE0, 0x7E,
  0x0E, 0x0E, 0x06, 0x60, 0xE0, 0xE0, 0xE7, 0x0F, 0x1F, 0x0E, 0x70, 0x7F,
  0x7B, 0xC7, 0x07, 0xF3, 0xF8, 0x70, 0x1C, 0x1E, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x30, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x38, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC,
  0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xF0, 0x1F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E,
  0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x03, 0xEF, 0x01, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x87, 0xC7, 0xC0, 0x7C, 0xF0,
  0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0E, 0x78, 0x03, 0xCF, 0x80,
  0xF8, 0xF8, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0x3C, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x07, 0xF3,
  0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0x87, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x80, 0x7C, 0xFC, 0x3F, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x7E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0,
  0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xCF, 0x00, 0xF8, 0xF8,
  0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3B, 0xFB, 0x80, 0x1D, 0xFD,
  0xC0, 0x1E, 0xFE, 0xF0, 0x0E, 0x7F, 0x38, 0x07, 0x3F, 0x9C, 0x07, 0x9F,
  0xCF, 0x03, 0x8F, 0xE3, 0x81, 0xC7, 0xF1, 0xC1, 0xE3, 0xF8, 0xF0, 0xE1,
  0xFC, 0x38, 0x70, 0xFE, 0x1C, 0x78, 0x7F, 0x0F, 0x38, 0x3F, 0x83, 0x9C,
  0x1F, 0xC1, 0xDE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0x80, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x3F, 0x80,
  0xE0, 0x1C, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xF7, 0x00,
  0xFF, 0x78, 0x0F, 0xF3, 0x80, 0xFF, 0x3C, 0x0F, 0xF1, 0xC0, 0xFF, 0x1E,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x78, 0xFF, 0x07, 0x8F, 0xF0,
  0x3C, 0xFF, 0x01, 0xCF, 0xF0, 0x1E, 0xFF, 0x00, 0xEF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xF1, 0xF8, 0x7C, 0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x3F, 0x1F,
  0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x78, 0x07, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x03, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0x80, 0x03, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDE,
  0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C,
  0x01, 0xE1, 0xF0, 0x1F, 0x07, 0xE3, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x08, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78,
  0x1F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0xF0,
  0x03, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x1F, 0x3C, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xEF, 0x00,
  0x3D, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8,
  0x7C, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x3D, 0xC0, 0x0F, 0x70, 0x03,
  0xDE, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xDE, 0x01, 0xE3, 0xE1, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE,
  0x01, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x1C, 0x01, 0xE0,
  0x78, 0x07, 0x81, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C,
  0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x3D, 0xC0, 0x1E, 0x00, 0xF7, 0x80, 0x78, 0x03, 0x9E, 0x01, 0xF0,
  0x1E, 0x78, 0x07, 0xC0, 0x78, 0xE0, 0x3F, 0x01, 0xE3, 0x80, 0xFC, 0x07,
  0x8F, 0x03, 0xF0, 0x1C, 0x3C, 0x0E, 0xE0, 0x70, 0xF0, 0x3B, 0x83, 0xC1,
  0xC1, 0xCE, 0x0F, 0x07, 0x07, 0x38, 0x3C, 0x1C, 0x1C, 0x70, 0xE0, 0x78,
  0x71, 0xC3, 0x81, 0xE3, 0x87, 0x0E, 0x03, 0x8E, 0x1C, 0x78, 0x0E, 0x38,
  0x71, 0xE0, 0x38, 0xE0, 0xE7, 0x00, 0xF7, 0x83, 0x9C, 0x03, 0xDC, 0x0E,
  0x70, 0x07, 0x70, 0x3B, 0xC0, 0x1D, 0xC0, 0x7F, 0x00, 0x77, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x7C,
  0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7C, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F,
  0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xFF,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x77, 0x03,
  0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x3C, 0x70, 0xE7, 0x87, 0x38, 0x3D, 0xC0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E,
  0x78, 0x1E, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0xFE, 0x1F, 0xFE,
  0x3F, 0xFE, 0x7C, 0x0E, 0x78, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0x7C, 0x7E, 0x7F, 0xFE, 0x3F, 0xEF, 0x0F, 0x8F, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xEF, 0xF8, 0xFF, 0xFC,
  0xFC, 0x7E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xFC, 0x7E, 0xFF, 0xFC, 0xEF, 0xF8,
  0xE3, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x70, 0x0F,
  0x78, 0x0E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xCF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7E, 0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xE7,
  0x07, 0xC7, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x06, 0x7E, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xF0,
  0x7F, 0x07, 0xF0, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0xC7,
  0x1F, 0xF7, 0x3F, 0xF7, 0x7E, 0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x7E, 0x3F,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x30, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8F, 0x87, 0x7F, 0xCF, 0xFF,
  0x9F, 0x8F, 0xBE, 0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0x7C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xEF, 0xDF,
  0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x3C,
  0xE0, 0x78, 0xE0, 0xF8, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE3, 0xC0,
  0xE7, 0x80, 0xEF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0,
  0xF3, 0xC0, 0xE1, 0xE0, 0xE1, 0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78,
  0xE0, 0x3C, 0xE0, 0x3E, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0,
  0x7C, 0x3B, 0xFE, 0x7F, 0xCF, 0xFF, 0xBF, 0xFB, 0xF1, 0xFE, 0x3E, 0xF0,
  0x3F, 0x07, 0xFC, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x0F,
  0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x78,
  0x0F, 0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F, 0x80,
  0x78, 0x0F, 0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F,
  0x80, 0x78, 0x0F, 0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xF0, 0xE3, 0xE1,
  0xDF, 0xF3, 0xFF, 0xE7, 0xE3, 0xEF, 0x83, 0xDE, 0x03, 0xB8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0x87, 0xC7,
  0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x8F, 0x87, 0x87, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0x80, 0xE3, 0xE0, 0xEF, 0xF8, 0xFF, 0xFC, 0xFC, 0x7E, 0xF0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x1E, 0xF0, 0x1E, 0xF8, 0x7E, 0xFF, 0xFC, 0xEF, 0xF8, 0xE3, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xC7, 0x1F, 0xF7, 0x3F, 0xFF, 0x7C,
  0x3F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE7, 0xF7, 0xFF, 0xFF, 0xFF,
  0x87, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xE3, 0xE7, 0x81, 0xEE, 0x03, 0xDC, 0x07, 0xBC, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xF0, 0xF9, 0xFF, 0xE1, 0xFF, 0x80,
  0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F,
  0x01, 0xFC, 0x1F, 0x81, 0xF0, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xE3, 0xFB, 0xFF, 0xF3, 0xFD, 0xE3, 0xF3, 0xC0, 0xF0,
  0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0xF8, 0x0E,
  0x03, 0xDC, 0x0F, 0x81, 0xEE, 0x07, 0xC0, 0xE7, 0x83, 0xE0, 0x73, 0xC1,
  0xF8, 0x78, 0xE1, 0xFC, 0x3C, 0x70, 0xEE, 0x1C, 0x3C, 0x77, 0x0E, 0x1E,
  0x3B, 0xC7, 0x07, 0x38, 0xE7, 0x83, 0x9C, 0x73, 0x81, 0xCE, 0x39, 0xC0,
  0xF7, 0x0E, 0xE0, 0x3F, 0x07, 0x70, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C,
  0x1C, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x78,
  0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C,
  0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1E, 0x70,
  0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x3C, 0x0F,
  0x81, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF8, 0x7E, 0x0F,
  0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF8, 0x0F, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x38, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xC1, 0xF0, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x83, 0x80, 0xC0, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x1D, 0xFF, 0x03, 0xFD, 0xF0, 0x7E, 0x0F, 0xBD, 0xC0,
  0xFF, 0xB8, 0x0F, 0xE0, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 30, 10, 3, -30 },
  { 16, 8, 10, 13, 3, -32 },
  { 26, 19, 30, 23, 3, -30 },
  { 98, 16, 38, 21, 2, -34 },
  { 174, 23, 30, 27, 2, -30 },
  { 261, 20, 30, 23, 2, -30 },
  { 336, 3, 10, 7, 2, -32 },
  { 340, 9, 44, 13, 3, -34 },
  { 390, 10, 44, 13, 1, -34 },
  { 445, 17, 17, 18, 1, -30 },
  { 482, 17, 22, 21, 2, -25 },
  { 529, 5, 10, 8, 1, -5 },
  { 536, 8, 3, 10, 1, -14 },
  { 539, 5, 5, 11, 3, -5 },
  { 543, 13, 33, 16, 1, -30 },
  { 597, 16, 30, 21, 2, -30 },
  { 657, 10, 30, 21, 3, -30 },
  { 695, 17, 30, 21, 2, -30 },
  { 759, 16, 30, 21, 2, -30 },
  { 819, 18, 30, 21, 1, -30 },
  { 887, 16, 30, 21, 3, -30 },
  { 947, 16, 30, 21, 3, -30 },
  { 1007, 17, 30, 21, 2, -30 },
  { 1071, 16, 30, 21, 2, -30 },
  { 1131, 16, 30, 21, 2, -30 },
  { 1191, 5, 23, 10, 3, -23 },
  { 1206, 6, 28, 9, 1, -23 },
  { 1227, 14, 19, 19, 2, -23 },
  { 1261, 14, 12, 20, 3, -20 },
  { 1282, 15, 19, 19, 3, -23 },
  { 1318, 14, 30, 18, 2, -30 },
  { 1371, 28, 38, 32, 2, -29 },
  { 1504, 22, 30, 24, 1, -30 },
  { 1587, 18, 30, 23, 3, -30 },
  { 1655, 19, 30, 24, 3, -30 },
  { 1727, 18, 30, 24, 3, -30 },
  { 1795, 16, 30, 21, 3, -30 },
  { 1855, 16, 30, 20, 3, -30 },
  { 1915, 19, 30, 25, 3, -30 },
  { 1987, 20, 30, 26, 3, -30 },
  { 2062, 4, 30, 11, 3, -30 },
  { 2077, 16, 30, 20, 1, -30 },
  { 2137, 20, 30, 23, 3, -30 },
  { 2212, 16, 30, 20, 3, -30 },
  { 2272, 25, 30, 32, 3, -30 },
  { 2366, 20, 30, 26, 3, -30 },
  { 2441, 20, 30, 25, 3, -30 },
  { 2516, 19, 30, 23, 3, -30 },
  { 2588, 21, 35, 25, 2, -30 },
  { 2680, 19, 30, 22, 3, -30 },
  { 2752, 18, 30, 22, 2, -30 },
  { 2820, 20, 30, 22, 1, -30 },
  { 2895, 18, 30, 24, 3, -30 },
  { 2963, 22, 30, 24, 1, -30 },
  { 3046, 30, 30, 32, 1, -30 },
  { 3159, 21, 30, 23, 1, -30 },
  { 3238, 20, 30, 22, 1, -30 },
  { 3313, 18, 30, 22, 2, -30 },
  { 3381, 7, 40, 11, 3, -34 },
  { 3416, 14, 33, 16, 1, -30 },
  { 3474, 6, 40, 11, 1, -34 },
  { 3504, 13, 15, 16, 1, -30 },
  { 3529, 16, 3, 17, 1, 0 },
  { 3535, 9, 6, 13, 1, -31 },
  { 3542, 16, 22, 20, 2, -22 },
  { 3586, 16, 32, 21, 3, -32 },
  { 3650, 16, 22, 19, 2, -22 },
  { 3694, 16, 32, 21, 2, -32 },
  { 3758, 16, 22, 20, 2, -22 },
  { 3802, 12, 32, 13, 1, -32 },
  { 3850, 16, 31, 21, 2, -22 },
  { 3912, 15, 32, 20, 3, -32 },
  { 3972, 4, 30, 10, 3, -30 },
  { 3987, 7, 39, 9, 0, -30 },
  { 4022, 16, 32, 19, 3, -32 },
  { 4086, 4, 32, 10, 3, -32 },
  { 4102, 26, 22, 32, 3, -22 },
  { 4174, 15, 22, 20, 3, -22 },
  { 4216, 17, 22, 21, 2, -22 },
  { 4263, 16, 31, 21, 3, -22 },
  { 4325, 16, 31, 21, 2, -22 },
  { 4387, 9, 22, 13, 3, -22 },
  { 4412, 15, 22, 19, 2, -22 },
  { 4454, 11, 28, 12, 0, -28 },
  { 4493, 15, 22, 20, 3, -22 },
  { 4535, 16, 22, 18, 1, -22 },
  { 4579, 25, 22, 27, 1, -22 },
  { 4648, 16, 22, 18, 1, -22 },
  { 4692, 16, 31, 18, 1, -22 },
  { 4754, 15, 22, 18, 2, -22 },
  { 4796, 11, 41, 13, 1, -33 },
  { 4853, 3, 36, 10, 4, -30 },
  { 4867, 10, 41, 13, 1, -33 },
  { 4919, 19, 8, 25, 3, -16 },
};

const GFXfont RobotoCondensed_Regular42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_REGULAR42PT7B_H_
