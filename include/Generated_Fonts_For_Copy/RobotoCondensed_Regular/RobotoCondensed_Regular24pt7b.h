#ifndef _ROBOTOCONDENSED_REGULAR24PT7B_H_
#define _ROBOTOCONDENSED_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x99, 0x99, 0x99, 0x08, 0x81, 0x10,
  0x66, 0x0C, 0xCF, 0xFF, 0xFF, 0xC4, 0x40, 0x88, 0x33, 0x06, 0x60, 0xCC,
  0x7F, 0xEF, 0xFC, 0x44, 0x19, 0x83, 0x30, 0x66, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0x78, 0x3F, 0x1C, 0x66, 0x19, 0x86, 0x60, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x60, 0x1B, 0x07, 0xE1, 0x98, 0x67, 0xF8, 0x78, 0x0C, 0x03,
  0x00, 0x38, 0x03, 0xE0, 0x31, 0x11, 0x88, 0x8C, 0x4C, 0x62, 0x41, 0xF6,
  0x07, 0x60, 0x02, 0x00, 0x37, 0x81, 0x3E, 0x1B, 0x30, 0x98, 0x8C, 0xC4,
  0x46, 0x60, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xF0, 0x33, 0x06, 0x18, 0x61,
  0x03, 0x30, 0x36, 0x01, 0xC0, 0x3C, 0x07, 0xE6, 0x66, 0x6C, 0x36, 0xC3,
  0xCC, 0x1C, 0x61, 0xC7, 0xFE, 0x1E, 0x70, 0xFF, 0xF0, 0x08, 0xCC, 0x46,
  0x33, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0xC6, 0x10, 0xC3,
  0x08, 0x86, 0x30, 0xC2, 0x18, 0xC6, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19,
  0x8C, 0x62, 0x31, 0x18, 0x80, 0x0C, 0x03, 0x00, 0xC1, 0xB3, 0xFF, 0xC3,
  0x81, 0xE0, 0xEC, 0x33, 0x08, 0x40, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x77, 0x76, 0x64,
  0xFF, 0xBC, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0x1E, 0x1F, 0x98, 0x6C,
  0x36, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x36, 0x1B, 0x0D,
  0x8E, 0x7E, 0x1E, 0x00, 0x0C, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x1E, 0x1F, 0xC6, 0x3B, 0x06, 0xC1, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0xFF, 0xFF, 0xC0, 0x1E, 0x3F, 0x98, 0xFC, 0x3C, 0x18, 0x0C, 0x0E, 0x3E,
  0x1F, 0x01, 0xC0, 0x60, 0x3C, 0x1E, 0x0D, 0x8E, 0xFE, 0x1E, 0x00, 0x03,
  0x01, 0xC0, 0x70, 0x3C, 0x0B, 0x06, 0xC1, 0x30, 0xCC, 0x63, 0x18, 0xCC,
  0x33, 0xFF, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x3F, 0x98,
  0x0C, 0x06, 0x06, 0x03, 0x79, 0xFE, 0xC3, 0x01, 0xC0, 0x60, 0x3C, 0x1E,
  0x1F, 0x8C, 0xFE, 0x3C, 0x00, 0x0E, 0x1F, 0x1C, 0x0C, 0x0C, 0x06, 0x03,
  0x79, 0xFE, 0xE3, 0x61, 0xB0, 0x78, 0x3C, 0x1E, 0x1B, 0x8C, 0xFC, 0x3C,
  0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x1E,
  0x1F, 0x98, 0xEC, 0x36, 0x1B, 0x0D, 0x8E, 0x7E, 0x3F, 0x31, 0xD8, 0x78,
  0x3C, 0x1F, 0x0D, 0x86, 0xFE, 0x1E, 0x00, 0x1E, 0x3F, 0x98, 0xDC, 0x3C,
  0x1E, 0x0F, 0x07, 0xC3, 0x63, 0xBF, 0xCF, 0x60, 0x30, 0x18, 0x18, 0x1C,
  0x7C, 0x38, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x5D, 0x80, 0x00, 0x01, 0xB7,
  0xB4, 0x01, 0x07, 0x0F, 0x3C, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0x3C, 0x7E, 0xE7, 0xC3, 0x03, 0x03,
  0x07, 0x06, 0x0C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x03,
  0xE0, 0x0F, 0xF8, 0x1C, 0x0C, 0x10, 0x06, 0x30, 0x02, 0x61, 0xE3, 0x63,
  0xF3, 0x43, 0x31, 0x46, 0x31, 0xC6, 0x31, 0xC6, 0x21, 0xC4, 0x21, 0xC4,
  0x21, 0xC4, 0x63, 0x46, 0x63, 0x47, 0xF6, 0x63, 0x9C, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x06, 0x60, 0x33, 0x01, 0x98, 0x18, 0x60, 0xC3, 0x06,
  0x18, 0x7F, 0xE3, 0xFF, 0x18, 0x19, 0x80, 0xEC, 0x03, 0x60, 0x18, 0xFE,
  0x3F, 0xEC, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x3B, 0xFC, 0xFF, 0x30, 0x6C,
  0x1B, 0x03, 0xC0, 0xF0, 0x7C, 0x1B, 0xFE, 0xFE, 0x00, 0x0F, 0x83, 0xFC,
  0x30, 0xE6, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x07, 0x60, 0x66, 0x06, 0x30, 0xE3, 0xFC, 0x0F, 0x80, 0xFE,
  0x3F, 0xCC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x3B, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x6E, 0x00, 0xE0, 0x0E,
  0x00, 0xE3, 0xFE, 0x3F, 0xE0, 0x76, 0x07, 0x60, 0x76, 0x07, 0x30, 0x73,
  0xFE, 0x0F, 0x80, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3C, 0x1E, 0x1F,
  0x8C, 0xFE, 0x3E, 0x00, 0xC0, 0xD8, 0x33, 0x0E, 0x63, 0x8C, 0x61, 0x9C,
  0x37, 0x06, 0xC0, 0xFC, 0x1D, 0x83, 0x98, 0x63, 0x8C, 0x31, 0x87, 0x30,
  0x66, 0x06, 0xC0, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFD, 0x86,
  0xF6, 0x1B, 0xD8, 0x6F, 0x33, 0x3C, 0xCC, 0xF3, 0x33, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF0, 0xC3, 0xC3, 0x0C, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F,
  0x07, 0xB0, 0xF6, 0x1E, 0x63, 0xCC, 0x78, 0xCF, 0x19, 0xE1, 0xBC, 0x3F,
  0x83, 0xF0, 0x3E, 0x07, 0xC0, 0x60, 0x0F, 0x83, 0xFC, 0x30, 0xE6, 0x06,
  0x60, 0x76, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03,
  0x60, 0x76, 0x06, 0x30, 0xE3, 0xFC, 0x0F, 0x80, 0xFF, 0x3F, 0xEC, 0x1F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0xCC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0x60, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x0F, 0xC0, 0x0E, 0x00, 0x70, 0x02,
  0xFE, 0x3F, 0xEC, 0x1B, 0x07, 0xC0, 0xF0, 0x7C, 0x1F, 0x06, 0xFF, 0x3F,
  0x8C, 0x63, 0x0C, 0xC3, 0x30, 0x6C, 0x1B, 0x07, 0xC0, 0xC0, 0x1F, 0x0F,
  0xE6, 0x1D, 0x83, 0xE0, 0xD8, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0xF0, 0x36, 0x1D, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFC, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x19, 0xFE, 0x3E, 0x00, 0x60, 0x3B, 0x01, 0xDC, 0x0C, 0x60,
  0x63, 0x07, 0x18, 0x30, 0x61, 0x83, 0x1C, 0x18, 0xC0, 0xE6, 0x03, 0x30,
  0x1B, 0x00, 0xD8, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0xC1, 0x83,
  0xE0, 0xE1, 0xB0, 0x70, 0xCC, 0x38, 0x66, 0x3C, 0x33, 0x1A, 0x39, 0x8D,
  0x98, 0xC4, 0xCC, 0x36, 0x66, 0x1B, 0x13, 0x0D, 0x8D, 0x86, 0x87, 0x83,
  0x43, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x18, 0x18, 0x00, 0xE0,
  0x6C, 0x1D, 0xC3, 0x18, 0xE3, 0x98, 0x36, 0x07, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x7C, 0x0D, 0xC3, 0x98, 0x63, 0x9C, 0x33, 0x07, 0xE0, 0x60, 0x60,
  0x36, 0x07, 0x70, 0x63, 0x0E, 0x38, 0xC1, 0x8C, 0x19, 0x80, 0xD8, 0x0F,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xFF, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0xFF, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x10, 0x70, 0xE1, 0x46, 0xCD,
  0x93, 0x63, 0xC6, 0xFF, 0xFF, 0xC0, 0xE3, 0x0C, 0x1E, 0x3F, 0x98, 0xEC,
  0x30, 0x18, 0xFD, 0xFE, 0xC3, 0xC1, 0xE0, 0xF8, 0xEF, 0xF3, 0xD8, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD, 0x86, 0xC3, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x86, 0xFF, 0x6F, 0x00, 0x1E, 0x3F, 0x98, 0x78,
  0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xD8, 0x6F, 0xE1, 0xE0, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x19, 0xED, 0xFE, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x86, 0xC3, 0x7F, 0x9E, 0xC0, 0x1E, 0x3F, 0x98, 0x7C,
  0x3C, 0x1F, 0xFF, 0xFF, 0x80, 0xC0, 0x70, 0x18, 0x6F, 0xF1, 0xF0, 0x1C,
  0xF3, 0x1C, 0x73, 0xFF, 0xDC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC0, 0x3D, 0xBF, 0xD8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xD8, 0x6F, 0xF3, 0xD8, 0x0C, 0x06, 0x83, 0x7F, 0x1F, 0x00, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xDE, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x73, 0x00, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x37, 0xEE, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x3B, 0x19, 0x98, 0xD8, 0x7C, 0x3C, 0x1F, 0x0D, 0x86, 0x63,
  0x39, 0x8C, 0xC7, 0x61, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xDC, 0x79,
  0xFD, 0xFB, 0x1E, 0x36, 0x18, 0x6C, 0x30, 0xD8, 0x61, 0xF0, 0xC3, 0xE1,
  0x87, 0xC3, 0x0F, 0x86, 0x1F, 0x0C, 0x3E, 0x18, 0x7C, 0x30, 0xE0, 0xDE,
  0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x1E, 0x0F, 0xE6, 0x1B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x76, 0x18, 0xFE, 0x1E, 0x00, 0x9E, 0x7F, 0xB0, 0xD8, 0x6C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xB0, 0xDF, 0xED, 0xE6, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x00, 0x3D, 0xBF, 0xD8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xF0, 0xD8, 0x6F, 0xF3, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xFF,
  0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x00, 0x3E, 0x3F, 0x98, 0xCC,
  0x36, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xE0, 0xF8, 0xEF, 0xE3, 0xE0, 0x30,
  0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B,
  0xC3, 0xE1, 0xB0, 0xCC, 0x66, 0x63, 0x31, 0x98, 0x6C, 0x3C, 0x1E, 0x07,
  0x03, 0x01, 0x80, 0xC3, 0x0F, 0x0C, 0x3C, 0x71, 0xB1, 0xE6, 0x67, 0x99,
  0x96, 0x66, 0xD9, 0x1B, 0x3C, 0x2C, 0xF0, 0xE3, 0xC3, 0x86, 0x0E, 0x18,
  0x10, 0x60, 0xC3, 0xB1, 0x99, 0x86, 0xC3, 0xC0, 0xE0, 0x60, 0x38, 0x3C,
  0x3B, 0x19, 0xDC, 0x6C, 0x38, 0x61, 0x98, 0x66, 0x19, 0xCE, 0x33, 0x0C,
  0xC3, 0x30, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x78, 0x1C, 0x00, 0xFF, 0x7F, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x38, 0x18, 0x1F, 0xFF, 0xF8, 0x0C, 0x73, 0x0C, 0x30, 0xC3,
  0x0C, 0x31, 0xCE, 0x38, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x70,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x41, 0x83, 0x0C, 0x30, 0xC3, 0x0C,
  0x38, 0x61, 0xC3, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x84, 0x00,
  0x38, 0x37, 0xC3, 0x66, 0x64, 0x3E, 0xC1, 0xC0,
};

const GFXglyph RobotoCondensed_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 4, 6, 8, 2, -18 },
  { 9, 11, 17, 13, 2, -17 },
  { 33, 10, 22, 12, 1, -20 },
  { 61, 13, 17, 15, 1, -17 },
  { 89, 12, 17, 13, 1, -17 },
  { 115, 2, 6, 4, 1, -18 },
  { 117, 5, 25, 8, 2, -19 },
  { 133, 5, 25, 8, 1, -19 },
  { 149, 10, 10, 10, 0, -17 },
  { 162, 10, 12, 12, 1, -14 },
  { 177, 4, 6, 5, 0, -3 },
  { 180, 4, 2, 6, 1, -8 },
  { 181, 2, 3, 6, 2, -3 },
  { 182, 8, 18, 9, 0, -17 },
  { 200, 9, 17, 12, 1, -17 },
  { 220, 6, 17, 12, 2, -17 },
  { 233, 10, 17, 12, 1, -17 },
  { 255, 9, 17, 12, 1, -17 },
  { 275, 10, 17, 12, 1, -17 },
  { 297, 9, 17, 12, 2, -17 },
  { 317, 9, 17, 12, 2, -17 },
  { 337, 10, 17, 12, 1, -17 },
  { 359, 9, 17, 12, 1, -17 },
  { 379, 9, 17, 12, 1, -17 },
  { 399, 2, 13, 6, 2, -13 },
  { 403, 3, 16, 5, 1, -13 },
  { 409, 8, 11, 11, 1, -13 },
  { 420, 8, 7, 12, 2, -12 },
  { 427, 8, 11, 11, 2, -13 },
  { 438, 8, 17, 10, 1, -17 },
  { 455, 16, 22, 18, 1, -17 },
  { 499, 13, 17, 14, 0, -17 },
  { 527, 10, 17, 13, 2, -17 },
  { 549, 12, 17, 14, 1, -17 },
  { 575, 10, 17, 14, 2, -17 },
  { 597, 9, 17, 12, 2, -17 },
  { 617, 9, 17, 12, 2, -17 },
  { 637, 12, 17, 14, 1, -17 },
  { 663, 11, 17, 15, 2, -17 },
  { 687, 2, 17, 6, 2, -17 },
  { 692, 9, 17, 12, 1, -17 },
  { 712, 11, 17, 13, 2, -17 },
  { 736, 9, 17, 11, 2, -17 },
  { 756, 14, 17, 18, 2, -17 },
  { 786, 11, 17, 15, 2, -17 },
  { 810, 12, 17, 14, 1, -17 },
  { 836, 10, 17, 13, 2, -17 },
  { 858, 12, 20, 14, 1, -17 },
  { 888, 10, 17, 13, 2, -17 },
  { 910, 10, 17, 12, 1, -17 },
  { 932, 11, 17, 13, 1, -17 },
  { 956, 10, 17, 13, 2, -17 },
  { 978, 13, 17, 13, 0, -17 },
  { 1006, 17, 17, 18, 1, -17 },
  { 1043, 11, 17, 13, 1, -17 },
  { 1067, 12, 17, 13, 0, -17 },
  { 1093, 11, 17, 13, 1, -17 },
  { 1117, 4, 24, 6, 2, -20 },
  { 1129, 8, 18, 9, 1, -17 },
  { 1147, 4, 24, 6, 0, -20 },
  { 1159, 7, 9, 9, 1, -17 },
  { 1167, 9, 2, 10, 0, 0 },
  { 1170, 5, 3, 7, 1, -18 },
  { 1172, 9, 13, 12, 1, -13 },
  { 1187, 9, 18, 12, 2, -18 },
  { 1208, 9, 13, 11, 1, -13 },
  { 1223, 9, 18, 12, 1, -18 },
  { 1244, 9, 13, 11, 1, -13 },
  { 1259, 6, 18, 8, 1, -18 },
  { 1273, 9, 18, 12, 1, -13 },
  { 1294, 8, 18, 12, 2, -18 },
  { 1312, 2, 17, 6, 2, -17 },
  { 1317, 4, 22, 5, 0, -17 },
  { 1328, 9, 18, 11, 2, -18 },
  { 1349, 2, 18, 6, 2, -18 },
  { 1354, 15, 13, 18, 2, -13 },
  { 1379, 8, 13, 12, 2, -13 },
  { 1392, 10, 13, 12, 1, -13 },
  { 1409, 9, 18, 12, 2, -13 },
  { 1430, 9, 18, 12, 1, -13 },
  { 1451, 5, 13, 7, 2, -13 },
  { 1460, 9, 13, 11, 1, -13 },
  { 1475, 6, 16, 7, 0, -16 },
  { 1487, 8, 13, 12, 2, -13 },
  { 1500, 9, 13, 10, 1, -13 },
  { 1515, 14, 13, 16, 1, -13 },
  { 1538, 9, 13, 11, 1, -13 },
  { 1553, 10, 18, 10, 0, -13 },
  { 1576, 9, 13, 11, 1, -13 },
  { 1591, 6, 23, 7, 1, -19 },
  { 1609, 2, 20, 6, 2, -17 },
  { 1614, 6, 23, 7, 0, -19 },
  { 1632, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_Regular24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_REGULAR24PT7B_H_
