#ifndef _ROBOTOCONDENSED_REGULAR53PT7B_H_
#define _ROBOTOCONDENSED_REGULAR53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xBC, 0x80, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00,
  0x78, 0x3C, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x78,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x07,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x80, 0xE0,
  0x78, 0x1E, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x3C, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0x38, 0x78, 0x0E, 0x03, 0x87, 0x00, 0xE0, 0x78, 0xF0, 0x0F,
  0x07, 0x8E, 0x00, 0x70, 0xF1, 0xE0, 0x07, 0xFF, 0x1C, 0x00, 0x3F, 0xE3,
  0xC0, 0x01, 0xFC, 0x38, 0x00, 0x02, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x3F, 0x80, 0x03,
  0xC7, 0xFC, 0x00, 0x38, 0xFF, 0xE0, 0x07, 0x8F, 0x0E, 0x00, 0x71, 0xE0,
  0xF0, 0x0F, 0x1E, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0x1E, 0x1C, 0x07, 0x01,
  0xC1, 0xC0, 0x70, 0x3C, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x78, 0x1E,
  0x07, 0x07, 0x01, 0xE0, 0xF0, 0x30, 0x0F, 0x0E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3E,
  0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF8, 0x01,
  0xE0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xF9, 0xF0, 0x78, 0xF8, 0xFC,
  0x3C, 0x7C, 0x3E, 0x1E, 0x7C, 0x0F, 0x8F, 0x3E, 0x07, 0xE7, 0x9E, 0x01,
  0xF3, 0xCF, 0x00, 0x7F, 0xE7, 0x80, 0x3F, 0xE3, 0xC0, 0x0F, 0xF1, 0xF0,
  0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x07,
  0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0xF8, 0x1F, 0xF8, 0x3E,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x10, 0x03,
  0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x00, 0x10, 0x40, 0x06, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x06, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0x01,
  0xC0, 0x5F, 0x0E, 0x1E, 0xFF, 0x73, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB,
  0xC0, 0x0F, 0x8F, 0x00, 0x78, 0x7C, 0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x80,
  0xC0, 0x38, 0x02, 0x00, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF3, 0xE7, 0x82, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0x9F, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xE7,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE3,
  0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFD, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xBF, 0xC7, 0xC0, 0x7C, 0x78, 0x03,
  0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xFB,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7B,
  0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x3C,
  0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x78, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xF1, 0xFC, 0x7C, 0x07,
  0xE0, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7,
  0xE0, 0x7C, 0x3F, 0xBF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x3E, 0x01, 0xE7, 0xFC, 0x0F, 0x7F, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFC, 0x3F, 0x3F, 0x80, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xF7, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3F,
  0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xF0, 0xFC, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFD,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xBF, 0x87,
  0xE0, 0xFC, 0x7C, 0x07, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xF7, 0xC0,
  0x3F, 0x7C, 0x07, 0xF7, 0xE1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDE, 0x0F,
  0xF9, 0xE0, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0xFB, 0xEF, 0xBE, 0xF8, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFB, 0xFF, 0xBE, 0x20, 0x1E,
  0x3F, 0x3F, 0x3F, 0x1E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x70, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x9F, 0x83, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x3E, 0x01,
  0xE3, 0xC0, 0x1F, 0xF0, 0x1C, 0x78, 0x07, 0xFF, 0x03, 0x8E, 0x01, 0xF3,
  0xE0, 0x73, 0xC0, 0x7C, 0x3C, 0x0F, 0x78, 0x0F, 0x07, 0x80, 0xEE, 0x03,
  0xC0, 0xF0, 0x1D, 0xC0, 0x78, 0x1E, 0x03, 0xF8, 0x0E, 0x03, 0xC0, 0x7F,
  0x03, 0xC0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0x01, 0xFC, 0x0F, 0x01, 0xE0,
  0x3F, 0x81, 0xE0, 0x38, 0x07, 0xF0, 0x78, 0x07, 0x00, 0xFC, 0x0F, 0x00,
  0xE0, 0x1F, 0x81, 0xE0, 0x1C, 0x03, 0xF0, 0x3C, 0x03, 0x80, 0x7E, 0x07,
  0x80, 0xF0, 0x1F, 0xE0, 0xF0, 0x1E, 0x03, 0xBC, 0x1E, 0x03, 0xC0, 0x77,
  0x81, 0xE0, 0xF8, 0x1E, 0xF0, 0x3C, 0x1F, 0x03, 0x8E, 0x07, 0xCF, 0xF0,
  0xF1, 0xC0, 0x7F, 0xDF, 0xFC, 0x3C, 0x0F, 0xF1, 0xFF, 0x07, 0x80, 0xFC,
  0x1F, 0xC0, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x10,
  0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x1F, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0,
  0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x3E,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF8, 0x07, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x01, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xF0,
  0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0xFF,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF0, 0x1F, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x0F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x03,
  0xE7, 0xE0, 0x7C, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03,
  0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFB, 0xE0,
  0x03, 0xF8, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF7, 0x80, 0x01, 0xEF, 0xF7, 0xC0, 0x01, 0xEF, 0xF7, 0xC0,
  0x03, 0xEF, 0xF3, 0xC0, 0x03, 0xCF, 0xFB, 0xC0, 0x03, 0xDF, 0xFB, 0xE0,
  0x07, 0xDF, 0xF9, 0xE0, 0x07, 0x9F, 0xF9, 0xE0, 0x07, 0x9F, 0xF9, 0xF0,
  0x0F, 0x9F, 0xF8, 0xF0, 0x0F, 0x1F, 0xF8, 0xF0, 0x0F, 0x1F, 0xF8, 0xF8,
  0x1F, 0x1F, 0xF8, 0x78, 0x1E, 0x1F, 0xF8, 0x78, 0x1E, 0x1F, 0xF8, 0x7C,
  0x3E, 0x1F, 0xF8, 0x3C, 0x3C, 0x1F, 0xF8, 0x3C, 0x3C, 0x1F, 0xF8, 0x3E,
  0x7C, 0x1F, 0xF8, 0x1E, 0x78, 0x1F, 0xF8, 0x1E, 0x78, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0xF0, 0x03, 0xFF, 0x7C, 0x01, 0xFF,
  0x9E, 0x00, 0xFF, 0xCF, 0x80, 0x7F, 0xE3, 0xC0, 0x3F, 0xF1, 0xF0, 0x1F,
  0xF8, 0x78, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x0F, 0x03, 0xFF, 0x07, 0xC1,
  0xFF, 0x81, 0xE0, 0xFF, 0xC0, 0xF8, 0x7F, 0xE0, 0x3C, 0x3F, 0xF0, 0x1F,
  0x1F, 0xF8, 0x07, 0x8F, 0xFC, 0x03, 0xE7, 0xFE, 0x00, 0xFB, 0xFF, 0x00,
  0x3D, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E,
  0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0,
  0x07, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x23, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0x80, 0x7F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00,
  0xF7, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00,
  0x3E, 0x00, 0x3C, 0xF0, 0x01, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x80, 0x1F,
  0x3E, 0x00, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xF0, 0x07, 0xCF, 0x80, 0x3F,
  0x80, 0x3E, 0x3C, 0x01, 0xDC, 0x01, 0xE1, 0xE0, 0x1E, 0xF0, 0x0F, 0x0F,
  0x00, 0xF7, 0x80, 0xF8, 0x7C, 0x07, 0xBC, 0x07, 0xC3, 0xE0, 0x3D, 0xE0,
  0x3E, 0x0F, 0x03, 0xC7, 0x01, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC0,
  0xF1, 0xE0, 0xF8, 0x1F, 0x07, 0x8F, 0x07, 0xC0, 0xF8, 0x38, 0x38, 0x3E,
  0x07, 0xC3, 0xC1, 0xE1, 0xE0, 0x1E, 0x1E, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x78, 0x78, 0x07, 0x87, 0x83, 0xC7, 0xC0, 0x3E, 0x78, 0x0E, 0x3E, 0x01,
  0xF3, 0xC0, 0x79, 0xE0, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x1E,
  0x78, 0x01, 0xE7, 0x00, 0x73, 0xC0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F,
  0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x83,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xBF, 0xC7, 0xE0, 0x7C,
  0x7C, 0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFE,
  0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x0F, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xBE, 0x0F, 0xF1, 0xF0, 0x10, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x20, 0x0F, 0x8F, 0xF0, 0x7D, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0x03, 0xE7, 0xE0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x7D, 0xFC, 0x07, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xEF, 0xFE, 0x1F, 0x1F, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x9F,
  0xC7, 0xE0, 0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xC3, 0xF9, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3F,
  0xCF, 0x87, 0xFF, 0x7C, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x03, 0xF9,
  0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7E, 0x7E,
  0x07, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFB, 0xE0, 0x7F, 0x9F,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x0C, 0x7E, 0x01, 0xE3, 0xFC, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x10, 0x07, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0x1F,
  0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xDF, 0x07, 0xF9, 0xF0, 0x08, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x30, 0x03, 0xE3, 0xC0, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x8F, 0xF1, 0xF7, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF7, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x07, 0x87, 0xC3,
  0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xFF,
  0xFB, 0xFD, 0xFC, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00,
  0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8,
  0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x7C, 0xFF, 0x03,
  0xFE, 0x3E, 0xFF, 0xE3, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xF0, 0x3F, 0xC0, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xF0, 0x07,
  0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00,
  0x78, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xC0,
  0x0F, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0xF8,
  0x01, 0xE0, 0x07, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x78, 0x01, 0xFF,
  0x00, 0x3C, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x3F,
  0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x07,
  0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3C, 0x00,
  0xFF, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x1F, 0xE3, 0xEF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1E, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xEF, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF0, 0x7F,
  0xBF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x80, 0x3E, 0xFE, 0x03, 0xE7, 0xFC, 0xFF, 0x3F, 0xFF, 0xF1,
  0xF7, 0xFF, 0x0F, 0x9F, 0xF0, 0x7C, 0x08, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xF3, 0xFC, 0xFF, 0x9F,
  0x81, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDE, 0x00, 0x3E,
  0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0,
  0x3F, 0x3F, 0x03, 0xF9, 0xFE, 0x7F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFD, 0xF0,
  0x3F, 0xCF, 0x80, 0x20, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFB, 0xF8, 0xF8, 0x1F, 0x9E, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03,
  0xDF, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1E,
  0xFC, 0x07, 0xCF, 0xF7, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x00, 0x80, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x7F, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xF7, 0x87, 0xF8, 0xF0, 0x18, 0x00, 0xF8,
  0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x7C,
  0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3D,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x78, 0x03, 0xC0, 0x1F, 0x78, 0x03, 0xE0, 0x1E, 0x7C, 0x07, 0xE0,
  0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x3C, 0x07, 0xE0, 0x3E, 0x3C, 0x07, 0xF0,
  0x3E, 0x3E, 0x0F, 0xF0, 0x3C, 0x3E, 0x0F, 0xF0, 0x3C, 0x1E, 0x0F, 0x78,
  0x3C, 0x1E, 0x0E, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x1F, 0x1E, 0x78,
  0x78, 0x0F, 0x1E, 0x3C, 0x78, 0x0F, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x3C,
  0xF0, 0x0F, 0xBC, 0x3C, 0xF0, 0x07, 0xBC, 0x1E, 0xF0, 0x07, 0xF8, 0x1E,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC1,
  0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0xDF,
  0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xF7, 0xC0, 0x0F, 0x9E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xC0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0x7C,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x07, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x10, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x40, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0xFE, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x02, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xCF, 0xFE, 0x01, 0xE7, 0xFF,
  0x80, 0xF7, 0xC7, 0xE0, 0xFB, 0xC1, 0xFC, 0xF9, 0xE0, 0x7F, 0xFD, 0xE0,
  0x1F, 0xFC, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 39, 13, 4, -38 },
  { 26, 10, 13, 17, 4, -40 },
  { 43, 25, 38, 29, 3, -38 },
  { 162, 20, 51, 26, 3, -45 },
  { 290, 28, 40, 34, 3, -39 },
  { 430, 25, 40, 29, 3, -39 },
  { 555, 4, 12, 9, 3, -40 },
  { 561, 12, 55, 17, 3, -43 },
  { 644, 12, 55, 17, 1, -43 },
  { 727, 21, 22, 23, 1, -38 },
  { 785, 22, 28, 26, 2, -32 },
  { 862, 7, 13, 10, 1, -6 },
  { 874, 11, 4, 13, 1, -18 },
  { 880, 6, 6, 14, 4, -5 },
  { 885, 17, 41, 20, 1, -38 },
  { 973, 20, 40, 26, 3, -39 },
  { 1073, 13, 38, 26, 4, -38 },
  { 1135, 22, 39, 26, 2, -39 },
  { 1243, 20, 40, 26, 3, -39 },
  { 1343, 23, 38, 26, 2, -38 },
  { 1453, 20, 39, 26, 4, -38 },
  { 1551, 21, 39, 26, 3, -38 },
  { 1654, 22, 38, 26, 2, -38 },
  { 1759, 20, 40, 26, 3, -39 },
  { 1859, 20, 39, 26, 3, -39 },
  { 1957, 6, 29, 12, 4, -28 },
  { 1979, 8, 35, 11, 1, -28 },
  { 2014, 18, 23, 24, 2, -28 },
  { 2066, 18, 14, 25, 4, -25 },
  { 2098, 18, 23, 24, 4, -28 },
  { 2150, 18, 40, 22, 2, -39 },
  { 2240, 35, 49, 41, 3, -37 },
  { 2455, 28, 38, 31, 1, -38 },
  { 2588, 22, 38, 29, 4, -38 },
  { 2693, 25, 40, 30, 3, -39 },
  { 2818, 23, 38, 30, 4, -38 },
  { 2928, 20, 38, 26, 4, -38 },
  { 3023, 20, 38, 25, 4, -38 },
  { 3118, 25, 40, 31, 3, -39 },
  { 3243, 25, 38, 33, 4, -38 },
  { 3362, 5, 38, 13, 4, -38 },
  { 3386, 20, 39, 26, 2, -38 },
  { 3484, 25, 38, 29, 4, -38 },
  { 3603, 20, 38, 25, 4, -38 },
  { 3698, 32, 38, 40, 4, -38 },
  { 3850, 25, 38, 33, 4, -38 },
  { 3969, 26, 40, 32, 3, -39 },
  { 4099, 23, 38, 29, 4, -38 },
  { 4209, 26, 45, 32, 3, -39 },
  { 4356, 23, 38, 28, 4, -38 },
  { 4466, 23, 40, 27, 2, -39 },
  { 4581, 24, 38, 28, 2, -38 },
  { 4695, 24, 39, 30, 3, -38 },
  { 4812, 28, 38, 30, 1, -38 },
  { 4945, 37, 38, 40, 2, -38 },
  { 5121, 26, 38, 29, 2, -38 },
  { 5245, 26, 38, 28, 1, -38 },
  { 5369, 23, 38, 28, 2, -38 },
  { 5479, 8, 51, 13, 4, -43 },
  { 5530, 18, 41, 20, 1, -38 },
  { 5623, 8, 51, 13, 1, -43 },
  { 5674, 16, 19, 20, 2, -38 },
  { 5712, 20, 4, 21, 1, 0 },
  { 5722, 11, 8, 16, 1, -40 },
  { 5733, 20, 30, 25, 3, -29 },
  { 5808, 21, 41, 26, 3, -40 },
  { 5916, 20, 30, 24, 3, -29 },
  { 5991, 21, 41, 26, 2, -40 },
  { 6099, 20, 30, 25, 3, -29 },
  { 6174, 14, 41, 17, 2, -41 },
  { 6246, 20, 40, 26, 3, -29 },
  { 6346, 19, 40, 26, 3, -40 },
  { 6441, 5, 38, 12, 4, -38 },
  { 6465, 9, 49, 12, -1, -38 },
  { 6521, 20, 40, 24, 3, -40 },
  { 6621, 4, 40, 12, 4, -40 },
  { 6641, 33, 29, 40, 3, -29 },
  { 6761, 19, 29, 26, 3, -29 },
  { 6830, 22, 30, 27, 2, -29 },
  { 6913, 21, 40, 26, 3, -29 },
  { 7018, 21, 40, 27, 2, -29 },
  { 7123, 12, 29, 16, 3, -29 },
  { 7167, 19, 30, 24, 3, -29 },
  { 7239, 13, 36, 16, 1, -35 },
  { 7298, 19, 29, 26, 3, -28 },
  { 7367, 20, 28, 23, 1, -28 },
  { 7437, 32, 28, 34, 1, -28 },
  { 7549, 21, 28, 23, 1, -28 },
  { 7623, 20, 39, 22, 1, -28 },
  { 7721, 19, 28, 23, 2, -28 },
  { 7788, 13, 50, 16, 2, -41 },
  { 7870, 3, 45, 13, 5, -38 },
  { 7887, 13, 50, 16, 1, -41 },
  { 7969, 25, 10, 31, 3, -20 },
};

const GFXfont RobotoCondensed_Regular53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_REGULAR53PT7B_H_
