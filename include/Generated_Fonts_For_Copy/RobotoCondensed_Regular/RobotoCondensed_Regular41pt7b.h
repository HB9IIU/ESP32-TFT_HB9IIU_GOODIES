#ifndef _ROBOTOCONDENSED_REGULAR41PT7B_H_
#define _ROBOTOCONDENSED_REGULAR41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x70, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC6, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0C, 0x18, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x1C, 0x38, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x87, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x06, 0x0C,
  0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E,
  0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x7E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x18, 0x70, 0x00, 0xE0, 0xC1, 0xC3,
  0x83, 0x06, 0x0E, 0x0C, 0x38, 0x38, 0x30, 0xC0, 0xE0, 0xC7, 0x03, 0x87,
  0x18, 0x06, 0x1C, 0xE0, 0x1E, 0xE7, 0x00, 0x3F, 0x9C, 0x00, 0x78, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x63, 0xF0, 0x03, 0x9C, 0xE0,
  0x0C, 0xE1, 0xC0, 0x73, 0x87, 0x01, 0x8E, 0x1C, 0x0E, 0x38, 0x30, 0x70,
  0xE0, 0xC1, 0xC3, 0x87, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x00, 0x7B,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xE3, 0xC0, 0x3C, 0x1C, 0x03, 0xC1, 0xC0, 0x3C, 0x1C, 0x03,
  0xC1, 0xC0, 0x3C, 0x3C, 0x01, 0xC7, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x1C, 0x3D, 0xE1,
  0xC7, 0x8F, 0x1C, 0xF0, 0x79, 0xCF, 0x07, 0x9C, 0xF0, 0x3F, 0xCF, 0x01,
  0xF8, 0xF0, 0x1F, 0x8F, 0x00, 0xF0, 0x78, 0x0F, 0x87, 0xC3, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0x9E, 0x07, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0x01, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0x80, 0x40,
  0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0x20, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xE1, 0x86, 0xF9,
  0x9F, 0xFF, 0xFF, 0x3F, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E,
  0x70, 0x1C, 0x78, 0x3C, 0x38, 0x38, 0x38, 0x00, 0x10, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x39, 0xCE, 0x77, 0xBD, 0xDE, 0xE2,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x07, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1E,
  0x3C, 0x3C, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0xC0, 0xF0, 0xFD,
  0xFF, 0xFF, 0xFC, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xC7, 0x81, 0xE7, 0x80, 0x73, 0xC0, 0x3D,
  0xE0, 0x1E, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x7C, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x78,
  0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0x78, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78,
  0x0F, 0x1E, 0x03, 0x87, 0x81, 0xC1, 0xE0, 0x70, 0x78, 0x38, 0x1E, 0x1E,
  0x07, 0x87, 0x01, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x73,
  0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7C, 0xFC, 0x70, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x1E, 0x78, 0x1E, 0x7C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x07,
  0xE0, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x8F, 0x87, 0x7F, 0x8F,
  0xFF, 0x9F, 0x8F, 0xBE, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x3C,
  0x78, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C,
  0x78, 0x3C, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F, 0x78, 0x3F, 0x7C, 0x7F,
  0x3F, 0xFE, 0x1F, 0xEE, 0x0F, 0x8E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x00, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x3D, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x8E, 0x38, 0xE3, 0x9E, 0x79, 0xCE, 0x18, 0x00, 0x08,
  0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0xF0,
  0x07, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x00, 0x18, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x87,
  0xFF, 0x3F, 0x3E, 0xF0, 0x7B, 0x80, 0xEE, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x7C, 0x0C, 0x38, 0x1F,
  0xE0, 0xE3, 0x01, 0xFF, 0x06, 0x70, 0x38, 0x70, 0x67, 0x07, 0x07, 0x06,
  0x70, 0x70, 0x70, 0x66, 0x0E, 0x06, 0x06, 0xE0, 0xE0, 0x60, 0x6E, 0x0E,
  0x06, 0x07, 0xE0, 0xE0, 0xE0, 0x6E, 0x0E, 0x0E, 0x06, 0xE0, 0xE0, 0xE0,
  0x6E, 0x1E, 0x0E, 0x06, 0xE1, 0xE0, 0xE0, 0x6E, 0x0E, 0x0E, 0x0E, 0x60,
  0xE1, 0xE0, 0xC6, 0x0F, 0x3E, 0x1C, 0x70, 0xFF, 0x73, 0x87, 0x07, 0xE7,
  0xF0, 0x70, 0x3C, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x20, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xCE,
  0x00, 0x0F, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00,
  0x1C, 0x1E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0x38,
  0x07, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x03,
  0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x71, 0xE0, 0x01, 0xE7,
  0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0,
  0x0E, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x07, 0xCF, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xF9, 0xE0, 0x3E, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x87, 0xE3, 0xE0, 0x3C, 0x78, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x77, 0x80, 0x0E,
  0xF0, 0x03, 0xDE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC3, 0xE1, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xC1, 0xF8, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x0F, 0x3C, 0x1F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0x87, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x70, 0x00, 0xEE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFD, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x01, 0xDE, 0x00,
  0x39, 0xE0, 0x07, 0x3E, 0x01, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xE0, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01,
  0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C,
  0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFD, 0xE0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0xF8, 0xF0, 0x0F,
  0x1E, 0x00, 0xF3, 0xC0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xDC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3B,
  0xFD, 0xC0, 0x1D, 0xFE, 0xF0, 0x1E, 0xFF, 0x38, 0x0E, 0x7F, 0x9C, 0x07,
  0x3F, 0xCF, 0x07, 0x9F, 0xE3, 0x83, 0x8F, 0xF1, 0xC1, 0xC7, 0xF8, 0xF1,
  0xE3, 0xFC, 0x38, 0xE1, 0xFE, 0x1C, 0x70, 0xFF, 0x0E, 0x78, 0x7F, 0x83,
  0xB8, 0x3F, 0xC1, 0xDC, 0x1F, 0xE0, 0xEE, 0x0F, 0xF0, 0x3E, 0x07, 0xF8,
  0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x03, 0x80, 0xFF, 0x01, 0xC0, 0x78,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xF7, 0x00, 0xFE, 0xF0, 0x1F,
  0xCE, 0x03, 0xF9, 0xE0, 0x7F, 0x1C, 0x0F, 0xE3, 0xC1, 0xFC, 0x38, 0x3F,
  0x87, 0x87, 0xF0, 0x70, 0xFE, 0x0F, 0x1F, 0xC0, 0xF3, 0xF8, 0x0E, 0x7F,
  0x01, 0xEF, 0xE0, 0x1D, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0xBC,
  0x00, 0x77, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x73, 0xC0, 0x1E, 0x7C, 0x07, 0x87, 0xE3, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xEF, 0x00, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF8, 0xFC, 0x3C, 0x03,
  0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x03, 0xC1, 0xF0, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F,
  0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3C, 0x1E, 0x0F, 0x03, 0x83, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x0F, 0x9E, 0x01, 0xE7, 0x00, 0x3B, 0xC0,
  0x0E, 0x70, 0x03, 0xDE, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1E, 0x78, 0x07, 0x9F, 0x87, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEF,
  0x00, 0x3B, 0xC0, 0x1E, 0xF8, 0x07, 0x9F, 0x07, 0xC3, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x1C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xE0, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x3D, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x7B, 0x80, 0x3C, 0x03, 0xDE, 0x01, 0xE0, 0x1E, 0xF0, 0x0F, 0x00, 0xE7,
  0x80, 0xF8, 0x07, 0x1C, 0x07, 0xE0, 0x78, 0xE0, 0x3F, 0x03, 0xC7, 0x01,
  0xF8, 0x1E, 0x3C, 0x1D, 0xC0, 0xE1, 0xE0, 0xE7, 0x07, 0x07, 0x07, 0x38,
  0x38, 0x38, 0x39, 0xC3, 0xC1, 0xC3, 0x8E, 0x1E, 0x0F, 0x1C, 0x70, 0xE0,
  0x78, 0xE1, 0xC7, 0x01, 0xC7, 0x0E, 0x38, 0x0E, 0x38, 0x71, 0xC0, 0x73,
  0x83, 0x9E, 0x03, 0x9C, 0x0E, 0xE0, 0x1E, 0xE0, 0x77, 0x00, 0x77, 0x03,
  0xB8, 0x03, 0xF0, 0x1D, 0xC0, 0x1F, 0x80, 0x6E, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xF7, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00,
  0xF0, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xFF, 0x00,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x1C,
  0x07, 0x81, 0xE0, 0x70, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00,
  0x71, 0xE0, 0x07, 0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x77, 0x03, 0xB8,
  0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x07,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xEE, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC1,
  0xEE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7D, 0xF1, 0xFB,
  0xFF, 0xF3, 0xFD, 0xE1, 0xF1, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC7,
  0xC3, 0xBF, 0xE7, 0xFF, 0xEF, 0xC7, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE3, 0xEF, 0xFF,
  0xDD, 0xFF, 0x38, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3C, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x0E, 0xF0, 0x0E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xCF, 0x1F, 0xEF, 0x3F,
  0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F,
  0xEF, 0x07, 0xCF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78,
  0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x04, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x01,
  0xF0, 0x7F, 0x0F, 0xE0, 0xF8, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xCF,
  0x1F, 0xEF, 0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C, 0x3F,
  0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x20, 0x1E, 0x38, 0x3E, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x8F, 0x8E, 0xFF, 0x3F, 0xFE, 0xFC, 0x7F, 0xC0, 0xFF, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xC0, 0xEF, 0xFE, 0x00, 0x00, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x1C, 0xF3, 0xC7, 0x00,
  0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFF, 0xFB,
  0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7B, 0x81, 0xE7, 0x07, 0x8E,
  0x1F, 0x1C, 0x3C, 0x38, 0xF0, 0x73, 0xC0, 0xE7, 0x81, 0xDE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3C, 0xF0, 0x70, 0xF0, 0xE1, 0xE1,
  0xC1, 0xE3, 0x83, 0xC7, 0x03, 0xCE, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE3, 0xE0, 0xFC, 0x77, 0xF8, 0xFF, 0x3F, 0xFE, 0xFF, 0xDF, 0x0F, 0xF1,
  0xFF, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x3F, 0x80, 0x70, 0x0F, 0xC0, 0x38,
  0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03,
  0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0,
  0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC,
  0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1C, 0xE3, 0xE3, 0xBF,
  0xCF, 0xFF, 0xBF, 0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0x87, 0xC7, 0x81, 0xF3, 0x80,
  0x7B, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1D, 0xE0, 0x0E, 0x70, 0x0F,
  0x3C, 0x07, 0x8F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xE3,
  0xE1, 0xDF, 0xF3, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xF7, 0xFF,
  0xEE, 0xFF, 0x9C, 0x7C, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xCF, 0x1F, 0xEF,
  0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF,
  0x1F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE7, 0xF7, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCE, 0x03, 0x9C, 0x07, 0x3C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xF0, 0xF1, 0xFF, 0xE1, 0xFF,
  0x81, 0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0,
  0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0xDC, 0x7C, 0x70, 0xF0, 0x0E, 0xF0, 0x0E,
  0x70, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x38,
  0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x78, 0x1E, 0x03, 0x9C, 0x0F,
  0x01, 0xCE, 0x07, 0xC1, 0xE7, 0x03, 0xE0, 0xF3, 0xC3, 0xF0, 0x70, 0xE1,
  0xF8, 0x38, 0x70, 0xEE, 0x1C, 0x38, 0x77, 0x1E, 0x1E, 0x73, 0x8E, 0x07,
  0x39, 0xC7, 0x03, 0x9C, 0x73, 0x81, 0xCE, 0x3B, 0xC0, 0xEE, 0x1D, 0xC0,
  0x7F, 0x0E, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x07,
  0x00, 0xF8, 0x1E, 0x78, 0x1E, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E,
  0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x3C,
  0x38, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7B, 0x80, 0xE7, 0x83, 0xCF, 0x07, 0x8E, 0x0E, 0x1E, 0x1C,
  0x3C, 0x78, 0x38, 0xF0, 0x71, 0xC0, 0xF3, 0x81, 0xEF, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x07, 0x83, 0xF0, 0x7C,
  0x0F, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0x03, 0xC0, 0x7C, 0x0F, 0x07, 0xC3, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0xF8, 0x38, 0x0C, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x1D, 0xFF, 0x03,
  0xF9, 0xF0, 0xEE, 0x1F, 0x3D, 0xC1, 0xFF, 0x38, 0x1F, 0xE0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 8, 10, 13, 3, -31 },
  { 26, 18, 29, 22, 3, -29 },
  { 92, 16, 37, 20, 2, -33 },
  { 166, 22, 29, 26, 2, -29 },
  { 246, 20, 29, 22, 2, -29 },
  { 319, 3, 10, 7, 2, -31 },
  { 323, 9, 42, 13, 3, -33 },
  { 371, 9, 42, 13, 1, -33 },
  { 419, 16, 17, 18, 1, -29 },
  { 453, 17, 21, 20, 2, -24 },
  { 498, 5, 10, 8, 1, -4 },
  { 505, 8, 3, 10, 1, -14 },
  { 508, 4, 4, 11, 3, -4 },
  { 510, 13, 32, 15, 1, -29 },
  { 562, 16, 29, 20, 2, -29 },
  { 620, 10, 29, 20, 3, -29 },
  { 657, 17, 29, 20, 2, -29 },
  { 719, 16, 29, 20, 2, -29 },
  { 777, 18, 29, 20, 1, -29 },
  { 843, 16, 29, 20, 3, -29 },
  { 901, 15, 29, 20, 3, -29 },
  { 956, 16, 29, 20, 2, -29 },
  { 1014, 16, 29, 20, 2, -29 },
  { 1072, 16, 29, 20, 2, -29 },
  { 1130, 4, 22, 10, 3, -22 },
  { 1141, 6, 28, 8, 1, -22 },
  { 1162, 13, 18, 18, 2, -22 },
  { 1192, 14, 11, 20, 3, -19 },
  { 1212, 14, 18, 19, 3, -22 },
  { 1244, 14, 29, 17, 2, -29 },
  { 1295, 28, 38, 32, 2, -29 },
  { 1428, 22, 29, 24, 1, -29 },
  { 1508, 17, 29, 22, 3, -29 },
  { 1570, 19, 29, 23, 2, -29 },
  { 1639, 18, 29, 23, 3, -29 },
  { 1705, 16, 29, 20, 3, -29 },
  { 1763, 15, 29, 20, 3, -29 },
  { 1818, 19, 29, 24, 2, -29 },
  { 1887, 19, 29, 25, 3, -29 },
  { 1956, 4, 29, 10, 3, -29 },
  { 1971, 16, 29, 20, 1, -29 },
  { 2029, 19, 29, 22, 3, -29 },
  { 2098, 15, 29, 20, 3, -29 },
  { 2153, 25, 29, 31, 3, -29 },
  { 2244, 19, 29, 25, 3, -29 },
  { 2313, 19, 29, 25, 3, -29 },
  { 2382, 18, 29, 23, 3, -29 },
  { 2448, 20, 34, 25, 2, -29 },
  { 2533, 18, 29, 22, 3, -29 },
  { 2599, 18, 29, 21, 2, -29 },
  { 2665, 19, 29, 21, 1, -29 },
  { 2734, 18, 29, 23, 3, -29 },
  { 2800, 21, 29, 23, 1, -29 },
  { 2877, 29, 29, 31, 1, -29 },
  { 2983, 20, 29, 23, 1, -29 },
  { 3056, 20, 29, 22, 1, -29 },
  { 3129, 18, 29, 21, 2, -29 },
  { 3195, 6, 39, 10, 3, -33 },
  { 3225, 14, 32, 15, 1, -29 },
  { 3281, 6, 39, 10, 1, -33 },
  { 3311, 13, 15, 15, 1, -29 },
  { 3336, 16, 3, 17, 0, 0 },
  { 3342, 8, 6, 13, 1, -31 },
  { 3348, 15, 22, 20, 2, -22 },
  { 3390, 15, 31, 20, 3, -31 },
  { 3449, 16, 22, 19, 2, -22 },
  { 3493, 16, 31, 20, 2, -31 },
  { 3555, 16, 22, 19, 2, -22 },
  { 3599, 12, 31, 13, 1, -31 },
  { 3646, 16, 30, 20, 2, -22 },
  { 3706, 14, 31, 20, 3, -31 },
  { 3761, 4, 30, 9, 3, -30 },
  { 3776, 6, 38, 9, 0, -30 },
  { 3805, 15, 31, 18, 3, -31 },
  { 3864, 3, 31, 9, 3, -31 },
  { 3876, 25, 22, 31, 3, -22 },
  { 3945, 14, 22, 20, 3, -22 },
  { 3984, 17, 22, 21, 2, -22 },
  { 4031, 15, 30, 20, 3, -22 },
  { 4088, 16, 30, 21, 2, -22 },
  { 4148, 9, 22, 13, 3, -22 },
  { 4173, 15, 22, 19, 2, -22 },
  { 4215, 11, 27, 12, 0, -27 },
  { 4253, 14, 22, 20, 3, -22 },
  { 4292, 16, 22, 18, 1, -22 },
  { 4336, 25, 22, 27, 1, -22 },
  { 4405, 16, 22, 18, 1, -22 },
  { 4449, 15, 30, 17, 1, -22 },
  { 4506, 14, 22, 18, 2, -22 },
  { 4545, 11, 39, 13, 1, -32 },
  { 4599, 3, 34, 10, 4, -29 },
  { 4612, 10, 39, 13, 1, -32 },
  { 4661, 19, 8, 24, 3, -16 },
};

const GFXfont RobotoCondensed_Regular41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_REGULAR41PT7B_H_
