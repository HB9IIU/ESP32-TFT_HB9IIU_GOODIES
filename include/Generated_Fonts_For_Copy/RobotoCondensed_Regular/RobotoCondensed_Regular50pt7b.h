#ifndef _ROBOTOCONDENSED_REGULAR50PT7B_H_
#define _ROBOTOCONDENSED_REGULAR50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xE0,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0x00, 0x70, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x3C, 0x00,
  0x70, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x81, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xC1, 0xF1, 0xF0,
  0x1F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0,
  0x1F, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x03,
  0xE7, 0xE0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xE0, 0xF0, 0x10, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x38, 0x0E, 0x07, 0x1E,
  0x03, 0x81, 0xC7, 0x00, 0xE0, 0xF3, 0xC0, 0x3C, 0x78, 0xE0, 0x07, 0xFE,
  0x78, 0x00, 0xFF, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x38, 0xFF, 0x00, 0x0E, 0x7F,
  0xE0, 0x07, 0x1E, 0x3C, 0x03, 0xCF, 0x07, 0x00, 0xE3, 0x81, 0xC0, 0x78,
  0xE0, 0x70, 0x1C, 0x38, 0x1C, 0x0F, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x18, 0x0F, 0x07, 0x02, 0x01, 0xE3,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x0F,
  0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF8,
  0x3C, 0x7C, 0x7C, 0x3C, 0xF8, 0x7C, 0x3C, 0xF0, 0x3E, 0x3C, 0xF0, 0x1F,
  0x7C, 0xF0, 0x1F, 0x78, 0xF0, 0x0F, 0xF8, 0xF0, 0x07, 0xF8, 0xF0, 0x07,
  0xF0, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xF8, 0x7E, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0x3E, 0x07, 0xFC, 0x3E, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x0C, 0x03, 0x80, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0C, 0x00, 0x80, 0x40, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x60, 0xF0, 0x6F, 0x8F, 0x1E, 0xFF, 0xEF, 0xEF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00,
  0xF9, 0xE0, 0x0F, 0x1F, 0x01, 0xE0, 0xF0, 0x3E, 0x07, 0x81, 0xC0, 0x70,
  0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0xF9,
  0xF3, 0xC7, 0x8F, 0x3E, 0x79, 0xF3, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8,
  0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0x7C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9F, 0x01,
  0xE1, 0xF0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFE,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x7C, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9F, 0x00, 0xFB, 0xC0,
  0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDF, 0x00, 0xF1, 0xF0, 0x3E, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1F,
  0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x9F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7C, 0x1F, 0x8F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x9E, 0x01,
  0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x8F, 0xC0, 0xF7, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFE, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x0F, 0x7C, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0x8F, 0x81, 0xF1, 0xF8, 0x7C, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E,
  0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x0F, 0x83, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x0F, 0xC7, 0xC0, 0x78, 0xF0,
  0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xF0,
  0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x1E, 0x03,
  0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x7F, 0x3F, 0xFF, 0xCF, 0xFE,
  0xF1, 0xFF, 0x3C, 0x1F, 0x8F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7B, 0xFF, 0xDF, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xBF, 0xFD, 0xF7, 0x80, 0x3E, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3C, 0xF0, 0x40, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x87, 0x80, 0x3F, 0x00,
  0xE3, 0x80, 0x3F, 0xC0, 0x73, 0xC0, 0x3F, 0xF8, 0x39, 0xC0, 0x3C, 0x3C,
  0x1C, 0xE0, 0x3C, 0x1C, 0x07, 0x70, 0x1C, 0x0E, 0x03, 0xF8, 0x1E, 0x07,
  0x01, 0xFC, 0x0F, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xC0, 0x7E, 0x07, 0x80,
  0xE0, 0x3F, 0x03, 0xC0, 0x70, 0x1F, 0x81, 0xE0, 0x78, 0x0F, 0xC0, 0xE0,
  0x3C, 0x07, 0xE0, 0x70, 0x1E, 0x03, 0xF0, 0x38, 0x0F, 0x01, 0xF8, 0x1C,
  0x07, 0x80, 0xFC, 0x0E, 0x03, 0x80, 0xEE, 0x07, 0x01, 0xC0, 0x77, 0x03,
  0xC1, 0xF0, 0x3B, 0xC1, 0xE0, 0xF8, 0x39, 0xE0, 0xF8, 0xFC, 0x3C, 0x70,
  0x3F, 0xEF, 0xFC, 0x38, 0x1F, 0xE7, 0xFC, 0x1E, 0x07, 0xE1, 0xFC, 0x0F,
  0x00, 0x00, 0x10, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0xEF,
  0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x07,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x00,
  0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0,
  0x01, 0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F,
  0x00, 0xFC, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x01,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x78, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0xC0,
  0x03, 0xCF, 0xC0, 0x0F, 0x8F, 0xC0, 0x7F, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFD, 0xE0,
  0x01, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x8F, 0x00, 0x3E, 0x1E, 0x00,
  0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C,
  0x03, 0xC1, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00,
  0x3C, 0xFC, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xC0, 0x1F, 0x8F, 0x80, 0x3E,
  0x0F, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3F, 0x03, 0xC0,
  0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0xFC, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xFB, 0xC0, 0x01,
  0xF7, 0x80, 0x03, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1E, 0xFF, 0x78, 0x00, 0x7B, 0xFD, 0xE0, 0x01, 0xEF, 0xF7, 0xC0,
  0x0F, 0x3F, 0xCF, 0x00, 0x3C, 0xFF, 0x3C, 0x00, 0xF3, 0xFC, 0xF8, 0x07,
  0x8F, 0xF1, 0xE0, 0x1E, 0x3F, 0xC7, 0x80, 0x78, 0xFF, 0x1E, 0x03, 0xC3,
  0xFC, 0x3C, 0x0F, 0x1F, 0xF0, 0xF0, 0x3C, 0x7F, 0xC3, 0xC1, 0xE1, 0xFF,
  0x07, 0x87, 0x87, 0xFC, 0x1E, 0x1E, 0x1F, 0xF0, 0x78, 0xF0, 0x7F, 0xC0,
  0xF3, 0xC1, 0xFF, 0x03, 0xCF, 0x07, 0xFC, 0x0F, 0x78, 0x1F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xF0,
  0x1F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC0, 0x3E, 0x01, 0xFF, 0x00, 0x78, 0x07,
  0xFC, 0x01, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xEF, 0x00, 0x3F, 0xDF, 0x00, 0x7F,
  0x9E, 0x00, 0xFF, 0x1E, 0x01, 0xFE, 0x3C, 0x03, 0xFC, 0x3C, 0x07, 0xF8,
  0x78, 0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x3F, 0xC0, 0xF0, 0x7F, 0x81,
  0xE0, 0xFF, 0x01, 0xE1, 0xFE, 0x03, 0xC3, 0xFC, 0x03, 0xC7, 0xF8, 0x07,
  0x8F, 0xF0, 0x07, 0x9F, 0xE0, 0x0F, 0x3F, 0xC0, 0x0F, 0x7F, 0x80, 0x1E,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0,
  0x03, 0xF3, 0xC0, 0x07, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0,
  0x0F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0xE3, 0xC0,
  0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3C,
  0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1F,
  0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x03, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0,
  0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0,
  0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0x7C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x00,
  0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0xC0,
  0x78, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x7B,
  0xE0, 0x07, 0xC0, 0x0F, 0x7C, 0x00, 0xF8, 0x01, 0xE7, 0x80, 0x3F, 0x00,
  0x7C, 0xF0, 0x07, 0xE0, 0x0F, 0x9E, 0x00, 0xFE, 0x01, 0xF3, 0xE0, 0x1F,
  0xC0, 0x3C, 0x7C, 0x03, 0xB8, 0x07, 0x87, 0x80, 0xF7, 0x00, 0xF0, 0xF0,
  0x1E, 0xF0, 0x3E, 0x1E, 0x03, 0xDE, 0x07, 0xC3, 0xC0, 0x73, 0xC0, 0xF0,
  0x7C, 0x1E, 0x38, 0x1E, 0x07, 0x83, 0xC7, 0x03, 0xC0, 0xF0, 0x78, 0xF0,
  0x78, 0x1E, 0x0E, 0x1E, 0x1F, 0x03, 0xC1, 0xC3, 0xC3, 0xC0, 0x7C, 0x78,
  0x38, 0x78, 0x07, 0x8F, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E,
  0x38, 0x1E, 0x7C, 0x03, 0xCF, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x39, 0xE0,
  0x07, 0xBC, 0x07, 0xBC, 0x00, 0xF7, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x0E,
  0xF0, 0x03, 0xFC, 0x01, 0xDC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xC0, 0x07,
  0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03,
  0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0x70,
  0x1E, 0xF0, 0x39, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0x87, 0x8F, 0x07, 0x1E,
  0x0F, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0xC1, 0xF7, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x07, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xC3,
  0xF0, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x8F, 0xC1, 0xF7, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x0F, 0xDF, 0x80, 0x7B, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xDF, 0xC1, 0xFB, 0xFF,
  0xFF, 0x7B, 0xFF, 0xCF, 0x3F, 0xF1, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x3E, 0x7C,
  0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x3F, 0x1E, 0x1F, 0xFB, 0xC7, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3E, 0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0x7B, 0xE0, 0x0F, 0x7C, 0x03, 0xE7, 0xC0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xDE, 0x07, 0xE3, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xE0, 0x7C, 0x78, 0x07, 0xDF, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0C, 0x7E, 0x07, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0x03, 0xF1, 0xE1, 0xFF, 0xBC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xE0, 0x7E,
  0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x00, 0xF7,
  0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFD, 0xE0,
  0x7E, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC6,
  0x00, 0xF8, 0xE0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0xFC, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFE, 0x0F, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xF0, 0x7F, 0xFE, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x7F, 0xBF, 0xDF, 0xCF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFD,
  0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83,
  0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7C, 0x0F,
  0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xE1, 0xE7,
  0xFC, 0x3F, 0xF3, 0xDF, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFF, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x07, 0xFC, 0x01,
  0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F,
  0x00, 0x7F, 0xC0, 0x1E, 0x00, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x00, 0x78,
  0x03, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x03, 0xC0,
  0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x7F, 0xC0, 0x1E, 0x00,
  0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x00, 0x78, 0x03, 0xFE, 0x00, 0xF0, 0x07,
  0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0x80, 0x3C,
  0xF0, 0xFC, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF, 0xFE, 0xFE, 0x0F, 0xBF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E,
  0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x81, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0xFC, 0x1E, 0x7F,
  0xE3, 0xDF, 0xFE, 0x7F, 0xFF, 0xEF, 0xE0, 0xFD, 0xF0, 0x0F, 0xBE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xF8, 0x1F,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFB, 0xFF, 0x1F, 0x1F, 0x83, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF1,
  0xE1, 0xFF, 0xBC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xE0, 0x7E, 0xF8, 0x07,
  0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x3E,
  0x7C, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFD, 0xE0, 0x7E, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0xF1, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9F,
  0x01, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x7C, 0x03, 0xDF,
  0x81, 0xF3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x01,
  0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x78, 0x0F,
  0xDF, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xEF, 0x1F, 0xF3, 0xC1, 0xF8, 0xF0,
  0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x3C,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0,
  0x78, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x01, 0xC7, 0x80,
  0x3C, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0x80, 0x3D, 0xE0, 0x1E, 0x00, 0xF7, 0x80, 0x7C,
  0x07, 0xDE, 0x01, 0xF0, 0x1E, 0x7C, 0x0F, 0xC0, 0x78, 0xF0, 0x3F, 0x01,
  0xE3, 0xC0, 0xFE, 0x07, 0x8F, 0x07, 0xF8, 0x3C, 0x3C, 0x1F, 0xE0, 0xF0,
  0x78, 0x7B, 0x83, 0xC1, 0xE1, 0xCF, 0x0F, 0x07, 0x8F, 0x3C, 0x78, 0x1E,
  0x3C, 0x71, 0xE0, 0x3C, 0xF1, 0xE7, 0x80, 0xF3, 0x87, 0x9E, 0x03, 0xDE,
  0x1E, 0x70, 0x0F, 0x78, 0x3B, 0xC0, 0x1D, 0xC0, 0xFF, 0x00, 0x7F, 0x03,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3,
  0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0x79, 0xE0,
  0x07, 0xBE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x79,
  0xE0, 0x0F, 0x9E, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E,
  0x07, 0xC3, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x08, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x1C, 0xFF, 0xC0, 0x3B, 0xFF,
  0xC0, 0x77, 0x8F, 0xC1, 0xEF, 0x07, 0xC7, 0xFC, 0x0F, 0xFF, 0x78, 0x0F,
  0xFC, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 36, 12, 4, -36 },
  { 24, 10, 12, 16, 3, -38 },
  { 39, 23, 36, 27, 3, -36 },
  { 143, 19, 46, 25, 3, -41 },
  { 253, 26, 36, 32, 3, -36 },
  { 370, 24, 37, 27, 3, -36 },
  { 481, 3, 12, 9, 3, -38 },
  { 486, 11, 51, 16, 3, -40 },
  { 557, 12, 51, 16, 1, -40 },
  { 634, 20, 21, 22, 1, -36 },
  { 687, 21, 25, 25, 2, -29 },
  { 753, 7, 12, 10, 1, -5 },
  { 764, 10, 4, 12, 1, -17 },
  { 769, 5, 5, 13, 4, -5 },
  { 773, 16, 39, 19, 1, -36 },
  { 851, 19, 36, 25, 3, -36 },
  { 937, 12, 36, 25, 4, -36 },
  { 991, 21, 36, 25, 2, -36 },
  { 1086, 19, 36, 25, 2, -36 },
  { 1172, 22, 36, 25, 1, -36 },
  { 1271, 19, 36, 25, 4, -36 },
  { 1357, 19, 36, 25, 3, -36 },
  { 1443, 20, 36, 25, 2, -36 },
  { 1533, 19, 36, 25, 3, -36 },
  { 1619, 18, 36, 25, 3, -36 },
  { 1700, 6, 27, 12, 3, -27 },
  { 1721, 7, 34, 10, 1, -27 },
  { 1751, 17, 22, 22, 2, -27 },
  { 1798, 17, 14, 24, 4, -24 },
  { 1828, 18, 22, 23, 3, -27 },
  { 1878, 17, 36, 21, 2, -36 },
  { 1955, 33, 46, 38, 3, -35 },
  { 2145, 27, 36, 29, 1, -36 },
  { 2267, 20, 36, 27, 4, -36 },
  { 2357, 23, 36, 28, 3, -36 },
  { 2461, 21, 36, 29, 4, -36 },
  { 2556, 19, 36, 25, 4, -36 },
  { 2642, 18, 36, 24, 4, -36 },
  { 2723, 23, 36, 30, 3, -36 },
  { 2827, 23, 36, 31, 4, -36 },
  { 2931, 5, 36, 13, 4, -36 },
  { 2954, 20, 36, 24, 1, -36 },
  { 3044, 23, 36, 27, 4, -36 },
  { 3148, 18, 36, 24, 4, -36 },
  { 3229, 30, 36, 38, 4, -36 },
  { 3364, 23, 36, 31, 4, -36 },
  { 3468, 24, 36, 30, 3, -36 },
  { 3576, 22, 36, 28, 4, -36 },
  { 3675, 24, 42, 30, 3, -36 },
  { 3801, 22, 36, 27, 4, -36 },
  { 3900, 22, 36, 26, 2, -36 },
  { 3999, 24, 36, 26, 1, -36 },
  { 4107, 22, 36, 28, 3, -36 },
  { 4206, 26, 36, 28, 1, -36 },
  { 4323, 35, 36, 38, 2, -36 },
  { 4481, 24, 36, 28, 2, -36 },
  { 4589, 24, 36, 26, 1, -36 },
  { 4697, 22, 36, 26, 2, -36 },
  { 4796, 8, 49, 13, 3, -41 },
  { 4845, 17, 39, 18, 1, -36 },
  { 4928, 8, 49, 13, 1, -41 },
  { 4977, 15, 18, 19, 2, -36 },
  { 5011, 19, 4, 20, 1, 0 },
  { 5021, 11, 7, 15, 1, -37 },
  { 5031, 18, 26, 24, 3, -26 },
  { 5090, 19, 38, 25, 3, -38 },
  { 5181, 19, 26, 23, 2, -26 },
  { 5243, 19, 38, 25, 2, -38 },
  { 5334, 19, 26, 23, 2, -26 },
  { 5396, 13, 39, 16, 2, -39 },
  { 5460, 19, 36, 25, 2, -26 },
  { 5546, 18, 38, 24, 3, -38 },
  { 5632, 5, 35, 11, 3, -35 },
  { 5654, 9, 45, 11, -1, -35 },
  { 5705, 19, 38, 23, 3, -38 },
  { 5796, 4, 38, 11, 4, -38 },
  { 5815, 31, 26, 38, 3, -26 },
  { 5916, 18, 26, 24, 3, -26 },
  { 5975, 21, 26, 25, 2, -26 },
  { 6044, 19, 36, 25, 3, -26 },
  { 6130, 19, 36, 25, 2, -26 },
  { 6216, 11, 26, 15, 3, -26 },
  { 6252, 18, 26, 23, 2, -26 },
  { 6311, 12, 33, 15, 1, -33 },
  { 6361, 18, 26, 24, 3, -26 },
  { 6420, 19, 26, 21, 1, -26 },
  { 6482, 30, 26, 33, 1, -26 },
  { 6580, 20, 26, 22, 1, -26 },
  { 6645, 19, 36, 21, 1, -26 },
  { 6731, 18, 26, 22, 2, -26 },
  { 6790, 12, 48, 15, 2, -39 },
  { 6862, 4, 43, 12, 4, -36 },
  { 6884, 13, 48, 15, 1, -39 },
  { 6962, 23, 10, 29, 3, -20 },
};

const GFXfont RobotoCondensed_Regular50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_REGULAR50PT7B_H_
