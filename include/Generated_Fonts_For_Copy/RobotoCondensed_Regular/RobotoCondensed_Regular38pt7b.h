#ifndef _ROBOTOCONDENSED_REGULAR38PT7B_H_
#define _ROBOTOCONDENSED_REGULAR38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00,
  0x0E, 0xFF, 0xE0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x01,
  0xC3, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x06, 0x1C, 0x01, 0x86, 0x00, 0xE1,
  0x80, 0x38, 0x60, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x30, 0xC0,
  0x1C, 0x30, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x06,
  0x18, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0C, 0x38, 0x03, 0x0E,
  0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x07, 0x1C, 0x01, 0x87, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xFE, 0x0F,
  0xFE, 0x1E, 0x3C, 0x78, 0x3C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xEF, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3D, 0xC0, 0x73, 0xC1, 0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x73, 0x80, 0x0E,
  0x18, 0x20, 0xE1, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x0C, 0x18, 0xE0,
  0xE1, 0x8C, 0x0E, 0x19, 0xC0, 0x73, 0x98, 0x07, 0xF3, 0x80, 0x1E, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE3, 0xC0, 0x0C, 0xFE, 0x01, 0xCE, 0x70, 0x19,
  0xC7, 0x03, 0x98, 0x30, 0x31, 0x83, 0x07, 0x18, 0x30, 0x61, 0x83, 0x0E,
  0x18, 0x30, 0xC1, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xFE, 0x00, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x38, 0x38, 0x0E,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x39, 0xE7, 0x0E,
  0x71, 0xE3, 0xBC, 0x3C, 0xEE, 0x07, 0x73, 0x81, 0xFC, 0xE0, 0x3F, 0x3C,
  0x07, 0x8F, 0x01, 0xE1, 0xE0, 0xFC, 0x3F, 0xFF, 0x87, 0xFD, 0xE0, 0xFC,
  0x3C, 0xFF, 0xFF, 0xF6, 0xC0, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x02, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x06, 0x02, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x08, 0x38, 0x1C, 0x73, 0xBF, 0xDF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x00, 0xE7, 0x01, 0xCF, 0x07, 0x0E, 0x0E,
  0x0C, 0x08, 0x10, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0x40, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x83, 0xCE, 0x03, 0x9C,
  0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x77,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9E, 0x0F, 0x1C, 0x3C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x1F, 0x00, 0x01, 0x83, 0xC7, 0xFF, 0xFF, 0xBF, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xCF, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0xF0, 0x3B, 0x80, 0xFE,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x0F, 0xF0,
  0x3F, 0x80, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xDE, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x03, 0x9E, 0x01, 0xCF,
  0x01, 0xC7, 0x80, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78,
  0x3C, 0x38, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F,
  0xF8, 0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xDF, 0x07, 0xFF, 0x1F, 0xFC, 0x78, 0xF8, 0x80, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0xFF, 0x03, 0x9E, 0x1E, 0x7F, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0x00,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xF8, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE7, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0xC3, 0xDF,
  0x03, 0xBC, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0x77, 0x01, 0xEF, 0x03, 0x8E, 0x07, 0x1E, 0x1E, 0x1F, 0xF8, 0x1F, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3,
  0xC7, 0x83, 0xCE, 0x07, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xF0, 0x78,
  0xE1, 0xE1, 0xFF, 0x80, 0xFE, 0x03, 0xFE, 0x0F, 0x1E, 0x38, 0x1E, 0x70,
  0x1D, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0x9C, 0x07,
  0x3C, 0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF, 0xFF,
  0x3F, 0xDC, 0x3E, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x7C, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0xEF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x77, 0xB9, 0xDC, 0x40, 0x00, 0x08,
  0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0xF8, 0x1F, 0x83, 0xF0,
  0x7F, 0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F, 0xC0, 0xFF, 0x0F,
  0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFC,
  0xFE, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x18, 0x70, 0x00, 0x06, 0x38, 0x0F, 0x03, 0x18, 0x1F, 0xE1, 0xDC,
  0x1E, 0xF0, 0x6E, 0x0E, 0x38, 0x36, 0x0E, 0x1C, 0x1B, 0x07, 0x0E, 0x0F,
  0x83, 0x07, 0x07, 0xC3, 0x83, 0x83, 0xE1, 0xC1, 0xC1, 0xF0, 0xE0, 0xE0,
  0xF8, 0x70, 0x70, 0x7C, 0x38, 0x30, 0x3E, 0x1C, 0x18, 0x1F, 0x0E, 0x0C,
  0x1F, 0x87, 0x0E, 0x0D, 0xC3, 0x8F, 0x8E, 0x60, 0xFF, 0xCE, 0x30, 0x7E,
  0x7F, 0x1C, 0x1E, 0x1E, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x07, 0xC3, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xBC, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x0F, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xE0, 0x70, 0x1C, 0x07,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3C, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xF8, 0x3C, 0x3C, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xE3, 0xC0, 0x78,
  0xF8, 0x3C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E,
  0x78, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0F,
  0x70, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0xF8, 0x1F, 0x1F, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xC0, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0x9C, 0x0F, 0x3C,
  0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0xE0, 0x0F, 0xB8, 0x03, 0xCE,
  0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x0F, 0x03, 0x87,
  0x80, 0xE1, 0xE0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xBC, 0x00, 0xEF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xE7, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x0E,
  0x0F, 0x03, 0x81, 0xE0, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x01, 0xE3, 0x80,
  0x78, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x78, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x77, 0xEE, 0x00, 0xEF, 0xDC, 0x03,
  0xDF, 0x9C, 0x07, 0x3F, 0x38, 0x0E, 0x7E, 0x70, 0x3D, 0xFC, 0x70, 0x73,
  0xF8, 0xE0, 0xE7, 0xF1, 0xC3, 0xCF, 0xE1, 0xC7, 0x1F, 0xC3, 0x8E, 0x3F,
  0x87, 0x3C, 0x7F, 0x07, 0x70, 0xFE, 0x0E, 0xE1, 0xFC, 0x1D, 0xC3, 0xF8,
  0x1F, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0x70, 0x3F, 0x80,
  0xE0, 0x78, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xB8, 0x0F, 0xE7, 0x03, 0xF9, 0xC0,
  0xFE, 0x38, 0x3F, 0x8E, 0x0F, 0xE1, 0xC3, 0xF8, 0x70, 0xFE, 0x0E, 0x3F,
  0x83, 0x8F, 0xE0, 0x73, 0xF8, 0x1C, 0xFE, 0x03, 0xBF, 0x80, 0xEF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3C, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E,
  0x3C, 0x07, 0x9E, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x03,
  0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xDC, 0x01, 0xEE, 0x01, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x07, 0x83,
  0xC0, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDE,
  0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xBC,
  0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x3C, 0xF0, 0x07, 0x0F, 0x01, 0xE1, 0xF0, 0x78, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1C, 0x07, 0xCE, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1E, 0xE0,
  0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x03, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1E, 0x1C, 0x07,
  0x0E, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0x79, 0xC0, 0x3C, 0xE0, 0x0F, 0x70,
  0x07, 0xB8, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E,
  0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x1C,
  0xF8, 0x1E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0xEF,
  0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x01, 0xC3, 0x80, 0x3C,
  0x38, 0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x81, 0xC0, 0x78, 0x1C, 0x07,
  0x01, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x71,
  0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x03,
  0xB8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x01, 0xEE, 0x01, 0xC0, 0x3D,
  0xC0, 0x3C, 0x07, 0x38, 0x0F, 0x80, 0xE7, 0x81, 0xF0, 0x1C, 0xF0, 0x3E,
  0x03, 0x8E, 0x07, 0xE0, 0xF1, 0xC0, 0xDC, 0x1C, 0x38, 0x3B, 0x83, 0x87,
  0x07, 0x30, 0x70, 0xF0, 0xE6, 0x0E, 0x0E, 0x18, 0xE3, 0xC1, 0xC7, 0x1C,
  0x70, 0x38, 0xE3, 0x8E, 0x07, 0x1C, 0x31, 0xC0, 0xF3, 0x87, 0x38, 0x0E,
  0x60, 0xE7, 0x01, 0xDC, 0x1D, 0xC0, 0x3B, 0x81, 0xB8, 0x07, 0x70, 0x37,
  0x00, 0xEC, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0,
  0xF0, 0x3C, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x80, 0x1E, 0x70, 0x07, 0x8F,
  0x00, 0xF0, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x3C, 0x3C, 0x07,
  0x8F, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00,
  0x79, 0xE0, 0x1E, 0x38, 0x07, 0x0F, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x78,
  0x1E, 0x1C, 0x03, 0x87, 0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8F, 0xFF, 0xFC, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x19, 0x83, 0x9C, 0x39, 0xC3, 0x0E,
  0x70, 0xE7, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78,
  0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70,
  0x3B, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFC, 0xFF, 0xF7, 0xF3, 0xDE,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7D, 0xFF, 0xF3,
  0xFF, 0xC7, 0xC7, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE7, 0xC3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1D, 0xF0, 0x7B, 0xFF, 0xE7, 0xBF, 0xCF, 0x3E, 0x00, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x7E, 0x01,
  0xFC, 0x0F, 0x78, 0x38, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x3E, 0x73, 0xFD, 0xDF, 0xFF, 0x78, 0x7F, 0xC0, 0xFF, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xF7, 0x0F, 0x9C,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x70, 0x3F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x02, 0x78, 0x1C, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x03,
  0xE0, 0xFC, 0x3F, 0x8F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x1F,
  0xFB, 0xFF, 0x7F, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x0F, 0x9C, 0xFF, 0x77, 0xFF, 0xDE, 0x1F, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0x78, 0x7D, 0xFF, 0xF3, 0xFD,
  0xC3, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC8, 0x0F, 0x30, 0x79, 0xFF,
  0xE3, 0xFF, 0x03, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x8F, 0x7F, 0x3F,
  0xFE, 0xFC, 0x7B, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1C, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x07,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0xFB, 0xEF, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x7B, 0xC1, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C,
  0xF0, 0x7B, 0xC0, 0xF7, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xBC,
  0x1E, 0x38, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xF1, 0xE0, 0xF3, 0xC1, 0xE7,
  0x81, 0xEF, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF3, 0xE0, 0xF8, 0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFE,
  0xF8, 0x7F, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3C, 0x07, 0xF0, 0x1C, 0x07,
  0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07,
  0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07,
  0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x1C, 0x07,
  0xF0, 0x1C, 0x07, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0x1E, 0xF8, 0x3F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDE,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xB8, 0x0E, 0x78, 0x3C, 0x7F, 0xF0,
  0x7F, 0xC0, 0x3E, 0x00, 0xE3, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xC1, 0xEF,
  0x01, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0xF8, 0x3D,
  0xFF, 0xF3, 0xFF, 0xE7, 0x9F, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x9C, 0xFF,
  0x77, 0xFF, 0xDE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0x78, 0x3D, 0xFF, 0xF3, 0xFD, 0xC3, 0xE7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF7, 0xFF,
  0xFF, 0xFF, 0x8F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xE7, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xEE, 0x03, 0xFC,
  0x0E, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0xFC, 0x3F, 0x07, 0xC0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3,
  0xFD, 0xC7, 0xE7, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70, 0x38,
  0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38,
  0x0C, 0xE0, 0x3B, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0xE0, 0x38, 0x1F, 0xE0, 0x70, 0x39, 0xC1, 0xE0, 0x73, 0x83,
  0xE0, 0xE7, 0x07, 0xC1, 0xCE, 0x0F, 0x87, 0x0E, 0x3F, 0x0E, 0x1C, 0x77,
  0x1C, 0x38, 0xEE, 0x38, 0x73, 0x9C, 0xE0, 0xF7, 0x19, 0xC0, 0xEE, 0x3B,
  0x81, 0xD8, 0x77, 0x03, 0xF0, 0xEC, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x03, 0xE0, 0x1E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0xF0, 0x3C, 0xF0, 0x78, 0xE1, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x9C, 0x03,
  0xB8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFE,
  0x01, 0xDC, 0x07, 0x3C, 0x1E, 0x38, 0x38, 0x78, 0xF0, 0x71, 0xC0, 0xF7,
  0x80, 0xE0, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xE1,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xF0, 0xF3, 0x81, 0xCE, 0x07, 0x38, 0x1D,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x01, 0xF0, 0x07,
  0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x80, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x3E, 0x0F, 0x03,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x3C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0xC1, 0xE0, 0xF0, 0xF0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38,
  0x1C, 0x3C, 0x1C, 0x0C, 0x00, 0x1F, 0x01, 0xCF, 0xE0, 0x77, 0xFC, 0x1D,
  0xC7, 0x8E, 0xE0, 0xFF, 0xB8, 0x1F, 0xC0, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 27, 9, 3, -27 },
  { 15, 7, 9, 12, 3, -29 },
  { 23, 18, 27, 21, 2, -27 },
  { 84, 15, 34, 19, 2, -31 },
  { 148, 20, 27, 24, 2, -27 },
  { 216, 18, 27, 21, 2, -27 },
  { 277, 3, 9, 7, 2, -29 },
  { 281, 9, 39, 12, 2, -30 },
  { 325, 9, 39, 12, 1, -30 },
  { 369, 15, 16, 16, 1, -27 },
  { 399, 15, 20, 19, 2, -22 },
  { 437, 5, 9, 7, 1, -4 },
  { 443, 8, 3, 9, 1, -13 },
  { 446, 4, 4, 10, 3, -4 },
  { 448, 12, 29, 14, 1, -27 },
  { 492, 15, 27, 19, 2, -27 },
  { 543, 9, 27, 19, 3, -27 },
  { 574, 15, 27, 19, 2, -27 },
  { 625, 14, 27, 19, 2, -27 },
  { 673, 17, 27, 19, 1, -27 },
  { 731, 14, 27, 19, 3, -27 },
  { 779, 15, 27, 19, 2, -27 },
  { 830, 15, 27, 19, 2, -27 },
  { 881, 15, 27, 19, 2, -27 },
  { 932, 14, 27, 19, 2, -27 },
  { 980, 4, 20, 9, 3, -20 },
  { 990, 5, 25, 8, 1, -20 },
  { 1006, 13, 16, 17, 1, -20 },
  { 1032, 13, 11, 18, 3, -18 },
  { 1050, 13, 16, 18, 3, -20 },
  { 1076, 13, 27, 16, 1, -27 },
  { 1120, 25, 35, 29, 2, -27 },
  { 1230, 20, 27, 22, 1, -27 },
  { 1298, 16, 27, 21, 3, -27 },
  { 1352, 18, 27, 22, 2, -27 },
  { 1413, 16, 27, 22, 3, -27 },
  { 1467, 14, 27, 19, 3, -27 },
  { 1515, 14, 27, 18, 3, -27 },
  { 1563, 18, 27, 22, 2, -27 },
  { 1624, 18, 27, 24, 3, -27 },
  { 1685, 3, 27, 10, 3, -27 },
  { 1696, 15, 27, 18, 1, -27 },
  { 1747, 18, 27, 21, 3, -27 },
  { 1808, 14, 27, 18, 3, -27 },
  { 1856, 23, 27, 29, 3, -27 },
  { 1934, 18, 27, 24, 3, -27 },
  { 1995, 18, 27, 23, 2, -27 },
  { 2056, 17, 27, 21, 3, -27 },
  { 2114, 19, 32, 23, 2, -27 },
  { 2190, 17, 27, 20, 3, -27 },
  { 2248, 16, 27, 20, 2, -27 },
  { 2302, 18, 27, 20, 1, -27 },
  { 2363, 17, 27, 21, 2, -27 },
  { 2421, 20, 27, 21, 1, -27 },
  { 2489, 27, 27, 29, 1, -27 },
  { 2581, 19, 27, 21, 1, -27 },
  { 2646, 18, 27, 20, 1, -27 },
  { 2707, 16, 27, 20, 2, -27 },
  { 2761, 6, 37, 10, 3, -31 },
  { 2789, 13, 29, 14, 1, -27 },
  { 2837, 6, 37, 10, 1, -31 },
  { 2865, 12, 13, 14, 1, -27 },
  { 2885, 15, 3, 15, 0, 0 },
  { 2891, 8, 5, 12, 1, -28 },
  { 2896, 14, 20, 18, 2, -20 },
  { 2931, 15, 29, 19, 2, -29 },
  { 2986, 14, 20, 18, 2, -20 },
  { 3021, 14, 29, 19, 2, -29 },
  { 3072, 14, 20, 18, 2, -20 },
  { 3107, 11, 29, 12, 1, -29 },
  { 3147, 14, 28, 19, 2, -20 },
  { 3196, 14, 29, 18, 2, -29 },
  { 3247, 3, 27, 9, 3, -27 },
  { 3258, 6, 35, 9, 0, -27 },
  { 3285, 15, 29, 17, 2, -29 },
  { 3340, 3, 29, 9, 3, -29 },
  { 3351, 24, 20, 29, 2, -20 },
  { 3411, 14, 20, 18, 2, -20 },
  { 3446, 15, 20, 19, 2, -20 },
  { 3484, 15, 28, 19, 2, -20 },
  { 3537, 14, 28, 19, 2, -20 },
  { 3586, 9, 20, 12, 2, -20 },
  { 3609, 14, 20, 17, 2, -20 },
  { 3644, 10, 25, 11, 0, -25 },
  { 3676, 14, 20, 18, 2, -20 },
  { 3711, 14, 20, 16, 1, -20 },
  { 3746, 23, 20, 25, 1, -20 },
  { 3804, 15, 20, 17, 1, -20 },
  { 3842, 14, 28, 16, 1, -20 },
  { 3891, 13, 20, 17, 2, -20 },
  { 3924, 10, 37, 12, 1, -30 },
  { 3971, 3, 32, 9, 3, -27 },
  { 3983, 9, 37, 12, 1, -30 },
  { 4025, 18, 7, 22, 2, -14 },
};

const GFXfont RobotoCondensed_Regular38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_REGULAR38PT7B_H_
