#ifndef _ROBOTOCONDENSED_REGULAR62PT7B_H_
#define _ROBOTOCONDENSED_REGULAR62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFE, 0x20, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x0F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xF3,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x3E, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0xF7, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x03, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0xF0,
  0x07, 0x80, 0x78, 0x78, 0x03, 0xC0, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x3C,
  0x00, 0x78, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x1E, 0x00, 0x0F, 0xFF, 0x1E,
  0x00, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x08, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x01, 0xE1, 0xFF, 0x80, 0x00,
  0xF1, 0xFF, 0xE0, 0x00, 0xF1, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x7C, 0x00,
  0x78, 0xF8, 0x1E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x3C, 0x3C, 0x07, 0x80,
  0x3C, 0x1E, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x70,
  0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0x7C, 0x0F, 0x00, 0xC0, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x07, 0xC3, 0xF9, 0xF8, 0x1F, 0x0F, 0xC3,
  0xF0, 0x7C, 0x7E, 0x0F, 0xE1, 0xF1, 0xF0, 0x1F, 0x87, 0xCF, 0xC0, 0x3F,
  0x3E, 0x3F, 0x00, 0xFE, 0xF8, 0xFC, 0x01, 0xFB, 0xE3, 0xE0, 0x03, 0xFF,
  0x8F, 0xC0, 0x07, 0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F,
  0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0x01, 0xFF,
  0xFC, 0x7E, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x80, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x80, 0x7C, 0x02, 0x78, 0x3E, 0x0F, 0x3F, 0x9E, 0x1F, 0xBF, 0xFF,
  0x7F, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x0F, 0x80,
  0x7E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x70, 0x01, 0x00, 0x20,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0xF8, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x84, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0xFC,
  0x1F, 0xE3, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF8,
  0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7B, 0xF0, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0x83, 0xFC, 0x3E, 0x00, 0xFC, 0x04, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0xC3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0xFF, 0xC0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00,
  0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xEF, 0xC0, 0x07,
  0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0xFE, 0x7F, 0x83, 0xF8, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0x3F, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F,
  0x00, 0xFF, 0x3F, 0x83, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xBE, 0x07, 0xFE, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xFF, 0xFF, 0xFF, 0x7C, 0x20, 0x0F,
  0x0F, 0xCF, 0xE7, 0xF1, 0xF8, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0x87, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF0, 0x10, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xFF,
  0x00, 0xF0, 0x78, 0x01, 0xFF, 0xE0, 0x1C, 0x1E, 0x00, 0xFF, 0xFC, 0x07,
  0x8F, 0x00, 0x7E, 0x1F, 0x01, 0xE3, 0xC0, 0x1F, 0x03, 0xC0, 0x78, 0xF0,
  0x0F, 0x81, 0xF0, 0x0E, 0x7C, 0x03, 0xC0, 0x7C, 0x03, 0x9E, 0x01, 0xF0,
  0x1F, 0x00, 0xE7, 0x80, 0x78, 0x07, 0x80, 0x3D, 0xE0, 0x1E, 0x01, 0xE0,
  0x0F, 0x78, 0x0F, 0x80, 0x78, 0x03, 0xDE, 0x03, 0xE0, 0x1E, 0x00, 0xF7,
  0x80, 0xF0, 0x07, 0x80, 0x3D, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x0F,
  0x00, 0x78, 0x03, 0xFE, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0x81, 0xF0, 0x07,
  0x80, 0x3B, 0xE0, 0x7C, 0x01, 0xE0, 0x0E, 0xF8, 0x1F, 0x00, 0xF8, 0x07,
  0xBE, 0x07, 0xC0, 0x3E, 0x01, 0xE7, 0x81, 0xF0, 0x0F, 0x80, 0x79, 0xE0,
  0x3C, 0x03, 0xE0, 0x1C, 0x78, 0x0F, 0x81, 0xF8, 0x0F, 0x1E, 0x03, 0xE0,
  0x7E, 0x03, 0xC7, 0x80, 0xFC, 0x3F, 0x81, 0xE1, 0xE0, 0x3F, 0xFF, 0xF0,
  0xF8, 0x7C, 0x07, 0xFF, 0x7F, 0xFC, 0x0F, 0x00, 0xFF, 0x8F, 0xFE, 0x03,
  0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0xF8, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE7, 0xC0, 0x07, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xF0, 0x01, 0xFC,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x03, 0xFB, 0xE0, 0x03, 0xFD, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC1, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xF1, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xF8, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xF1, 0xF0,
  0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xF8, 0x1F, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x7C,
  0x0F, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3E, 0x7F, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x0F, 0xBF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xF0, 0x7C, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xFD,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x03, 0xEF, 0xFD,
  0xF0, 0x00, 0x1F, 0x7F, 0xEF, 0xC0, 0x01, 0xF3, 0xFF, 0x3E, 0x00, 0x0F,
  0x9F, 0xF9, 0xF0, 0x00, 0x7C, 0xFF, 0xCF, 0xC0, 0x07, 0xC7, 0xFE, 0x3E,
  0x00, 0x3E, 0x3F, 0xF1, 0xF0, 0x01, 0xF1, 0xFF, 0x8F, 0x80, 0x1F, 0x0F,
  0xFC, 0x3E, 0x00, 0xF8, 0x7F, 0xE1, 0xF0, 0x07, 0xC3, 0xFF, 0x0F, 0x80,
  0x7C, 0x1F, 0xF8, 0x3E, 0x03, 0xE0, 0xFF, 0xC1, 0xF0, 0x1F, 0x07, 0xFE,
  0x0F, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x7C,
  0x0F, 0xFC, 0x0F, 0x87, 0xC0, 0x7F, 0xE0, 0x3E, 0x3E, 0x03, 0xFF, 0x01,
  0xF1, 0xF0, 0x1F, 0xF8, 0x0F, 0x8F, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07,
  0xFE, 0x01, 0xF7, 0xC0, 0x3F, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0,
  0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE,
  0xF8, 0x00, 0x7F, 0xF7, 0xC0, 0x03, 0xFF, 0x9F, 0x00, 0x1F, 0xFC, 0xF8,
  0x00, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0x1F, 0x00, 0x3F, 0xF8, 0x7C, 0x01,
  0xFF, 0xC3, 0xE0, 0x0F, 0xFE, 0x0F, 0x80, 0x7F, 0xF0, 0x7C, 0x03, 0xFF,
  0x81, 0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x3E, 0x07, 0xFF, 0x01,
  0xF8, 0x3F, 0xF8, 0x07, 0xC1, 0xFF, 0xC0, 0x3F, 0x0F, 0xFE, 0x00, 0xF8,
  0x7F, 0xF0, 0x07, 0xE3, 0xFF, 0x80, 0x1F, 0x1F, 0xFC, 0x00, 0xFC, 0xFF,
  0xE0, 0x03, 0xE7, 0xFF, 0x00, 0x1F, 0xBF, 0xF8, 0x00, 0x7D, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF,
  0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x03, 0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0xFF, 0x3E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xFD, 0xF0, 0x00, 0x7F, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x08, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x0F, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xFC, 0x00,
  0x7C, 0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x1F,
  0x00, 0x79, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x1F, 0x00,
  0xF9, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x1F, 0x80, 0xF0,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0xF0,
  0x1F, 0x00, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x3F,
  0x00, 0xFC, 0x1E, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x00,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x00, 0x7C,
  0x3C, 0x03, 0xC7, 0xE0, 0x07, 0xE3, 0xC0, 0x3C, 0x7C, 0x00, 0x3E, 0x7C,
  0x03, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x03,
  0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x01, 0xEF,
  0x80, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xBC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0x83, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x80, 0xF1, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3D, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x01, 0xF1, 0xF8, 0x03, 0xE7,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0,
  0x1F, 0xCF, 0xF1, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xBF, 0x0F, 0xFE,
  0x7E, 0x0F, 0xF8, 0x7C, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC3, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00,
  0xFC, 0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xF0, 0xF9, 0xFF,
  0xE0, 0xF8, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x3F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xF8, 0x3F, 0x87, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xFE, 0x3F, 0x07, 0xFF, 0xBF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x3F, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0x03, 0xFE, 0x1F, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x08, 0x7E, 0x00, 0x1C,
  0x3F, 0x00, 0x3C, 0x3F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x9F,
  0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x3F, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x1C, 0x00, 0xFE, 0x1E, 0x01, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x10, 0x0F, 0x87, 0xFC, 0x3E, 0x7F, 0xF8, 0xFB, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFC, 0x7F, 0xBF, 0xC0, 0x7E, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x7B, 0xFF,
  0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFD, 0xFF, 0xBF, 0xE7,
  0xFC, 0xFF, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x7C,
  0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x87, 0xC0,
  0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0xC0, 0x7C, 0x3F,
  0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8,
  0x07, 0xE1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xE7, 0xC0, 0x0F, 0xCF, 0x80,
  0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x04,
  0x01, 0xF1, 0xFF, 0x00, 0xFF, 0x83, 0xE7, 0xFF, 0x87, 0xFF, 0x87, 0xDF,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xF0, 0xFF, 0xF8,
  0x7F, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0x00, 0x7D, 0xF0, 0x01, 0xFC, 0x00, 0xFB, 0xE0, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x00,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x04, 0x03, 0xE1, 0xFF, 0x0F,
  0x9F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xEF, 0xF0,
  0x1F, 0xBF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xC0,
  0xF9, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x87, 0xFC,
  0xFF, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFF, 0x83, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0xFF, 0xC0,
  0xF8, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x0F, 0xFF, 0xBF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x13, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7C, 0x00,
  0xFD, 0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFE, 0x0F, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x20, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x20, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF, 0x80,
  0xFF, 0x7F, 0x8F, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xF7, 0xC7, 0xFF, 0x9F,
  0x07, 0xFC, 0x7C, 0x02, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0,
  0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0,
  0x01, 0xF7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7D, 0xF8,
  0x03, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0xFE, 0x01,
  0xF1, 0xF0, 0x0F, 0xF0, 0x0F, 0x8F, 0x80, 0x7F, 0x80, 0x7C, 0x3E, 0x03,
  0xFC, 0x03, 0xE1, 0xF0, 0x3F, 0xF0, 0x3E, 0x0F, 0x81, 0xFF, 0x81, 0xF0,
  0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xF0, 0x79, 0xF0, 0x7C, 0x0F, 0x87, 0xCF,
  0x83, 0xC0, 0x7C, 0x3E, 0x7C, 0x3E, 0x03, 0xE1, 0xE1, 0xE1, 0xF0, 0x0F,
  0x0F, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x7C, 0x78, 0x03, 0xE7, 0xC3, 0xE3,
  0xC0, 0x1F, 0x3C, 0x0F, 0x3E, 0x00, 0xF9, 0xE0, 0x7D, 0xF0, 0x03, 0xFF,
  0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x03, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xC0,
  0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0x80,
  0x07, 0xEF, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0x83, 0xE0,
  0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xC7, 0xFF,
  0x00, 0x3E, 0x7F, 0xFC, 0x01, 0xF7, 0xFF, 0xF0, 0x0F, 0x3E, 0x1F, 0xC0,
  0xFB, 0xE0, 0x7F, 0x0F, 0xDF, 0x01, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0xE7,
  0xC0, 0x1F, 0xFE, 0x3C, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 45, 15, 5, -44 },
  { 35, 13, 15, 20, 4, -47 },
  { 60, 28, 44, 34, 4, -44 },
  { 214, 24, 59, 31, 3, -52 },
  { 391, 33, 46, 39, 3, -45 },
  { 581, 30, 46, 34, 3, -45 },
  { 754, 5, 14, 11, 3, -47 },
  { 763, 14, 64, 19, 4, -50 },
  { 875, 14, 64, 20, 2, -50 },
  { 987, 25, 26, 27, 1, -44 },
  { 1069, 25, 32, 31, 3, -36 },
  { 1169, 8, 15, 12, 1, -7 },
  { 1184, 13, 5, 15, 1, -21 },
  { 1193, 7, 7, 16, 4, -6 },
  { 1200, 20, 48, 23, 1, -44 },
  { 1320, 24, 46, 31, 3, -45 },
  { 1458, 15, 44, 31, 5, -44 },
  { 1541, 25, 45, 31, 3, -45 },
  { 1682, 24, 46, 31, 3, -45 },
  { 1820, 27, 44, 31, 2, -44 },
  { 1969, 24, 45, 31, 4, -44 },
  { 2104, 24, 45, 31, 4, -44 },
  { 2239, 25, 44, 31, 3, -44 },
  { 2377, 23, 46, 31, 4, -45 },
  { 2510, 24, 45, 31, 3, -45 },
  { 2645, 7, 34, 14, 4, -33 },
  { 2675, 9, 41, 13, 1, -33 },
  { 2722, 21, 27, 28, 2, -33 },
  { 2793, 21, 18, 30, 5, -30 },
  { 2841, 22, 27, 29, 4, -33 },
  { 2916, 22, 46, 26, 2, -45 },
  { 3043, 42, 57, 48, 3, -43 },
  { 3343, 33, 44, 36, 1, -44 },
  { 3525, 25, 44, 34, 5, -44 },
  { 3663, 28, 46, 35, 4, -45 },
  { 3824, 27, 44, 35, 5, -44 },
  { 3973, 23, 44, 31, 5, -44 },
  { 4100, 23, 44, 30, 5, -44 },
  { 4227, 28, 46, 37, 4, -45 },
  { 4388, 29, 44, 38, 5, -44 },
  { 4548, 6, 44, 16, 5, -44 },
  { 4581, 24, 45, 30, 2, -44 },
  { 4716, 29, 44, 34, 5, -44 },
  { 4876, 23, 44, 29, 5, -44 },
  { 5003, 37, 44, 47, 5, -44 },
  { 5207, 29, 44, 38, 5, -44 },
  { 5367, 29, 46, 37, 4, -45 },
  { 5534, 27, 44, 34, 5, -44 },
  { 5683, 30, 52, 37, 4, -45 },
  { 5878, 27, 44, 33, 5, -44 },
  { 6027, 27, 46, 32, 3, -45 },
  { 6183, 29, 44, 32, 2, -44 },
  { 6343, 27, 45, 35, 4, -44 },
  { 6495, 33, 44, 35, 1, -44 },
  { 6677, 44, 44, 47, 2, -44 },
  { 6919, 30, 44, 34, 2, -44 },
  { 7084, 31, 44, 33, 1, -44 },
  { 7255, 27, 44, 32, 3, -44 },
  { 7404, 10, 59, 16, 4, -50 },
  { 7478, 20, 48, 23, 2, -44 },
  { 7598, 10, 59, 16, 1, -50 },
  { 7672, 19, 22, 23, 2, -44 },
  { 7725, 23, 5, 25, 1, 0 },
  { 7740, 12, 9, 19, 2, -47 },
  { 7754, 23, 35, 30, 3, -34 },
  { 7855, 24, 48, 31, 4, -47 },
  { 7999, 23, 35, 29, 3, -34 },
  { 8100, 24, 48, 31, 3, -47 },
  { 8244, 24, 35, 29, 3, -34 },
  { 8349, 17, 48, 20, 2, -48 },
  { 8451, 24, 47, 31, 3, -34 },
  { 8592, 22, 47, 30, 4, -47 },
  { 8722, 6, 45, 14, 4, -45 },
  { 8756, 11, 58, 14, -1, -45 },
  { 8836, 23, 47, 28, 4, -47 },
  { 8972, 6, 47, 14, 4, -47 },
  { 9008, 39, 34, 47, 4, -34 },
  { 9174, 22, 34, 30, 4, -34 },
  { 9268, 25, 35, 31, 3, -34 },
  { 9378, 24, 47, 31, 4, -34 },
  { 9519, 24, 47, 31, 3, -34 },
  { 9660, 14, 34, 19, 4, -34 },
  { 9720, 22, 35, 28, 3, -34 },
  { 9817, 15, 42, 18, 1, -41 },
  { 9896, 22, 34, 30, 4, -33 },
  { 9990, 24, 33, 27, 1, -33 },
  { 10089, 37, 33, 40, 2, -33 },
  { 10242, 24, 33, 27, 2, -33 },
  { 10341, 24, 46, 26, 1, -33 },
  { 10479, 22, 33, 27, 3, -33 },
  { 10570, 16, 59, 19, 2, -48 },
  { 10688, 5, 52, 15, 5, -44 },
  { 10721, 16, 59, 19, 1, -48 },
  { 10839, 29, 12, 37, 4, -24 },
};

const GFXfont RobotoCondensed_Regular62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_REGULAR62PT7B_H_
