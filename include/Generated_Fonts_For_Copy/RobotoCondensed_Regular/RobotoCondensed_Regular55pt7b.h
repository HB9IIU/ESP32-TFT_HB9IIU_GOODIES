#ifndef _ROBOTOCONDENSED_REGULAR55PT7B_H_
#define _ROBOTOCONDENSED_REGULAR55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBE, 0xFF, 0xE7, 0x88, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE,
  0x1C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x1C, 0x0F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0x03, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0,
  0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x7E, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x3C, 0x02, 0x03, 0xC0, 0xE0, 0x3C, 0x1C, 0x07, 0x81,
  0xC0, 0xE0, 0x3C, 0x1E, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x0F, 0x0F, 0x01,
  0xC0, 0x78, 0x70, 0x0F, 0x03, 0x87, 0x80, 0x78, 0x3C, 0x38, 0x01, 0xE1,
  0xE3, 0xC0, 0x0F, 0xFE, 0x1C, 0x00, 0x3F, 0xE1, 0xE0, 0x00, 0xFE, 0x1E,
  0x00, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC3, 0xF8, 0x00,
  0x1C, 0x3F, 0xE0, 0x01, 0xE3, 0xFF, 0x80, 0x0E, 0x3E, 0x3E, 0x00, 0xF1,
  0xE0, 0xF0, 0x07, 0x0E, 0x03, 0x80, 0x78, 0x70, 0x1C, 0x03, 0x83, 0x80,
  0xE0, 0x3C, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC1,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xE0, 0xF0, 0x10, 0x0F, 0x8F, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xF7, 0xC0, 0xF0, 0xF9, 0xF8, 0x3C, 0x7C, 0x3F, 0x0F, 0x1F, 0x07,
  0xC3, 0xCF, 0x81, 0xF8, 0xF3, 0xE0, 0x3F, 0x7C, 0xF8, 0x07, 0xDF, 0x3E,
  0x00, 0xFF, 0x8F, 0x80, 0x3F, 0xE3, 0xE0, 0x07, 0xF8, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0xE1, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xF7, 0xE0, 0xFF, 0xF8, 0xF8, 0x0F, 0xF8, 0x3F, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x00, 0x10,
  0x01, 0x80, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x06, 0x00, 0x10, 0x40, 0x03, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1C,
  0x1E, 0x0E, 0xFE, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0xCF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1E,
  0x03, 0xE0, 0x38, 0x07, 0x00, 0x40, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3C, 0xF9, 0xF7, 0xCF, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7B, 0xFF, 0xFF, 0x78, 0x80, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0x8F, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xE0,
  0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xE0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xF8, 0x1F,
  0x87, 0xC0, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xCF,
  0x80, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0x03, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0xFC, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xF3,
  0xE0, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x7E, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFD, 0xFF, 0x1F, 0x01, 0xF8, 0x30, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x1F,
  0x9F, 0x81, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x8F, 0xC0, 0xFB, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0,
  0xFC, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x03, 0xE7, 0xE0, 0x3E, 0x3F, 0x07, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE0, 0xFC, 0x3E,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFC,
  0x1F, 0x87, 0xC0, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x07, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0xBF, 0x03, 0xF8, 0xFC,
  0x3F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFE, 0xF0, 0x7F, 0xE7, 0x80, 0xFC, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0xFB, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xF8, 0x80, 0x1F, 0x3F, 0x3F,
  0x3F, 0x1F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0xF8, 0x70, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x03, 0xC1, 0xC0, 0x07, 0xE0, 0x0E, 0x1E, 0x00, 0x7F, 0xC0, 0x70, 0xF0,
  0x0F, 0xFF, 0x03, 0xC7, 0x00, 0x7F, 0xF8, 0x0E, 0x78, 0x07, 0x83, 0xC0,
  0x73, 0xC0, 0x7C, 0x1E, 0x03, 0x9E, 0x03, 0xC0, 0xF0, 0x1C, 0xE0, 0x3C,
  0x07, 0x80, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0xF8, 0x0F, 0x01, 0xE0, 0x3F,
  0xC0, 0x70, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0x78, 0x0F, 0xF0, 0x3C, 0x03,
  0x80, 0x7F, 0x81, 0xE0, 0x1C, 0x03, 0xFC, 0x0F, 0x00, 0xE0, 0x1D, 0xE0,
  0x78, 0x0F, 0x00, 0xEF, 0x03, 0xC0, 0x78, 0x07, 0x78, 0x1E, 0x03, 0xC0,
  0x3B, 0xC0, 0xF0, 0x1E, 0x03, 0xDE, 0x07, 0x80, 0xF0, 0x1C, 0xF0, 0x3C,
  0x0F, 0x80, 0xE3, 0x81, 0xF0, 0xFC, 0x0F, 0x1C, 0x07, 0xCF, 0xF0, 0xF0,
  0xF0, 0x3F, 0xF7, 0xFF, 0x07, 0x80, 0xFF, 0x1F, 0xF0, 0x1C, 0x03, 0xF0,
  0x7F, 0x00, 0xF0, 0x04, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0x80, 0x7F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8,
  0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xFB, 0xE0, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0,
  0x1F, 0xC1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x9F,
  0x80, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0,
  0x7F, 0x01, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xF0, 0xF8,
  0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8,
  0x01, 0xF8, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xF0, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0x81,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0C, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F,
  0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x81,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xF3, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xF8,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3D, 0xFF, 0x78, 0x00, 0x3E, 0xFF, 0xBE, 0x00, 0x1F, 0x7F, 0xDF, 0x00,
  0x0F, 0x3F, 0xE7, 0x80, 0x0F, 0x9F, 0xF3, 0xE0, 0x07, 0xCF, 0xF9, 0xF0,
  0x03, 0xC7, 0xFC, 0x78, 0x03, 0xE3, 0xFE, 0x3E, 0x01, 0xF1, 0xFF, 0x1F,
  0x00, 0xF0, 0xFF, 0x87, 0x80, 0xF8, 0xFF, 0xC3, 0xC0, 0x7C, 0x7F, 0xE1,
  0xF0, 0x3C, 0x3F, 0xF0, 0x78, 0x3E, 0x1F, 0xF8, 0x3C, 0x1F, 0x0F, 0xFC,
  0x1F, 0x0F, 0x07, 0xFE, 0x07, 0x8F, 0x83, 0xFF, 0x03, 0xC7, 0xC1, 0xFF,
  0x81, 0xF3, 0xC0, 0xFF, 0xC0, 0x79, 0xE0, 0x7F, 0xE0, 0x3D, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x07,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x3E, 0x00,
  0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x3E, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x7F, 0xEF, 0x80, 0x1F,
  0xF9, 0xF0, 0x07, 0xFE, 0x3C, 0x01, 0xFF, 0x8F, 0x80, 0x7F, 0xE1, 0xE0,
  0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x0F, 0x01, 0xFF, 0x83, 0xE0, 0x7F, 0xE0,
  0x78, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x03, 0xC1, 0xFF, 0x80, 0xF8, 0x7F,
  0xE0, 0x1E, 0x1F, 0xF8, 0x07, 0xC7, 0xFE, 0x00, 0xF1, 0xFF, 0x80, 0x3E,
  0x7F, 0xE0, 0x07, 0xDF, 0xF8, 0x01, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBC,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8,
  0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x04, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8,
  0x07, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F,
  0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F,
  0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xDE, 0x00, 0x3F, 0x00, 0x1F, 0x7C,
  0x00, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0xE0,
  0x0F, 0x9F, 0x00, 0x3F, 0x80, 0x3E, 0x3C, 0x01, 0xFE, 0x00, 0xF8, 0xF8,
  0x07, 0xB8, 0x03, 0xE3, 0xE0, 0x1E, 0xF0, 0x0F, 0x0F, 0x80, 0x7B, 0xC0,
  0x7C, 0x3E, 0x03, 0xCF, 0x01, 0xF0, 0x78, 0x0F, 0x3C, 0x07, 0xC1, 0xE0,
  0x3C, 0x78, 0x1F, 0x07, 0xC0, 0xF1, 0xE0, 0x78, 0x1F, 0x07, 0xC7, 0x81,
  0xE0, 0x7C, 0x1E, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x38, 0x3E, 0x03, 0xC1,
  0xE0, 0xF0, 0xF8, 0x0F, 0x87, 0x83, 0xC3, 0xC0, 0x3E, 0x3C, 0x0F, 0x0F,
  0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x07, 0x8F,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x1E, 0x78,
  0x01, 0xF7, 0x80, 0x39, 0xE0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x0F, 0x70,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0x3E, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xC7,
  0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0xBE, 0x03, 0xDE, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E,
  0x78, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0x01, 0xF7, 0xC0,
  0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xF7, 0xC0, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0xFF, 0x1F, 0x00, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x1F, 0xF0, 0x79, 0xFF, 0xC3, 0xDF,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x1F, 0xBE, 0x00, 0x7D,
  0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xCF, 0xE0, 0x7E, 0x7F,
  0xFF, 0xF3, 0xDF, 0xFF, 0x1E, 0x7F, 0xF0, 0xF1, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x81, 0xF0, 0x7F, 0x8F, 0x8F, 0xFF, 0x7C, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7E, 0x07, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE1, 0xFF, 0xDF, 0x07, 0xF8, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07,
  0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x63, 0xF0, 0x0F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC7, 0xC7, 0xFF, 0xBE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x03, 0xFD, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x3F, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xEF, 0x83, 0xFC, 0x7C, 0x03, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x84, 0x00, 0x7C, 0x70,
  0x07, 0xE3, 0xE0, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x08, 0x0F, 0x1F, 0xE1, 0xE7, 0xFF,
  0x3D, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x07, 0xDF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xE0, 0x67, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x01, 0xE0, 0xFC, 0x3F, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xE1, 0xFB, 0xFE, 0xFF, 0x3F, 0x8F, 0xC0, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xEF, 0x00, 0xFC, 0xF0, 0x0F, 0x8F,
  0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x07, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80,
  0xF1, 0xF8, 0x0F, 0x3F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0x8F,
  0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xF0, 0xF0,
  0x1F, 0x0F, 0x01, 0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xEF,
  0x00, 0x3E, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x3C,
  0x7F, 0x81, 0xFF, 0x0F, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0x07, 0xEF, 0x80, 0x7F, 0x80,
  0xFB, 0xE0, 0x0F, 0xC0, 0x1F, 0xF0, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x03,
  0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xC0,
  0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xFF,
  0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xE0, 0x07,
  0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0x80,
  0x1F, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3E,
  0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x10, 0x1E, 0x3F, 0xC3, 0xCF, 0xFE, 0x7B, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFC, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8,
  0xFC, 0x0F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0xF8, 0x3C, 0xFF,
  0xE1, 0xEF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x03, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xE0,
  0x3F, 0x3F, 0xFF, 0xF1, 0xEF, 0xFF, 0x8F, 0x7F, 0xF8, 0x78, 0xFF, 0x03,
  0xC0, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC7, 0xC7, 0xFF,
  0xBE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x01, 0xFD, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x01, 0xFB, 0xF0,
  0x1F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xEF, 0x83, 0xFC, 0x7C,
  0x01, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0xFC, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xEF,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xEF, 0x80, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x10, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x03, 0xF0, 0x04, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xDF, 0x0F, 0xF9, 0xF0, 0x08, 0x00, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xBC, 0x00, 0xF0, 0x07, 0xDF, 0x00, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0x01, 0xE7, 0xC0, 0x3F, 0x00, 0xF1, 0xE0, 0x3F,
  0x80, 0xF8, 0xF8, 0x1F, 0xC0, 0x7C, 0x7C, 0x0F, 0xF0, 0x3E, 0x3E, 0x07,
  0xF8, 0x1E, 0x0F, 0x07, 0xBC, 0x0F, 0x07, 0x83, 0xDF, 0x0F, 0x83, 0xE1,
  0xE7, 0x87, 0xC1, 0xF0, 0xF3, 0xC3, 0xC0, 0x78, 0xF1, 0xE1, 0xE0, 0x3C,
  0x78, 0xF8, 0xF0, 0x1F, 0x3C, 0x3C, 0xF8, 0x0F, 0xBE, 0x1E, 0x78, 0x03,
  0xDE, 0x0F, 0x3C, 0x01, 0xEF, 0x03, 0xDE, 0x00, 0xF7, 0x81, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x07, 0xC0, 0xFC,
  0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x1E,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x01, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0E, 0x00, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40,
  0x01, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0xF1, 0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x0F, 0x3E, 0x7E, 0x03,
  0xDF, 0x0F, 0xC1, 0xE7, 0x81, 0xFD, 0xF9, 0xE0, 0x3F, 0xFC, 0xF8, 0x07,
  0xFF, 0x3C, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 40, 14, 4, -39 },
  { 31, 11, 13, 18, 4, -41 },
  { 49, 25, 39, 30, 4, -39 },
  { 171, 21, 52, 27, 3, -46 },
  { 308, 29, 41, 35, 3, -40 },
  { 457, 26, 41, 30, 3, -40 },
  { 591, 4, 13, 10, 3, -41 },
  { 598, 13, 57, 17, 3, -44 },
  { 691, 13, 57, 18, 1, -44 },
  { 784, 22, 23, 24, 1, -39 },
  { 848, 23, 28, 27, 2, -32 },
  { 929, 7, 14, 11, 1, -6 },
  { 942, 11, 4, 14, 1, -19 },
  { 948, 6, 6, 15, 4, -5 },
  { 953, 18, 42, 20, 1, -39 },
  { 1048, 21, 41, 27, 3, -40 },
  { 1156, 13, 39, 27, 4, -39 },
  { 1220, 22, 40, 27, 3, -40 },
  { 1330, 21, 41, 27, 3, -40 },
  { 1438, 24, 39, 27, 2, -39 },
  { 1555, 21, 40, 27, 4, -39 },
  { 1660, 20, 40, 27, 4, -39 },
  { 1760, 23, 39, 27, 2, -39 },
  { 1873, 21, 41, 27, 3, -40 },
  { 1981, 21, 40, 27, 3, -40 },
  { 2086, 6, 30, 13, 4, -29 },
  { 2109, 8, 37, 11, 1, -29 },
  { 2146, 18, 24, 25, 2, -29 },
  { 2200, 19, 15, 26, 4, -26 },
  { 2236, 19, 25, 25, 4, -30 },
  { 2296, 19, 41, 23, 2, -40 },
  { 2394, 37, 50, 42, 3, -38 },
  { 2626, 30, 39, 32, 1, -39 },
  { 2773, 23, 39, 30, 4, -39 },
  { 2886, 26, 41, 31, 3, -40 },
  { 3020, 24, 39, 31, 4, -39 },
  { 3137, 21, 39, 27, 4, -39 },
  { 3240, 21, 39, 26, 4, -39 },
  { 3343, 26, 41, 33, 3, -40 },
  { 3477, 26, 39, 34, 4, -39 },
  { 3604, 5, 39, 14, 4, -39 },
  { 3629, 21, 40, 27, 2, -39 },
  { 3734, 26, 39, 30, 4, -39 },
  { 3861, 21, 39, 26, 4, -39 },
  { 3964, 33, 39, 42, 4, -39 },
  { 4125, 26, 39, 34, 4, -39 },
  { 4252, 27, 41, 33, 3, -40 },
  { 4391, 24, 39, 30, 4, -39 },
  { 4508, 27, 47, 33, 3, -40 },
  { 4667, 24, 39, 29, 4, -39 },
  { 4784, 24, 41, 29, 2, -40 },
  { 4907, 25, 39, 29, 2, -39 },
  { 5029, 25, 40, 31, 3, -39 },
  { 5154, 29, 39, 31, 1, -39 },
  { 5296, 38, 39, 42, 2, -39 },
  { 5482, 27, 39, 30, 2, -39 },
  { 5614, 27, 39, 29, 1, -39 },
  { 5746, 24, 39, 29, 2, -39 },
  { 5863, 9, 53, 14, 4, -45 },
  { 5923, 19, 42, 20, 1, -39 },
  { 6023, 9, 53, 14, 1, -45 },
  { 6083, 17, 20, 20, 2, -39 },
  { 6126, 21, 4, 22, 1, 0 },
  { 6137, 11, 8, 17, 2, -41 },
  { 6148, 20, 31, 26, 3, -30 },
  { 6226, 21, 42, 27, 4, -41 },
  { 6337, 20, 31, 25, 3, -30 },
  { 6415, 21, 42, 27, 3, -41 },
  { 6526, 21, 31, 26, 3, -30 },
  { 6608, 15, 42, 17, 2, -42 },
  { 6687, 21, 41, 27, 3, -30 },
  { 6795, 19, 41, 27, 4, -41 },
  { 6893, 5, 40, 13, 4, -40 },
  { 6918, 10, 51, 12, -1, -40 },
  { 6982, 20, 41, 25, 4, -41 },
  { 7085, 5, 41, 13, 4, -41 },
  { 7111, 34, 30, 41, 4, -30 },
  { 7239, 19, 30, 27, 4, -30 },
  { 7311, 22, 31, 28, 3, -30 },
  { 7397, 21, 41, 27, 4, -30 },
  { 7505, 21, 41, 28, 3, -30 },
  { 7613, 12, 30, 17, 4, -30 },
  { 7658, 19, 31, 25, 3, -30 },
  { 7732, 13, 37, 16, 1, -36 },
  { 7793, 20, 30, 27, 3, -29 },
  { 7868, 21, 29, 24, 1, -29 },
  { 7945, 33, 29, 36, 1, -29 },
  { 8065, 22, 29, 24, 1, -29 },
  { 8145, 21, 40, 23, 1, -29 },
  { 8250, 19, 29, 24, 3, -29 },
  { 8319, 14, 53, 17, 2, -43 },
  { 8412, 4, 46, 13, 5, -39 },
  { 8435, 14, 53, 17, 1, -43 },
  { 8528, 26, 11, 32, 3, -22 },
};

const GFXfont RobotoCondensed_Regular55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_REGULAR55PT7B_H_
