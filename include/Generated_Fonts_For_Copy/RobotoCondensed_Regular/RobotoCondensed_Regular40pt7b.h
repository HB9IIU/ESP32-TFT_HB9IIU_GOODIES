#ifndef _ROBOTOCONDENSED_REGULAR40PT7B_H_
#define _ROBOTOCONDENSED_REGULAR40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x6F, 0xF6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xC6, 0xC6, 0xC6,
  0xC6, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x86,
  0x00, 0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x18, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x60, 0x0E, 0x18, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1C, 0x38,
  0x07, 0x0C, 0x01, 0xC3, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7C, 0x38, 0x1E, 0x78, 0x1E,
  0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E,
  0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x38, 0x70, 0x40, 0xE1, 0xC1, 0x83, 0x87, 0x0E, 0x0E, 0x0C, 0x30, 0x38,
  0x71, 0xC0, 0xE1, 0xC6, 0x03, 0x87, 0x38, 0x07, 0xB9, 0xC0, 0x0F, 0xE7,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0xF8,
  0x00, 0xE7, 0xF0, 0x03, 0x3D, 0xE0, 0x1C, 0xE3, 0x80, 0xE3, 0x06, 0x03,
  0x8C, 0x1C, 0x1C, 0x30, 0x70, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0C, 0x0E,
  0x38, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x3C, 0x38, 0x03, 0x8F, 0x00, 0x7B, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x71, 0xEF, 0x0E, 0x79,
  0xE1, 0xCE, 0x1E, 0x7B, 0xC1, 0xEE, 0x78, 0x3D, 0xCE, 0x03, 0xF9, 0xE0,
  0x3E, 0x3C, 0x07, 0xC3, 0x80, 0xF8, 0x7C, 0x3F, 0x87, 0xFF, 0xF8, 0x7F,
  0xEF, 0x03, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x01, 0x81, 0xC1,
  0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x06, 0x01, 0x00, 0x40, 0x60, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0x83, 0x81, 0x80, 0x40, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0xE3, 0x86, 0xFB, 0xBE, 0xFF, 0xFF, 0x3F, 0xFC,
  0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C, 0x70, 0x38, 0x38,
  0x38, 0x38, 0x10, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7B, 0xDE, 0xF7, 0xBD,
  0xDE, 0xE2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x81, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00,
  0xEE, 0x01, 0xDE, 0x07, 0xBC, 0x0E, 0x3C, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0,
  0x3F, 0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0xFF, 0xFC, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x70, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x01, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x7F, 0x80, 0xFC, 0x01,
  0xFE, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xB8, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xE7,
  0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xCF, 0x83, 0xFF, 0x87, 0xFF, 0x8F, 0x9F, 0x9C, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x07,
  0xB8, 0x1E, 0x78, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x01, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x9F, 0x87, 0x7F, 0x8F, 0xFF, 0x9F, 0x8F,
  0xBC, 0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0x3C, 0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x81, 0xCF, 0x03, 0xDC, 0x07,
  0xB8, 0x0F, 0x70, 0x1E, 0xF0, 0x3D, 0xE0, 0x71, 0xE1, 0xE1, 0xFF, 0x81,
  0xFE, 0x07, 0xFE, 0x1E, 0x1E, 0x78, 0x1E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x7C, 0x3C, 0x7F, 0xF8,
  0x7F, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7,
  0x83, 0xCE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDE, 0x0F, 0xBE, 0x3F, 0x3F, 0xFE,
  0x3F, 0xDC, 0x3E, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x39, 0xF7, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x38,
  0xE7, 0x9C, 0x73, 0x84, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x3F,
  0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x0F,
  0x81, 0xFF, 0x1F, 0xFD, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0xC7, 0x01, 0xF0, 0x38, 0xC0, 0x7F, 0x83, 0x38, 0x1F,
  0xF0, 0x67, 0x07, 0x8E, 0x0C, 0xE0, 0xE1, 0xC1, 0xD8, 0x38, 0x38, 0x3F,
  0x07, 0x07, 0x07, 0xE0, 0xE0, 0xE0, 0xFC, 0x1C, 0x1C, 0x1F, 0x87, 0x03,
  0x83, 0xF0, 0xE0, 0x70, 0x7E, 0x1C, 0x0C, 0x0F, 0xC3, 0x81, 0x81, 0xB8,
  0x70, 0x70, 0x37, 0x0F, 0x0E, 0x0E, 0x60, 0xE3, 0xE1, 0x8C, 0x1F, 0xFE,
  0xF1, 0xC1, 0xF9, 0xFC, 0x38, 0x1E, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xF0, 0x04, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1E, 0x00, 0x70,
  0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x73, 0x80, 0x03, 0xBC, 0x00,
  0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07,
  0xCF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xF1,
  0xE0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0x87, 0xC3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0x73, 0xC0, 0x0F, 0x70,
  0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0xF7, 0x00, 0x1E, 0xF0, 0x03, 0xCE, 0x00, 0x71, 0xE0,
  0x1E, 0x1F, 0x0F, 0x83, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3D,
  0xE0, 0x3E, 0xF0, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x87, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0x7B, 0x80, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x79, 0xE0, 0x0F, 0x1F, 0x07, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xBC, 0x0F, 0x7C, 0x3C,
  0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0,
  0x3C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xEF, 0x00, 0xF9, 0xE0, 0x1E, 0x1E,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x7C, 0x3C, 0x07,
  0x87, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1F, 0x78, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0x77, 0xEF, 0x00, 0xF7,
  0xE7, 0x00, 0xE7, 0xE7, 0x00, 0xE7, 0xE7, 0x81, 0xE7, 0xF3, 0x81, 0xC7,
  0xF3, 0x81, 0xC7, 0xF3, 0xC3, 0xC7, 0xF1, 0xC3, 0x87, 0xF1, 0xC3, 0x87,
  0xF1, 0xE3, 0x87, 0xF0, 0xE7, 0x07, 0xF0, 0xE7, 0x07, 0xF0, 0x77, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3C, 0x07,
  0xF0, 0x3C, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xF7, 0x01, 0xFE, 0xF0, 0x3F, 0xCE, 0x07, 0xF9, 0xE0, 0xFF, 0x1C,
  0x1F, 0xE3, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x8F, 0xF0, 0x71, 0xFE, 0x0F,
  0x3F, 0xC0, 0xE7, 0xF8, 0x0E, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xF0, 0xF8, 0x3C,
  0x03, 0xC3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0xC0,
  0x3C, 0x1F, 0x0F, 0x81, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x07, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xF0, 0xF8,
  0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC3,
  0xC0, 0x3C, 0x3F, 0x0F, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x40, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xF8, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x07, 0xBC, 0x01, 0xCF,
  0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83,
  0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1E, 0xF0, 0x0F, 0x7C, 0x1F, 0x1F, 0xFF, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1E, 0x7C, 0x1F, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xF0,
  0x00, 0x77, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E,
  0x1C, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xE0,
  0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x78, 0x07, 0x83, 0x80,
  0x3C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x3C, 0x70, 0x00, 0xE7,
  0x80, 0x07, 0x38, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0xF0, 0x07, 0x00, 0x77, 0x00, 0x70, 0x07, 0x70, 0x0F, 0x80, 0xF7,
  0x80, 0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x0E, 0x38, 0x1D,
  0x80, 0xE3, 0x81, 0xDC, 0x1E, 0x3C, 0x1D, 0xC1, 0xE3, 0xC1, 0xDC, 0x1E,
  0x1C, 0x1D, 0xC1, 0xC1, 0xC3, 0x8E, 0x1C, 0x1C, 0x38, 0xE1, 0xC1, 0xC3,
  0x8E, 0x3C, 0x1E, 0x38, 0xE3, 0xC0, 0xE7, 0x06, 0x38, 0x0E, 0x70, 0x73,
  0x80, 0xE7, 0x07, 0x38, 0x0E, 0x70, 0x77, 0x80, 0xFE, 0x03, 0x78, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x38, 0x01, 0xE0, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x07,
  0x9E, 0x00, 0x39, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0,
  0x78, 0x78, 0x0F, 0x07, 0x01, 0xC0, 0xF0, 0x78, 0x0E, 0x0E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF,
  0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xDC, 0x1D, 0xC1, 0xDC, 0x38, 0xE3, 0x8E,
  0x38, 0xE7, 0x07, 0x70, 0x77, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3,
  0xE1, 0xE7, 0x81, 0xCE, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0xFC, 0x3F,
  0xF8, 0xFF, 0xF3, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E,
  0xF0, 0x3C, 0xF0, 0xF9, 0xFF, 0xF9, 0xFE, 0xF1, 0xF9, 0xE0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xCF, 0xC3, 0xBF, 0xC7, 0xFF, 0xCF, 0x87, 0xDE, 0x07,
  0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1D, 0xE0, 0x7B, 0xE1,
  0xF7, 0xFF, 0xCE, 0xFF, 0x1C, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE1, 0xE7, 0x01, 0xDE, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x03, 0xF8,
  0x07, 0x70, 0x1E, 0xF8, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x1F, 0x1C, 0x7F, 0xB9, 0xFF, 0xF7, 0xC3, 0xEF,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0E, 0xE0, 0x3D,
  0xF0, 0xF9, 0xFF, 0xF1, 0xFE, 0xE1, 0xF1, 0xC0, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x0C, 0xF8, 0x3C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00,
  0x01, 0xE0, 0xFC, 0x3F, 0x87, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x1F, 0xFB, 0xFF, 0x7F, 0xE1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0xCE, 0x3F, 0xDC, 0xFF, 0xFB,
  0xE1, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0x70, 0x1E, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0x70, 0xFC, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x20, 0x1E, 0x70, 0x79, 0xFF, 0xF1, 0xFF, 0xC0, 0x7E,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x8F, 0x8E, 0xFF, 0x3F, 0xFE, 0xF8, 0x7B,
  0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0xEF, 0xFE, 0x00, 0x00, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x1C, 0xF3, 0xC7,
  0x00, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xFE,
  0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xF3, 0x81, 0xE7, 0x07, 0x8E,
  0x1E, 0x1C, 0x78, 0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x1E, 0x70, 0x38, 0xF0, 0x70, 0xF0, 0xE1, 0xE1,
  0xC1, 0xE3, 0x81, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0xE0,
  0xF8, 0x77, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0x0F, 0xE3, 0xEF, 0x03,
  0xE0, 0xF7, 0x01, 0xE0, 0x3B, 0x80, 0xF0, 0x1D, 0xC0, 0x78, 0x0F, 0xE0,
  0x3C, 0x07, 0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0xFE,
  0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0F,
  0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x07, 0x80,
  0xFE, 0x03, 0xC0, 0x78, 0xE3, 0xE3, 0xBF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0,
  0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xE7,
  0xE1, 0xDF, 0xE3, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDC, 0x03, 0xB8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0E, 0xF0, 0x3D, 0xF0, 0xFB, 0xFF, 0xE7, 0x7F,
  0x8E, 0x7E, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x8E, 0x3F, 0xDC, 0xFF, 0xFB,
  0xE1, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0x70, 0x1E, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0x70, 0xF8, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0xE7, 0xEF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3D, 0xC0, 0x77, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x1D, 0xE0, 0xF7, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x3F, 0x07, 0xC0, 0xF0, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC3, 0xF7, 0xFF, 0xDF, 0xFF, 0x1F, 0x3C, 0xF0, 0x1F, 0xE0,
  0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C,
  0x3C, 0x78, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x38, 0x0F, 0xF0, 0x3C, 0x0F, 0x70, 0x3C, 0x0E, 0x70, 0x3C,
  0x0E, 0x70, 0x7E, 0x0E, 0x78, 0x7E, 0x1E, 0x38, 0x7E, 0x1C, 0x38, 0x7E,
  0x1C, 0x38, 0xE7, 0x1C, 0x3C, 0xE7, 0x1C, 0x1C, 0xE7, 0x38, 0x1D, 0xC7,
  0x38, 0x1D, 0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x0F, 0xC3, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0xF0, 0x1E, 0xF0, 0x38, 0xE0, 0xF1, 0xE1, 0xC1,
  0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xBC, 0x0F, 0x38, 0x1C, 0x78,
  0x78, 0x79, 0xE0, 0xF3, 0xC0, 0xFF, 0x01, 0xE0, 0xF0, 0x1F, 0xE0, 0x3B,
  0xC0, 0x73, 0x81, 0xE7, 0x83, 0xCF, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x3C,
  0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x3F, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xF0, 0x3C, 0x1F, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x1C, 0xFF, 0x83,
  0xBC, 0xF0, 0x77, 0x0F, 0x9C, 0xE0, 0xFF, 0xB8, 0x0F, 0xE0, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 28, 10, 3, -28 },
  { 15, 8, 10, 13, 3, -30 },
  { 25, 18, 28, 22, 3, -28 },
  { 88, 16, 36, 20, 2, -32 },
  { 160, 22, 28, 25, 2, -28 },
  { 237, 19, 28, 22, 2, -28 },
  { 304, 3, 9, 7, 2, -30 },
  { 308, 9, 41, 13, 3, -32 },
  { 355, 9, 41, 13, 1, -32 },
  { 402, 16, 17, 17, 1, -28 },
  { 436, 16, 20, 20, 2, -23 },
  { 476, 5, 10, 8, 1, -4 },
  { 483, 8, 3, 10, 1, -14 },
  { 486, 4, 4, 11, 3, -4 },
  { 488, 13, 30, 15, 1, -28 },
  { 537, 15, 28, 20, 2, -28 },
  { 590, 10, 28, 20, 3, -28 },
  { 625, 16, 28, 20, 2, -28 },
  { 681, 15, 28, 20, 2, -28 },
  { 734, 18, 28, 20, 1, -28 },
  { 797, 15, 28, 20, 3, -28 },
  { 850, 15, 28, 20, 3, -28 },
  { 903, 16, 28, 20, 2, -28 },
  { 959, 15, 28, 20, 2, -28 },
  { 1012, 15, 28, 20, 2, -28 },
  { 1065, 4, 21, 9, 3, -21 },
  { 1076, 6, 27, 8, 1, -21 },
  { 1097, 13, 17, 18, 2, -21 },
  { 1125, 14, 11, 19, 3, -19 },
  { 1145, 14, 17, 18, 3, -21 },
  { 1175, 13, 28, 17, 2, -28 },
  { 1221, 27, 37, 31, 2, -28 },
  { 1346, 21, 28, 23, 1, -28 },
  { 1420, 17, 28, 22, 3, -28 },
  { 1480, 19, 28, 23, 2, -28 },
  { 1547, 17, 28, 23, 3, -28 },
  { 1607, 15, 28, 20, 3, -28 },
  { 1660, 15, 28, 19, 3, -28 },
  { 1713, 19, 28, 24, 2, -28 },
  { 1780, 19, 28, 25, 3, -28 },
  { 1847, 4, 28, 10, 3, -28 },
  { 1861, 15, 28, 19, 1, -28 },
  { 1914, 19, 28, 22, 3, -28 },
  { 1981, 15, 28, 19, 3, -28 },
  { 2034, 24, 28, 30, 3, -28 },
  { 2118, 19, 28, 25, 3, -28 },
  { 2185, 20, 28, 24, 2, -28 },
  { 2255, 18, 28, 22, 3, -28 },
  { 2318, 20, 33, 24, 2, -28 },
  { 2401, 18, 28, 21, 3, -28 },
  { 2464, 17, 28, 21, 2, -28 },
  { 2524, 19, 28, 21, 1, -28 },
  { 2591, 17, 28, 22, 3, -28 },
  { 2651, 21, 28, 22, 1, -28 },
  { 2725, 28, 28, 30, 1, -28 },
  { 2823, 20, 28, 22, 1, -28 },
  { 2893, 19, 28, 21, 1, -28 },
  { 2960, 17, 28, 21, 2, -28 },
  { 3020, 6, 39, 10, 3, -33 },
  { 3050, 13, 30, 15, 1, -28 },
  { 3099, 6, 39, 10, 1, -33 },
  { 3129, 12, 14, 15, 1, -28 },
  { 3150, 16, 3, 16, 0, 0 },
  { 3156, 8, 6, 12, 1, -30 },
  { 3162, 15, 21, 19, 2, -21 },
  { 3202, 15, 30, 20, 3, -30 },
  { 3259, 15, 21, 18, 2, -21 },
  { 3299, 15, 30, 20, 2, -30 },
  { 3356, 15, 21, 19, 2, -21 },
  { 3396, 11, 30, 13, 1, -30 },
  { 3438, 15, 29, 20, 2, -21 },
  { 3493, 14, 30, 19, 3, -30 },
  { 3546, 4, 29, 9, 3, -29 },
  { 3561, 6, 37, 9, 0, -29 },
  { 3589, 15, 30, 18, 3, -30 },
  { 3646, 3, 30, 9, 3, -30 },
  { 3658, 25, 21, 30, 3, -21 },
  { 3724, 14, 21, 19, 3, -21 },
  { 3761, 16, 21, 20, 2, -21 },
  { 3803, 15, 29, 20, 3, -21 },
  { 3858, 15, 29, 20, 2, -21 },
  { 3913, 8, 21, 12, 3, -21 },
  { 3934, 14, 21, 18, 2, -21 },
  { 3971, 10, 26, 12, 0, -26 },
  { 4004, 14, 21, 19, 3, -21 },
  { 4041, 15, 21, 17, 1, -21 },
  { 4081, 24, 21, 26, 1, -21 },
  { 4144, 15, 21, 18, 1, -21 },
  { 4184, 15, 29, 17, 1, -21 },
  { 4239, 14, 21, 18, 2, -21 },
  { 4276, 10, 38, 12, 1, -31 },
  { 4324, 3, 33, 10, 3, -28 },
  { 4337, 10, 38, 12, 1, -31 },
  { 4385, 19, 8, 24, 2, -16 },
};

const GFXfont RobotoCondensed_Regular40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_REGULAR40PT7B_H_
