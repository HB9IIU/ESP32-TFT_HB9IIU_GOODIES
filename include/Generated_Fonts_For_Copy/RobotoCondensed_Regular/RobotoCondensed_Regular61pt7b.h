#ifndef _ROBOTOCONDENSED_REGULAR61PT7B_H_
#define _ROBOTOCONDENSED_REGULAR61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBE, 0xFF, 0xFF, 0x88, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0xE3, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x07, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xE0, 0xF0,
  0x07, 0x80, 0xF0, 0xF0, 0x01, 0xE0, 0x78, 0x78, 0x00, 0xF0, 0x7C, 0x78,
  0x00, 0x7C, 0x7C, 0x3C, 0x00, 0x1F, 0xFE, 0x3C, 0x00, 0x07, 0xFE, 0x1E,
  0x00, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x40, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x03, 0xC3, 0xFF, 0x00, 0x01,
  0xE3, 0xFF, 0xC0, 0x01, 0xE1, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x78, 0x00,
  0xF0, 0xF0, 0x3E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x80,
  0x3C, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3E,
  0x03, 0x80, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x01, 0xE0, 0xFE,
  0x7E, 0x07, 0x83, 0xF1, 0xF8, 0x1E, 0x1F, 0x83, 0xF0, 0xF8, 0x7C, 0x07,
  0xE3, 0xE3, 0xF0, 0x1F, 0x8F, 0x8F, 0xC0, 0x3F, 0x3E, 0x3E, 0x00, 0x7F,
  0xF0, 0xF8, 0x01, 0xFF, 0xC3, 0xE0, 0x03, 0xFF, 0x0F, 0xC0, 0x07, 0xF8,
  0x3F, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xEF, 0xC0, 0x7F, 0xFE, 0x3F, 0x80, 0xFF, 0xF0, 0x7E, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x80, 0x80, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C, 0x02, 0x7C, 0x3C, 0x1F,
  0xFF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x06, 0x00, 0xF0, 0x02, 0x00, 0x40,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7C, 0xF8, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x84, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xF8, 0x7F, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xF0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x3E, 0x01, 0xFC, 0x04, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x83,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0xFC, 0xFF, 0xC1, 0xF7, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xF8, 0x1F, 0x9F, 0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x07, 0xF0, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF,
  0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x9F, 0x80, 0xFF, 0x3F, 0x83, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFE, 0xF8, 0x7F, 0xF9, 0xF0, 0x7F, 0xE3, 0xE0, 0x3F,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x0F,
  0x0F, 0xCF, 0xE7, 0xF1, 0xF8, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE0, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xE7, 0xF9, 0xFC,
  0x0F, 0xCF, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xFF, 0x80, 0x38, 0x3C,
  0x00, 0xFF, 0xF0, 0x1E, 0x3E, 0x00, 0xFF, 0xF8, 0x0F, 0x1E, 0x00, 0xF8,
  0x3C, 0x03, 0x8F, 0x00, 0x78, 0x1E, 0x01, 0xC7, 0x80, 0x78, 0x0F, 0x00,
  0xE7, 0x80, 0x3C, 0x07, 0x80, 0x7B, 0xC0, 0x3C, 0x03, 0xC0, 0x3D, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x80,
  0x78, 0x07, 0xBC, 0x07, 0x80, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x1E, 0x01,
  0xFF, 0x01, 0xE0, 0x1F, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0x80,
  0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x7C, 0x03, 0xC0, 0x1F, 0xE0, 0x3E, 0x01,
  0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x78, 0x0F, 0x80, 0x78, 0x03,
  0x9E, 0x07, 0xC0, 0x3C, 0x03, 0xCF, 0x03, 0xE0, 0x3E, 0x01, 0xE7, 0x81,
  0xF0, 0x1F, 0x00, 0xE3, 0xC0, 0x7C, 0x1F, 0x80, 0xF1, 0xE0, 0x3E, 0x1F,
  0xE0, 0xF0, 0xF0, 0x1F, 0xFE, 0xF0, 0xF8, 0x7C, 0x07, 0xFE, 0x7F, 0xF8,
  0x1E, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0x80,
  0x1C, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xC0, 0x07, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80,
  0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xF0, 0x01, 0xFC,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00,
  0x07, 0xEF, 0x80, 0x07, 0xF7, 0xC0, 0x07, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x07,
  0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xF8,
  0x00, 0xFE, 0x3E, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF1, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF,
  0xE0, 0x3F, 0x8F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xEF,
  0x80, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x7F, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80,
  0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0xF8, 0xFE, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x80,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFE, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFB, 0xE0, 0x00, 0x7D,
  0xFF, 0xBE, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x7D, 0xFF, 0x9F, 0x00,
  0x0F, 0x9F, 0xF9, 0xF0, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x0F, 0x9F, 0xF8,
  0xF8, 0x01, 0xF1, 0xFF, 0x8F, 0x80, 0x1F, 0x1F, 0xF8, 0xF8, 0x01, 0xF1,
  0xFF, 0x87, 0xC0, 0x3E, 0x1F, 0xF8, 0x7C, 0x03, 0xE1, 0xFF, 0x87, 0xC0,
  0x3E, 0x1F, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF8,
  0x3E, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F, 0x81,
  0xFF, 0x81, 0xF0, 0xF8, 0x1F, 0xF8, 0x0F, 0x8F, 0x01, 0xFF, 0x80, 0xF9,
  0xF0, 0x1F, 0xF8, 0x0F, 0x9F, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFB, 0xE0, 0x01, 0xFF, 0xBE, 0x00, 0x1F, 0xF9, 0xF0,
  0x01, 0xFF, 0x9F, 0x00, 0x1F, 0xF8, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F,
  0xF8, 0x7C, 0x01, 0xFF, 0x87, 0xC0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83,
  0xE0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0x81,
  0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x07, 0xC1, 0xFF, 0x80, 0x7E, 0x1F, 0xF8,
  0x03, 0xE1, 0xFF, 0x80, 0x3F, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0x80, 0x1F,
  0x9F, 0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x0F, 0xDF, 0xF8, 0x00, 0x7D, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3E,
  0x00, 0x1F, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7E,
  0xF8, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF3,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x3F, 0x8F, 0x80,
  0x07, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xFE, 0x00,
  0x7C, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xEF, 0x00, 0x7E, 0x1F, 0x80, 0x3D, 0xE0, 0x0F, 0xC1, 0xF0,
  0x0F, 0xBE, 0x01, 0xF0, 0x3E, 0x01, 0xF3, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x78, 0x07, 0xC0, 0xF8, 0x07, 0x8F, 0x00, 0xF8, 0x1F, 0x80, 0xF1, 0xF0,
  0x3F, 0x01, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC3, 0xC0, 0xF8,
  0x07, 0xC0, 0xF0, 0x78, 0x1F, 0x00, 0xF8, 0x1E, 0x0F, 0x03, 0xE0, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x1E, 0x1F, 0x00, 0x3E, 0x1E,
  0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x00, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0xF1, 0xF0, 0x01, 0xF3, 0xC0, 0x1E, 0x7C,
  0x00, 0x3E, 0x78, 0x03, 0xCF, 0x80, 0x07, 0xCF, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x00, 0xF7, 0xC0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x07, 0x8F,
  0x01, 0xF1, 0xE0, 0x3C, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F,
  0x87, 0x81, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x01,
  0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F,
  0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3,
  0xF0, 0x0F, 0xE7, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0x0F,
  0xFF, 0x3F, 0x07, 0xFC, 0x7E, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x3F, 0xE0, 0x7C, 0xFF, 0xF0, 0xFB, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3,
  0xFE, 0x0F, 0xE7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7E, 0xFE, 0x01, 0xFD, 0xFF, 0x07, 0xF3, 0xFF, 0xFF, 0xE7,
  0xDF, 0xFF, 0x8F, 0x9F, 0xFE, 0x1F, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0x87, 0xFF, 0x9F,
  0x1F, 0xFF, 0xBE, 0x7F, 0xFF, 0xFC, 0xFF, 0x0F, 0xFB, 0xF8, 0x07, 0xF7,
  0xE0, 0x07, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0xFE,
  0x7F, 0x87, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFD, 0xF0, 0xFF, 0xF3, 0xE0,
  0x7F, 0xC7, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x61,
  0xF8, 0x01, 0xE3, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0x81, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFD, 0xF3,
  0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF8, 0x07, 0xF3, 0xFC, 0x3F, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0x87, 0xFF, 0x9F, 0x03, 0xFE, 0x3E, 0x00,
  0x40, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC6, 0x00, 0x3F, 0x0F, 0x00, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x87, 0xF8, 0x3E, 0x7F, 0xF8, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xF8, 0x7F, 0xBF, 0xC0, 0x7E, 0xFE, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xFB, 0xFF,
  0x7F, 0xCF, 0xF9, 0xFE, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x7E, 0x7C, 0x01, 0xF8, 0xF8, 0x07, 0xF1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F,
  0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80,
  0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F,
  0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3,
  0xFE, 0x03, 0xFE, 0x0F, 0x9F, 0xFC, 0x1F, 0xFE, 0x3E, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFE, 0x1F, 0xFE, 0x1F, 0xEF, 0xE0,
  0x1F, 0xF0, 0x1F, 0xBF, 0x00, 0x7F, 0x80, 0x3E, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xFE,
  0x0F, 0x9F, 0xFE, 0x3E, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xEF,
  0xF0, 0x1F, 0xBF, 0x80, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFC, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF1, 0xFF, 0x03, 0xE7, 0xFF, 0x87, 0xDF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x3F, 0x80, 0x7F, 0x7E, 0x00, 0x7E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0, 0x3F,
  0x9F, 0xFF, 0xFF, 0x3E, 0xFF, 0xFC, 0x7C, 0xFF, 0xF0, 0xF8, 0xFF, 0x81,
  0xF0, 0x10, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x7C, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xF0, 0x7F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xEF, 0x87, 0xFF, 0xDF, 0x03, 0xFE, 0x3E, 0x00, 0x40,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC7,
  0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3E, 0x7F, 0x83, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x10, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x30, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0xDF, 0xC3, 0xFF, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xC3, 0xFF, 0x3F, 0x00, 0x80,
  0x00, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xC0, 0x07, 0xDF, 0x00,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xC0, 0x1F,
  0x1F, 0x00, 0xFE, 0x00, 0xF8, 0xF8, 0x07, 0xF8, 0x0F, 0x87, 0xC0, 0x3F,
  0xC0, 0x7C, 0x1F, 0x03, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0xF0, 0x1F, 0x07,
  0xC0, 0xF7, 0xC0, 0xF0, 0x3E, 0x07, 0xBE, 0x0F, 0x80, 0xF8, 0x7C, 0xF0,
  0x7C, 0x07, 0xC3, 0xE7, 0x83, 0xE0, 0x3E, 0x1E, 0x3E, 0x1F, 0x01, 0xF1,
  0xF1, 0xF0, 0xF0, 0x07, 0x8F, 0x87, 0x8F, 0x80, 0x3E, 0x78, 0x3E, 0x7C,
  0x01, 0xF3, 0xC1, 0xF3, 0xE0, 0x0F, 0xBE, 0x07, 0x9E, 0x00, 0x3D, 0xF0,
  0x3D, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF1, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x0F, 0xBE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF1, 0xF0, 0x07,
  0xE3, 0xE0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xF0, 0x03,
  0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0x7C,
  0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x00, 0xF3, 0xFF, 0xE0, 0x0F,
  0x7F, 0xFF, 0x01, 0xF7, 0xC3, 0xF8, 0x1F, 0xF8, 0x1F, 0xC3, 0xEF, 0x80,
  0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xCF, 0x00, 0x3F, 0xF8, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoCondensed_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 44, 15, 5, -43 },
  { 34, 12, 15, 20, 4, -46 },
  { 57, 28, 43, 33, 4, -43 },
  { 208, 24, 57, 30, 3, -50 },
  { 379, 33, 45, 39, 3, -44 },
  { 565, 30, 45, 33, 3, -44 },
  { 734, 5, 14, 11, 3, -46 },
  { 743, 14, 63, 19, 4, -49 },
  { 854, 13, 63, 19, 2, -49 },
  { 957, 24, 25, 26, 1, -43 },
  { 1032, 25, 32, 30, 3, -36 },
  { 1132, 8, 15, 12, 1, -7 },
  { 1147, 13, 5, 15, 1, -21 },
  { 1156, 7, 7, 16, 4, -6 },
  { 1163, 20, 47, 23, 1, -43 },
  { 1281, 24, 45, 30, 3, -44 },
  { 1416, 14, 43, 30, 5, -43 },
  { 1492, 25, 44, 30, 3, -44 },
  { 1630, 23, 45, 30, 3, -44 },
  { 1760, 26, 43, 30, 2, -43 },
  { 1900, 24, 44, 30, 4, -43 },
  { 2032, 23, 44, 30, 4, -43 },
  { 2159, 24, 43, 30, 3, -43 },
  { 2288, 24, 45, 30, 3, -44 },
  { 2423, 23, 44, 30, 3, -44 },
  { 2550, 7, 33, 14, 4, -32 },
  { 2579, 9, 40, 12, 1, -32 },
  { 2624, 21, 27, 27, 2, -33 },
  { 2695, 21, 17, 29, 4, -29 },
  { 2740, 22, 27, 28, 4, -33 },
  { 2815, 21, 45, 26, 2, -44 },
  { 2934, 41, 57, 47, 3, -43 },
  { 3227, 33, 43, 35, 1, -43 },
  { 3405, 25, 43, 33, 5, -43 },
  { 3540, 28, 45, 35, 4, -44 },
  { 3698, 26, 43, 35, 5, -43 },
  { 3838, 23, 43, 30, 5, -43 },
  { 3962, 22, 43, 29, 5, -43 },
  { 4081, 28, 45, 36, 4, -44 },
  { 4239, 28, 43, 38, 5, -43 },
  { 4390, 5, 43, 15, 5, -43 },
  { 4417, 23, 44, 29, 2, -43 },
  { 4544, 28, 43, 33, 5, -43 },
  { 4695, 22, 43, 29, 5, -43 },
  { 4814, 36, 43, 46, 5, -43 },
  { 5008, 28, 43, 38, 5, -43 },
  { 5159, 29, 45, 37, 4, -44 },
  { 5323, 26, 43, 34, 5, -43 },
  { 5463, 30, 51, 37, 3, -44 },
  { 5655, 26, 43, 32, 5, -43 },
  { 5795, 26, 45, 32, 3, -44 },
  { 5942, 28, 43, 32, 2, -43 },
  { 6093, 27, 44, 34, 4, -43 },
  { 6242, 32, 43, 34, 1, -43 },
  { 6414, 43, 43, 46, 2, -43 },
  { 6646, 30, 43, 34, 2, -43 },
  { 6808, 30, 43, 32, 1, -43 },
  { 6970, 26, 43, 32, 3, -43 },
  { 7110, 10, 59, 15, 4, -50 },
  { 7184, 20, 47, 23, 2, -43 },
  { 7302, 10, 59, 15, 1, -50 },
  { 7376, 19, 22, 23, 2, -43 },
  { 7429, 23, 5, 25, 1, 0 },
  { 7444, 12, 9, 19, 2, -46 },
  { 7458, 23, 34, 29, 3, -33 },
  { 7556, 23, 47, 30, 4, -46 },
  { 7692, 23, 34, 28, 3, -33 },
  { 7790, 23, 47, 30, 3, -46 },
  { 7926, 23, 34, 29, 3, -33 },
  { 8024, 17, 47, 19, 2, -47 },
  { 8124, 23, 45, 30, 3, -33 },
  { 8254, 22, 46, 29, 4, -46 },
  { 8381, 6, 43, 14, 4, -43 },
  { 8414, 11, 55, 14, -1, -43 },
  { 8490, 23, 46, 27, 4, -46 },
  { 8623, 6, 46, 14, 4, -46 },
  { 8658, 38, 33, 46, 4, -33 },
  { 8815, 22, 33, 30, 4, -33 },
  { 8906, 25, 34, 31, 3, -33 },
  { 9013, 23, 45, 30, 4, -33 },
  { 9143, 23, 45, 31, 3, -33 },
  { 9273, 13, 33, 19, 4, -33 },
  { 9327, 22, 34, 28, 3, -33 },
  { 9421, 15, 41, 18, 1, -40 },
  { 9498, 22, 33, 29, 4, -32 },
  { 9589, 24, 32, 26, 1, -32 },
  { 9685, 37, 32, 40, 1, -32 },
  { 9833, 23, 32, 27, 2, -32 },
  { 9925, 23, 44, 25, 1, -32 },
  { 10052, 21, 32, 27, 3, -32 },
  { 10136, 15, 59, 19, 2, -48 },
  { 10247, 5, 51, 15, 5, -43 },
  { 10279, 15, 59, 19, 1, -48 },
  { 10390, 28, 12, 36, 4, -24 },
};

const GFXfont RobotoCondensed_Regular61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_REGULAR61PT7B_H_
