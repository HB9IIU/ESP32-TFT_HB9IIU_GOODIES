#ifndef _ROBOTOCONDENSED_REGULAR22PT7B_H_
#define _ROBOTOCONDENSED_REGULAR22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xDE, 0xF7, 0xBD, 0x80, 0x0C, 0x83, 0x20,
  0x88, 0x26, 0x7F, 0xDF, 0xF1, 0x90, 0x64, 0x11, 0x04, 0xCF, 0xFC, 0x4C,
  0x32, 0x0C, 0x82, 0x20, 0x88, 0x08, 0x04, 0x07, 0x8F, 0xE6, 0x33, 0x19,
  0x86, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0x60, 0x3E, 0x0F, 0x06, 0xC6, 0x7F,
  0x1F, 0x02, 0x01, 0x00, 0x70, 0x04, 0x80, 0xCC, 0xCC, 0xC8, 0xCD, 0x84,
  0x90, 0x73, 0x00, 0x20, 0x06, 0x00, 0x4E, 0x09, 0xB0, 0x93, 0x13, 0x13,
  0x13, 0x01, 0xB0, 0x0E, 0x1C, 0x07, 0xC1, 0x8C, 0x31, 0x86, 0x30, 0x6C,
  0x0F, 0x00, 0xC0, 0x7C, 0x0D, 0x9B, 0x1B, 0x63, 0xEC, 0x39, 0xC7, 0x1F,
  0xF1, 0xF6, 0xFF, 0xC0, 0x08, 0xC4, 0x62, 0x31, 0x8C, 0x46, 0x31, 0x8C,
  0x61, 0x0C, 0x63, 0x08, 0x61, 0x0C, 0x20, 0x84, 0x10, 0xC6, 0x18, 0xC6,
  0x30, 0x84, 0x31, 0x08, 0xC6, 0x31, 0x88, 0xC4, 0x42, 0x00, 0x0C, 0x06,
  0x03, 0x1F, 0x73, 0xF0, 0xE0, 0xD8, 0x66, 0x22, 0x00, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x87, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x6D,
  0xB4, 0xFF, 0xF0, 0x02, 0x0C, 0x18, 0x20, 0xC1, 0x82, 0x0C, 0x18, 0x20,
  0xC1, 0x82, 0x0C, 0x18, 0x20, 0x40, 0x3C, 0x3F, 0x18, 0xC8, 0x6C, 0x16,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x24, 0x33, 0x19, 0xF8, 0x78,
  0x0B, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x3E, 0x3F,
  0x98, 0xD8, 0x6C, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03,
  0x03, 0x03, 0xFF, 0xFF, 0x3C, 0x7E, 0xC3, 0xC3, 0x03, 0x03, 0x03, 0x1E,
  0x1E, 0x03, 0x03, 0x01, 0xC3, 0xC3, 0x7F, 0x3C, 0x06, 0x03, 0x03, 0x81,
  0x41, 0xA0, 0x90, 0xC8, 0xC4, 0x62, 0x61, 0x3F, 0xFF, 0xF0, 0x20, 0x10,
  0x08, 0x04, 0x7F, 0x7F, 0xC0, 0xC0, 0xC0, 0xFC, 0xFE, 0xC6, 0x03, 0x03,
  0x03, 0x03, 0x83, 0xC6, 0xFE, 0x3C, 0x0E, 0x0F, 0x0C, 0x0C, 0x06, 0x03,
  0xF1, 0xFD, 0xC6, 0xC1, 0xE0, 0xF0, 0x68, 0x36, 0x1B, 0x18, 0xFC, 0x3C,
  0xFF, 0xFF, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x3C, 0x3F, 0x18, 0xCC, 0x64, 0x33,
  0x19, 0x8C, 0x7C, 0x3E, 0x31, 0xB0, 0x58, 0x3C, 0x1B, 0x19, 0xFC, 0x7C,
  0x3C, 0x7E, 0x63, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3, 0x63, 0x7F, 0x3B, 0x03,
  0x03, 0x06, 0x3C, 0x38, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x76, 0x00, 0x00,
  0x00, 0x02, 0x26, 0x64, 0x02, 0x0C, 0x7B, 0xCE, 0x1C, 0x1E, 0x0F, 0x06,
  0x04, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x3C, 0xFF, 0x1E, 0x30, 0x60, 0xC3,
  0x86, 0x18, 0x20, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x07, 0xE0, 0x1C, 0xE0,
  0x60, 0x61, 0x80, 0x66, 0x00, 0x4C, 0x38, 0x90, 0xD9, 0xA3, 0x33, 0xC4,
  0x43, 0x98, 0x87, 0x31, 0x1E, 0x62, 0x3C, 0xCC, 0x59, 0xFD, 0x91, 0xCE,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x71, 0x00, 0x3E, 0x00, 0x06, 0x00,
  0x70, 0x07, 0x00, 0xD0, 0x0D, 0x80, 0xD8, 0x19, 0x81, 0x8C, 0x18, 0xC1,
  0x0C, 0x3F, 0xE3, 0xFE, 0x30, 0x66, 0x06, 0x60, 0x36, 0x03, 0xFE, 0x7F,
  0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0xFC, 0xFE, 0x61, 0xB0, 0x78, 0x3C,
  0x1E, 0x1B, 0xFD, 0xFC, 0x1F, 0x07, 0xF1, 0xC3, 0x30, 0x66, 0x0D, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x66, 0x0C, 0xC1, 0x8F,
  0xE0, 0xF8, 0xFC, 0x7F, 0x30, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1B, 0xF9, 0xF8, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x0F, 0xE6, 0x0D, 0x83, 0xC0, 0xF0, 0x0C,
  0x03, 0x00, 0xC3, 0xF0, 0xFC, 0x05, 0x81, 0x60, 0x5C, 0x33, 0xFC, 0x7E,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3,
  0xC3, 0xC7, 0x7E, 0x3C, 0xC1, 0xB0, 0xCC, 0x73, 0x18, 0xCC, 0x37, 0x0D,
  0x83, 0xE0, 0xF8, 0x33, 0x0C, 0xE3, 0x18, 0xC7, 0x30, 0xCC, 0x1B, 0x07,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFB, 0x07,
  0xF8, 0x3F, 0xC3, 0x7B, 0x1B, 0xD8, 0xDE, 0xCC, 0xF3, 0x67, 0x9B, 0x3C,
  0xF1, 0xE3, 0x8F, 0x1C, 0x78, 0xC3, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xF0,
  0xF4, 0x3D, 0x8F, 0x23, 0xCC, 0xF1, 0x3C, 0x6F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x03, 0x1F, 0x07, 0xF1, 0xC3, 0x30, 0x66, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x36, 0x0C, 0xE1, 0x8F, 0xE0, 0xF8,
  0xFE, 0x7F, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0x7F, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x1F, 0x07, 0xF1, 0x83, 0x30, 0x6C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x36, 0x0C,
  0xC1, 0x8F, 0xE0, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0xFC, 0x7F, 0xB0,
  0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x86, 0xFF, 0x7E, 0x31, 0x98, 0xCC, 0x36,
  0x1B, 0x07, 0x83, 0x1E, 0x1F, 0xC6, 0x1B, 0x06, 0xC0, 0x98, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1B, 0x02, 0xC1, 0x98, 0x67, 0xF8, 0x78, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x60, 0xD8,
  0x77, 0xF8, 0x7C, 0x60, 0x36, 0x06, 0x60, 0x63, 0x06, 0x30, 0x63, 0x0C,
  0x30, 0xC1, 0x8C, 0x19, 0x81, 0x98, 0x09, 0x80, 0xD0, 0x0F, 0x00, 0x70,
  0x06, 0x00, 0x60, 0xC1, 0x07, 0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x26, 0x28,
  0xCC, 0xD9, 0x99, 0xB3, 0x33, 0x66, 0x64, 0x4C, 0x48, 0x90, 0xF1, 0xE1,
  0xE3, 0xC3, 0x83, 0x87, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0xC0, 0xD8, 0x76,
  0x18, 0xCE, 0x33, 0x07, 0xC1, 0xE0, 0x30, 0x0E, 0x07, 0x81, 0xF0, 0xCC,
  0x33, 0x98, 0x66, 0x1F, 0x03, 0x60, 0x6C, 0x1D, 0xC3, 0x18, 0x63, 0x18,
  0x33, 0x06, 0xC0, 0x78, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xFF, 0xBF, 0xE0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xE0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0F, 0xFF, 0xFF, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0x83,
  0x02, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x83, 0x02,
  0x06, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0,
  0x30, 0xC3, 0x9E, 0x69, 0x3C, 0xF1, 0xFF, 0xFF, 0xC0, 0xC6, 0x30, 0x3E,
  0x7F, 0x63, 0x03, 0x03, 0x3F, 0x73, 0xC3, 0xC3, 0xC3, 0x7F, 0x3B, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD, 0xC6, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x8D, 0xFE, 0xDE, 0x00, 0x3E, 0x7F, 0x63, 0xC1, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC1, 0x63, 0x7F, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x3D, 0x7F, 0xE3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE3, 0x7F, 0x3D,
  0x3C, 0x7F, 0x63, 0xC3, 0xC1, 0xFF, 0xFF, 0xC0, 0xC0, 0x61, 0x7F, 0x3E,
  0x1C, 0xF6, 0x18, 0x63, 0xEF, 0x98, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x60, 0x3D, 0x7F, 0xE3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE3, 0x7F,
  0x3D, 0x03, 0x43, 0x7F, 0x3C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x68, 0x04,
  0x92, 0x49, 0x24, 0x92, 0x6C, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6F, 0xE0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1B, 0x19, 0x98, 0xDC, 0x6C, 0x3E,
  0x1F, 0x0E, 0xC6, 0x33, 0x19, 0x86, 0xC3, 0x00, 0xFF, 0xFF, 0x80, 0xDE,
  0x7B, 0xFF, 0xFE, 0x38, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0,
  0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xDE, 0xFF, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3E, 0x3F, 0x98, 0xD8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0x9F, 0xC7, 0xC0, 0xDE, 0x7F,
  0xB8, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xBF, 0xDB, 0xCC,
  0x06, 0x03, 0x01, 0x80, 0x3D, 0x7F, 0xE3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xE3, 0x7F, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xDF, 0xF9, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x80, 0x3C, 0x7E, 0xC3, 0xC3, 0x60, 0x78, 0x1E, 0x07,
  0xC3, 0xC3, 0x7E, 0x3C, 0x30, 0xCF, 0xFF, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x3C, 0x70, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x63, 0x7F, 0x3F, 0x61, 0xB0, 0x98, 0xC4, 0x63, 0x31, 0x90, 0xD8, 0x2C,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC6, 0x1E, 0x30, 0xB1, 0xCD, 0x9E, 0x64,
  0xF3, 0x36, 0x91, 0xA6, 0x8F, 0x3C, 0x39, 0xE1, 0xC6, 0x0C, 0x30, 0x61,
  0x80, 0xC3, 0xC6, 0x66, 0x2C, 0x3C, 0x18, 0x38, 0x3C, 0x6C, 0x66, 0xC6,
  0xC3, 0x61, 0xB1, 0x98, 0xCC, 0x63, 0x21, 0xB0, 0xD8, 0x2C, 0x1C, 0x0E,
  0x03, 0x01, 0x01, 0x80, 0xC1, 0xC0, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x0C,
  0x18, 0x38, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0x08, 0xCC, 0x63, 0x18, 0xC4,
  0x67, 0x30, 0xC2, 0x18, 0xC6, 0x31, 0x8C, 0x30, 0x80, 0xFF, 0xFF, 0xE0,
  0x41, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x71, 0xC6, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x18, 0x40, 0x38, 0x6F, 0x89, 0x1F, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 16, 5, 2, -16 },
  { 5, 5, 5, 7, 1, -17 },
  { 9, 10, 16, 12, 1, -16 },
  { 29, 9, 20, 11, 1, -18 },
  { 52, 12, 16, 14, 1, -16 },
  { 76, 11, 16, 12, 1, -16 },
  { 98, 2, 5, 4, 1, -17 },
  { 100, 5, 23, 7, 1, -18 },
  { 115, 5, 23, 7, 1, -18 },
  { 130, 9, 9, 9, 0, -16 },
  { 141, 9, 12, 11, 1, -14 },
  { 155, 3, 5, 4, 0, -2 },
  { 157, 4, 2, 5, 1, -8 },
  { 158, 2, 2, 6, 2, -2 },
  { 159, 7, 17, 8, 0, -16 },
  { 174, 9, 16, 11, 1, -16 },
  { 192, 5, 16, 11, 2, -16 },
  { 202, 9, 16, 11, 1, -16 },
  { 220, 8, 16, 11, 1, -16 },
  { 236, 9, 16, 11, 1, -16 },
  { 254, 8, 16, 11, 2, -16 },
  { 270, 9, 16, 11, 1, -16 },
  { 288, 9, 16, 11, 1, -16 },
  { 306, 9, 16, 11, 1, -16 },
  { 324, 8, 16, 11, 1, -16 },
  { 340, 3, 11, 5, 1, -11 },
  { 345, 4, 14, 4, 0, -11 },
  { 352, 7, 10, 10, 1, -12 },
  { 361, 7, 7, 11, 2, -11 },
  { 368, 8, 10, 10, 1, -12 },
  { 378, 7, 16, 9, 1, -16 },
  { 392, 15, 20, 17, 1, -15 },
  { 430, 12, 16, 13, 0, -16 },
  { 454, 9, 16, 12, 2, -16 },
  { 472, 11, 16, 12, 1, -16 },
  { 494, 9, 16, 13, 2, -16 },
  { 512, 8, 16, 11, 2, -16 },
  { 528, 8, 16, 11, 2, -16 },
  { 544, 10, 16, 13, 1, -16 },
  { 564, 10, 16, 14, 2, -16 },
  { 584, 2, 16, 6, 2, -16 },
  { 588, 8, 16, 11, 1, -16 },
  { 604, 10, 16, 12, 2, -16 },
  { 624, 8, 16, 10, 2, -16 },
  { 640, 13, 16, 17, 2, -16 },
  { 666, 10, 16, 14, 2, -16 },
  { 686, 11, 16, 13, 1, -16 },
  { 708, 9, 16, 12, 2, -16 },
  { 726, 11, 19, 13, 1, -16 },
  { 753, 9, 16, 12, 2, -16 },
  { 771, 10, 16, 11, 1, -16 },
  { 791, 10, 16, 11, 1, -16 },
  { 811, 10, 16, 12, 1, -16 },
  { 831, 12, 16, 12, 0, -16 },
  { 855, 15, 16, 17, 1, -16 },
  { 885, 10, 16, 12, 1, -16 },
  { 905, 11, 16, 12, 0, -16 },
  { 927, 10, 16, 12, 1, -16 },
  { 947, 4, 21, 6, 1, -18 },
  { 958, 7, 17, 8, 1, -16 },
  { 973, 4, 21, 6, 0, -18 },
  { 984, 6, 8, 8, 1, -16 },
  { 990, 9, 2, 9, 0, 0 },
  { 993, 4, 3, 7, 1, -16 },
  { 995, 8, 12, 11, 1, -12 },
  { 1007, 9, 17, 11, 1, -17 },
  { 1027, 8, 12, 10, 1, -12 },
  { 1039, 8, 17, 11, 1, -17 },
  { 1056, 8, 12, 10, 1, -12 },
  { 1068, 6, 17, 7, 1, -17 },
  { 1081, 8, 16, 11, 1, -12 },
  { 1097, 8, 17, 11, 1, -17 },
  { 1114, 3, 16, 5, 1, -16 },
  { 1120, 3, 20, 5, 0, -16 },
  { 1128, 9, 17, 10, 1, -17 },
  { 1148, 1, 17, 5, 2, -17 },
  { 1151, 14, 12, 17, 1, -12 },
  { 1172, 8, 12, 11, 1, -12 },
  { 1184, 9, 12, 11, 1, -12 },
  { 1198, 9, 16, 11, 1, -12 },
  { 1216, 8, 16, 11, 1, -12 },
  { 1232, 5, 12, 7, 1, -12 },
  { 1240, 8, 12, 10, 1, -12 },
  { 1252, 6, 14, 7, 0, -14 },
  { 1263, 8, 12, 11, 1, -12 },
  { 1275, 9, 12, 9, 0, -12 },
  { 1289, 13, 12, 14, 1, -12 },
  { 1309, 8, 12, 10, 1, -12 },
  { 1321, 9, 16, 9, 0, -12 },
  { 1339, 8, 12, 10, 1, -12 },
  { 1351, 5, 21, 7, 1, -17 },
  { 1365, 1, 19, 5, 2, -16 },
  { 1368, 6, 21, 7, 0, -17 },
  { 1384, 11, 4, 13, 1, -8 },
};

const GFXfont RobotoCondensed_Regular22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_REGULAR22PT7B_H_
