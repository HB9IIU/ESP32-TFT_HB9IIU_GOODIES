#ifndef _ROBOTOCONDENSED_REGULAR46PT7B_H_
#define _ROBOTOCONDENSED_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xEF, 0xFF, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0x83, 0xE3, 0xC0, 0x78, 0xF0,
  0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x7C, 0x07,
  0xCF, 0x83, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x03,
  0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE1, 0xC0, 0xE0, 0x70,
  0xE0, 0x70, 0x38, 0xE0, 0x1C, 0x1C, 0x60, 0x0E, 0x1C, 0x70, 0x03, 0xFE,
  0x70, 0x01, 0xFE, 0x38, 0x00, 0x3E, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F, 0x00, 0x07, 0x1F, 0xC0,
  0x07, 0x1F, 0xF0, 0x03, 0x9E, 0x38, 0x03, 0x8E, 0x0E, 0x01, 0xC7, 0x07,
  0x01, 0xC3, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x70, 0x38, 0x38, 0x10, 0x1E, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x81,
  0xC0, 0x1E, 0x03, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78,
  0x00, 0xF9, 0xF0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0xF0, 0xFB, 0xE1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0xC7, 0x8F, 0x07, 0xCF, 0x3C, 0x07, 0x9C, 0x78,
  0x0F, 0xF8, 0xF0, 0x0F, 0xF1, 0xE0, 0x0F, 0xC1, 0xE0, 0x1F, 0x83, 0xC0,
  0x1F, 0x07, 0xC0, 0x7F, 0x07, 0xF7, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFE,
  0x3E, 0x03, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x00, 0x40,
  0x30, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x40, 0x0C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01,
  0xE0, 0x18, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x1E, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xDE, 0x00,
  0xF3, 0xC0, 0x78, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0x80, 0x40, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF7, 0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x07, 0xCF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xBE, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xE1, 0xFB,
  0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x40, 0xF0, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xDF, 0x87,
  0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x1E, 0x01, 0xE7, 0x80,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x79, 0xE0, 0x1E,
  0x7C, 0x0F, 0x8F, 0xCF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1E,
  0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x07, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83,
  0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE7, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF0, 0x7E, 0x18,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0xCF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x3E, 0x0F, 0x7F, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0x3E,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x81, 0xE3, 0xC1, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xEF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xE0, 0xF0, 0xFD, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0x0F,
  0x8F, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xF7, 0x81, 0xF3, 0xFB, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFD, 0xF8, 0x3C, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0x79, 0xE0,
  0x1E, 0x70, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0x7C, 0x0F, 0xCF, 0x07, 0xF3,
  0xF7, 0xFC, 0x7F, 0xEF, 0x0F, 0xF3, 0x81, 0xF9, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F,
  0xFF, 0x70, 0x3C, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF3, 0xC7, 0x9E, 0x08, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xF8,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x07, 0xC0, 0x71, 0xC0, 0x3F, 0xC0, 0xE3, 0x80, 0xFF, 0xC0, 0xC7, 0x03,
  0xC3, 0x81, 0xDE, 0x07, 0x07, 0x03, 0xB8, 0x1E, 0x0E, 0x07, 0x70, 0x38,
  0x1C, 0x0E, 0xE0, 0x70, 0x38, 0x1D, 0xC1, 0xE0, 0x70, 0x3B, 0x83, 0x80,
  0xE0, 0x77, 0x07, 0x01, 0xC0, 0xEE, 0x0E, 0x03, 0x81, 0xDC, 0x1C, 0x07,
  0x03, 0xB8, 0x38, 0x1E, 0x07, 0x70, 0x70, 0x38, 0x0E, 0xE0, 0xE0, 0x70,
  0x19, 0xC1, 0xC0, 0xE0, 0x73, 0x83, 0xC3, 0xE0, 0xE7, 0x07, 0xCF, 0xC3,
  0x8E, 0x07, 0xFB, 0xFE, 0x1E, 0x0F, 0xE3, 0xF8, 0x1C, 0x07, 0x83, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0xF8, 0x07, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xDC,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF0, 0x0F, 0xBC, 0x01,
  0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x07, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xE0, 0x3E, 0x1E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00,
  0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xEF,
  0x01, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x3F, 0x3E,
  0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF3,
  0xF0, 0x1F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E,
  0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00,
  0xF8, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07,
  0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x7B, 0xE0,
  0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x03, 0xE1, 0xE0,
  0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x3E,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xEF, 0x00, 0x1F, 0xFD, 0xE0, 0x03, 0xFF, 0xBC, 0x00, 0x77, 0xF3, 0x80,
  0x1E, 0xFE, 0x78, 0x03, 0xDF, 0xCF, 0x00, 0x73, 0xF8, 0xE0, 0x1E, 0x7F,
  0x9E, 0x03, 0xCF, 0xF3, 0xC0, 0x71, 0xFE, 0x38, 0x1E, 0x3F, 0xC7, 0x83,
  0xC7, 0xF8, 0xF0, 0x70, 0xFF, 0x0E, 0x1E, 0x1F, 0xE1, 0xE3, 0xC3, 0xFC,
  0x3C, 0x70, 0x7F, 0x83, 0x9E, 0x0F, 0xF0, 0x7B, 0xC1, 0xFE, 0x0F, 0x70,
  0x3F, 0xC0, 0xEE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x1F, 0xE0,
  0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x0E, 0x01,
  0xE0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xBC, 0x03, 0xFD, 0xE0, 0x1F, 0xE7, 0x80, 0xFF, 0x3C, 0x07, 0xF8,
  0xF0, 0x3F, 0xC7, 0x81, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x83, 0xC3,
  0xFC, 0x1E, 0x1F, 0xE0, 0x78, 0xFF, 0x03, 0xC7, 0xF8, 0x0F, 0x3F, 0xC0,
  0x79, 0xFE, 0x01, 0xEF, 0xF0, 0x0F, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3E, 0x03, 0xF0, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x9E,
  0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x8F, 0x00, 0x3C, 0x3F, 0x03, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0xCF,
  0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03,
  0xEF, 0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0x80, 0x0F,
  0x1F, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF,
  0x00, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00,
  0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x03, 0xC7, 0xC0, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x7E, 0x03, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80,
  0x1E, 0x7C, 0x03, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x07,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x00, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0,
  0x1F, 0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x1E, 0xF8, 0x07, 0xE0,
  0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x0F, 0xE0,
  0x3C, 0x78, 0x0F, 0xE0, 0x3C, 0x78, 0x0E, 0xF0, 0x3C, 0x3C, 0x0E, 0x70,
  0x3C, 0x3C, 0x1E, 0x70, 0x3C, 0x3C, 0x1E, 0x70, 0x78, 0x3C, 0x1C, 0x70,
  0x78, 0x3C, 0x1C, 0x78, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1E, 0x3C, 0x38,
  0x78, 0x1E, 0x38, 0x38, 0x70, 0x1E, 0x38, 0x3C, 0xF0, 0x1E, 0x38, 0x1C,
  0xF0, 0x0E, 0x78, 0x1C, 0xF0, 0x0F, 0x78, 0x1C, 0xF0, 0x0F, 0x70, 0x1C,
  0xE0, 0x0F, 0x70, 0x1E, 0xE0, 0x0F, 0x70, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x3C,
  0x03, 0xC1, 0xF0, 0x0F, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x00,
  0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xE0, 0x0F,
  0x87, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF8, 0x3E, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3C,
  0x00, 0xF0, 0xF8, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x03,
  0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0xFF, 0xFF,
  0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0x01,
  0xDC, 0x07, 0x78, 0x3D, 0xE0, 0xE3, 0x87, 0x8F, 0x1E, 0x3C, 0x70, 0x73,
  0xC1, 0xEF, 0x07, 0xB8, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xCF, 0xC7, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xF3, 0xE0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x07, 0xDE, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x1F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC7, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x3E,
  0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBE, 0x01, 0xEF, 0xC0, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3D, 0xFF, 0x0F, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x7B, 0xC0,
  0x0E, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0xE7,
  0x80, 0x79, 0xF0, 0x3E, 0x3F, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x1F, 0x8F, 0x1F, 0xFB, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xF0,
  0x3F, 0x78, 0x07, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFE, 0xF0, 0x7E, 0x3C, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFE, 0xFC, 0x3C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x11, 0xF0, 0x0E, 0x3F, 0x9F, 0x87, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xE3, 0xC7, 0xFE, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x7C, 0x0F, 0xDE, 0x01, 0xF7, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x7D, 0xF0, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xBC, 0x1F,
  0x8F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x40, 0x1E, 0x38, 0x0F,
  0x8F, 0xCF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF8, 0xF7, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x67, 0xBF, 0xE7, 0x00,
  0x00, 0x07, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x06, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x03,
  0xEF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE1, 0xF0, 0xF1, 0xF0, 0x78,
  0xF0, 0x3C, 0xF8, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x7C, 0xF0, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07,
  0x87, 0x83, 0xE3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1F, 0x78, 0x07, 0xBC,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xF0, 0x1F, 0x87,
  0xBF, 0xE3, 0xFE, 0x3F, 0xFF, 0xBF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0x81,
  0xFC, 0x1F, 0x78, 0x07, 0xC0, 0x7B, 0xC0, 0x3E, 0x03, 0xFE, 0x01, 0xE0,
  0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x78, 0x03, 0xFC, 0x03, 0xC0, 0x1F,
  0xE0, 0x1E, 0x00, 0xFF, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0x80, 0x3F, 0xC0,
  0x3C, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x78,
  0x03, 0xFC, 0x03, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0xFF, 0x00, 0xF0, 0x07,
  0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x3C, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0xF1,
  0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0xC3, 0xC0, 0x78, 0xF8,
  0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x79, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xFB,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xF1, 0xF8, 0x3D, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0xFB, 0xE0, 0x3C, 0xFE, 0x7F, 0x3F, 0xFF, 0x8F, 0x7F, 0xC3,
  0xC7, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xE3, 0xC7, 0xFE, 0xF3, 0xFF, 0xFC, 0xFE, 0xFF, 0x7C, 0x0F, 0xDE, 0x01,
  0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7D, 0xF0, 0x1F, 0x3F, 0xBF, 0xCF, 0xFF,
  0xF0, 0xFF, 0xBC, 0x1F, 0x8F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0xF3, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xFE,
  0x0F, 0xFF, 0x87, 0xEF, 0xE7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01,
  0xEF, 0x81, 0xE7, 0xF7, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3F,
  0x87, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0xF0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1C, 0x78, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x1C,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0xCE,
  0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0x78, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x1E, 0x78, 0x0F, 0x01, 0xE7, 0x81, 0xF0,
  0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1C, 0x3C, 0x1F, 0x83, 0xC3,
  0xC3, 0xFC, 0x3C, 0x3C, 0x3B, 0xC3, 0xC3, 0xC3, 0x9C, 0x38, 0x1C, 0x79,
  0xC3, 0x81, 0xE7, 0x9E, 0x78, 0x1E, 0x71, 0xE7, 0x81, 0xE7, 0x0E, 0x70,
  0x0E, 0xF0, 0xE7, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x78,
  0x07, 0x9F, 0x03, 0xE3, 0xC0, 0xF0, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0x87,
  0x80, 0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0F, 0x03,
  0xE7, 0xC0, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF,
  0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x3D,
  0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x07,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x20, 0x00, 0x0F, 0x00, 0x01,
  0xFE, 0x01, 0xDF, 0xF8, 0x0E, 0xFF, 0xE0, 0x7F, 0x0F, 0x87, 0xF8, 0x3F,
  0xFB, 0x80, 0xFF, 0xDC, 0x03, 0xFC, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 33, 11, 4, -33 },
  { 18, 9, 11, 15, 3, -35 },
  { 31, 21, 33, 25, 3, -33 },
  { 118, 18, 42, 23, 2, -38 },
  { 213, 25, 33, 29, 2, -33 },
  { 317, 23, 33, 25, 2, -33 },
  { 412, 4, 11, 8, 2, -35 },
  { 418, 10, 48, 14, 3, -37 },
  { 478, 11, 48, 15, 1, -37 },
  { 544, 18, 19, 20, 1, -33 },
  { 587, 19, 24, 23, 2, -28 },
  { 644, 6, 11, 9, 1, -5 },
  { 653, 9, 3, 11, 1, -15 },
  { 657, 5, 5, 12, 3, -5 },
  { 661, 15, 36, 17, 1, -33 },
  { 729, 17, 33, 23, 3, -33 },
  { 800, 10, 33, 23, 4, -33 },
  { 842, 19, 33, 23, 2, -33 },
  { 921, 18, 33, 23, 2, -33 },
  { 996, 20, 33, 23, 1, -33 },
  { 1079, 18, 33, 23, 3, -33 },
  { 1154, 17, 33, 23, 3, -33 },
  { 1225, 19, 33, 23, 2, -33 },
  { 1304, 17, 33, 23, 3, -33 },
  { 1375, 18, 33, 23, 2, -33 },
  { 1450, 5, 25, 11, 3, -25 },
  { 1466, 7, 31, 9, 1, -25 },
  { 1494, 15, 21, 21, 2, -25 },
  { 1534, 16, 13, 22, 3, -22 },
  { 1560, 16, 21, 21, 3, -25 },
  { 1602, 15, 33, 19, 2, -33 },
  { 1664, 31, 42, 35, 2, -32 },
  { 1827, 25, 33, 27, 1, -33 },
  { 1931, 18, 33, 25, 4, -33 },
  { 2006, 21, 33, 26, 3, -33 },
  { 2093, 19, 33, 26, 4, -33 },
  { 2172, 17, 33, 23, 4, -33 },
  { 2243, 17, 33, 22, 4, -33 },
  { 2314, 21, 33, 27, 3, -33 },
  { 2401, 21, 33, 29, 4, -33 },
  { 2488, 4, 33, 12, 4, -33 },
  { 2505, 18, 33, 22, 1, -33 },
  { 2580, 21, 33, 25, 4, -33 },
  { 2667, 16, 33, 22, 4, -33 },
  { 2733, 27, 33, 35, 4, -33 },
  { 2845, 21, 33, 29, 4, -33 },
  { 2932, 22, 33, 28, 3, -33 },
  { 3023, 20, 33, 26, 4, -33 },
  { 3106, 22, 39, 28, 3, -33 },
  { 3214, 20, 33, 24, 4, -33 },
  { 3297, 20, 33, 24, 2, -33 },
  { 3380, 22, 33, 24, 1, -33 },
  { 3471, 20, 33, 26, 3, -33 },
  { 3554, 24, 33, 26, 1, -33 },
  { 3653, 32, 33, 35, 2, -33 },
  { 3785, 22, 33, 25, 2, -33 },
  { 3876, 22, 33, 24, 1, -33 },
  { 3967, 20, 33, 24, 2, -33 },
  { 4050, 8, 44, 12, 3, -37 },
  { 4094, 15, 36, 17, 1, -33 },
  { 4162, 7, 44, 12, 1, -37 },
  { 4201, 14, 16, 17, 2, -33 },
  { 4229, 17, 3, 19, 1, 0 },
  { 4236, 10, 7, 14, 1, -35 },
  { 4245, 17, 24, 22, 3, -24 },
  { 4296, 18, 35, 23, 3, -35 },
  { 4375, 18, 24, 21, 2, -24 },
  { 4429, 18, 35, 23, 2, -35 },
  { 4508, 18, 24, 22, 2, -24 },
  { 4562, 12, 35, 15, 2, -35 },
  { 4615, 18, 33, 23, 2, -24 },
  { 4690, 16, 35, 22, 3, -35 },
  { 4760, 5, 33, 11, 3, -33 },
  { 4781, 8, 42, 10, -1, -33 },
  { 4823, 17, 35, 21, 3, -35 },
  { 4898, 4, 35, 11, 3, -35 },
  { 4916, 29, 24, 35, 3, -24 },
  { 5003, 16, 24, 22, 3, -24 },
  { 5051, 19, 24, 23, 2, -24 },
  { 5108, 18, 33, 23, 3, -24 },
  { 5183, 18, 33, 23, 2, -24 },
  { 5258, 10, 24, 14, 3, -24 },
  { 5288, 17, 24, 21, 2, -24 },
  { 5339, 11, 30, 14, 1, -30 },
  { 5381, 16, 24, 22, 3, -24 },
  { 5429, 18, 24, 20, 1, -24 },
  { 5483, 28, 24, 30, 1, -24 },
  { 5567, 18, 24, 20, 1, -24 },
  { 5621, 17, 33, 19, 1, -24 },
  { 5692, 16, 24, 20, 2, -24 },
  { 5740, 11, 44, 14, 2, -36 },
  { 5801, 3, 39, 11, 4, -33 },
  { 5816, 11, 44, 14, 1, -36 },
  { 5877, 21, 9, 27, 3, -18 },
};

const GFXfont RobotoCondensed_Regular46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_REGULAR46PT7B_H_
