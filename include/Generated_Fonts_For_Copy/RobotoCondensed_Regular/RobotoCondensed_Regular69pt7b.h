#ifndef _ROBOTOCONDENSED_REGULAR69PT7B_H_
#define _ROBOTOCONDENSED_REGULAR69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE7, 0xFF, 0xFF, 0xFF, 0x7C, 0x70, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7,
  0xF0, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3C, 0x01,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x07, 0xC1,
  0xF0, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x0F, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC3, 0xC0,
  0x00, 0xFF, 0xFC, 0x3E, 0x00, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x0F, 0xFC,
  0x1F, 0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00,
  0x01, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0xFF,
  0xFC, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x0F, 0x80, 0x07,
  0xC3, 0xC0, 0x3C, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x03, 0xE1, 0xF0, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x0F, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0xC0,
  0x78, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0xF8,
  0x1F, 0x00, 0x60, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0xF8, 0x1F, 0xEF, 0xE0, 0x3E, 0x07, 0xF1, 0xFC, 0x0F,
  0x83, 0xF8, 0x7F, 0x03, 0xE0, 0xFC, 0x0F, 0xE0, 0xF8, 0x7E, 0x01, 0xFC,
  0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0x87, 0xE0, 0x0F, 0xE7, 0xE1, 0xF8, 0x01,
  0xFD, 0xF0, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x0F, 0xFF, 0x07, 0xE0,
  0x01, 0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xFE, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xFC,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E,
  0x79, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x0F,
  0x00, 0x07, 0xC0, 0xF0, 0x1E, 0x7F, 0x0F, 0x0F, 0xEF, 0xFE, 0xF7, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF0, 0xF0,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x9F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xE7, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F,
  0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F, 0xE7, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xEF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFE,
  0x03, 0xFC, 0x3E, 0x00, 0x7F, 0x81, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xE7, 0xF0, 0x03, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xF3, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x01, 0xF9, 0xFF, 0xC0, 0x3F, 0x7F, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3, 0xFE, 0x03, 0xFC,
  0xFF, 0x80, 0x3F, 0x9F, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xBF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFC, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xF7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xFC,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF7, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x3F, 0xE1, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0x8F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x07, 0x01, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE,
  0x3F, 0x83, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0x78, 0x06, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x7F, 0x00, 0x7E,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xC3,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0x8F, 0x00, 0x1F, 0xCF, 0xE0, 0x1E, 0x3C,
  0x00, 0xFC, 0x0F, 0x80, 0x79, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE7, 0xC0,
  0x1F, 0x00, 0xF0, 0x07, 0x9E, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7B, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0x80, 0x7C,
  0x01, 0xF0, 0x03, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x7C, 0x01,
  0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xEF, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xBC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0xF0, 0x0F, 0x80, 0x1E, 0x00,
  0x7B, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xEF, 0x80, 0xF8, 0x03, 0xE0, 0x0F,
  0xBE, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF3,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC7, 0x80, 0x7E, 0x0F, 0xF0, 0x1E, 0x1E,
  0x01, 0xFC, 0x7F, 0xC0, 0xF8, 0x7C, 0x07, 0xFF, 0xDF, 0x8F, 0xC1, 0xF0,
  0x0F, 0xFF, 0x3F, 0xFE, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0x80,
  0x3F, 0x80, 0xFF, 0x80, 0x3E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7E, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xF0,
  0x0F, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xF3, 0xF0, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xFC, 0x3F, 0x01, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x3F, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFF,
  0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x01, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x07, 0xF8, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF,
  0xE0, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x00, 0x7E,
  0xFF, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0xFC, 0xFC, 0x00, 0x07, 0xCF, 0xFF,
  0x3F, 0x00, 0x03, 0xF3, 0xFF, 0xCF, 0xC0, 0x00, 0xFC, 0xFF, 0xF1, 0xF0,
  0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xFF, 0x1F, 0x80, 0x07,
  0xE3, 0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xFF, 0x07, 0xC0, 0x0F, 0x83, 0xFF, 0xC1,
  0xF8, 0x07, 0xE0, 0xFF, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0x80,
  0x7C, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFF, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xFF,
  0x01, 0xF8, 0x7E, 0x03, 0xFF, 0xC0, 0x3E, 0x1F, 0x00, 0xFF, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xF0, 0x00, 0x3F,
  0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x3F,
  0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x3F,
  0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F,
  0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x03, 0xF0, 0x3F,
  0xFC, 0x01, 0xF8, 0x3F, 0xFC, 0x01, 0xF8, 0x3F, 0xFC, 0x00, 0xFC, 0x3F,
  0xFC, 0x00, 0x7C, 0x3F, 0xFC, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x3E, 0x3F,
  0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x1F, 0xBF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x0F, 0xFE, 0x3F, 0x00,
  0x03, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x1F, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFB,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3E,
  0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC3, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC0, 0x0F, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x03, 0xF0,
  0x7C, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x7C, 0x7E, 0x00, 0x1F,
  0x8F, 0x80, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x80, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x00,
  0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xF0, 0x00,
  0x3F, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x1E, 0xFC, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7,
  0xFF, 0x87, 0xE3, 0xFC, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xE7, 0xE3, 0xFF, 0xE3, 0xF0, 0x7F, 0xE1, 0xF8, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0xF8, 0x1F, 0x9F, 0xFF, 0x83,
  0xF7, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0x80,
  0xFF, 0x3F, 0xC0, 0x07, 0xE7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0xF0,
  0x1F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x1F, 0xBF, 0xFF, 0xC3,
  0xF3, 0xFF, 0xF0, 0x7E, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xC3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF8, 0x01, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x01, 0xFF, 0x87, 0xE0,
  0xFF, 0xFC, 0xFC, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x9F, 0x80, 0xFF, 0xC3, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x0F, 0xE0, 0x01, 0xE1, 0xFE, 0x00,
  0x7E, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0xFC, 0x1F,
  0xFF, 0x9F, 0x87, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xF0, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x07,
  0xF9, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xDF, 0x83, 0xFF, 0xF3, 0xF0, 0x1F, 0xFC, 0x7E, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x06, 0x00, 0x0F, 0xE1, 0xF0, 0x03, 0xF8,
  0x3F, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x3F, 0xF0, 0x7E, 0x3F, 0xFE, 0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF7, 0xFE, 0x03, 0xFB, 0xFE, 0x00, 0xFD, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xF0, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE9, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF,
  0xCF, 0xF0, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x7C, 0x00, 0x7F,
  0x3E, 0x00, 0x7F, 0x1F, 0x00, 0x7F, 0x0F, 0x80, 0x7F, 0x87, 0xC0, 0x3F,
  0x83, 0xE0, 0x3F, 0x81, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x1F,
  0xC0, 0x3E, 0x1F, 0xC0, 0x1F, 0x1F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF,
  0xE0, 0x03, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07,
  0xF1, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0x3F,
  0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xF1, 0xF0, 0x01, 0xFC, 0xF8, 0x00,
  0xFE, 0x7C, 0x00, 0x3F, 0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0xF8, 0x07, 0xFF,
  0x0F, 0x9F, 0xFF, 0x07, 0xFF, 0xE3, 0xEF, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x1F, 0xF8, 0x3F,
  0x1F, 0xFF, 0x1F, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0x01, 0xFD, 0xFF, 0x00, 0x7E, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x87, 0xFE, 0x03, 0xF3, 0xFF, 0xF0,
  0x7E, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0,
  0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xE7, 0xFC,
  0x03, 0xFC, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF8,
  0x7E, 0x7F, 0xFE, 0x0F, 0xC3, 0xFF, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xF8, 0xFC, 0x1F, 0xFF, 0x9F, 0x87, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF3, 0xFF, 0xCF, 0xF0, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xDF, 0x83, 0xFF, 0xF3, 0xF0, 0x1F, 0xFC, 0x7E,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1E, 0xFC, 0x7F, 0xFC, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x9F, 0xF0, 0xFE, 0x01, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF7, 0xE0, 0xFF, 0xE3, 0xF0, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xCF,
  0x80, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x03, 0xF3, 0xF0, 0x03,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xFF, 0x00,
  0x7C, 0x3E, 0x00, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0xFF, 0xC0, 0x3F, 0x0F,
  0xC0, 0x7F, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0x9F, 0x83,
  0xE0, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x07,
  0xE3, 0xE1, 0xF0, 0xFC, 0x03, 0xF1, 0xF0, 0x7C, 0x7C, 0x01, 0xF8, 0xF8,
  0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x0F, 0xCF,
  0x80, 0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x03,
  0xFF, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x3F, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x2F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x03, 0xC3, 0xFF, 0xF0,
  0x03, 0xE3, 0xFF, 0xFC, 0x01, 0xF1, 0xFF, 0xFF, 0x00, 0xF9, 0xF8, 0x3F,
  0xC0, 0xFC, 0xF8, 0x0F, 0xFF, 0xFC, 0x7C, 0x03, 0xFF, 0xFC, 0x7E, 0x00,
  0x7F, 0xFE, 0x3E, 0x00, 0x1F, 0xFE, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_Regular69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 50, 17, 5, -49 },
  { 45, 13, 17, 22, 5, -52 },
  { 73, 32, 49, 38, 4, -49 },
  { 269, 26, 64, 34, 4, -57 },
  { 477, 37, 51, 44, 4, -50 },
  { 713, 34, 51, 38, 3, -50 },
  { 930, 6, 16, 12, 3, -52 },
  { 942, 16, 71, 22, 4, -55 },
  { 1084, 15, 71, 22, 2, -55 },
  { 1218, 28, 29, 30, 1, -49 },
  { 1320, 28, 36, 34, 3, -40 },
  { 1446, 9, 17, 14, 1, -7 },
  { 1466, 14, 5, 17, 2, -23 },
  { 1475, 8, 8, 18, 5, -7 },
  { 1483, 22, 53, 26, 1, -49 },
  { 1629, 26, 51, 34, 4, -50 },
  { 1795, 17, 49, 34, 5, -49 },
  { 1900, 28, 50, 34, 3, -50 },
  { 2075, 27, 51, 34, 3, -50 },
  { 2248, 30, 49, 34, 2, -49 },
  { 2432, 26, 50, 34, 5, -49 },
  { 2595, 27, 50, 34, 4, -49 },
  { 2764, 28, 49, 34, 3, -49 },
  { 2936, 26, 51, 34, 4, -50 },
  { 3102, 27, 50, 34, 3, -50 },
  { 3271, 7, 38, 16, 5, -37 },
  { 3305, 11, 47, 14, 1, -37 },
  { 3370, 23, 30, 31, 3, -37 },
  { 3457, 24, 18, 33, 5, -32 },
  { 3511, 24, 30, 32, 5, -37 },
  { 3601, 23, 51, 29, 3, -50 },
  { 3748, 46, 63, 53, 4, -48 },
  { 4111, 37, 49, 40, 1, -49 },
  { 4338, 29, 49, 38, 5, -49 },
  { 4516, 32, 51, 39, 4, -50 },
  { 4720, 30, 49, 39, 5, -49 },
  { 4904, 27, 49, 34, 5, -49 },
  { 5070, 26, 49, 33, 5, -49 },
  { 5230, 32, 51, 41, 4, -50 },
  { 5434, 32, 49, 43, 5, -49 },
  { 5630, 6, 49, 17, 6, -49 },
  { 5667, 26, 50, 33, 2, -49 },
  { 5830, 32, 49, 38, 5, -49 },
  { 6026, 26, 49, 33, 5, -49 },
  { 6186, 42, 49, 52, 5, -49 },
  { 6444, 32, 49, 43, 5, -49 },
  { 6640, 33, 51, 41, 4, -50 },
  { 6851, 31, 49, 38, 5, -49 },
  { 7041, 34, 58, 41, 4, -50 },
  { 7288, 31, 49, 37, 5, -49 },
  { 7478, 30, 51, 36, 3, -50 },
  { 7670, 32, 49, 36, 2, -49 },
  { 7866, 31, 50, 39, 4, -49 },
  { 8060, 36, 49, 39, 1, -49 },
  { 8281, 49, 49, 53, 2, -49 },
  { 8582, 34, 49, 38, 2, -49 },
  { 8791, 34, 49, 36, 1, -49 },
  { 9000, 30, 49, 36, 3, -49 },
  { 9184, 11, 67, 17, 5, -56 },
  { 9277, 23, 53, 26, 2, -49 },
  { 9430, 11, 67, 17, 1, -56 },
  { 9523, 21, 25, 26, 2, -49 },
  { 9589, 26, 5, 28, 1, 0 },
  { 9606, 14, 10, 21, 2, -52 },
  { 9624, 25, 38, 33, 4, -37 },
  { 9743, 27, 53, 34, 4, -52 },
  { 9922, 26, 38, 32, 3, -37 },
  { 10046, 27, 53, 34, 3, -52 },
  { 10225, 27, 38, 32, 3, -37 },
  { 10354, 19, 53, 22, 2, -53 },
  { 10480, 27, 51, 34, 3, -37 },
  { 10653, 25, 52, 33, 4, -52 },
  { 10816, 6, 49, 16, 5, -49 },
  { 10853, 12, 63, 15, -1, -49 },
  { 10948, 25, 52, 31, 5, -52 },
  { 11111, 6, 52, 16, 5, -52 },
  { 11150, 42, 37, 52, 5, -37 },
  { 11345, 25, 37, 33, 4, -37 },
  { 11461, 28, 38, 35, 3, -37 },
  { 11594, 27, 51, 34, 4, -37 },
  { 11767, 27, 51, 35, 3, -37 },
  { 11940, 16, 37, 21, 4, -37 },
  { 12014, 25, 38, 31, 3, -37 },
  { 12133, 17, 46, 20, 1, -45 },
  { 12231, 25, 37, 33, 4, -36 },
  { 12347, 26, 36, 30, 2, -36 },
  { 12464, 41, 36, 45, 2, -36 },
  { 12649, 26, 36, 30, 2, -36 },
  { 12766, 26, 50, 29, 1, -36 },
  { 12929, 25, 36, 30, 3, -36 },
  { 13042, 18, 66, 21, 2, -54 },
  { 13191, 5, 58, 17, 6, -49 },
  { 13228, 18, 66, 21, 1, -54 },
  { 13377, 33, 13, 41, 4, -27 },
};

const GFXfont RobotoCondensed_Regular69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_REGULAR69PT7B_H_
