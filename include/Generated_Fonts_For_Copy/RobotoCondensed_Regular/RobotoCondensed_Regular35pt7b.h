#ifndef _ROBOTOCONDENSED_REGULAR35PT7B_H_
#define _ROBOTOCONDENSED_REGULAR35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xE7,
  0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0x03, 0x8E, 0x03, 0x8C, 0x03, 0x0C,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x7F, 0xFF,
  0x7F, 0xFF, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0x70, 0x1C, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0xFC, 0x0F, 0xF0, 0xFF, 0xCF, 0x0E, 0x70, 0x7B, 0x81,
  0xDC, 0x0E, 0xE0, 0x77, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0,
  0x3B, 0x83, 0xDF, 0xFC, 0x7F, 0xC0, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x3C, 0x00, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0x61, 0x83, 0x0C, 0x30, 0xE1,
  0x87, 0x18, 0x30, 0xE7, 0x06, 0x1C, 0xC0, 0xC3, 0x38, 0x1C, 0xE6, 0x01,
  0xF9, 0x80, 0x1E, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x9E, 0x00, 0x67, 0xE0,
  0x1D, 0xCE, 0x03, 0x30, 0xC0, 0xE6, 0x1C, 0x18, 0xC3, 0x87, 0x18, 0x70,
  0xC3, 0x0E, 0x38, 0x61, 0x82, 0x0E, 0x70, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x83,
  0x81, 0xC1, 0xC0, 0x71, 0xE0, 0x39, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x31, 0xCE, 0x19, 0xE3, 0x8C, 0xE1, 0xEE,
  0x70, 0x7F, 0x38, 0x1F, 0x9C, 0x0F, 0x8E, 0x03, 0xC7, 0x83, 0xE1, 0xFF,
  0xF8, 0x7F, 0xDE, 0x0F, 0x87, 0x00, 0xFF, 0xFF, 0x01, 0x03, 0x07, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x38,
  0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x06, 0x38, 0xCF, 0xFF, 0x9F, 0xFF, 0x83, 0xF0, 0x07,
  0xC0, 0x1D, 0x80, 0x3B, 0x80, 0xE3, 0x83, 0x83, 0x81, 0x04, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x39, 0xCE, 0x73,
  0x9D, 0xCE, 0x20, 0xFF, 0xFF, 0xF8, 0x67, 0xF7, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x00, 0x0F, 0x81,
  0xFF, 0x0F, 0xFC, 0xE0, 0xE7, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x07, 0xBC, 0x38, 0xFF, 0xC3,
  0xFC, 0x0F, 0x80, 0x03, 0x0F, 0x3F, 0xFF, 0xF7, 0x87, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1C, 0x1C, 0xE0,
  0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xE0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x39,
  0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0,
  0x31, 0xC0, 0xE3, 0x81, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xDF, 0x07, 0xFF, 0x1F,
  0xFC, 0x78, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x76,
  0x01, 0xDC, 0x0F, 0x70, 0x39, 0xE1, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0,
  0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x9F, 0x0E, 0xFE, 0x3F, 0xFC, 0xF8, 0x7B, 0xC0,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9C, 0x0E, 0x70,
  0x38, 0xE1, 0xE3, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC,
  0xE0, 0xE7, 0x07, 0xF8, 0x1F, 0x80, 0xEE, 0x07, 0x70, 0x73, 0x83, 0x8F,
  0xF8, 0x3F, 0x83, 0xFE, 0x3C, 0x79, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xB8, 0x3D, 0xFF, 0xC7, 0xFC, 0x0F, 0x80,
  0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xB8, 0x7D, 0xFF,
  0xE7, 0xF7, 0x1F, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x7F, 0x03, 0xF0, 0x1E, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0x70, 0x33, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x7B, 0xDC, 0xE7, 0x73, 0x88, 0x00, 0x10, 0x07, 0x00, 0xF0, 0x3F,
  0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x78,
  0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F,
  0x83, 0xFE, 0x7F, 0xE7, 0x0F, 0x70, 0x7E, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x78, 0x03,
  0x80, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x70, 0x3E, 0x0C, 0xC0, 0xFE, 0x0D, 0x83, 0xCE, 0x1B, 0x06, 0x18, 0x3E,
  0x1C, 0x30, 0x7C, 0x30, 0x60, 0xF0, 0x60, 0xC1, 0xE1, 0xC1, 0x83, 0xC3,
  0x83, 0x07, 0x87, 0x06, 0x0F, 0x0E, 0x1C, 0x1E, 0x1C, 0x38, 0x6C, 0x38,
  0xF0, 0xDC, 0x3F, 0xE3, 0xB8, 0x7E, 0xFE, 0x30, 0x78, 0xF0, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x60, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x33,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0x80, 0x71, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8,
  0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xEF,
  0xFF, 0x3F, 0xF0, 0xFF, 0xF3, 0x81, 0xEE, 0x03, 0xB8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xEF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x1E, 0x78, 0x0F,
  0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x3C, 0x1E, 0x1F, 0xFC,
  0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x03, 0xCE,
  0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x03, 0xDC, 0x0F, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x78, 0x0F, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x07, 0x3C, 0x0F, 0x1F, 0xFE, 0x0F,
  0xFC, 0x03, 0xF0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xB8, 0x3D, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0xE0, 0x1E, 0xE0, 0x3C,
  0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xE0, 0xE3, 0xC0,
  0xE7, 0x80, 0xE7, 0x00, 0xEF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xF3, 0x80, 0xF3, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x78,
  0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x77,
  0xEC, 0x03, 0xBF, 0x70, 0x1D, 0xFB, 0x81, 0xCF, 0xCC, 0x0E, 0x7E, 0x70,
  0x73, 0xF3, 0x87, 0x1F, 0x8C, 0x38, 0xFC, 0x71, 0xC7, 0xE3, 0x9C, 0x3F,
  0x0C, 0xE1, 0xF8, 0x77, 0x0F, 0xC3, 0xB0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C,
  0x1F, 0x83, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xEE,
  0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x03,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39,
  0xC0, 0x1D, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0x7F, 0xF8,
  0x1F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x01,
  0xEE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x01, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0x83,
  0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xCE, 0x00, 0xE7, 0x80,
  0xF1, 0xE0, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0x03, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x3B, 0x80, 0xF7, 0x03, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x70, 0xF0,
  0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x07, 0x70, 0x0E, 0xE0, 0x1E, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0x78, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0E, 0xF0, 0x0F, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0E, 0x3C,
  0x1E, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0,
  0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xE0,
  0x03, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x9E, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x3C, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x18, 0xE0, 0x07,
  0x38, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0xB8,
  0x0E, 0x03, 0x9C, 0x07, 0x01, 0xCE, 0x07, 0xC0, 0xE7, 0x03, 0xE0, 0x73,
  0x81, 0xF0, 0x38, 0xE0, 0xD8, 0x38, 0x70, 0x6E, 0x1C, 0x38, 0x77, 0x0E,
  0x1C, 0x3B, 0x87, 0x0E, 0x18, 0xC3, 0x83, 0x0C, 0x61, 0x81, 0xCE, 0x39,
  0xC0, 0xE7, 0x1C, 0xE0, 0x73, 0x06, 0x70, 0x39, 0x83, 0x38, 0x1D, 0xC1,
  0xD8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x00, 0x70, 0x07, 0xBC, 0x03, 0x8E, 0x03, 0xC7, 0x81, 0xC1,
  0xC1, 0xE0, 0xF0, 0xE0, 0x38, 0xF0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0x78, 0x07, 0x9C, 0x03, 0x8F, 0x03, 0xC3, 0x81, 0xC1, 0xE1,
  0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x0E, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0xF8,
  0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC3, 0x81, 0xE1, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x70, 0x1E, 0x38, 0x07, 0x3C, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8F, 0xFF, 0xFC, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F,
  0xFF, 0xF8, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x36, 0x0E, 0xE1,
  0x8C, 0x71, 0xCE, 0x39, 0x83, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE0,
  0xEE, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFE, 0x3F, 0xF3, 0xE3, 0xBC, 0x1D,
  0xC0, 0xEE, 0x07, 0x70, 0x3B, 0xC3, 0xDF, 0xFE, 0x7F, 0xF8, 0xF1, 0xC0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE7, 0xC3, 0xBF, 0xCF, 0xFF, 0x3C, 0x1E, 0xF0, 0x3B, 0x80,
  0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3B, 0xC0, 0xEF, 0x07, 0xBF, 0xFC, 0xEF, 0xF3, 0x9F, 0x00, 0x0F, 0x81,
  0xFF, 0x1F, 0xFD, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xF0, 0x1F, 0xC1, 0xCF, 0xFE,
  0x3F, 0xE0, 0x7C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x1F, 0x39, 0xFF, 0xDF, 0xFF, 0xE0, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xEF, 0xFF, 0x3F, 0xF8, 0xF9, 0xC0, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xE0, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0xCF,
  0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0xFF, 0xBF, 0xE1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0x1F, 0x39, 0xFF, 0xDF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC1, 0xEF, 0xFF, 0x3F, 0xF8, 0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xB0, 0x39, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0xC7, 0x7F, 0x3F,
  0xFD, 0xF0, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xC0, 0x6F, 0xF6, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x70, 0x10, 0xE3, 0x86, 0x00, 0x00, 0x0E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x3B, 0xEF, 0xB8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x77, 0x07, 0xB8, 0x79, 0xC7, 0x8E, 0x38,
  0x73, 0x83, 0xBC, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xE1, 0xC7, 0x0E,
  0x1C, 0x70, 0xF3, 0x83, 0x9C, 0x1E, 0xE0, 0x7F, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0xC3, 0xE3, 0xBF,
  0x9F, 0xEF, 0xFF, 0xFF, 0xBC, 0x1F, 0x0F, 0xF0, 0x78, 0x1F, 0x80, 0xE0,
  0x7E, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E,
  0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03,
  0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x70, 0xE7, 0xC7,
  0x7F, 0x3F, 0xFD, 0xF0, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xC0, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1C, 0x1E, 0xF0,
  0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0xE7, 0x07, 0x9F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00,
  0xE7, 0xC3, 0xBF, 0xCF, 0xFF, 0x3C, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3B, 0x80,
  0xEF, 0x07, 0xBF, 0xFC, 0xEF, 0xF3, 0x9F, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1F, 0x39, 0xFF, 0xDF,
  0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xEF, 0xFF, 0x3F, 0xF8,
  0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xE0,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0xFF, 0x3F, 0xE1, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xF8, 0x7C, 0x1E,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3D, 0xC3,
  0xEF, 0xFF, 0x3F, 0xB8, 0xF9, 0xC0, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x30, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xC6, 0x07, 0x70,
  0x3B, 0x80, 0xD8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x70, 0x3F, 0x03, 0x81, 0xB8, 0x3C, 0x1C, 0xE1, 0xF0, 0xE7, 0x0F,
  0x87, 0x38, 0x7C, 0x31, 0xC7, 0x63, 0x87, 0x3B, 0x9C, 0x39, 0x9C, 0xE1,
  0xCC, 0x66, 0x0E, 0xE3, 0x30, 0x37, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x83,
  0xC0, 0x7C, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x70, 0x18, 0x00,
  0xF0, 0x3B, 0x83, 0x9E, 0x1C, 0x71, 0xC1, 0xCE, 0x0E, 0xE0, 0x3F, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x81, 0xDC, 0x1E, 0x70, 0xE3,
  0x8F, 0x0E, 0x70, 0x7F, 0x81, 0xC0, 0xE0, 0x3F, 0x03, 0xBC, 0x1C, 0xE0,
  0xE7, 0x0F, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xC0, 0xCE, 0x07, 0x70,
  0x3B, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF1, 0xF0, 0xF0, 0x7C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x0F, 0x07, 0x0F, 0x1E, 0x1C,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0xE0,
  0xC0, 0x1E, 0x03, 0x9F, 0x81, 0x9F, 0xE0, 0xCC, 0x78, 0xEE, 0x1F, 0xE7,
  0x07, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 25, 9, 3, -25 },
  { 11, 7, 8, 11, 2, -26 },
  { 18, 16, 25, 19, 2, -25 },
  { 68, 13, 32, 17, 2, -29 },
  { 120, 19, 25, 22, 2, -25 },
  { 180, 17, 25, 19, 2, -25 },
  { 234, 2, 8, 6, 2, -26 },
  { 236, 8, 36, 11, 2, -28 },
  { 272, 8, 36, 11, 1, -28 },
  { 308, 15, 14, 15, 0, -25 },
  { 335, 15, 18, 17, 1, -20 },
  { 369, 5, 9, 7, 0, -4 },
  { 375, 7, 3, 9, 1, -12 },
  { 378, 4, 4, 9, 2, -4 },
  { 380, 11, 27, 13, 1, -25 },
  { 418, 13, 25, 17, 2, -25 },
  { 459, 8, 25, 17, 3, -25 },
  { 484, 14, 25, 17, 2, -25 },
  { 528, 13, 25, 17, 2, -25 },
  { 569, 15, 25, 17, 1, -25 },
  { 616, 14, 25, 17, 2, -25 },
  { 660, 14, 25, 17, 2, -25 },
  { 704, 15, 25, 17, 1, -25 },
  { 751, 13, 25, 17, 2, -25 },
  { 792, 13, 25, 17, 2, -25 },
  { 833, 4, 19, 8, 2, -19 },
  { 843, 5, 24, 7, 1, -19 },
  { 858, 12, 16, 16, 1, -19 },
  { 882, 12, 10, 17, 3, -17 },
  { 897, 13, 16, 16, 2, -19 },
  { 923, 12, 25, 15, 1, -25 },
  { 961, 23, 32, 27, 2, -24 },
  { 1053, 18, 25, 20, 1, -25 },
  { 1110, 14, 25, 19, 3, -25 },
  { 1154, 16, 25, 20, 2, -25 },
  { 1204, 15, 25, 20, 3, -25 },
  { 1251, 13, 25, 17, 3, -25 },
  { 1292, 13, 25, 17, 3, -25 },
  { 1333, 16, 25, 21, 2, -25 },
  { 1383, 16, 25, 22, 3, -25 },
  { 1433, 3, 25, 9, 3, -25 },
  { 1443, 13, 25, 17, 1, -25 },
  { 1484, 16, 25, 19, 3, -25 },
  { 1534, 13, 25, 17, 3, -25 },
  { 1575, 21, 25, 26, 3, -25 },
  { 1641, 16, 25, 22, 3, -25 },
  { 1691, 17, 25, 21, 2, -25 },
  { 1745, 15, 25, 19, 3, -25 },
  { 1792, 17, 29, 21, 2, -25 },
  { 1854, 15, 25, 19, 3, -25 },
  { 1901, 16, 25, 18, 1, -25 },
  { 1951, 16, 25, 18, 1, -25 },
  { 2001, 16, 25, 20, 2, -25 },
  { 2051, 18, 25, 20, 1, -25 },
  { 2108, 25, 25, 27, 1, -25 },
  { 2187, 17, 25, 19, 1, -25 },
  { 2241, 17, 25, 18, 1, -25 },
  { 2295, 15, 25, 18, 2, -25 },
  { 2342, 6, 33, 9, 2, -28 },
  { 2367, 11, 27, 13, 1, -25 },
  { 2405, 5, 33, 9, 1, -28 },
  { 2426, 11, 12, 13, 1, -25 },
  { 2443, 14, 3, 14, 0, 0 },
  { 2449, 7, 5, 11, 1, -26 },
  { 2454, 13, 18, 17, 2, -18 },
  { 2484, 14, 26, 17, 2, -26 },
  { 2530, 13, 18, 16, 2, -18 },
  { 2560, 13, 26, 17, 2, -26 },
  { 2603, 13, 18, 16, 2, -18 },
  { 2633, 10, 26, 11, 1, -26 },
  { 2666, 13, 25, 17, 2, -18 },
  { 2707, 13, 26, 17, 2, -26 },
  { 2750, 4, 25, 8, 2, -25 },
  { 2763, 6, 32, 8, 0, -25 },
  { 2787, 13, 26, 16, 2, -26 },
  { 2830, 3, 26, 8, 3, -26 },
  { 2840, 22, 18, 26, 2, -18 },
  { 2890, 13, 18, 17, 2, -18 },
  { 2920, 14, 18, 18, 2, -18 },
  { 2952, 14, 25, 17, 2, -18 },
  { 2996, 13, 25, 18, 2, -18 },
  { 3037, 8, 18, 11, 2, -18 },
  { 3055, 12, 18, 16, 2, -18 },
  { 3082, 9, 23, 10, 0, -23 },
  { 3108, 13, 18, 17, 2, -18 },
  { 3138, 13, 18, 15, 1, -18 },
  { 3168, 21, 18, 23, 1, -18 },
  { 3216, 13, 18, 15, 1, -18 },
  { 3246, 13, 25, 15, 1, -18 },
  { 3287, 12, 18, 15, 2, -18 },
  { 3314, 9, 33, 11, 1, -27 },
  { 3352, 3, 30, 9, 3, -25 },
  { 3364, 8, 33, 11, 1, -27 },
  { 3397, 17, 7, 21, 2, -14 },
};

const GFXfont RobotoCondensed_Regular35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_REGULAR35PT7B_H_
