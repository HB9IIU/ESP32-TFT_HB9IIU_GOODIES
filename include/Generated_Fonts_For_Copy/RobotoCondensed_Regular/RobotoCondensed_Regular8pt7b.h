#ifndef _ROBOTOCONDENSED_REGULAR8PT7B_H_
#define _ROBOTOCONDENSED_REGULAR8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x80, 0x2E, 0xDD, 0x80, 0x06, 0x94, 0x29, 0x60, 0x45, 0x98,
  0x66, 0xAC, 0x66, 0x67, 0xB7, 0xC0, 0xFE, 0x95, 0x56, 0x5D, 0x10, 0x04,
  0xF4, 0xC0, 0xC0, 0x00, 0x25, 0x25, 0x00, 0x69, 0x99, 0x96, 0x75, 0x50,
  0x69, 0x22, 0x4F, 0x74, 0x9A, 0xC0, 0x22, 0x6A, 0xF2, 0xD3, 0x13, 0x80,
  0x53, 0x5B, 0x80, 0xF2, 0x22, 0x44, 0x69, 0x66, 0x96, 0x76, 0xB2, 0xC0,
  0x00, 0x08, 0x71, 0x80, 0xF0, 0x98, 0x74, 0xA0, 0x80, 0x31, 0x29, 0x6D,
  0xB6, 0xD4, 0x0C, 0x22, 0x65, 0x79, 0xD6, 0xFB, 0xC0, 0x65, 0x88, 0x97,
  0xD6, 0xDB, 0x80, 0xF2, 0x69, 0xC0, 0xF2, 0x69, 0x00, 0x69, 0x8B, 0x97,
  0x16, 0xFB, 0x40, 0x7C, 0x04, 0x9A, 0xC0, 0x3B, 0x6D, 0x40, 0x12, 0x49,
  0xC0, 0x99, 0x9F, 0xFB, 0x16, 0xFB, 0x40, 0x65, 0x99, 0x97, 0xD6, 0xE9,
  0x00, 0x69, 0x99, 0x97, 0x10, 0xD6, 0xEB, 0x40, 0x69, 0x42, 0x97, 0xF2,
  0x22, 0x22, 0x36, 0xDB, 0xC0, 0x99, 0x56, 0x62, 0x86, 0x57, 0x5E, 0x49,
  0x20, 0x95, 0x62, 0x69, 0x95, 0x62, 0x22, 0xF2, 0x24, 0x4F, 0xFF, 0x91,
  0x24, 0x40, 0xFF, 0x4A, 0x80, 0xE0, 0x40, 0x6E, 0xB0, 0x93, 0x5B, 0x80,
  0xF2, 0x30, 0x27, 0xDA, 0xC0, 0x7E, 0x30, 0x55, 0x50, 0xF6, 0xB2, 0xC0,
  0xAF, 0xF0, 0x3C, 0xBF, 0x93, 0x4D, 0x80, 0xFC, 0xFD, 0x6B, 0x50, 0xFF,
  0x69, 0x96, 0xD6, 0xE8, 0x00, 0xF6, 0xB2, 0x00, 0xF0, 0xE8, 0xB0, 0x55,
  0x40, 0xFF, 0xAD, 0x20, 0xAD, 0x54, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00,
  0x69, 0x70, 0x56, 0x54, 0x7E, 0x15, 0x58, 0x70,
};

const GFXglyph RobotoCondensed_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 3, 6, 4, 1, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 1, 0, -6 },
  { 18, 1, 8, 3, 1, -6 },
  { 19, 2, 8, 3, 0, -6 },
  { 21, 3, 4, 3, 0, -6 },
  { 23, 4, 4, 4, 0, -5 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 2, 1, -1 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 4, 6, 4, 0, -6 },
  { 34, 2, 6, 4, 1, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 3, 6, 4, 1, -6 },
  { 48, 3, 6, 4, 1, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 3, 6, 4, 0, -6 },
  { 60, 1, 4, 2, 0, -4 },
  { 61, 1, 5, 2, 0, -4 },
  { 62, 3, 3, 4, 0, -4 },
  { 64, 2, 2, 4, 1, -4 },
  { 65, 2, 3, 4, 1, -4 },
  { 66, 3, 6, 3, 0, -6 },
  { 69, 6, 8, 6, 0, -6 },
  { 75, 4, 6, 5, 0, -6 },
  { 78, 3, 6, 4, 1, -6 },
  { 81, 4, 6, 5, 0, -6 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 3, 6, 4, 1, -6 },
  { 90, 3, 6, 4, 1, -6 },
  { 93, 4, 6, 5, 0, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 1, 6, 2, 1, -6 },
  { 100, 3, 6, 4, 0, -6 },
  { 103, 3, 6, 4, 1, -6 },
  { 106, 3, 6, 4, 1, -6 },
  { 109, 4, 6, 6, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 0, -6 },
  { 118, 3, 6, 4, 1, -6 },
  { 121, 4, 7, 5, 0, -6 },
  { 125, 3, 6, 4, 1, -6 },
  { 128, 4, 6, 4, 0, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 6, 6, 6, 0, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 4, 6, 4, 0, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 1, 8, 2, 1, -7 },
  { 155, 3, 6, 3, 0, -6 },
  { 158, 1, 8, 2, 0, -7 },
  { 159, 3, 3, 3, 0, -6 },
  { 161, 3, 1, 3, 0, 0 },
  { 162, 2, 1, 2, 0, -6 },
  { 163, 3, 4, 4, 0, -4 },
  { 165, 3, 6, 4, 1, -6 },
  { 168, 3, 4, 4, 0, -4 },
  { 170, 3, 6, 4, 0, -6 },
  { 173, 3, 4, 4, 0, -4 },
  { 175, 2, 6, 3, 0, -6 },
  { 177, 3, 6, 4, 0, -4 },
  { 180, 2, 6, 4, 1, -6 },
  { 182, 1, 6, 2, 0, -6 },
  { 183, 1, 8, 2, 0, -6 },
  { 184, 3, 6, 4, 1, -6 },
  { 187, 1, 6, 2, 0, -6 },
  { 188, 5, 4, 6, 1, -4 },
  { 191, 2, 4, 4, 1, -4 },
  { 192, 4, 4, 4, 0, -4 },
  { 194, 3, 6, 4, 1, -4 },
  { 197, 3, 6, 4, 0, -4 },
  { 200, 1, 4, 2, 1, -4 },
  { 201, 3, 4, 4, 0, -4 },
  { 203, 2, 5, 2, 0, -5 },
  { 205, 2, 4, 4, 1, -4 },
  { 206, 3, 4, 3, 0, -4 },
  { 208, 5, 4, 5, 0, -4 },
  { 211, 3, 4, 4, 0, -4 },
  { 213, 3, 6, 3, 0, -4 },
  { 216, 3, 4, 4, 0, -4 },
  { 218, 2, 7, 2, 0, -6 },
  { 220, 1, 7, 2, 0, -6 },
  { 221, 2, 7, 2, 0, -6 },
  { 223, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoCondensed_Regular8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_REGULAR8PT7B_H_
