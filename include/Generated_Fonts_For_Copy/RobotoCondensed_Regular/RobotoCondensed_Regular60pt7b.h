#ifndef _ROBOTOCONDENSED_REGULAR60PT7B_H_
#define _ROBOTOCONDENSED_REGULAR60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x40, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0x1F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xF0,
  0x0F, 0xC7, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x01, 0x00, 0xF0, 0x1E, 0x01,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x0E,
  0x00, 0xF0, 0x1E, 0x1E, 0x00, 0xF0, 0x1E, 0x1C, 0x00, 0x78, 0x3C, 0x3C,
  0x00, 0x7C, 0x7C, 0x78, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x1F, 0xF8, 0xF0,
  0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x01, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x0F, 0x1F,
  0xFE, 0x00, 0x1E, 0x3E, 0x3E, 0x00, 0x1E, 0x3C, 0x1F, 0x00, 0x3C, 0x3C,
  0x0F, 0x00, 0x3C, 0x78, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x70, 0x78,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0x80, 0x3C,
  0x1F, 0x00, 0x80, 0x3E, 0x1E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x03, 0xE1, 0xF9, 0xF8, 0x1F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC,
  0x1F, 0x87, 0xC7, 0xC0, 0xFC, 0x3E, 0x7E, 0x03, 0xF1, 0xE3, 0xE0, 0x0F,
  0xDF, 0x1F, 0x00, 0x7F, 0xF8, 0xF8, 0x01, 0xFF, 0xC7, 0xC0, 0x07, 0xFC,
  0x3E, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0xC1, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0x01, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x03,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x08, 0x80, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C, 0x02, 0x7C, 0x3C,
  0x1E, 0xFF, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xEF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x83,
  0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0xE0, 0x02, 0x00,
  0x40, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x78,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFB, 0xFF, 0xFF,
  0xEF, 0x84, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x0F,
  0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F, 0x81, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0x83, 0xF8, 0x7E, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xF0, 0x7F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF8,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x80,
  0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x3F,
  0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC3, 0xF0, 0x3F, 0x87, 0xC0, 0x3F, 0x81, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xE0,
  0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0xF9, 0xFF, 0xC1, 0xF7,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0x8F, 0xF0, 0x3F, 0x9F, 0xC0,
  0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07,
  0xF0, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x7F, 0x80,
  0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F,
  0x83, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xC0,
  0x07, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0xFF, 0x3F, 0x03, 0xFE,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB, 0xE0, 0x7F, 0xE7, 0xC0,
  0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xEF,
  0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xEF, 0xFF, 0xFF, 0xBE, 0x10,
  0x0F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF8, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE3, 0xF0, 0xF0, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x1F, 0x80, 0x1E, 0x1E, 0x00,
  0x7F, 0xE0, 0x1E, 0x1E, 0x00, 0xFF, 0xF0, 0x0E, 0x3C, 0x01, 0xFF, 0xF8,
  0x0E, 0x3C, 0x01, 0xF0, 0x78, 0x0F, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x78,
  0x03, 0xC0, 0x78, 0x0F, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x78, 0x07, 0x80,
  0xF0, 0x07, 0x78, 0x0F, 0x80, 0xF0, 0x07, 0x78, 0x0F, 0x00, 0xF0, 0x07,
  0x78, 0x0F, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xF0, 0x1F,
  0x00, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0xF0,
  0x07, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0,
  0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF0, 0x0E, 0xF0, 0x1E, 0x01,
  0xF0, 0x0E, 0x78, 0x1F, 0x01, 0xF0, 0x1E, 0x78, 0x1F, 0x03, 0xF0, 0x1E,
  0x78, 0x1F, 0x03, 0xF0, 0x3C, 0x78, 0x0F, 0x87, 0xF0, 0x3C, 0x78, 0x0F,
  0xFF, 0xF8, 0xF8, 0x7C, 0x07, 0xFE, 0x7F, 0xF0, 0x3C, 0x07, 0xFC, 0x7F,
  0xE0, 0x3C, 0x03, 0xF8, 0x3F, 0xC0, 0x3E, 0x00, 0x40, 0x04, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x01, 0xFE,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFE, 0x3E, 0x00, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x07,
  0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x07, 0xE0,
  0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0x7D, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x3F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xDF, 0xFF, 0xC0, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x07, 0xDF,
  0xFB, 0xE0, 0x00, 0xF9, 0xFF, 0xBE, 0x00, 0x0F, 0x9F, 0xF9, 0xF0, 0x00,
  0xF9, 0xFF, 0x9F, 0x00, 0x1F, 0x1F, 0xF9, 0xF0, 0x01, 0xF1, 0xFF, 0x8F,
  0x80, 0x1F, 0x1F, 0xF8, 0xF8, 0x03, 0xE3, 0xFF, 0x8F, 0x80, 0x3E, 0x3F,
  0xF8, 0x7C, 0x03, 0xE3, 0xFF, 0x87, 0xC0, 0x7C, 0x3F, 0xF8, 0x7C, 0x07,
  0xC3, 0xFF, 0x83, 0xE0, 0x7C, 0x3F, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0x83,
  0xE0, 0xF8, 0x3F, 0xF8, 0x1F, 0x0F, 0x83, 0xFF, 0x81, 0xF1, 0xF0, 0x3F,
  0xF8, 0x1F, 0x1F, 0x03, 0xFF, 0x80, 0xF9, 0xF0, 0x3F, 0xF8, 0x0F, 0xBE,
  0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xBE, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFD, 0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x3F, 0xF3, 0xE0, 0x07, 0xFE, 0x7C,
  0x00, 0xFF, 0xC7, 0xC0, 0x1F, 0xF8, 0xFC, 0x03, 0xFF, 0x0F, 0x80, 0x7F,
  0xE1, 0xF8, 0x0F, 0xFC, 0x1F, 0x01, 0xFF, 0x83, 0xF0, 0x3F, 0xF0, 0x3E,
  0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x07, 0xC3, 0xFF,
  0x00, 0xF8, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0x1F,
  0x3F, 0xF0, 0x03, 0xE7, 0xFE, 0x00, 0x3E, 0xFF, 0xC0, 0x07, 0xDF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x1F, 0xCF, 0x80,
  0x03, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFE, 0xF8, 0x00, 0x7F, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x01, 0xFC, 0x01,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x01,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x02, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x7F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC1, 0xFE, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0,
  0x0F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xF0, 0x00, 0xFD,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xFE,
  0x00, 0x7E, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0xF0, 0x07,
  0xC3, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xEF, 0x00, 0x7C, 0x1F,
  0x00, 0xFB, 0xC0, 0x1F, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC7, 0x80, 0xF8, 0x1F, 0x01, 0xF1, 0xE0,
  0x3E, 0x03, 0xE0, 0x78, 0x78, 0x0F, 0x80, 0xF8, 0x1E, 0x1F, 0x07, 0xE0,
  0x3E, 0x07, 0x87, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x03,
  0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x1E, 0x3E,
  0x00, 0x7C, 0x78, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0x80, 0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x3C, 0x00, 0x3E, 0xF0,
  0x03, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xBC, 0x03, 0xCF,
  0x00, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x1E, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0xF8,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0x80, 0x7E,
  0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x03, 0xF3, 0xF8,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF3, 0xF0, 0x1F,
  0xE7, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0x0F, 0xFF, 0x3E,
  0x07, 0xF8, 0x7E, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x80, 0x1F, 0x1F, 0xF0, 0x3E, 0x7F,
  0xF8, 0x7D, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xF3, 0xF8, 0x07,
  0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x7F, 0x00,
  0xFC, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0xE3, 0xEF, 0xFF, 0xC7, 0xCF, 0xFF,
  0x0F, 0x8F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF8, 0x01,
  0xF3, 0xF0, 0x07, 0xE3, 0xF8, 0x1F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x02, 0x03, 0xE0, 0x7F,
  0xC7, 0xC3, 0xFF, 0xCF, 0x8F, 0xFF, 0xDF, 0x3F, 0xFF, 0xFE, 0x7F, 0x07,
  0xFD, 0xFC, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x80, 0x7F, 0x3F, 0x83, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFE,
  0xF8, 0x7F, 0xF9, 0xF0, 0x3F, 0xE3, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x63, 0xF8, 0x01, 0xE3, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x07,
  0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFD, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0,
  0x7F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF8, 0x07, 0xF3, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xEF, 0x87, 0xFF, 0x9F, 0x03, 0xFE, 0x3E, 0x00, 0x40, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x86, 0x00, 0x3F,
  0x0F, 0x00, 0xFC, 0x3F, 0xDF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x7F, 0xC3, 0xE7, 0xFF, 0x1F, 0x7F, 0xFC,
  0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xBF, 0x80, 0x7D, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0x80, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x07, 0xEF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xE3, 0xE0, 0x3F,
  0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F,
  0x8F, 0xC0, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0x9F, 0x00, 0xFC, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x3E,
  0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x01,
  0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3F,
  0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC7, 0xFC, 0x07, 0xFC, 0x3E, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xC3, 0xFB,
  0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xFC, 0x3E, 0x7F,
  0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFB, 0xF8, 0x07, 0xDF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x01, 0xF1, 0xFF, 0x03, 0xE7, 0xFF, 0x87, 0xDF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0x7E, 0x7E, 0x00,
  0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xF0, 0x0F, 0xCF, 0xF0,
  0x3F, 0x9F, 0xFF, 0xFE, 0x3E, 0xFF, 0xFC, 0x7C, 0xFF, 0xF0, 0xF8, 0xFF,
  0x81, 0xF0, 0x10, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFD, 0xF3,
  0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF3, 0xF8, 0x1F, 0xE7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0x03, 0xFE, 0x7E, 0x00,
  0x40, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x83, 0xF9, 0xF8, 0x07, 0xEF, 0x80,
  0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x08, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0xFE, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0x1F, 0x00, 0x80, 0x00, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0,
  0x07, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0x80, 0x1F, 0x7C, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x80,
  0x1F, 0x3E, 0x01, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0xC0, 0x3E, 0x3E, 0x01,
  0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x3E, 0x1E, 0x03, 0xFE, 0x03, 0xC1,
  0xF0, 0x3F, 0xE0, 0x7C, 0x1F, 0x03, 0xDE, 0x07, 0xC1, 0xF0, 0x7D, 0xF0,
  0x7C, 0x1F, 0x07, 0xDF, 0x07, 0x80, 0xF8, 0x78, 0xF0, 0xF8, 0x0F, 0x87,
  0x8F, 0x0F, 0x80, 0xF8, 0xF8, 0xF8, 0xF8, 0x0F, 0x8F, 0x0F, 0x8F, 0x00,
  0x78, 0xF0, 0x78, 0xF0, 0x07, 0xDF, 0x07, 0x9F, 0x00, 0x7D, 0xF0, 0x7D,
  0xF0, 0x07, 0xDE, 0x07, 0xDE, 0x00, 0x3D, 0xE0, 0x3D, 0xE0, 0x03, 0xFE,
  0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0xF8, 0x01,
  0xF9, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFC,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0x1F, 0xF8, 0x01, 0xF3, 0xFF, 0xE0, 0x1F, 0x7F, 0xFE,
  0x01, 0xE7, 0xC3, 0xF0, 0x3E, 0xF8, 0x1F, 0x83, 0xEF, 0x80, 0xFF, 0xFC,
  0xF0, 0x07, 0xFF, 0xCF, 0x00, 0x3F, 0xF8, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 44, 15, 5, -43 },
  { 29, 12, 14, 19, 4, -45 },
  { 50, 27, 43, 33, 4, -43 },
  { 196, 23, 56, 30, 3, -50 },
  { 357, 32, 45, 38, 3, -44 },
  { 537, 29, 45, 33, 3, -44 },
  { 701, 4, 14, 10, 3, -45 },
  { 708, 13, 62, 19, 4, -48 },
  { 809, 13, 62, 19, 2, -48 },
  { 910, 24, 25, 26, 1, -43 },
  { 985, 24, 31, 30, 3, -35 },
  { 1078, 8, 15, 12, 1, -6 },
  { 1093, 13, 4, 15, 1, -20 },
  { 1100, 7, 7, 16, 4, -6 },
  { 1107, 19, 47, 22, 1, -43 },
  { 1219, 23, 45, 30, 3, -44 },
  { 1349, 14, 43, 30, 5, -43 },
  { 1425, 24, 44, 30, 3, -44 },
  { 1557, 23, 45, 30, 3, -44 },
  { 1687, 26, 43, 30, 2, -43 },
  { 1827, 23, 44, 30, 4, -43 },
  { 1954, 23, 44, 30, 4, -43 },
  { 2081, 24, 43, 30, 3, -43 },
  { 2210, 23, 45, 30, 3, -44 },
  { 2340, 23, 44, 30, 3, -44 },
  { 2467, 7, 33, 14, 4, -32 },
  { 2496, 9, 41, 12, 1, -32 },
  { 2543, 20, 26, 27, 2, -32 },
  { 2608, 21, 18, 29, 4, -29 },
  { 2656, 21, 26, 28, 4, -32 },
  { 2725, 21, 45, 25, 2, -44 },
  { 2844, 40, 55, 46, 3, -42 },
  { 3119, 32, 43, 35, 1, -43 },
  { 3291, 24, 43, 33, 5, -43 },
  { 3420, 27, 45, 34, 4, -44 },
  { 3572, 26, 43, 34, 5, -43 },
  { 3712, 23, 43, 30, 5, -43 },
  { 3836, 22, 43, 29, 5, -43 },
  { 3955, 27, 45, 35, 4, -44 },
  { 4107, 28, 43, 37, 5, -43 },
  { 4258, 5, 43, 15, 5, -43 },
  { 4285, 23, 44, 29, 2, -43 },
  { 4412, 27, 43, 33, 5, -43 },
  { 4558, 22, 43, 29, 5, -43 },
  { 4677, 36, 43, 45, 5, -43 },
  { 4871, 27, 43, 37, 5, -43 },
  { 5017, 28, 45, 36, 4, -44 },
  { 5175, 26, 43, 33, 5, -43 },
  { 5315, 30, 51, 36, 3, -44 },
  { 5507, 26, 43, 32, 5, -43 },
  { 5647, 27, 45, 31, 2, -44 },
  { 5799, 28, 43, 31, 2, -43 },
  { 5950, 26, 44, 34, 4, -43 },
  { 6093, 31, 43, 34, 1, -43 },
  { 6260, 42, 43, 46, 2, -43 },
  { 6486, 29, 43, 33, 2, -43 },
  { 6642, 30, 43, 32, 1, -43 },
  { 6804, 26, 43, 31, 3, -43 },
  { 6944, 10, 58, 15, 4, -49 },
  { 7017, 19, 47, 22, 2, -43 },
  { 7129, 10, 58, 15, 1, -49 },
  { 7202, 18, 21, 22, 2, -43 },
  { 7250, 23, 4, 24, 1, 0 },
  { 7262, 12, 9, 19, 2, -45 },
  { 7276, 23, 34, 29, 3, -33 },
  { 7374, 23, 46, 30, 4, -45 },
  { 7507, 23, 34, 28, 3, -33 },
  { 7605, 23, 46, 30, 3, -45 },
  { 7738, 23, 34, 28, 3, -33 },
  { 7836, 16, 46, 19, 2, -46 },
  { 7928, 23, 45, 30, 3, -33 },
  { 8058, 21, 45, 29, 4, -45 },
  { 8177, 6, 43, 14, 4, -43 },
  { 8210, 10, 55, 13, -1, -43 },
  { 8279, 22, 45, 27, 4, -45 },
  { 8403, 5, 45, 14, 4, -45 },
  { 8432, 37, 33, 45, 4, -33 },
  { 8585, 21, 33, 29, 4, -33 },
  { 8672, 24, 34, 30, 3, -33 },
  { 8774, 23, 45, 30, 4, -33 },
  { 8904, 23, 45, 30, 3, -33 },
  { 9034, 13, 33, 18, 4, -33 },
  { 9088, 21, 34, 27, 3, -33 },
  { 9178, 14, 40, 18, 1, -39 },
  { 9248, 21, 33, 29, 4, -32 },
  { 9335, 23, 32, 26, 1, -32 },
  { 9427, 36, 32, 39, 1, -32 },
  { 9571, 23, 32, 26, 2, -32 },
  { 9663, 23, 44, 25, 1, -32 },
  { 9790, 21, 32, 26, 3, -32 },
  { 9874, 15, 58, 18, 2, -47 },
  { 9983, 5, 51, 15, 5, -43 },
  { 10015, 15, 58, 18, 1, -47 },
  { 10124, 28, 12, 35, 4, -24 },
};

const GFXfont RobotoCondensed_Regular60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_REGULAR60PT7B_H_
