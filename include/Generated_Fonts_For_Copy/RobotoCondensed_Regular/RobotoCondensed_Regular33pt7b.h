#ifndef _ROBOTOCONDENSED_REGULAR33PT7B_H_
#define _ROBOTOCONDENSED_REGULAR33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xC0, 0x0D, 0xF0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0x62, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0x60, 0x38,
  0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8E, 0x3F, 0xFF, 0x7F, 0xFE, 0x1C, 0x60,
  0x30, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x3F, 0xFF, 0x7F, 0xFE, 0x18,
  0x60, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x07, 0x18, 0x0C, 0x30,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0x03, 0xFC, 0x3F, 0xF1, 0xC3,
  0xCE, 0x0E, 0x60, 0x73, 0x03, 0x9C, 0x1C, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0x80, 0x1D, 0xC0, 0x7E, 0x03, 0xF0,
  0x3B, 0xC1, 0xCF, 0xFE, 0x3F, 0xE0, 0xFC, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x39, 0x80, 0x18, 0x61, 0x8C, 0x31, 0xC6,
  0x18, 0xC3, 0x0C, 0xC1, 0x86, 0x60, 0xE6, 0x60, 0x3F, 0x30, 0x0F, 0x30,
  0x00, 0x18, 0x00, 0x19, 0xE0, 0x1D, 0xF8, 0x0C, 0xC6, 0x0C, 0xE3, 0x06,
  0x61, 0x86, 0x30, 0xC3, 0x18, 0x63, 0x0C, 0x30, 0x83, 0x18, 0x01, 0xF8,
  0x00, 0x78, 0x0F, 0x80, 0x1F, 0xC0, 0x3D, 0xE0, 0x78, 0xE0, 0x70, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x1F, 0x80, 0x1E, 0x00,
  0x3E, 0x00, 0x7F, 0x0C, 0x73, 0x8C, 0xE3, 0xCC, 0xE1, 0xDC, 0xE0, 0xFC,
  0xE0, 0xF8, 0xE0, 0x78, 0xF0, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x8E,
  0xFF, 0xFF, 0x02, 0x0C, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70,
  0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x04, 0x81, 0x83, 0x83, 0x83,
  0x07, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC3, 0x86, 0x1C, 0x70,
  0xC1, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x63, 0x09, 0xFD,
  0xE7, 0xFF, 0xC3, 0xF0, 0x07, 0x80, 0x3F, 0x01, 0xCE, 0x07, 0x38, 0x38,
  0x70, 0x00, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x39, 0xCE, 0x73,
  0xB9, 0xCC, 0xFF, 0xF0, 0x2F, 0xF7, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x7F, 0xE3, 0xFC, 0x0F,
  0x80, 0x02, 0x3D, 0xFF, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1F, 0x81,
  0xFE, 0x1F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0x83, 0xFC, 0x7F, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x7B, 0xE3, 0xFC, 0x1F, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0D, 0xC0, 0x77, 0x01,
  0x9C, 0x0E, 0x70, 0x31, 0xC1, 0xC7, 0x06, 0x1C, 0x38, 0x71, 0xC1, 0xC7,
  0x07, 0x38, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0x83, 0xFF, 0x1F, 0xFC, 0xE0, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x3B, 0x01, 0xDC, 0x1E, 0xE0,
  0xE3, 0xDF, 0x0F, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x78,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE7, 0x87, 0xFF, 0x3F, 0x79,
  0xE0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x01, 0x9C,
  0x1C, 0xE0, 0xE3, 0xDE, 0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x76,
  0x07, 0x70, 0xE3, 0xFE, 0x1F, 0xC3, 0xFC, 0x70, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0x7D, 0xE3, 0xFC, 0x1F, 0x80,
  0x1F, 0x03, 0xFC, 0x7F, 0xCF, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xF3, 0xFF, 0x1E, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x3F, 0x83, 0xF0, 0x3C, 0x00, 0x2F,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2F, 0xF6, 0x23, 0x9E, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x9C, 0xCE, 0x20, 0x00, 0x20,
  0x0C, 0x07, 0x83, 0xF1, 0xF8, 0x7C, 0x3E, 0x07, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x01, 0xF0,
  0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFC,
  0x7F, 0xE7, 0x0E, 0xE0, 0x6E, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x78, 0x3C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00,
  0xC3, 0x00, 0x03, 0x9C, 0x0F, 0x06, 0x60, 0x7E, 0x19, 0x83, 0x98, 0x6E,
  0x1C, 0x60, 0xF0, 0x61, 0x83, 0xC3, 0x86, 0x0F, 0x0C, 0x18, 0x3C, 0x30,
  0x60, 0xF0, 0xC1, 0x83, 0xC3, 0x06, 0x0F, 0x0C, 0x18, 0x6C, 0x30, 0xE1,
  0xB0, 0xC3, 0x86, 0xC3, 0xDE, 0x33, 0x87, 0xDF, 0xC6, 0x0E, 0x3C, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC1,
  0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0C, 0x60,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xE6, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xFF, 0x87, 0xFF, 0x3F,
  0xFD, 0xC0, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0x77, 0xFF,
  0x3F, 0xF1, 0xFF, 0xCE, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0x7F, 0xF3, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xC0, 0xE7, 0x01, 0xEE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0xC0, 0xE3,
  0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x38,
  0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B,
  0x80, 0xEE, 0x03, 0xB8, 0x3C, 0xFF, 0xF3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xC0, 0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0xC0, 0x73, 0xFF,
  0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xE1, 0xE7, 0xFE, 0x1F, 0xF0, 0x3E, 0x00,
  0xE0, 0x3D, 0xC0, 0x73, 0x81, 0xC7, 0x07, 0x8E, 0x1E, 0x1C, 0x38, 0x38,
  0xE0, 0x73, 0xC0, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1E, 0xF0, 0x38, 0xE0, 0x70, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0x81, 0xC7,
  0x03, 0xCE, 0x03, 0x9C, 0x07, 0xB8, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xF6, 0x01, 0xDE,
  0xE0, 0x3B, 0xDC, 0x07, 0x79, 0x81, 0xCF, 0x38, 0x39, 0xE7, 0x07, 0x7C,
  0x61, 0xCF, 0x8E, 0x39, 0xF1, 0xC7, 0x3E, 0x18, 0xC7, 0xC3, 0xB8, 0xF8,
  0x76, 0x1F, 0x06, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x81, 0xC1, 0xF0,
  0x38, 0x38, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x01, 0xFF, 0x03, 0xF6, 0x07, 0xEE, 0x0F, 0xCE, 0x1F, 0x9C, 0x3F, 0x1C,
  0x7E, 0x38, 0xFC, 0x39, 0xF8, 0x73, 0xF0, 0x77, 0xE0, 0xEF, 0xC0, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0x80, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E,
  0x78, 0x1C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1C, 0x70, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0,
  0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x07, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0xE3, 0x83, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xC0,
  0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xC1, 0xE7, 0x01, 0xCE, 0x01, 0xDC,
  0x03, 0xB8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0x00, 0x07, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B,
  0xC0, 0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3B, 0x80, 0x73, 0x81, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF0, 0x00,
  0xE0, 0x07, 0xF0, 0x03, 0xBC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0xC0,
  0x70, 0xE0, 0x38, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03,
  0x87, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x0C, 0xE0, 0x07, 0x70,
  0x03, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1D, 0xC0, 0xF0, 0x3B, 0x81, 0xE0,
  0x77, 0x07, 0xC1, 0xCE, 0x0F, 0x83, 0x9C, 0x1B, 0x07, 0x18, 0x37, 0x0E,
  0x38, 0x66, 0x1C, 0x71, 0xCC, 0x30, 0xE3, 0x98, 0xE1, 0xC6, 0x39, 0xC1,
  0x8C, 0x73, 0x83, 0xB8, 0x67, 0x07, 0x70, 0xCC, 0x0E, 0xC1, 0xF8, 0x1D,
  0x83, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0F, 0x70, 0x0E,
  0x38, 0x1E, 0x38, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x0E, 0x78, 0x0E, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x38, 0x1C, 0x3C, 0x38, 0x1C,
  0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0x70, 0x07, 0xB8, 0x03, 0x8E, 0x03,
  0xC7, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x70, 0x0E,
  0x38, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8F, 0xFF, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x7F, 0xFF, 0x0C, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0x0E, 0xC3, 0x30, 0xCE,
  0x73, 0x98, 0x66, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0x70, 0x07, 0x00,
  0x71, 0xFF, 0x3F, 0xF7, 0x87, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF,
  0xF7, 0xF7, 0x3E, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0xC7, 0xFF, 0x3F, 0xFD, 0xE0, 0xEE,
  0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0x78, 0x3B, 0xFF, 0xDF, 0xFC, 0xE7, 0xC0, 0x1F, 0x83, 0xFC,
  0x7F, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x07, 0xE0, 0x7E, 0x07, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1F,
  0x77, 0xFF, 0x7F, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x7F, 0xF3, 0xFF, 0x1F,
  0x70, 0x1F, 0x83, 0xFC, 0x7F, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x02, 0x7D, 0xF3,
  0xFE, 0x1F, 0x80, 0x07, 0x87, 0xC7, 0xE3, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0xFF, 0x7F, 0x8E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x1F, 0x37, 0xFF, 0x7F,
  0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x7F, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x60, 0xF7, 0xBE, 0x7F, 0xC1, 0xF8, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFE, 0xFF,
  0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFD, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xCE, 0x00, 0x00, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF,
  0xFF, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0xE7, 0x0F, 0x38, 0x71, 0xC7, 0x0E, 0x70, 0x77,
  0x83, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xB8, 0x39, 0xC1, 0xC7, 0x0E, 0x1C,
  0x70, 0xE3, 0x83, 0x9C, 0x1E, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE7, 0x87, 0xC7, 0xFF, 0x7F, 0x3F, 0xFF,
  0xFD, 0xE1, 0xF0, 0xEE, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC,
  0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0,
  0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0,
  0x70, 0x38, 0xE7, 0x8E, 0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0x0F, 0x81, 0xFF, 0x1F, 0x7D, 0xE0, 0xEE, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x39, 0xF7, 0xC7, 0xFC, 0x0F, 0x80, 0xE7, 0xC7, 0xFF, 0x3F,
  0xFD, 0xE0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0x78, 0x3B, 0xFF, 0xDF, 0xFC, 0xE7, 0xC7,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1F,
  0x77, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x7D, 0xF7, 0xFF, 0x1F,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xEF,
  0xFF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0x1F, 0x0F, 0xF9, 0xEF, 0xF0, 0x7E, 0x0F, 0xC0, 0x1C, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xC1, 0xFE, 0xFB, 0xFE,
  0x1F, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xF0, 0xF8, 0x3C, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F,
  0x7F, 0xF7, 0xFF, 0x1E, 0x70, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x70,
  0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x19, 0x81, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0xE0, 0x6E, 0x0E, 0x0E,
  0xE0, 0xF0, 0xE6, 0x0F, 0x0E, 0x71, 0xF0, 0xC7, 0x1B, 0x0C, 0x71, 0xB9,
  0xC3, 0x3B, 0x9C, 0x3B, 0x99, 0x83, 0xB1, 0x98, 0x3B, 0x1F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0x70, 0x0C,
  0x06, 0x00, 0xE0, 0x73, 0x87, 0x9C, 0x38, 0x73, 0xC1, 0x9C, 0x0F, 0xC0,
  0x3E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x3B, 0x03, 0x9C, 0x1C,
  0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x70, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x31, 0xC3, 0x9C, 0x39, 0xC3, 0x98, 0x1B, 0x81, 0xF8,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0x07, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xF0, 0x38,
  0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x1E,
  0x0F, 0x0F, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x70, 0xE0, 0x80, 0x1E, 0x06, 0xFE, 0x0D, 0xFE, 0x3F, 0x1F,
  0xFE, 0x1F, 0xC0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 23, 8, 3, -23 },
  { 10, 7, 8, 11, 2, -25 },
  { 17, 15, 23, 18, 2, -23 },
  { 61, 13, 29, 16, 2, -26 },
  { 109, 17, 23, 21, 2, -23 },
  { 158, 16, 23, 18, 2, -23 },
  { 204, 2, 8, 6, 2, -25 },
  { 206, 7, 34, 10, 2, -26 },
  { 236, 7, 34, 11, 1, -26 },
  { 266, 14, 14, 14, 0, -23 },
  { 291, 14, 17, 16, 1, -20 },
  { 321, 5, 8, 7, 0, -4 },
  { 326, 6, 2, 8, 1, -11 },
  { 328, 4, 4, 9, 2, -4 },
  { 330, 10, 25, 12, 1, -23 },
  { 362, 12, 23, 16, 2, -23 },
  { 397, 7, 23, 16, 3, -23 },
  { 418, 13, 23, 16, 2, -23 },
  { 456, 12, 23, 16, 2, -23 },
  { 491, 14, 23, 16, 1, -23 },
  { 532, 13, 23, 16, 2, -23 },
  { 570, 13, 23, 16, 2, -23 },
  { 608, 14, 23, 16, 1, -23 },
  { 649, 12, 23, 16, 2, -23 },
  { 684, 12, 23, 16, 2, -23 },
  { 719, 4, 18, 8, 2, -18 },
  { 728, 5, 22, 7, 1, -18 },
  { 742, 11, 15, 15, 1, -18 },
  { 763, 12, 10, 16, 2, -16 },
  { 778, 12, 15, 15, 2, -18 },
  { 801, 12, 23, 14, 1, -23 },
  { 836, 22, 30, 25, 2, -23 },
  { 919, 17, 23, 19, 1, -23 },
  { 968, 13, 23, 18, 3, -23 },
  { 1006, 15, 23, 19, 2, -23 },
  { 1050, 14, 23, 19, 3, -23 },
  { 1091, 12, 23, 16, 3, -23 },
  { 1126, 12, 23, 16, 3, -23 },
  { 1161, 15, 23, 20, 2, -23 },
  { 1205, 15, 23, 20, 3, -23 },
  { 1249, 3, 23, 8, 3, -23 },
  { 1258, 13, 23, 16, 1, -23 },
  { 1296, 15, 23, 18, 3, -23 },
  { 1340, 12, 23, 16, 3, -23 },
  { 1375, 19, 23, 25, 3, -23 },
  { 1430, 15, 23, 20, 3, -23 },
  { 1474, 16, 23, 20, 2, -23 },
  { 1520, 14, 23, 18, 3, -23 },
  { 1561, 16, 27, 20, 2, -23 },
  { 1615, 14, 23, 18, 3, -23 },
  { 1656, 15, 23, 17, 1, -23 },
  { 1700, 15, 23, 17, 1, -23 },
  { 1744, 15, 23, 19, 2, -23 },
  { 1788, 17, 23, 19, 1, -23 },
  { 1837, 23, 23, 25, 1, -23 },
  { 1904, 16, 23, 18, 1, -23 },
  { 1950, 17, 23, 17, 0, -23 },
  { 1999, 15, 23, 17, 1, -23 },
  { 2043, 6, 32, 8, 2, -27 },
  { 2067, 11, 25, 12, 1, -23 },
  { 2102, 6, 32, 8, 0, -27 },
  { 2126, 10, 12, 12, 1, -23 },
  { 2141, 13, 2, 13, 0, 0 },
  { 2145, 7, 5, 10, 1, -25 },
  { 2150, 12, 17, 16, 2, -17 },
  { 2176, 13, 25, 16, 2, -25 },
  { 2217, 12, 17, 15, 2, -17 },
  { 2243, 12, 25, 16, 2, -25 },
  { 2281, 12, 17, 15, 2, -17 },
  { 2307, 9, 25, 10, 1, -25 },
  { 2336, 12, 24, 16, 2, -17 },
  { 2372, 12, 25, 16, 2, -25 },
  { 2410, 3, 23, 8, 2, -23 },
  { 2419, 5, 30, 7, 0, -23 },
  { 2438, 13, 25, 15, 2, -25 },
  { 2479, 3, 25, 8, 2, -25 },
  { 2489, 21, 17, 25, 2, -17 },
  { 2534, 12, 17, 16, 2, -17 },
  { 2560, 13, 17, 17, 2, -17 },
  { 2588, 13, 24, 16, 2, -17 },
  { 2627, 12, 24, 17, 2, -17 },
  { 2663, 7, 17, 10, 2, -17 },
  { 2678, 11, 17, 15, 2, -17 },
  { 2702, 9, 22, 10, 0, -22 },
  { 2727, 12, 17, 16, 2, -17 },
  { 2753, 12, 17, 14, 1, -17 },
  { 2779, 20, 17, 21, 1, -17 },
  { 2822, 13, 17, 14, 1, -17 },
  { 2850, 12, 24, 14, 1, -17 },
  { 2886, 11, 17, 14, 2, -17 },
  { 2910, 8, 32, 10, 1, -26 },
  { 2942, 2, 27, 8, 3, -23 },
  { 2949, 8, 32, 10, 1, -26 },
  { 2981, 15, 6, 19, 2, -13 },
};

const GFXfont RobotoCondensed_Regular33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_REGULAR33PT7B_H_
