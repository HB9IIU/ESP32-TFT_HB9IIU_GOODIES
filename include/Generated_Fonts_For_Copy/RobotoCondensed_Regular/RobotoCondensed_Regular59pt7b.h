#ifndef _ROBOTOCONDENSED_REGULAR59PT7B_H_
#define _ROBOTOCONDENSED_REGULAR59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x02,
  0x7F, 0xFF, 0xFF, 0xC8, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC1, 0xF0, 0x1F,
  0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF8, 0x01, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E,
  0x0E, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0xF0, 0x1E, 0x1C, 0x00, 0xF0, 0x1C,
  0x3C, 0x00, 0x78, 0x3C, 0x78, 0x00, 0x7C, 0x7C, 0x78, 0x00, 0x3F, 0xF8,
  0xF0, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x01, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x80, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x0F, 0x0F, 0xF8, 0x00, 0x0E,
  0x1F, 0xFC, 0x00, 0x1E, 0x3E, 0x3E, 0x00, 0x1C, 0x3C, 0x1E, 0x00, 0x3C,
  0x78, 0x1E, 0x00, 0x38, 0x78, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0x00, 0xF0,
  0x78, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0x80,
  0x3C, 0x1E, 0x00, 0x80, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xBF, 0x03, 0xC1, 0xF8, 0xF8, 0x1E, 0x1F, 0x87, 0xE0, 0xF0,
  0xF8, 0x1F, 0x87, 0x8F, 0xC0, 0x7E, 0x7C, 0x7C, 0x03, 0xF3, 0xE3, 0xE0,
  0x0F, 0xDF, 0x1F, 0x00, 0x3F, 0xF0, 0xF8, 0x01, 0xFF, 0x87, 0xC0, 0x07,
  0xFC, 0x3E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x7F, 0xC0, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0x3F, 0x80, 0xFF, 0xC0, 0xFC, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01,
  0x80, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x60, 0x01,
  0x00, 0x80, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x38,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x3C, 0x0E, 0x7E, 0x3C, 0x7E, 0xFF, 0xBD, 0xFE, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xC7, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x06,
  0x00, 0xE0, 0x02, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xDF,
  0x00, 0x1F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xE0,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x03, 0xF8,
  0x7E, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00,
  0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7,
  0xF0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xF0, 0x3F, 0x87, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE3,
  0xE0, 0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x87,
  0xE0, 0x3E, 0x7F, 0xE0, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF,
  0x3F, 0xC0, 0xFC, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F,
  0x01, 0xF0, 0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0xFC, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xF0, 0xF8, 0x03,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB,
  0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0xE0, 0xFE, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0x7E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xDF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xF7, 0xC1, 0xFF, 0x9F, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x39, 0xFB, 0xF7, 0xFF, 0xCF, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73,
  0xF7, 0xFF, 0xFF, 0x9F, 0x08, 0x0E, 0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC7, 0xC7, 0xE1,
  0xE0, 0x20, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xF8, 0xFE, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x80, 0x3C, 0x1E,
  0x00, 0x7F, 0xC0, 0x1C, 0x3C, 0x00, 0xFF, 0xF0, 0x1C, 0x3C, 0x01, 0xFF,
  0xF0, 0x1E, 0x3C, 0x03, 0xE0, 0xF0, 0x1E, 0x78, 0x03, 0xC0, 0xF0, 0x0E,
  0x78, 0x07, 0xC0, 0xF0, 0x0E, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x78, 0x0F,
  0x80, 0xF0, 0x0E, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x78, 0x0F, 0x00, 0xF0,
  0x0E, 0xF0, 0x1F, 0x00, 0xF0, 0x0E, 0xF0, 0x1F, 0x00, 0xF0, 0x0E, 0xF0,
  0x1E, 0x00, 0xF0, 0x0E, 0xF0, 0x1E, 0x01, 0xE0, 0x0E, 0xF0, 0x1E, 0x01,
  0xE0, 0x0E, 0xF0, 0x1E, 0x01, 0xE0, 0x0E, 0xF0, 0x1E, 0x01, 0xE0, 0x0E,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0xF0, 0x1E,
  0x01, 0xE0, 0x1C, 0x70, 0x1E, 0x03, 0xE0, 0x3C, 0x78, 0x1F, 0x07, 0xE0,
  0x3C, 0x78, 0x1F, 0x87, 0xF0, 0x78, 0x78, 0x0F, 0xFE, 0xF0, 0xF0, 0x78,
  0x0F, 0xFC, 0xFF, 0xF0, 0x3C, 0x07, 0xFC, 0x7F, 0xE0, 0x3C, 0x03, 0xF0,
  0x3F, 0x80, 0x3C, 0x00, 0x40, 0x04, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x01,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x0F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xC0, 0x1F,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80,
  0x3F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x1F, 0xC7, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x3E, 0x7E, 0x01, 0xF9, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xDF, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xC7, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC3,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x01,
  0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0xFC, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xDF, 0x00, 0x01, 0xFF, 0xFB,
  0xE0, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x0F, 0xBF, 0xE7, 0xC0, 0x01, 0xF7,
  0xFC, 0xF8, 0x00, 0x3E, 0xFF, 0x9F, 0x00, 0x0F, 0x9F, 0xF9, 0xF0, 0x01,
  0xF3, 0xFF, 0x3E, 0x00, 0x3E, 0x7F, 0xE7, 0xC0, 0x0F, 0x8F, 0xFC, 0x7C,
  0x01, 0xF1, 0xFF, 0x8F, 0x80, 0x3E, 0x3F, 0xF1, 0xF0, 0x0F, 0x87, 0xFE,
  0x1F, 0x01, 0xF0, 0xFF, 0xC3, 0xE0, 0x3E, 0x1F, 0xF8, 0x7C, 0x0F, 0x83,
  0xFF, 0x07, 0x81, 0xF0, 0x7F, 0xE0, 0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0x0F,
  0x81, 0xFF, 0x81, 0xE1, 0xF0, 0x3F, 0xF0, 0x3E, 0x3C, 0x07, 0xFE, 0x07,
  0xCF, 0x80, 0xFF, 0xC0, 0x79, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x03, 0xFF,
  0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00,
  0x3C, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFD, 0xF0, 0x01, 0xFF, 0xBE, 0x00, 0x3F, 0xF3,
  0xE0, 0x07, 0xFE, 0x7C, 0x00, 0xFF, 0xC7, 0xC0, 0x1F, 0xF8, 0xF8, 0x03,
  0xFF, 0x0F, 0x80, 0x7F, 0xE1, 0xF0, 0x0F, 0xFC, 0x1F, 0x01, 0xFF, 0x83,
  0xE0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F,
  0xF8, 0x07, 0xC3, 0xFF, 0x00, 0xF8, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x01,
  0xF1, 0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x03, 0xE7, 0xFE, 0x00, 0x3E, 0xFF,
  0xC0, 0x07, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80,
  0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8,
  0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xC0, 0x03, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xEF, 0x80, 0x07, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x04, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xC0, 0x0F, 0xE3, 0xE0, 0x01, 0xF9, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0x9F, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3E,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xF8, 0x03, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0x8F, 0xE0, 0x07, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xDF,
  0x00, 0x0F, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0x03, 0xF7, 0xC0, 0x03,
  0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF8, 0x00, 0xF9, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x1F,
  0x00, 0x7F, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0xE0, 0x0F, 0x87, 0xC0, 0x1E,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0x9E, 0x01,
  0xF0, 0x7C, 0x07, 0xCF, 0x01, 0xF8, 0x3E, 0x03, 0xC7, 0x80, 0xF8, 0x1F,
  0x01, 0xE3, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0xF0, 0x3E, 0x03, 0xE0, 0xF8,
  0x78, 0x1F, 0x01, 0xF0, 0x7C, 0x3C, 0x0F, 0x80, 0xF8, 0x3C, 0x1F, 0x0F,
  0x80, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x07, 0xC7, 0x80, 0xF0, 0xF8, 0x03, 0xE3, 0xC0,
  0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x0F, 0x3E,
  0x00, 0x3E, 0xF0, 0x07, 0x9F, 0x00, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x0F,
  0xBC, 0x00, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xFC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1E, 0x1E,
  0x07, 0x87, 0x83, 0xE1, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xE7,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0,
  0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x00,
  0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x9F, 0xC3, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFB, 0xF1, 0xFF, 0xCF, 0xC1, 0xFE, 0x1F, 0x00, 0x40,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE3, 0xFE, 0x0F, 0xBF, 0xFC, 0x3E, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xE0, 0x1F,
  0xBF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF3, 0xEF, 0xFF, 0x8F, 0x9F, 0xFC, 0x3E,
  0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x8F, 0xC0, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0xF1, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE,
  0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF,
  0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xF7, 0xC0, 0xFF,
  0x0F, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE3, 0xE0, 0x1F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x47, 0xE0, 0x07, 0x8F, 0xE0, 0x3F, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xF0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xF0, 0xFF,
  0xF3, 0xC7, 0xFF, 0xEF, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0xF7, 0xE0, 0x1F,
  0xDF, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xF7, 0xC0, 0xFF, 0x1F, 0x00, 0x60, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x60,
  0x03, 0xE3, 0xC0, 0x1F, 0x8F, 0xF3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x80, 0x7C, 0x7F, 0xC3, 0xE7, 0xFF, 0x1F, 0x7F, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xBF, 0x80, 0xFD, 0xF8, 0x03, 0xEF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x03, 0x81,
  0xF0, 0xFC, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xFF,
  0xEF, 0xFB, 0xFE, 0xFF, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E,
  0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x0F,
  0xC0, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E, 0x00,
  0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7E,
  0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xC7, 0xF8, 0x0F, 0xF8, 0x3E, 0xFF, 0xF0, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0x83,
  0xFF, 0x83, 0xFB, 0xF0, 0x0F, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0x80, 0x3E,
  0xF8, 0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x3E,
  0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xFC,
  0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x00,
  0x3F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFE, 0x00,
  0x3E, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x1F,
  0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFE,
  0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x80,
  0x1F, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x08, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xF7,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xC3, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x3E,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xFE, 0x0F,
  0xBF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xEF, 0xE0,
  0x1F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0xC0, 0xFE, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xBF, 0xFC, 0x3E, 0x3F, 0xE0, 0xF8, 0x18,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8,
  0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0xF7,
  0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xF7, 0xC0, 0xFF, 0x9F, 0x00,
  0x60, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xCF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xFE,
  0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x20, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x08, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xDF, 0x83, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0x7C, 0x3F, 0xE3, 0xE0, 0x10,
  0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x80,
  0x3E, 0x3C, 0x01, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xC0, 0x3C, 0x3E, 0x03,
  0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0xC0, 0x7C, 0x1E, 0x03, 0xFC, 0x07, 0xC1,
  0xF0, 0x3F, 0xE0, 0x78, 0x1F, 0x07, 0xDE, 0x07, 0x81, 0xF0, 0x79, 0xE0,
  0xF8, 0x0F, 0x07, 0x9E, 0x0F, 0x80, 0xF8, 0xF9, 0xF0, 0xF8, 0x0F, 0x8F,
  0x8F, 0x0F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F, 0x8F, 0x0F, 0x9F, 0x00,
  0x79, 0xF0, 0xF9, 0xF0, 0x07, 0xDE, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x79,
  0xE0, 0x07, 0xDE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F,
  0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x3F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xFB, 0xF0,
  0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0xDF, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x60, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0x80, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x40,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0xFF, 0xE0, 0x07, 0x9F,
  0xFE, 0x00, 0xF7, 0xFF, 0xE0, 0x3E, 0xF8, 0x7E, 0x07, 0xFE, 0x07, 0xE1,
  0xF7, 0x80, 0x7F, 0xFE, 0xF0, 0x07, 0xFF, 0x9E, 0x00, 0x7F, 0xE3, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 43, 15, 5, -42 },
  { 28, 12, 14, 19, 4, -44 },
  { 49, 27, 42, 32, 4, -42 },
  { 191, 23, 55, 29, 3, -49 },
  { 350, 32, 44, 37, 3, -43 },
  { 526, 29, 44, 32, 3, -43 },
  { 686, 4, 14, 10, 3, -44 },
  { 693, 13, 61, 19, 4, -47 },
  { 793, 13, 61, 19, 2, -47 },
  { 893, 24, 24, 25, 1, -42 },
  { 965, 25, 30, 29, 2, -34 },
  { 1059, 8, 15, 12, 1, -6 },
  { 1074, 12, 4, 15, 1, -20 },
  { 1080, 7, 7, 16, 4, -6 },
  { 1087, 19, 46, 22, 1, -42 },
  { 1197, 23, 44, 29, 3, -43 },
  { 1324, 14, 42, 29, 5, -42 },
  { 1398, 24, 43, 29, 3, -43 },
  { 1527, 22, 44, 29, 3, -43 },
  { 1648, 25, 42, 29, 2, -42 },
  { 1780, 23, 43, 29, 4, -42 },
  { 1904, 22, 43, 29, 4, -42 },
  { 2023, 25, 42, 29, 2, -42 },
  { 2155, 23, 44, 29, 3, -43 },
  { 2282, 22, 43, 29, 3, -43 },
  { 2401, 7, 32, 14, 4, -31 },
  { 2429, 9, 40, 12, 1, -31 },
  { 2474, 20, 26, 26, 2, -32 },
  { 2539, 20, 17, 28, 4, -28 },
  { 2582, 21, 26, 27, 4, -32 },
  { 2651, 20, 44, 25, 2, -43 },
  { 2761, 40, 54, 45, 3, -41 },
  { 3031, 32, 42, 34, 1, -42 },
  { 3199, 24, 42, 32, 5, -42 },
  { 3325, 27, 44, 33, 4, -43 },
  { 3474, 25, 42, 34, 5, -42 },
  { 3606, 22, 42, 29, 5, -42 },
  { 3722, 21, 42, 28, 5, -42 },
  { 3833, 27, 44, 35, 4, -43 },
  { 3982, 27, 42, 37, 5, -42 },
  { 4124, 5, 42, 15, 5, -42 },
  { 4151, 22, 43, 29, 2, -42 },
  { 4270, 27, 42, 32, 5, -42 },
  { 4412, 21, 42, 28, 5, -42 },
  { 4523, 35, 42, 45, 5, -42 },
  { 4707, 27, 42, 37, 5, -42 },
  { 4849, 28, 44, 35, 4, -43 },
  { 5003, 25, 42, 33, 5, -42 },
  { 5135, 29, 50, 35, 3, -43 },
  { 5317, 25, 42, 31, 5, -42 },
  { 5449, 26, 44, 31, 2, -43 },
  { 5592, 27, 42, 31, 2, -42 },
  { 5734, 26, 43, 33, 4, -42 },
  { 5874, 31, 42, 33, 1, -42 },
  { 6037, 41, 42, 45, 2, -42 },
  { 6253, 29, 42, 33, 2, -42 },
  { 6406, 29, 42, 31, 1, -42 },
  { 6559, 25, 42, 31, 3, -42 },
  { 6691, 10, 57, 15, 4, -48 },
  { 6763, 20, 46, 22, 1, -42 },
  { 6878, 9, 57, 15, 1, -48 },
  { 6943, 18, 21, 22, 2, -42 },
  { 6991, 22, 4, 24, 1, 0 },
  { 7002, 12, 8, 18, 2, -44 },
  { 7014, 22, 33, 28, 3, -32 },
  { 7105, 22, 45, 29, 4, -44 },
  { 7229, 22, 33, 27, 3, -32 },
  { 7320, 22, 45, 29, 3, -44 },
  { 7444, 22, 33, 28, 3, -32 },
  { 7535, 16, 45, 19, 2, -45 },
  { 7625, 22, 44, 29, 3, -32 },
  { 7746, 21, 44, 28, 4, -44 },
  { 7862, 6, 42, 14, 4, -42 },
  { 7894, 10, 54, 13, -1, -42 },
  { 7962, 22, 44, 27, 4, -44 },
  { 8083, 5, 44, 14, 4, -44 },
  { 8111, 37, 32, 44, 4, -32 },
  { 8259, 21, 32, 29, 4, -32 },
  { 8343, 24, 33, 30, 3, -32 },
  { 8442, 22, 44, 29, 4, -32 },
  { 8563, 22, 44, 30, 3, -32 },
  { 8684, 13, 32, 18, 4, -32 },
  { 8736, 21, 33, 27, 3, -32 },
  { 8823, 14, 40, 17, 1, -39 },
  { 8893, 21, 32, 29, 4, -31 },
  { 8977, 23, 31, 25, 1, -31 },
  { 9067, 36, 31, 38, 1, -31 },
  { 9207, 22, 31, 26, 2, -31 },
  { 9293, 22, 43, 25, 1, -31 },
  { 9412, 21, 31, 26, 3, -31 },
  { 9494, 15, 57, 18, 2, -46 },
  { 9601, 4, 50, 14, 5, -42 },
  { 9626, 15, 57, 18, 1, -46 },
  { 9733, 27, 12, 35, 4, -24 },
};

const GFXfont RobotoCondensed_Regular59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_REGULAR59PT7B_H_
