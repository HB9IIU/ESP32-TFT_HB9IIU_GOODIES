#ifndef _ROBOTOCONDENSED_REGULAR10PT7B_H_
#define _ROBOTOCONDENSED_REGULAR10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x55, 0xF6, 0xFA, 0xA0, 0x5E, 0xC6, 0x6F, 0x40, 0xC6,
  0xB8, 0x45, 0xB4, 0x60, 0x72, 0x94, 0xC5, 0xCD, 0xE0, 0xC0, 0x6A, 0xAA,
  0x90, 0x89, 0x22, 0x52, 0x50, 0x2D, 0x65, 0x21, 0x3E, 0x42, 0x00, 0x68,
  0xC0, 0x80, 0x24, 0xA4, 0xA4, 0xF6, 0xDB, 0x78, 0x75, 0x54, 0x74, 0x84,
  0x22, 0x21, 0xE0, 0x79, 0x12, 0x19, 0x70, 0x11, 0x94, 0xAF, 0x88, 0x40,
  0xE8, 0xE2, 0x1A, 0xE0, 0x73, 0xDB, 0x78, 0xF8, 0x84, 0x42, 0x11, 0x00,
  0xF6, 0xFB, 0x78, 0xF6, 0xDE, 0x70, 0x88, 0x40, 0x58, 0x16, 0x61, 0xE3,
  0x80, 0x8D, 0xC0, 0x69, 0x12, 0x40, 0x00, 0x7A, 0x1B, 0x75, 0xD7, 0x5A,
  0xE0, 0x70, 0x20, 0xC3, 0x14, 0x79, 0x28, 0x80, 0xE9, 0x9E, 0x99, 0xE0,
  0x79, 0x88, 0x89, 0x70, 0xE9, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88, 0xF0,
  0xF2, 0x79, 0x20, 0xF9, 0x8B, 0x99, 0x70, 0x99, 0x9F, 0x99, 0x90, 0xFE,
  0x11, 0x11, 0x19, 0x70, 0x9A, 0xCC, 0xAA, 0x90, 0x92, 0x49, 0x38, 0x8E,
  0x3C, 0xF5, 0xD6, 0xDA, 0x40, 0x99, 0xDB, 0xB9, 0x90, 0x79, 0x99, 0x99,
  0x70, 0xF9, 0x9F, 0x88, 0x80, 0xE9, 0x99, 0x99, 0xE1, 0xE9, 0x9E, 0xA9,
  0x90, 0x72, 0x50, 0x60, 0xC5, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x99,
  0x99, 0x99, 0xE0, 0x8A, 0x52, 0xA3, 0x18, 0x80, 0x92, 0xB5, 0x6A, 0xD6,
  0xAC, 0x89, 0x00, 0x4A, 0x8C, 0x43, 0x29, 0x20, 0x8A, 0x94, 0x42, 0x10,
  0x80, 0xF8, 0x84, 0x44, 0x23, 0xE0, 0xFF, 0xC0, 0x84, 0x44, 0x22, 0x22,
  0xD5, 0x55, 0x70, 0x4D, 0xD0, 0xF0, 0x50, 0xF7, 0xDE, 0x92, 0x7B, 0x6F,
  0x79, 0x89, 0x70, 0x11, 0x17, 0x99, 0x97, 0x79, 0xF8, 0x70, 0x69, 0x74,
  0x92, 0x79, 0x99, 0x71, 0x70, 0x92, 0x7B, 0x6D, 0xBE, 0x45, 0x55, 0x80,
  0x92, 0x5D, 0xB5, 0xFF, 0xFE, 0x9A, 0x69, 0xA4, 0xF6, 0xDA, 0x72, 0x63,
  0x17, 0x00, 0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x75,
  0x69, 0x70, 0x4B, 0xA4, 0x98, 0xB6, 0xDE, 0x95, 0x66, 0x20, 0x95, 0xD7,
  0x5A, 0x48, 0x56, 0x26, 0x50, 0x95, 0x66, 0x24, 0xC0, 0xF2, 0x24, 0xF0,
  0x29, 0x2C, 0x92, 0x44, 0xFF, 0x89, 0x22, 0x92, 0x50, 0xDB,
};

const GFXglyph RobotoCondensed_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 3, 1, -8 },
  { 3, 4, 7, 5, 1, -7 },
  { 7, 3, 9, 5, 1, -8 },
  { 11, 5, 7, 6, 1, -7 },
  { 16, 5, 7, 5, 0, -7 },
  { 21, 1, 2, 2, 0, -8 },
  { 22, 2, 10, 3, 1, -8 },
  { 25, 3, 10, 3, 0, -8 },
  { 29, 4, 4, 4, 0, -7 },
  { 31, 5, 5, 5, 0, -6 },
  { 35, 2, 3, 2, 0, -1 },
  { 36, 2, 1, 2, 0, -4 },
  { 37, 1, 1, 3, 1, -1 },
  { 38, 3, 8, 4, 0, -7 },
  { 41, 3, 7, 5, 1, -7 },
  { 44, 2, 7, 5, 1, -7 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 4, 7, 5, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 4, 7, 5, 1, -7 },
  { 64, 3, 7, 5, 1, -7 },
  { 67, 5, 7, 5, 0, -7 },
  { 72, 3, 7, 5, 1, -7 },
  { 75, 3, 7, 5, 1, -7 },
  { 78, 1, 5, 2, 1, -5 },
  { 79, 2, 7, 2, 0, -5 },
  { 81, 4, 4, 4, 0, -5 },
  { 83, 3, 3, 5, 1, -5 },
  { 85, 3, 4, 5, 1, -5 },
  { 87, 4, 7, 4, 0, -7 },
  { 91, 6, 9, 8, 1, -7 },
  { 98, 6, 7, 6, 0, -7 },
  { 104, 4, 7, 5, 1, -7 },
  { 108, 4, 7, 6, 1, -7 },
  { 112, 4, 7, 6, 1, -7 },
  { 116, 4, 7, 5, 1, -7 },
  { 120, 3, 7, 5, 1, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 1, 7, 3, 1, -7 },
  { 132, 4, 7, 5, 0, -7 },
  { 136, 4, 7, 5, 1, -7 },
  { 140, 3, 7, 5, 1, -7 },
  { 143, 6, 7, 8, 1, -7 },
  { 149, 4, 7, 6, 1, -7 },
  { 153, 4, 7, 6, 1, -7 },
  { 157, 4, 7, 6, 1, -7 },
  { 161, 4, 8, 6, 1, -7 },
  { 165, 4, 7, 5, 1, -7 },
  { 169, 5, 7, 5, 0, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 4, 7, 6, 1, -7 },
  { 183, 5, 7, 6, 0, -7 },
  { 188, 7, 7, 8, 0, -7 },
  { 195, 5, 7, 6, 0, -7 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 1, 10, 3, 1, -8 },
  { 212, 4, 8, 4, 0, -7 },
  { 216, 2, 10, 3, 0, -8 },
  { 219, 3, 4, 4, 0, -7 },
  { 221, 4, 1, 4, 0, 0 },
  { 222, 2, 2, 3, 0, -8 },
  { 223, 3, 5, 5, 1, -5 },
  { 225, 3, 8, 5, 1, -8 },
  { 228, 4, 5, 5, 0, -5 },
  { 231, 4, 8, 5, 0, -8 },
  { 235, 4, 5, 5, 0, -5 },
  { 238, 3, 8, 3, 0, -8 },
  { 241, 4, 7, 5, 0, -5 },
  { 245, 3, 8, 5, 1, -8 },
  { 248, 1, 7, 2, 1, -7 },
  { 249, 2, 9, 2, 0, -7 },
  { 252, 3, 8, 5, 1, -8 },
  { 255, 1, 8, 2, 1, -8 },
  { 256, 6, 5, 8, 1, -5 },
  { 260, 3, 5, 5, 1, -5 },
  { 262, 5, 5, 5, 0, -5 },
  { 266, 3, 7, 5, 1, -5 },
  { 269, 4, 7, 5, 0, -5 },
  { 273, 2, 5, 3, 1, -5 },
  { 275, 4, 5, 5, 0, -5 },
  { 278, 3, 7, 3, 0, -7 },
  { 281, 3, 5, 5, 1, -5 },
  { 283, 4, 5, 4, 0, -5 },
  { 286, 6, 5, 7, 0, -5 },
  { 290, 4, 5, 4, 0, -5 },
  { 293, 4, 7, 4, 0, -5 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 3, 10, 3, 0, -8 },
  { 304, 1, 8, 2, 1, -7 },
  { 305, 3, 10, 3, 0, -8 },
  { 309, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Regular10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_REGULAR10PT7B_H_
