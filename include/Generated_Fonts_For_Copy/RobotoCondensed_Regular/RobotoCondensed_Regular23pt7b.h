#ifndef _ROBOTOCONDENSED_REGULAR23PT7B_H_
#define _ROBOTOCONDENSED_REGULAR23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x99, 0x99, 0x99, 0x04, 0xC1, 0x98,
  0x33, 0x06, 0x47, 0xFE, 0xFF, 0xC2, 0x60, 0xCC, 0x19, 0x83, 0x20, 0x44,
  0x7F, 0xEF, 0xFC, 0x66, 0x0C, 0xC1, 0x90, 0x22, 0x00, 0x0C, 0x06, 0x07,
  0x87, 0xE6, 0x3B, 0x0D, 0x86, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x0F, 0x07, 0x83, 0x63, 0xBF, 0x8F, 0x81, 0x00, 0x80, 0x38, 0x02, 0x40,
  0x33, 0x11, 0x99, 0x8C, 0xC8, 0x66, 0xC1, 0x24, 0x07, 0x60, 0x02, 0x00,
  0x37, 0x01, 0x6C, 0x1A, 0x20, 0x91, 0x8C, 0x8C, 0x44, 0x42, 0x36, 0x00,
  0xE0, 0x1E, 0x07, 0xE1, 0xCC, 0x31, 0x86, 0x30, 0x66, 0x0F, 0x80, 0xE0,
  0x3C, 0x0F, 0x89, 0x99, 0x63, 0xEC, 0x3D, 0x83, 0x18, 0x73, 0xFE, 0x3E,
  0x60, 0xFF, 0xC0, 0x08, 0x21, 0x8C, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x30,
  0xC1, 0x86, 0x18, 0x61, 0x83, 0x0C, 0x18, 0x20, 0x80, 0x86, 0x10, 0xC2,
  0x18, 0xC6, 0x18, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x88, 0xC4, 0x62, 0x00,
  0x0C, 0x03, 0x00, 0xC1, 0xB6, 0xFF, 0xC7, 0x81, 0xE0, 0xD8, 0x33, 0x08,
  0x40, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x6D, 0xB6, 0x80, 0xFF, 0x3C, 0x03, 0x02, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60,
  0x60, 0x40, 0x1E, 0x1F, 0x98, 0xCC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1B, 0x0D, 0x8C, 0x7E, 0x1E, 0x00, 0x09, 0xFF,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0x3E, 0x3F, 0x98,
  0xF8, 0x3C, 0x18, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x81, 0x81,
  0x81, 0x81, 0xFF, 0xFF, 0x80, 0x3E, 0x3F, 0xB8, 0xD8, 0x30, 0x18, 0x0C,
  0x0C, 0x3C, 0x1E, 0x01, 0x80, 0x60, 0x3C, 0x1E, 0x0D, 0x8C, 0xFE, 0x3E,
  0x00, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63,
  0x18, 0xCC, 0x33, 0xFF, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F,
  0x7F, 0x40, 0x40, 0xC0, 0xC0, 0xFC, 0xFE, 0xC7, 0x03, 0x03, 0x03, 0xC3,
  0xC3, 0xC3, 0x7E, 0x3C, 0x0E, 0x0F, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0xF8,
  0xFE, 0x63, 0xF0, 0xF0, 0x6C, 0x36, 0x1B, 0x0D, 0xCE, 0x7E, 0x1E, 0x00,
  0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x00, 0x1E, 0x3F, 0x98, 0xCC,
  0x36, 0x1B, 0x0D, 0x8C, 0x7E, 0x3E, 0x31, 0x98, 0x78, 0x3C, 0x1E, 0x0D,
  0x8E, 0xFE, 0x1E, 0x00, 0x3C, 0x3F, 0x18, 0xD8, 0x6C, 0x1E, 0x0F, 0x07,
  0x83, 0x63, 0xBF, 0xCF, 0x60, 0x30, 0x30, 0x18, 0x18, 0x7C, 0x38, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x07, 0x70, 0x00, 0x00, 0x00, 0x03, 0x33, 0x66,
  0x40, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x07, 0x07,
  0x3C, 0xF0, 0xC0, 0x80, 0x3C, 0x7E, 0xC6, 0xC3, 0x03, 0x03, 0x06, 0x0E,
  0x0C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x03, 0xE0, 0x0F,
  0x78, 0x18, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x61, 0xC2, 0x43, 0x62, 0x46,
  0x22, 0xC6, 0x63, 0xC4, 0x63, 0xCC, 0x63, 0xCC, 0x62, 0xCC, 0x62, 0xCC,
  0x66, 0x47, 0xE4, 0x47, 0x38, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1E,
  0x60, 0x07, 0xC0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0xD8, 0x06,
  0xC0, 0x33, 0x03, 0x18, 0x18, 0xC0, 0xC2, 0x0C, 0x18, 0x7F, 0xC3, 0xFE,
  0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x18, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x0D, 0xFE, 0xFF, 0x61, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0xFE, 0xFE, 0x00, 0x0F, 0x07, 0xF9, 0xC3, 0x30, 0x36, 0x07, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x06, 0xC0, 0xDC, 0x31,
  0xFE, 0x0F, 0x00, 0xFC, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xB0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB0, 0x6C, 0x3B, 0xFC, 0xFC,
  0x00, 0xFF, 0x7F, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0xFF, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x36, 0x07, 0xC0, 0x30, 0x06,
  0x00, 0xC3, 0xF8, 0x7F, 0x01, 0xF0, 0x36, 0x06, 0xC0, 0xDC, 0x19, 0xFE,
  0x0F, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xC1, 0xF0,
  0x6C, 0x33, 0x1C, 0xCE, 0x33, 0x0D, 0x83, 0xE0, 0xF8, 0x3B, 0x0C, 0xE3,
  0x18, 0xC7, 0x30, 0xCC, 0x1B, 0x07, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xBD,
  0x06, 0xF6, 0x1B, 0xD8, 0xCF, 0x63, 0x3C, 0xCC, 0xF3, 0x63, 0xCD, 0x8F,
  0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xC3, 0x0C, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF1, 0xBC, 0x6F, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xC0, 0x0F, 0x07, 0xF9, 0xC3, 0x30, 0x36, 0x06,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x36, 0x06, 0xC0,
  0xDC, 0x31, 0xFE, 0x0F, 0x00, 0xFE, 0x3F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x06, 0xFF, 0xBF, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x00, 0x1F, 0x03, 0xFC, 0x70, 0xC6, 0x06, 0x60, 0x6C, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0x60, 0x66, 0x06,
  0x70, 0xC3, 0xFC, 0x1F, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0xFE, 0x3F, 0xCC,
  0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0xFF, 0x3F, 0x8C, 0x63, 0x1C,
  0xC3, 0x30, 0xCC, 0x1B, 0x06, 0xC1, 0xC0, 0x1E, 0x1F, 0xE6, 0x1B, 0x83,
  0xC0, 0xF8, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0xF0,
  0x36, 0x1D, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0C, 0xC1, 0x98, 0x31,
  0xFC, 0x1F, 0x00, 0x60, 0x36, 0x03, 0x60, 0x33, 0x06, 0x30, 0x63, 0x06,
  0x30, 0xC1, 0x8C, 0x18, 0xC1, 0x8C, 0x0D, 0x80, 0xD8, 0x0D, 0x80, 0x50,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3, 0x86, 0xC3,
  0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x62, 0xC6, 0x66, 0x44, 0x66, 0x6C, 0x36,
  0x6C, 0x34, 0x6C, 0x34, 0x2C, 0x3C, 0x2C, 0x3C, 0x38, 0x18, 0x38, 0x18,
  0x38, 0x18, 0x18, 0xE0, 0xEC, 0x19, 0x87, 0x18, 0xC3, 0x38, 0x36, 0x07,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x7C, 0x0D, 0x83, 0x38, 0x63, 0x18, 0x73,
  0x06, 0xC0, 0xE0, 0x60, 0x66, 0x06, 0x70, 0xE3, 0x0C, 0x30, 0xC1, 0x98,
  0x19, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xF8,
  0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x81,
  0x83, 0x02, 0x06, 0x0C, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0xF0, 0x30, 0x60, 0xE3, 0x46, 0xC9, 0xB3, 0x63, 0xFF,
  0xFF, 0xC0, 0xE6, 0x30, 0x3E, 0x3F, 0x98, 0xD8, 0x60, 0x31, 0xF9, 0xED,
  0xC6, 0xC3, 0x61, 0x9F, 0xE7, 0x30, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x79, 0xFE, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3,
  0xFF, 0x6F, 0x00, 0x3E, 0x3F, 0x98, 0xF8, 0x3C, 0x06, 0x03, 0x01, 0x80,
  0xC1, 0xB1, 0xDF, 0xC7, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0xF6, 0xFF, 0x63, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xC7, 0x7F,
  0x9E, 0xC0, 0x3E, 0x3F, 0x98, 0xD8, 0x3C, 0x1F, 0xFF, 0xFF, 0x80, 0xC0,
  0x30, 0x9F, 0xE7, 0xC0, 0x1C, 0xF3, 0x18, 0x61, 0x8F, 0xBE, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x80, 0x3D, 0xBF, 0xD8, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xB1, 0xDF, 0xE7, 0xB0, 0x18, 0x0D, 0x0E, 0xFE,
  0x3E, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x39, 0xFE, 0xE3,
  0x70, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xC0, 0xF0,
  0xFF, 0xFF, 0xFF, 0x72, 0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x6E, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8D, 0xCC, 0xEE,
  0x76, 0x3E, 0x1F, 0x0F, 0xC7, 0x63, 0x99, 0xCE, 0xE3, 0x70, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xDE, 0x79, 0xFF, 0xFB, 0x8E, 0x3E, 0x0C, 0x3C,
  0x18, 0x78, 0x30, 0xF0, 0x61, 0xE0, 0xC3, 0xC1, 0x87, 0x83, 0x0F, 0x06,
  0x1E, 0x0C, 0x30, 0xCE, 0x7F, 0xB8, 0xDC, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1E, 0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xB0, 0xDF, 0xC3, 0xC0, 0xDE, 0x7F, 0xB8, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xFF, 0xDB, 0xCC, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x00, 0x3D, 0xBF, 0xD8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xB0, 0xDF, 0xE7, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xDF,
  0xFE, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x3C, 0x7F, 0x63, 0xC3,
  0x60, 0x3C, 0x1E, 0x03, 0xC3, 0xE3, 0x7F, 0x3E, 0x30, 0xC3, 0x3F, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xF1, 0xC0, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0xDF, 0xE7, 0xB0, 0xC3, 0xC3,
  0xC3, 0x46, 0x66, 0x66, 0x64, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0xC2, 0x1E,
  0x38, 0xF1, 0xC7, 0x8E, 0x26, 0xD3, 0x36, 0xD9, 0xB6, 0xCD, 0x16, 0x38,
  0xE1, 0xC7, 0x0E, 0x38, 0x60, 0xC0, 0xC3, 0x67, 0x66, 0x3C, 0x3C, 0x18,
  0x18, 0x3C, 0x36, 0x66, 0xE7, 0xC3, 0x61, 0xB0, 0xD8, 0xCC, 0x63, 0x31,
  0x98, 0xD8, 0x2C, 0x1E, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0xE0,
  0x70, 0x00, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60,
  0xFF, 0xFF, 0x08, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x8E, 0x38, 0x60,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x41, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0xC3, 0x18, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x61, 0x00, 0x38, 0x2F, 0x8D, 0x99, 0xA3, 0xEC, 0x18,
};

const GFXglyph RobotoCondensed_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 4, 6, 7, 2, -17 },
  { 9, 11, 17, 13, 1, -17 },
  { 33, 9, 21, 11, 1, -19 },
  { 57, 13, 17, 15, 1, -17 },
  { 85, 11, 17, 13, 1, -17 },
  { 109, 2, 5, 4, 1, -17 },
  { 111, 6, 23, 7, 1, -18 },
  { 129, 5, 23, 7, 1, -18 },
  { 144, 10, 10, 10, 0, -17 },
  { 157, 9, 12, 11, 1, -14 },
  { 171, 3, 6, 5, 0, -2 },
  { 174, 4, 2, 6, 1, -8 },
  { 175, 2, 3, 6, 2, -3 },
  { 176, 8, 18, 9, 0, -17 },
  { 194, 9, 17, 11, 1, -17 },
  { 214, 5, 17, 11, 2, -17 },
  { 225, 9, 17, 11, 1, -17 },
  { 245, 9, 17, 11, 1, -17 },
  { 265, 10, 17, 11, 1, -17 },
  { 287, 8, 17, 11, 2, -17 },
  { 304, 9, 17, 11, 1, -17 },
  { 324, 9, 17, 11, 1, -17 },
  { 344, 9, 17, 11, 1, -17 },
  { 364, 9, 17, 11, 1, -17 },
  { 384, 2, 13, 5, 2, -13 },
  { 388, 4, 17, 5, 0, -13 },
  { 397, 8, 10, 10, 1, -12 },
  { 407, 8, 7, 11, 2, -11 },
  { 414, 8, 10, 11, 2, -12 },
  { 424, 8, 17, 10, 1, -17 },
  { 441, 16, 21, 18, 1, -16 },
  { 483, 13, 17, 13, 0, -17 },
  { 511, 9, 17, 13, 2, -17 },
  { 531, 11, 17, 13, 1, -17 },
  { 555, 10, 17, 13, 2, -17 },
  { 577, 9, 17, 11, 2, -17 },
  { 597, 8, 17, 11, 2, -17 },
  { 614, 11, 17, 14, 1, -17 },
  { 638, 10, 17, 14, 2, -17 },
  { 660, 2, 17, 6, 2, -17 },
  { 665, 8, 17, 11, 1, -17 },
  { 682, 10, 17, 13, 2, -17 },
  { 704, 8, 17, 11, 2, -17 },
  { 721, 14, 17, 17, 2, -17 },
  { 751, 10, 17, 14, 2, -17 },
  { 773, 11, 17, 14, 1, -17 },
  { 797, 10, 17, 13, 2, -17 },
  { 819, 12, 20, 14, 1, -17 },
  { 849, 10, 17, 12, 2, -17 },
  { 871, 10, 17, 12, 1, -17 },
  { 893, 10, 17, 12, 1, -17 },
  { 915, 11, 17, 13, 1, -17 },
  { 939, 12, 17, 13, 0, -17 },
  { 965, 16, 17, 18, 1, -17 },
  { 999, 11, 17, 13, 1, -17 },
  { 1023, 12, 17, 12, 0, -17 },
  { 1049, 10, 17, 12, 1, -17 },
  { 1071, 3, 23, 6, 2, -19 },
  { 1080, 7, 18, 9, 1, -17 },
  { 1096, 4, 23, 6, 0, -19 },
  { 1108, 7, 8, 9, 1, -17 },
  { 1115, 9, 2, 9, 0, 0 },
  { 1118, 4, 3, 7, 1, -17 },
  { 1120, 9, 12, 11, 1, -12 },
  { 1134, 9, 18, 11, 1, -18 },
  { 1155, 9, 12, 11, 1, -12 },
  { 1169, 9, 18, 11, 1, -18 },
  { 1190, 9, 12, 11, 1, -12 },
  { 1204, 6, 18, 7, 1, -18 },
  { 1218, 9, 17, 11, 1, -12 },
  { 1238, 9, 18, 11, 1, -18 },
  { 1259, 2, 16, 5, 2, -16 },
  { 1263, 4, 21, 5, 0, -16 },
  { 1274, 9, 18, 10, 1, -18 },
  { 1295, 2, 18, 5, 2, -18 },
  { 1300, 15, 12, 17, 1, -12 },
  { 1323, 9, 12, 11, 1, -12 },
  { 1337, 9, 12, 12, 1, -12 },
  { 1351, 9, 17, 11, 1, -12 },
  { 1371, 9, 17, 12, 1, -12 },
  { 1391, 6, 12, 7, 1, -12 },
  { 1400, 8, 12, 10, 1, -12 },
  { 1412, 6, 15, 7, 0, -15 },
  { 1424, 9, 12, 11, 1, -12 },
  { 1438, 8, 12, 10, 1, -12 },
  { 1450, 13, 12, 15, 1, -12 },
  { 1470, 8, 12, 10, 1, -12 },
  { 1482, 9, 17, 10, 0, -12 },
  { 1502, 8, 12, 10, 1, -12 },
  { 1514, 6, 22, 7, 1, -18 },
  { 1531, 2, 20, 6, 2, -17 },
  { 1536, 6, 22, 7, 0, -18 },
  { 1553, 11, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_Regular23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_REGULAR23PT7B_H_
