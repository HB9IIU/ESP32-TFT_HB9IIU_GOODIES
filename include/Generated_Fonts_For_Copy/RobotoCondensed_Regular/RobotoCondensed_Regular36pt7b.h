#ifndef _ROBOTOCONDENSED_REGULAR36PT7B_H_
#define _ROBOTOCONDENSED_REGULAR36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE6, 0xE6, 0xE6, 0xC6, 0xC6, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0x0C,
  0x01, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xDC,
  0x07, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0x9C, 0x00, 0x71, 0xC3, 0x0C,
  0x38, 0x61, 0x83, 0x1C, 0x30, 0x63, 0x06, 0x1C, 0xE0, 0xC3, 0x98, 0x1C,
  0xE7, 0x01, 0xFC, 0xC0, 0x1E, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x31, 0xE0, 0x0C, 0xFE, 0x01, 0x9C, 0xE0, 0x67, 0x0C, 0x1C, 0xE1, 0x83,
  0x1C, 0x30, 0xE3, 0x86, 0x18, 0x70, 0xC7, 0x0E, 0x18, 0x00, 0xE7, 0x00,
  0x1F, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x0E,
  0x03, 0x87, 0x03, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1E,
  0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEE, 0x1C,
  0xE7, 0x8E, 0xF1, 0xE7, 0x70, 0x73, 0xB8, 0x1F, 0x9C, 0x0F, 0xCE, 0x03,
  0xE7, 0x80, 0xE1, 0xC1, 0xF8, 0xFF, 0xFE, 0x3F, 0xE7, 0x07, 0xE3, 0xC0,
  0xFF, 0xFF, 0x01, 0x03, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x1C,
  0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x30,
  0x70, 0xE0, 0xC0, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x04,
  0x18, 0x0F, 0x33, 0xDF, 0xFF, 0x8F, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x3B,
  0x80, 0x73, 0x81, 0xC7, 0x03, 0x07, 0x02, 0x04, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x77, 0x77, 0x77, 0xEE, 0x40, 0xFF, 0xFF,
  0xF8, 0xEE, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1E,
  0x1C, 0x70, 0x39, 0xC0, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x87, 0x0F, 0xFC,
  0x1F, 0xE0, 0x3E, 0x00, 0x01, 0x0F, 0x3F, 0xFF, 0xF7, 0xC7, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1C,
  0x1E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE0, 0xEF, 0x03,
  0xF0, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x1F, 0xC0,
  0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xEF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03,
  0xB8, 0x03, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBC, 0x1F, 0xF9, 0xFF, 0xEF, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0xC3, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0xFE, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xCF, 0x07, 0xFF, 0x3F, 0xFC, 0xF8, 0x7B, 0xC0, 0xEF, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x3D, 0xE0,
  0xE3, 0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E,
  0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x87, 0x0F, 0xFC, 0x1F, 0xC0, 0xFF, 0x87, 0x87, 0x1C, 0x0E, 0xF0, 0x3B,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xE7, 0x07, 0x9F, 0xFC,
  0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xF8, 0xF1, 0xEF, 0x07,
  0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x07, 0xBC, 0x7D, 0xFF, 0xE7, 0xFF, 0x1F, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x07, 0x83, 0xF8, 0x1F, 0x80, 0xF0, 0x00, 0x7F,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x33, 0xDE, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xDE, 0xF7, 0x39, 0xDC,
  0x40, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F,
  0x80, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1,
  0xE7, 0x07, 0x78, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x0F, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xE1, 0xF0, 0x07, 0x00,
  0x78, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x38, 0x00,
  0x06, 0x30, 0x1E, 0x06, 0x70, 0x3F, 0x86, 0x60, 0x73, 0x87, 0x60, 0xE1,
  0x83, 0xE0, 0xC3, 0x83, 0xE1, 0xC3, 0x83, 0xE1, 0xC3, 0x83, 0xC1, 0x83,
  0x83, 0xC3, 0x83, 0x83, 0xC3, 0x83, 0x83, 0xC3, 0x83, 0x07, 0xC3, 0x83,
  0x06, 0xC3, 0x87, 0x06, 0xE1, 0xC7, 0x8E, 0xE1, 0xFF, 0x9C, 0x61, 0xF9,
  0xF8, 0x60, 0x70, 0xF0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07,
  0x18, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1C,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x9C, 0x00, 0x73, 0x80,
  0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x1C, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0x01, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x7B, 0x81, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0x38, 0x0E, 0x70, 0x0E,
  0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xB8,
  0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xEE,
  0x00, 0xF7, 0x00, 0x73, 0xC0, 0x38, 0xF0, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0x03, 0xCE, 0x03,
  0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xB8, 0x1E, 0x7F, 0xF8,
  0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xB8, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0x7F,
  0xFB, 0xFF, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x0F, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x1C, 0xF0, 0x3E, 0x3F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xE7, 0x87, 0x9F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0xE0, 0x0F, 0x70,
  0x0F, 0x38, 0x0F, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x83, 0x87, 0x81,
  0xC3, 0x80, 0xE3, 0xC0, 0x73, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xEE, 0x01, 0xE7, 0x80, 0xE1, 0xE0, 0x70, 0x70, 0x38,
  0x3C, 0x1C, 0x0F, 0x0E, 0x07, 0x87, 0x01, 0xE3, 0x80, 0x71, 0xC0, 0x3C,
  0xE0, 0x0F, 0x70, 0x07, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xEE, 0x01, 0xFF,
  0x70, 0x1D, 0xFB, 0x80, 0xEF, 0xCE, 0x07, 0x7E, 0x70, 0x73, 0xF3, 0x83,
  0x9F, 0x8C, 0x1C, 0xFC, 0x71, 0xC7, 0xE3, 0x8E, 0x3F, 0x0C, 0x71, 0xF8,
  0x77, 0x0F, 0xC3, 0xB8, 0x7E, 0x0D, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0,
  0xFC, 0x0F, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xDC, 0x0F, 0xEE, 0x07, 0xF3, 0x83, 0xF9, 0xC1, 0xFC, 0x70, 0xFE, 0x38,
  0x7F, 0x0E, 0x3F, 0x87, 0x1F, 0xC1, 0xCF, 0xE0, 0xE7, 0xF0, 0x3B, 0xF8,
  0x1D, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0x83, 0xE7, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77,
  0x00, 0x7B, 0xC0, 0x38, 0xF0, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xF0, 0x7C, 0x78, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x07, 0x1E, 0x03, 0xC3, 0xC1, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x40, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C,
  0x1E, 0x38, 0x0E, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78,
  0x0F, 0x3C, 0x1E, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70,
  0x0F, 0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xE0, 0x01, 0xFC,
  0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x03, 0x9E, 0x01, 0xE3, 0x80,
  0x70, 0xE0, 0x1C, 0x3C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x0E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x3C, 0x70, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x1C, 0x03, 0xB8,
  0x0F, 0x01, 0xDC, 0x07, 0x80, 0xEE, 0x03, 0xC0, 0x77, 0x01, 0xE0, 0x7B,
  0x81, 0xF0, 0x38, 0xE0, 0xFC, 0x1C, 0x70, 0x7E, 0x0E, 0x38, 0x33, 0x07,
  0x1C, 0x39, 0x83, 0x8E, 0x1C, 0xE3, 0x83, 0x8E, 0x71, 0xC1, 0xC6, 0x38,
  0xE0, 0xE3, 0x0C, 0x70, 0x73, 0x86, 0x38, 0x39, 0xC3, 0x98, 0x1C, 0xC1,
  0xDC, 0x07, 0x60, 0x6E, 0x03, 0xF0, 0x37, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0x80,
  0x70, 0xF0, 0x3C, 0x1C, 0x0E, 0x07, 0x87, 0x80, 0xE1, 0xC0, 0x3C, 0xF0,
  0x07, 0x38, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xCE, 0x00, 0xF3,
  0xC0, 0x38, 0x70, 0x1E, 0x1E, 0x07, 0x03, 0x83, 0xC0, 0xF0, 0xE0, 0x1C,
  0x78, 0x07, 0xBC, 0x00, 0xE0, 0xE0, 0x07, 0xF8, 0x03, 0xDC, 0x01, 0xCF,
  0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x38, 0x1E, 0x3C,
  0x07, 0x1C, 0x03, 0x9E, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3F, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xFE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xFF, 0xC0, 0x0E, 0x01, 0xC0, 0x3C,
  0x0F, 0x81, 0xF0, 0x37, 0x0E, 0xE1, 0xCC, 0x31, 0xCE, 0x39, 0xC3, 0x38,
  0x7E, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xF0, 0xE0,
  0xE0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0xEF, 0x07, 0xF0, 0x1C, 0x00,
  0xE0, 0x07, 0x0F, 0xF9, 0xFF, 0xDF, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFE, 0x1F, 0x7F, 0xFB, 0xFD, 0xC7, 0xCE, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE7, 0xE3,
  0xBF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03,
  0xFE, 0x1E, 0xFF, 0xFB, 0xBF, 0xCE, 0x3C, 0x00, 0x0F, 0xC1, 0xFF, 0x1F,
  0xFC, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1F, 0x80, 0xEE, 0x0F, 0x7F, 0xF1,
  0xFF, 0x03, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x1F, 0x39, 0xFF, 0xDF, 0xFE, 0xE0, 0xFF, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0F, 0x7F, 0xF9, 0xFF, 0xC7, 0xC6, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x4F,
  0x07, 0x7F, 0xF9, 0xFF, 0x83, 0xF0, 0x03, 0xC3, 0xF0, 0xFC, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0xFF, 0xBF, 0xE1, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x1F, 0x19, 0xFE, 0xDF, 0xFE, 0xE0, 0xFF, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0F, 0x7F, 0xF9, 0xFF, 0xC3, 0xCE, 0x00,
  0x70, 0x03, 0x80, 0x1D, 0x81, 0xEF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE3, 0xC7, 0x7F, 0xBF, 0xFD, 0xF0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0x6F, 0xF6, 0x00, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x18, 0xF3, 0xC6, 0x00,
  0x00, 0x0F, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x38, 0xEF, 0xBE, 0xE0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x7B, 0x83, 0xCE, 0x0E, 0x38, 0x70, 0xE3, 0xC3, 0x9E, 0x0E, 0x70, 0x3B,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0xE0, 0xE3, 0xC3, 0x87, 0x8E,
  0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7, 0xC1, 0xF1, 0xDF,
  0xEF, 0xF3, 0xFF, 0xDF, 0xF7, 0xC3, 0xE0, 0xEF, 0x03, 0xC1, 0xFC, 0x07,
  0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70,
  0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01,
  0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F,
  0x80, 0xE0, 0x38, 0xE3, 0xC7, 0x7F, 0xBF, 0xFD, 0xF0, 0xFF, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03,
  0xDE, 0x0E, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xE7, 0xC3, 0xBF, 0xCF,
  0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x1E,
  0xFF, 0xFB, 0xBF, 0xCE, 0x7C, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0x99, 0xFF, 0xDF, 0xFE, 0xE0,
  0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0F, 0x7F, 0xF9, 0xFF, 0xC3,
  0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xE1, 0xEE, 0x07, 0x70, 0x3B, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0xF0, 0x1F, 0x81, 0xFE, 0x0E, 0x7F, 0xF1,
  0xFF, 0x07, 0xE0, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE0, 0x7C, 0x3E, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0F, 0x7F, 0xF9, 0xFF, 0xC7,
  0xCE, 0xE0, 0x3B, 0x80, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xC3,
  0x87, 0x0E, 0x38, 0x38, 0xE0, 0x63, 0x81, 0xCC, 0x07, 0x70, 0x0D, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x70, 0x3F, 0x03, 0x81, 0xFC, 0x1E, 0x0E, 0xE1, 0xF0, 0x77, 0x0F, 0x87,
  0x38, 0x7C, 0x39, 0xC3, 0x71, 0xC7, 0x3B, 0x8E, 0x39, 0xDC, 0x61, 0xCE,
  0x67, 0x0E, 0x63, 0xB8, 0x3F, 0x1D, 0xC1, 0xF8, 0x6C, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0xF0, 0x39, 0xC1, 0xE7, 0x87, 0x0E, 0x3C, 0x1C, 0xE0, 0x77, 0x80,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0,
  0x73, 0x83, 0xCE, 0x0E, 0x1C, 0x78, 0x71, 0xC0, 0xEF, 0x03, 0xC0, 0xE0,
  0x3F, 0x01, 0xFC, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x38, 0xE3, 0x87, 0x1C,
  0x38, 0xE0, 0xC7, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x78,
  0x0F, 0x80, 0x78, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF1, 0xF0, 0xF0, 0x7C, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1F, 0x07, 0x87, 0xC7, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0xE0, 0xE0, 0x60, 0x00, 0x1E, 0x03, 0x9F, 0xC1, 0xDF, 0xF0, 0xEE,
  0x3C, 0xEE, 0x0F, 0xF7, 0x03, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 26, 9, 3, -26 },
  { 11, 8, 9, 12, 2, -27 },
  { 20, 17, 26, 20, 2, -26 },
  { 76, 14, 33, 18, 2, -30 },
  { 134, 19, 26, 23, 2, -26 },
  { 196, 17, 26, 20, 2, -26 },
  { 252, 2, 8, 6, 2, -27 },
  { 254, 8, 37, 11, 2, -29 },
  { 291, 8, 37, 11, 1, -29 },
  { 328, 15, 15, 16, 0, -26 },
  { 357, 14, 18, 18, 2, -21 },
  { 389, 4, 9, 7, 1, -4 },
  { 394, 7, 3, 9, 1, -13 },
  { 397, 4, 4, 10, 3, -4 },
  { 399, 11, 28, 13, 1, -26 },
  { 438, 14, 26, 18, 2, -26 },
  { 484, 8, 26, 18, 3, -26 },
  { 510, 14, 26, 18, 2, -26 },
  { 556, 13, 26, 18, 2, -26 },
  { 599, 16, 26, 18, 1, -26 },
  { 651, 13, 26, 18, 3, -26 },
  { 694, 14, 26, 18, 2, -26 },
  { 740, 14, 26, 18, 2, -26 },
  { 786, 14, 26, 18, 2, -26 },
  { 832, 13, 26, 18, 2, -26 },
  { 875, 4, 20, 8, 2, -20 },
  { 885, 5, 25, 7, 1, -20 },
  { 901, 12, 16, 16, 1, -19 },
  { 925, 12, 10, 17, 3, -17 },
  { 940, 13, 16, 17, 2, -19 },
  { 966, 13, 26, 15, 1, -26 },
  { 1009, 24, 33, 28, 2, -25 },
  { 1108, 19, 26, 21, 1, -26 },
  { 1170, 15, 26, 20, 3, -26 },
  { 1219, 17, 26, 20, 2, -26 },
  { 1275, 15, 26, 21, 3, -26 },
  { 1324, 14, 26, 18, 3, -26 },
  { 1370, 13, 26, 17, 3, -26 },
  { 1413, 17, 26, 21, 2, -26 },
  { 1469, 17, 26, 22, 3, -26 },
  { 1525, 3, 26, 9, 3, -26 },
  { 1535, 14, 26, 17, 1, -26 },
  { 1581, 17, 26, 20, 3, -26 },
  { 1637, 13, 26, 17, 3, -26 },
  { 1680, 21, 26, 27, 3, -26 },
  { 1749, 17, 26, 22, 3, -26 },
  { 1805, 17, 26, 22, 2, -26 },
  { 1861, 16, 26, 20, 3, -26 },
  { 1913, 18, 30, 22, 2, -26 },
  { 1981, 16, 26, 19, 3, -26 },
  { 2033, 16, 26, 19, 1, -26 },
  { 2085, 17, 26, 19, 1, -26 },
  { 2141, 16, 26, 20, 2, -26 },
  { 2193, 18, 26, 20, 1, -26 },
  { 2252, 25, 26, 27, 1, -26 },
  { 2334, 18, 26, 20, 1, -26 },
  { 2393, 17, 26, 19, 1, -26 },
  { 2449, 15, 26, 19, 2, -26 },
  { 2498, 6, 34, 9, 2, -29 },
  { 2524, 12, 28, 13, 1, -26 },
  { 2566, 5, 34, 9, 1, -29 },
  { 2588, 11, 13, 13, 1, -26 },
  { 2606, 14, 3, 15, 0, 0 },
  { 2612, 7, 5, 11, 1, -27 },
  { 2617, 13, 19, 17, 2, -19 },
  { 2648, 14, 27, 18, 2, -27 },
  { 2696, 13, 19, 17, 2, -19 },
  { 2727, 13, 27, 18, 2, -27 },
  { 2771, 13, 19, 17, 2, -19 },
  { 2802, 10, 27, 11, 1, -27 },
  { 2836, 13, 26, 18, 2, -19 },
  { 2879, 13, 27, 17, 2, -27 },
  { 2923, 4, 26, 8, 2, -26 },
  { 2936, 6, 33, 8, 0, -26 },
  { 2961, 14, 27, 16, 2, -27 },
  { 3009, 3, 27, 8, 3, -27 },
  { 3020, 23, 19, 27, 2, -19 },
  { 3075, 13, 19, 17, 2, -19 },
  { 3106, 14, 19, 18, 2, -19 },
  { 3140, 14, 26, 18, 2, -19 },
  { 3186, 13, 26, 18, 2, -19 },
  { 3229, 8, 19, 11, 2, -19 },
  { 3248, 13, 19, 16, 2, -19 },
  { 3279, 9, 24, 11, 0, -24 },
  { 3306, 13, 19, 17, 2, -19 },
  { 3337, 14, 19, 15, 1, -19 },
  { 3371, 21, 19, 23, 1, -19 },
  { 3421, 14, 19, 16, 1, -19 },
  { 3455, 13, 26, 15, 1, -19 },
  { 3498, 12, 19, 16, 2, -19 },
  { 3527, 9, 34, 11, 1, -28 },
  { 3566, 3, 31, 9, 3, -26 },
  { 3578, 9, 34, 11, 1, -28 },
  { 3617, 17, 7, 21, 2, -14 },
};

const GFXfont RobotoCondensed_Regular36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_REGULAR36PT7B_H_
