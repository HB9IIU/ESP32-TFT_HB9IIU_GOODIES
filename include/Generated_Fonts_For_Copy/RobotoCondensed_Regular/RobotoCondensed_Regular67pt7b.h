#ifndef _ROBOTOCONDENSED_REGULAR67PT7B_H_
#define _ROBOTOCONDENSED_REGULAR67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xFF, 0xBE, 0x38, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03,
  0xE0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFE,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x9F, 0xE0, 0x3F, 0xC7, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x30, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0xF0,
  0x0F, 0x80, 0x78, 0x1F, 0x00, 0xF8, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78,
  0x3E, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF8, 0x7C, 0x00, 0x7C,
  0x0F, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0x00,
  0x01, 0xFF, 0xE1, 0xF0, 0x00, 0x0F, 0xFC, 0x1E, 0x00, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00, 0x3C,
  0x1F, 0xF8, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x00, 0x78, 0x7F, 0xFE, 0x00,
  0x0F, 0x87, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x60, 0x07, 0x81, 0xF0, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0x81, 0xFC, 0xFE, 0x07, 0xC1, 0xFC, 0x3F, 0x03, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF0, 0xFC, 0x07, 0xF0, 0xF8, 0x7E, 0x01, 0xFC, 0x7C,
  0x3F, 0x00, 0xFE, 0x7E, 0x3F, 0x00, 0x3F, 0xBF, 0x1F, 0x80, 0x0F, 0xFF,
  0x0F, 0xC0, 0x07, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0xC1, 0xF0, 0x00, 0x7F,
  0xC0, 0xFC, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07,
  0xF8, 0x0F, 0xC0, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x01, 0xFE, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF3, 0xF8, 0x07, 0xFF,
  0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x40, 0x40, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x1F, 0x00, 0xCF,
  0x83, 0xE0, 0xF9, 0xFE, 0x7C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0x8F, 0xC7, 0xE7, 0xE3, 0xE3, 0xF0, 0xF0, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x07,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x0F, 0xBF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF,
  0x9F, 0xF8, 0xFE, 0x01, 0xFC, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x9F, 0xC0, 0x3F, 0x87, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xC7,
  0xFF, 0x01, 0xF3, 0xFF, 0xE0, 0x7D, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFE, 0x0F, 0xE3, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x3F, 0xC0, 0x07,
  0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xC7, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7F,
  0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xE0, 0x0F,
  0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xF8,
  0x3F, 0x83, 0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xE0, 0x0F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xF3,
  0xF8, 0x07, 0xFC, 0x7F, 0x87, 0xFF, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFB,
  0xE0, 0x7F, 0xFC, 0xF8, 0x0F, 0xFE, 0x3E, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x08, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x3E, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x1C, 0x02, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0x38,
  0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xFF, 0x80, 0x3C,
  0x1E, 0x00, 0x3F, 0xFC, 0x01, 0xE3, 0xE0, 0x07, 0xFF, 0xF0, 0x1E, 0x3C,
  0x00, 0xFE, 0x3F, 0x01, 0xE3, 0xC0, 0x0F, 0x81, 0xE0, 0x0E, 0x7C, 0x01,
  0xF0, 0x1E, 0x00, 0xF7, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x78, 0x03, 0xE0,
  0x1E, 0x00, 0xF7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x3E, 0x00,
  0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFF,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xFF, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xEF, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xCF, 0x80, 0xFC, 0x1F, 0xE0, 0x7C, 0x78,
  0x07, 0xE3, 0xFE, 0x07, 0x87, 0x80, 0x7F, 0xFB, 0xF1, 0xF8, 0x78, 0x07,
  0xFF, 0x9F, 0xFF, 0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3C, 0x01, 0xFE,
  0x07, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xCF, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0xFF,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0x3F,
  0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xCF, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x9F, 0xC0, 0x1F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0xCF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x1F, 0xBF, 0xC0, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x07,
  0xFE, 0x7F, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xDF, 0xFD, 0xF0, 0x00, 0x0F,
  0xDF, 0xFD, 0xF0, 0x00, 0x0F, 0xDF, 0xFD, 0xF8, 0x00, 0x0F, 0x9F, 0xFC,
  0xF8, 0x00, 0x0F, 0x9F, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0xFC, 0xFC, 0x00,
  0x1F, 0x1F, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0xFC, 0x7C, 0x00, 0x3F, 0x1F,
  0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0xFC, 0x3E,
  0x00, 0x7E, 0x1F, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0xFC, 0x1F, 0x00, 0x7C,
  0x1F, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0xFC, 0x1F, 0x80, 0xF8, 0x3F, 0xFC,
  0x0F, 0x80, 0xF8, 0x3F, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1,
  0xF0, 0x3F, 0xFC, 0x07, 0xC1, 0xF0, 0x3F, 0xFC, 0x07, 0xC3, 0xF0, 0x3F,
  0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0xFC, 0x03,
  0xE7, 0xE0, 0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xF7, 0xC0,
  0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0xBF, 0x00, 0x0F, 0xFF, 0x3F, 0x00,
  0x1F, 0xFE, 0x7E, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xF8, 0x7C, 0x00,
  0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0xC1, 0xF8, 0x07,
  0xFF, 0x81, 0xF0, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x03, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF,
  0xE0, 0x0F, 0x83, 0xFF, 0xC0, 0x1F, 0x87, 0xFF, 0x80, 0x1F, 0x0F, 0xFF,
  0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x3E, 0x3F, 0xFC, 0x00, 0x7E, 0x7F, 0xF8,
  0x00, 0x7C, 0xFF, 0xF0, 0x00, 0xFD, 0xFF, 0xE0, 0x00, 0xFB, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xC3, 0xF0,
  0x00, 0xFF, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF,
  0x1F, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFF,
  0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0x3F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0x8F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xCF, 0x00, 0x3F, 0x07,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0xFC,
  0x07, 0xC3, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x07, 0xC0, 0xFC, 0x01, 0xF0,
  0x3E, 0x07, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x07, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x3C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x00, 0x3E, 0x1F,
  0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xF8,
  0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x80, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x07, 0xCF, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x87, 0xFF, 0x07, 0xC7, 0xF8, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xFB, 0xF8,
  0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x87,
  0xFF, 0xCF, 0xC1, 0xFF, 0x87, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x03, 0xF1, 0xFF,
  0xC0, 0xFC, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFC, 0xFF, 0x80, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x80, 0x7F, 0x3F,
  0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF0, 0xFC, 0xFF, 0xF8,
  0x3F, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x03, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x07, 0xFE, 0x3F,
  0x07, 0xFF, 0xCF, 0xC3, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xC7,
  0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xC0, 0x0F, 0xF7, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xC7, 0xFC,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xBF, 0x07, 0xFF, 0xCF, 0xC0,
  0x7F, 0xE3, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8,
  0x7F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x02, 0x0F, 0xC0, 0x01, 0xC3, 0xFC, 0x01, 0xF8, 0x7F,
  0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xE3, 0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFC, 0x7F, 0xF3, 0xF8, 0x07, 0xFC, 0xFC, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xF3, 0xF8,
  0x07, 0xFC, 0x7F, 0xCF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFC, 0xFC, 0x07, 0xFE, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0xC0, 0x03, 0xF8, 0x78, 0x00, 0xFC, 0x1F, 0x80, 0xFF, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0x80, 0xFC, 0x3F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF3, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x38, 0xF9,
  0xFF, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFB, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x3F, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xCF, 0xFF, 0x87,
  0xFF, 0xE3, 0xF7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xF8, 0xFF, 0xFE, 0x3F, 0xEF, 0xF0, 0x0F, 0xFE, 0x03, 0xFB, 0xF8,
  0x01, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0xFC, 0x3F,
  0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xF3,
  0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x1F, 0xFC, 0x0F,
  0xCF, 0xFF, 0x83, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF,
  0xCF, 0xF8, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x07, 0xF3, 0xFF, 0x07,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0x83, 0xF1,
  0xFF, 0xC0, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE3, 0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF,
  0xBF, 0x1F, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xF8, 0x03, 0xFC, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0,
  0x07, 0xF3, 0xF8, 0x03, 0xFC, 0x7F, 0x83, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFB, 0xF0, 0x7F, 0xFC, 0xFC, 0x07, 0xFE, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xF8, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F,
  0x3F, 0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7F, 0x01, 0xFF, 0x3F, 0xCF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0x1F, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7C,
  0x7E, 0x00, 0xFF, 0x00, 0x7C, 0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x3E, 0x01,
  0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xF8, 0x3F, 0x01, 0xFF, 0x80,
  0xF8, 0x3F, 0x03, 0xEF, 0x80, 0xF8, 0x1F, 0x03, 0xEF, 0x81, 0xF8, 0x1F,
  0x03, 0xE7, 0xC1, 0xF0, 0x1F, 0x87, 0xC7, 0xC1, 0xF0, 0x1F, 0x87, 0xC7,
  0xC1, 0xF0, 0x0F, 0x87, 0xC7, 0xC1, 0xF0, 0x0F, 0x87, 0xC3, 0xE3, 0xF0,
  0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x07, 0xF0, 0xFC,
  0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC7, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x03,
  0x80, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3C,
  0x3F, 0xF8, 0x00, 0x78, 0xFF, 0xF8, 0x01, 0xF3, 0xFF, 0xF8, 0x03, 0xEF,
  0xE7, 0xF8, 0x07, 0xDF, 0x83, 0xF8, 0x1F, 0x3E, 0x03, 0xFC, 0x7E, 0xFC,
  0x03, 0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0xC7, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 49, 16, 5, -48 },
  { 44, 14, 16, 21, 4, -50 },
  { 72, 31, 48, 37, 4, -48 },
  { 258, 25, 63, 33, 4, -56 },
  { 455, 36, 50, 42, 3, -49 },
  { 680, 33, 50, 36, 3, -49 },
  { 887, 5, 16, 12, 3, -50 },
  { 897, 15, 69, 21, 4, -54 },
  { 1027, 15, 69, 21, 2, -54 },
  { 1157, 27, 28, 29, 1, -48 },
  { 1252, 27, 35, 33, 3, -40 },
  { 1371, 9, 17, 13, 1, -7 },
  { 1391, 13, 5, 17, 2, -23 },
  { 1400, 7, 8, 18, 5, -7 },
  { 1407, 22, 52, 25, 1, -48 },
  { 1550, 25, 50, 33, 4, -49 },
  { 1707, 16, 48, 33, 5, -48 },
  { 1803, 27, 49, 33, 3, -49 },
  { 1969, 26, 50, 33, 3, -49 },
  { 2132, 29, 48, 33, 2, -48 },
  { 2306, 25, 49, 33, 5, -48 },
  { 2460, 26, 49, 33, 4, -48 },
  { 2620, 27, 48, 33, 3, -48 },
  { 2782, 25, 50, 33, 4, -49 },
  { 2939, 26, 49, 33, 3, -49 },
  { 3099, 8, 37, 16, 4, -36 },
  { 3136, 10, 46, 14, 1, -36 },
  { 3194, 22, 30, 30, 3, -36 },
  { 3277, 23, 19, 32, 5, -32 },
  { 3332, 24, 30, 31, 4, -36 },
  { 3422, 22, 50, 28, 3, -49 },
  { 3560, 44, 62, 52, 4, -47 },
  { 3901, 36, 48, 39, 1, -48 },
  { 4117, 28, 48, 37, 5, -48 },
  { 4285, 31, 50, 38, 4, -49 },
  { 4479, 29, 48, 38, 5, -48 },
  { 4653, 26, 48, 33, 5, -48 },
  { 4809, 25, 48, 32, 5, -48 },
  { 4959, 31, 50, 40, 4, -49 },
  { 5153, 31, 48, 42, 5, -48 },
  { 5339, 6, 48, 17, 5, -48 },
  { 5375, 26, 49, 32, 2, -48 },
  { 5535, 31, 48, 37, 5, -48 },
  { 5721, 25, 48, 32, 5, -48 },
  { 5871, 40, 48, 51, 5, -48 },
  { 6111, 31, 48, 42, 5, -48 },
  { 6297, 32, 50, 40, 4, -49 },
  { 6497, 30, 48, 37, 5, -48 },
  { 6677, 33, 57, 40, 4, -49 },
  { 6913, 29, 48, 36, 5, -48 },
  { 7087, 29, 50, 35, 3, -49 },
  { 7269, 31, 48, 35, 2, -48 },
  { 7455, 30, 49, 38, 4, -48 },
  { 7639, 35, 48, 38, 1, -48 },
  { 7849, 47, 48, 51, 2, -48 },
  { 8131, 33, 48, 37, 2, -48 },
  { 8329, 33, 48, 35, 1, -48 },
  { 8527, 29, 48, 35, 3, -48 },
  { 8701, 10, 64, 17, 5, -54 },
  { 8781, 22, 52, 25, 2, -48 },
  { 8924, 11, 64, 17, 1, -54 },
  { 9012, 21, 24, 25, 2, -48 },
  { 9075, 25, 5, 27, 1, 0 },
  { 9091, 14, 10, 21, 2, -51 },
  { 9109, 25, 37, 32, 4, -36 },
  { 9225, 26, 51, 33, 4, -50 },
  { 9391, 26, 37, 31, 3, -36 },
  { 9512, 26, 51, 33, 3, -50 },
  { 9678, 26, 37, 31, 3, -36 },
  { 9799, 19, 51, 21, 2, -51 },
  { 9921, 26, 50, 33, 3, -36 },
  { 10084, 24, 50, 32, 4, -50 },
  { 10234, 7, 48, 15, 4, -48 },
  { 10276, 12, 62, 15, -1, -48 },
  { 10369, 26, 50, 30, 4, -50 },
  { 10532, 6, 50, 15, 5, -50 },
  { 10570, 42, 36, 50, 4, -36 },
  { 10759, 24, 36, 32, 4, -36 },
  { 10867, 28, 37, 34, 3, -36 },
  { 10997, 26, 50, 33, 4, -36 },
  { 11160, 26, 50, 34, 3, -36 },
  { 11323, 15, 36, 20, 4, -36 },
  { 11391, 24, 37, 31, 3, -36 },
  { 11502, 16, 45, 20, 1, -44 },
  { 11592, 24, 36, 32, 4, -35 },
  { 11700, 26, 35, 29, 1, -35 },
  { 11814, 40, 35, 44, 2, -35 },
  { 11989, 26, 35, 29, 2, -35 },
  { 12103, 26, 49, 28, 1, -35 },
  { 12263, 24, 35, 29, 3, -35 },
  { 12368, 17, 64, 21, 2, -52 },
  { 12504, 5, 57, 16, 6, -48 },
  { 12540, 17, 64, 21, 1, -52 },
  { 12676, 31, 13, 39, 4, -26 },
};

const GFXfont RobotoCondensed_Regular67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_REGULAR67PT7B_H_
