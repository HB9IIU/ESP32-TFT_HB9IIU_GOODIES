#ifndef _ROBOTOCONDENSED_REGULAR57PT7B_H_
#define _ROBOTOCONDENSED_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x40, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x70,
  0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x40, 0x3C,
  0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x0F, 0x01, 0xE0,
  0x38, 0x1C, 0x03, 0xC0, 0x70, 0x78, 0x07, 0x80, 0xE0, 0xE0, 0x0F, 0x03,
  0xC3, 0xC0, 0x1E, 0x07, 0x87, 0x00, 0x1C, 0x0F, 0x1E, 0x00, 0x3C, 0x3C,
  0x38, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x7F, 0x87,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x80, 0x00, 0x0F, 0x0F,
  0xE0, 0x00, 0x3C, 0x3F, 0xE0, 0x00, 0x78, 0xFF, 0xE0, 0x01, 0xE3, 0xE3,
  0xE0, 0x03, 0xC7, 0x83, 0xC0, 0x0F, 0x0E, 0x03, 0x80, 0x1C, 0x3C, 0x07,
  0x00, 0x78, 0x78, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x3C,
  0x07, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x01,
  0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x78, 0x3F,
  0x3F, 0x07, 0x87, 0xE3, 0xF0, 0x78, 0x7C, 0x1F, 0x87, 0x8F, 0xC0, 0xFC,
  0x78, 0xF8, 0x0F, 0xCF, 0x8F, 0x80, 0x7E, 0xF8, 0xF8, 0x03, 0xFF, 0x0F,
  0x80, 0x1F, 0xF0, 0xF8, 0x01, 0xFF, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xC7, 0xC0, 0x3F,
  0xF0, 0x7E, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x10, 0x03, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x00, 0x10, 0x40, 0x03, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x03, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x30, 0x3C, 0x06, 0x7C, 0x78, 0x7D, 0xFF, 0xF7, 0xFB, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x0F, 0x9F, 0x00, 0x1E, 0x1F,
  0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x70, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x78,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC7, 0xE0, 0x0F, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0x81, 0xFC, 0x3C, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x80,
  0x7C, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE1, 0xF8, 0x1F, 0x3F, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xE3, 0xF9, 0xFC, 0x07, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF,
  0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xFE, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xE7,
  0xF1, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xF7, 0xC1, 0xFF, 0x3E, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCF, 0xFF, 0xFF,
  0xF7, 0x80, 0x0C, 0x0F, 0x8F, 0xC7, 0xF3, 0xF0, 0xF8, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0x83, 0xC0, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x07,
  0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x3F, 0x00, 0x70, 0x78, 0x03, 0xFE,
  0x01, 0xE3, 0xC0, 0x1F, 0xFE, 0x03, 0x8F, 0x00, 0xFF, 0xF8, 0x0E, 0x3C,
  0x03, 0xC1, 0xE0, 0x39, 0xE0, 0x1E, 0x07, 0x80, 0xF7, 0x80, 0x78, 0x1E,
  0x03, 0xDE, 0x03, 0xC0, 0x78, 0x0F, 0x78, 0x0F, 0x01, 0xE0, 0x1D, 0xC0,
  0x7C, 0x07, 0x80, 0x77, 0x01, 0xE0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0x78,
  0x07, 0xF0, 0x1E, 0x01, 0xE0, 0x1F, 0xC0, 0x78, 0x07, 0x00, 0x7F, 0x03,
  0xE0, 0x1C, 0x01, 0xFC, 0x0F, 0x80, 0xF0, 0x07, 0xF0, 0x3C, 0x03, 0xC0,
  0x3F, 0xC0, 0xF0, 0x0F, 0x00, 0xFF, 0x03, 0xC0, 0x3C, 0x03, 0xBC, 0x0F,
  0x00, 0xF0, 0x0E, 0xF0, 0x3E, 0x03, 0xC0, 0x3B, 0xC0, 0xF8, 0x1F, 0x01,
  0xE7, 0x01, 0xE0, 0x7C, 0x07, 0x1C, 0x07, 0xC3, 0xF8, 0x3C, 0x78, 0x1F,
  0xFD, 0xE1, 0xE1, 0xE0, 0x3F, 0xF7, 0xFF, 0x87, 0x80, 0xFF, 0x8F, 0xFC,
  0x0F, 0x01, 0xFC, 0x1F, 0xC0, 0x3C, 0x00, 0x80, 0x08, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x07,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xF8, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xF8, 0x07,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF9, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0x81, 0xFF, 0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x01,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x3E, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0x8F, 0x81, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7E,
  0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xDF, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7D,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0x80,
  0x07, 0xF9, 0xF8, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xC1, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1,
  0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFD, 0xF0, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x0F, 0xBF, 0xF7,
  0xC0, 0x01, 0xF7, 0xFE, 0x7C, 0x00, 0x3C, 0xFF, 0xCF, 0x80, 0x0F, 0x9F,
  0xF9, 0xF0, 0x01, 0xF3, 0xFF, 0x1E, 0x00, 0x3C, 0x7F, 0xE3, 0xE0, 0x0F,
  0x8F, 0xFC, 0x7C, 0x01, 0xF1, 0xFF, 0x87, 0x80, 0x3C, 0x3F, 0xF0, 0xF8,
  0x0F, 0x87, 0xFE, 0x1F, 0x01, 0xF0, 0xFF, 0xC1, 0xE0, 0x3C, 0x1F, 0xF8,
  0x3E, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xF0, 0x7F, 0xE0, 0x78, 0x3C, 0x0F,
  0xFC, 0x0F, 0x8F, 0x81, 0xFF, 0x81, 0xF1, 0xF0, 0x3F, 0xF0, 0x1E, 0x3C,
  0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07,
  0xBC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF0, 0x07, 0xF0, 0x07,
  0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x78, 0x00, 0x7F,
  0xEF, 0x80, 0x0F, 0xFC, 0xF0, 0x01, 0xFF, 0x9F, 0x00, 0x3F, 0xF1, 0xE0,
  0x07, 0xFE, 0x3E, 0x00, 0xFF, 0xC3, 0xC0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF,
  0x07, 0x80, 0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0,
  0x3F, 0xF0, 0x1F, 0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x3E, 0x1F, 0xF8,
  0x07, 0xC3, 0xFF, 0x00, 0x7C, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x00, 0xF9,
  0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x01, 0xF7, 0xFE, 0x00, 0x3E, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0xE7, 0xC0, 0x03, 0xFB, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xEF, 0x80, 0x3F, 0xE7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x04, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03,
  0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xDF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF0, 0xFE, 0x03,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xC7,
  0xF0, 0x0F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xFF,
  0x00, 0x7C, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0x00, 0x7C,
  0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x3E, 0x01, 0xE7, 0x80, 0x78, 0x1F, 0x01,
  0xE7, 0x80, 0xF8, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x1F, 0x03, 0xE7, 0xC0,
  0xF8, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x0F, 0x87, 0x81,
  0xE1, 0xF0, 0x0F, 0x87, 0x81, 0xE1, 0xF0, 0x0F, 0x87, 0x81, 0xE1, 0xF0,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x07, 0xCF,
  0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0xF3,
  0xE0, 0x03, 0xDF, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0,
  0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBE, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE3, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3E, 0x7C, 0x0F, 0x3C, 0x07,
  0xBE, 0x03, 0xFF, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xF8, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F,
  0x83, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xEF, 0x8F, 0xFE, 0x7C, 0x3F, 0xE3,
  0xE0, 0x10, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE7, 0xFC, 0x0F, 0xBF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFC, 0x1F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B,
  0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xCF,
  0xF0, 0x7F, 0x3F, 0xFF, 0xF8, 0xF7, 0xFF, 0xE3, 0xCF, 0xFF, 0x0F, 0x1F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F,
  0x8F, 0xC0, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x83, 0xFE, 0x7C, 0x3F, 0xFB, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFB, 0xF8, 0x1F, 0xDF, 0x80, 0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0xFD, 0xFC, 0x0F, 0xE7, 0xFF,
  0xFF, 0x1F, 0xFF, 0x78, 0x7F, 0xF3, 0xC1, 0xFF, 0x1E, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x23, 0xF0, 0x03, 0x8F, 0xC0, 0x3E, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF3, 0xFF, 0xFF,
  0xBF, 0x81, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F, 0xFF,
  0xF1, 0xFF, 0xF7, 0x87, 0xFF, 0x3C, 0x1F, 0xF1, 0xE0, 0x08, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF1, 0x00, 0x1F,
  0x9E, 0x01, 0xF8, 0xFC, 0x3F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x8F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0,
  0x7E, 0xFE, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF0, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x07,
  0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x9F, 0xBF, 0xEF, 0xF3, 0xF8, 0xFC,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xC0, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE7,
  0xE0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0x03,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x3F, 0xE0, 0x7F, 0xC3, 0xCF, 0xFE, 0x1F, 0xFC, 0x7B, 0xFF,
  0xE7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x0F, 0xFC, 0x1F, 0xBF,
  0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C,
  0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00,
  0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC, 0xFF,
  0xFF, 0xEF, 0xF0, 0x7E, 0xFE, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xE0, 0x7F,
  0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF0, 0xFC, 0x07,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x8F, 0xF8, 0x3C, 0xFF, 0xF1, 0xEF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xBF,
  0x81, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7D, 0xFF, 0xE3, 0xE7, 0xFC,
  0x1F, 0x02, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF3, 0xFF, 0xFF, 0xBF, 0x81, 0xFD,
  0xF8, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C,
  0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0x7C, 0x1F, 0xF3, 0xE0, 0x08, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x00, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xF7, 0xE0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFD, 0xF0, 0xFF, 0x1F, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8,
  0x03, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x07,
  0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00,
  0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xCF, 0x80, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0xF8,
  0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x78, 0x7C, 0x07, 0xF0, 0x0F, 0x0F, 0x80,
  0xFE, 0x03, 0xE1, 0xF0, 0x3F, 0xC0, 0x7C, 0x3E, 0x07, 0xFC, 0x0F, 0x03,
  0xC0, 0xF7, 0x81, 0xE0, 0x7C, 0x1E, 0xF0, 0x7C, 0x0F, 0x87, 0xDF, 0x0F,
  0x81, 0xF0, 0xF3, 0xE1, 0xF0, 0x1E, 0x1E, 0x3C, 0x3C, 0x03, 0xE3, 0xC7,
  0x87, 0x80, 0x7C, 0xF8, 0xF9, 0xF0, 0x0F, 0x9E, 0x0F, 0x3E, 0x00, 0xF3,
  0xC1, 0xE7, 0x80, 0x1E, 0x78, 0x3C, 0xF0, 0x03, 0xFF, 0x07, 0xDE, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x3E, 0x0F,
  0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0xBE, 0x00,
  0x3E, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x8F, 0x80,
  0x3E, 0x7E, 0x00, 0xFD, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFB, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0xF0, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x01, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x70, 0x01, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3C,
  0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x00, 0xF3, 0xFF, 0xF0, 0x3E, 0xF8, 0x3F,
  0x07, 0x9E, 0x03, 0xFF, 0xF3, 0xC0, 0x3F, 0xFC, 0x78, 0x03, 0xFF, 0x9F,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 42, 14, 4, -41 },
  { 33, 11, 14, 18, 4, -43 },
  { 53, 26, 41, 31, 4, -41 },
  { 187, 22, 54, 28, 3, -48 },
  { 336, 31, 43, 36, 3, -42 },
  { 503, 28, 43, 31, 3, -42 },
  { 654, 4, 13, 10, 3, -43 },
  { 661, 12, 59, 18, 4, -46 },
  { 750, 13, 59, 18, 1, -46 },
  { 846, 23, 24, 25, 1, -41 },
  { 915, 24, 30, 28, 2, -34 },
  { 1005, 8, 14, 11, 1, -6 },
  { 1019, 12, 4, 14, 1, -19 },
  { 1025, 6, 7, 15, 4, -6 },
  { 1031, 18, 44, 21, 1, -41 },
  { 1130, 22, 43, 28, 3, -42 },
  { 1249, 14, 41, 28, 4, -41 },
  { 1321, 23, 42, 28, 3, -42 },
  { 1442, 21, 43, 28, 3, -42 },
  { 1555, 24, 41, 28, 2, -41 },
  { 1678, 22, 42, 28, 4, -41 },
  { 1794, 21, 42, 28, 4, -41 },
  { 1905, 24, 41, 28, 2, -41 },
  { 2028, 22, 43, 28, 3, -42 },
  { 2147, 21, 42, 28, 3, -42 },
  { 2258, 6, 32, 13, 4, -31 },
  { 2282, 9, 39, 12, 1, -31 },
  { 2326, 19, 26, 25, 2, -31 },
  { 2388, 20, 15, 27, 4, -27 },
  { 2426, 20, 26, 26, 4, -31 },
  { 2491, 20, 43, 24, 2, -42 },
  { 2599, 38, 53, 44, 3, -40 },
  { 2851, 31, 41, 33, 1, -41 },
  { 3010, 24, 41, 31, 4, -41 },
  { 3133, 27, 43, 32, 3, -42 },
  { 3279, 25, 41, 33, 4, -41 },
  { 3408, 22, 41, 28, 4, -41 },
  { 3521, 21, 41, 27, 4, -41 },
  { 3629, 27, 43, 34, 3, -42 },
  { 3775, 27, 41, 35, 4, -41 },
  { 3914, 5, 41, 14, 5, -41 },
  { 3940, 21, 42, 28, 2, -41 },
  { 4051, 27, 41, 31, 4, -41 },
  { 4190, 21, 41, 27, 4, -41 },
  { 4298, 35, 41, 43, 4, -41 },
  { 4478, 27, 41, 35, 4, -41 },
  { 4617, 28, 43, 34, 3, -42 },
  { 4768, 25, 41, 32, 4, -41 },
  { 4897, 28, 49, 34, 3, -42 },
  { 5069, 25, 41, 30, 4, -41 },
  { 5198, 25, 43, 30, 2, -42 },
  { 5333, 26, 41, 30, 2, -41 },
  { 5467, 25, 42, 32, 4, -41 },
  { 5599, 30, 41, 32, 1, -41 },
  { 5753, 40, 41, 43, 2, -41 },
  { 5958, 28, 41, 31, 2, -41 },
  { 6102, 28, 41, 30, 1, -41 },
  { 6246, 24, 41, 30, 3, -41 },
  { 6369, 9, 55, 14, 4, -46 },
  { 6431, 19, 44, 21, 1, -41 },
  { 6536, 9, 55, 14, 1, -46 },
  { 6598, 17, 20, 21, 2, -41 },
  { 6641, 21, 4, 23, 1, 0 },
  { 6652, 11, 8, 18, 2, -43 },
  { 6663, 21, 32, 27, 3, -31 },
  { 6747, 22, 44, 28, 4, -43 },
  { 6868, 21, 32, 26, 3, -31 },
  { 6952, 21, 44, 28, 3, -43 },
  { 7068, 21, 32, 27, 3, -31 },
  { 7152, 15, 44, 18, 2, -44 },
  { 7235, 21, 43, 28, 3, -31 },
  { 7348, 20, 43, 28, 4, -43 },
  { 7456, 5, 41, 13, 4, -41 },
  { 7482, 10, 53, 13, -1, -41 },
  { 7549, 21, 43, 26, 4, -43 },
  { 7662, 5, 43, 13, 4, -43 },
  { 7689, 35, 31, 43, 4, -31 },
  { 7825, 20, 31, 28, 4, -31 },
  { 7903, 23, 32, 29, 3, -31 },
  { 7995, 21, 43, 28, 4, -31 },
  { 8108, 21, 43, 29, 3, -31 },
  { 8221, 12, 31, 17, 4, -31 },
  { 8268, 20, 32, 26, 3, -31 },
  { 8348, 14, 38, 17, 1, -37 },
  { 8415, 20, 31, 28, 4, -30 },
  { 8493, 22, 30, 24, 1, -30 },
  { 8576, 35, 30, 37, 1, -30 },
  { 8708, 22, 30, 25, 1, -30 },
  { 8791, 22, 42, 24, 1, -30 },
  { 8907, 20, 30, 25, 3, -30 },
  { 8982, 14, 54, 17, 2, -44 },
  { 9077, 4, 49, 14, 5, -41 },
  { 9102, 14, 54, 17, 1, -44 },
  { 9197, 27, 11, 34, 3, -22 },
};

const GFXfont RobotoCondensed_Regular57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_REGULAR57PT7B_H_
