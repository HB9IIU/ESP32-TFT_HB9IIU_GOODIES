#ifndef _ROBOTOCONDENSED_EXTRABOLD32PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0x00,
  0x1D, 0xFF, 0xFD, 0xC0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xC7, 0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCE,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1D, 0xC0, 0x33, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x33, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0x9F, 0x1F, 0x7C,
  0x7D, 0xF1, 0xF7, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x7D, 0xF1, 0xF7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xCE, 0x38, 0xF3, 0x8E, 0x3C,
  0xE7, 0x0F, 0x39, 0x81, 0xCE, 0xE0, 0x7F, 0xF0, 0x0F, 0xDC, 0x01, 0xEE,
  0x00, 0x03, 0x80, 0x01, 0xCF, 0x00, 0x7F, 0xE0, 0x3B, 0xFC, 0x0E, 0xE7,
  0x07, 0x79, 0xC1, 0xDE, 0x70, 0xE7, 0x9C, 0x30, 0xE7, 0x04, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xCF, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF1, 0xE3, 0xFC, 0xF3, 0xFE, 0x7B, 0xEF, 0xFD,
  0xF3, 0xFC, 0xF9, 0xFE, 0x7C, 0x7F, 0x3F, 0x1F, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3E, 0x7E, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x06, 0x0F,
  0x1E, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x38,
  0x3C, 0x1E, 0x0E, 0x06, 0x02, 0x40, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C,
  0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0,
  0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x38, 0xCF, 0xFF,
  0x9F, 0xFF, 0x87, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0x81, 0xE3, 0x81,
  0x87, 0x01, 0x04, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7B, 0xDE, 0xF7, 0xBD, 0xFE, 0xE3,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x0F, 0xFE,
  0x7C, 0xF9, 0xF1, 0xE7, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE, 0x1F, 0x78, 0x7D, 0xF1,
  0xE7, 0xCF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x83,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xEF, 0x87,
  0xFE, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE,
  0xF8, 0xFB, 0xE1, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xCF, 0xDF, 0xFE, 0x7F, 0xF0, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xBC,
  0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7B, 0xC1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE,
  0x18, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0xCF,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x80,
  0xFE, 0x07, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7D, 0xE1,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0x78, 0x7D, 0xF1, 0xF7, 0xC7, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F,
  0xFE, 0x7C, 0xF9, 0xF1, 0xE7, 0xC7, 0x9F, 0x1E, 0x7C, 0xF8, 0xFF, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xF9, 0xF3, 0xE7, 0x87, 0xDE, 0x1F, 0xF8, 0x7D,
  0xE1, 0xF7, 0xCF, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x07,
  0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x7C, 0xF9, 0xF1, 0xEF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDF, 0x1F, 0x7F, 0xFC, 0xFF, 0xF3,
  0xFF, 0x83, 0xDE, 0x00, 0xF8, 0x03, 0xC0, 0x3F, 0x07, 0xF8, 0x1F, 0xC0,
  0x7E, 0x01, 0xE0, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3B, 0xFF, 0xFB, 0x80, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xCF, 0x3C, 0xF3, 0xDE, 0x79, 0xCF, 0x08, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xF3, 0xFF, 0xFF, 0x3F, 0x87, 0xC0, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xF0, 0x3E, 0x01, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C,
  0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x7F, 0xC1, 0xF8, 0x0F, 0x0F, 0xE7, 0xFF,
  0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xEF,
  0xFF, 0xF9, 0xFF, 0x9F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xC0, 0x7C, 0x1E, 0x00, 0x70, 0x70, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x0F, 0x87, 0x70, 0x7F, 0x1D, 0xC3, 0xFC, 0x77, 0x1E, 0x71,
  0xFC, 0x71, 0xC7, 0xE3, 0xC7, 0x1F, 0x8F, 0x1C, 0x7E, 0x38, 0x71, 0xF8,
  0xE1, 0xC7, 0xE3, 0x87, 0x1F, 0x8F, 0x3C, 0x7E, 0x3C, 0xF3, 0xBC, 0xFF,
  0xFE, 0x71, 0xFF, 0xF1, 0xC3, 0xCF, 0x87, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x08, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0xFF, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E,
  0xF8, 0x7D, 0xF3, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xDF, 0x0F, 0xBE,
  0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xF7, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xF8, 0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x8F,
  0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7D, 0xF0,
  0xFB, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xF0, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x7E,
  0x00, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9,
  0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0, 0xF9, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xB8, 0x7F, 0xFD, 0xE7, 0xBF, 0xEF, 0x3D, 0xFF, 0x79, 0xEF, 0xF9,
  0xEE, 0x7F, 0xCF, 0xF3, 0xFF, 0x7F, 0x9F, 0xF9, 0xFC, 0xFF, 0xCF, 0xC7,
  0xFE, 0x7E, 0x3F, 0xF3, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x78, 0x7F, 0xE3,
  0xC3, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0x9F,
  0xFB, 0xDF, 0xFB, 0xDF, 0xF9, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0,
  0xF9, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x0F, 0x9F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F,
  0xC0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFE, 0x3F, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9F,
  0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0x80, 0x01, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFB, 0xE1, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0x7C,
  0xF8, 0xF9, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xEF, 0x87, 0xDF, 0x0F,
  0xFE, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7,
  0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7D, 0xF0, 0xFB, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF,
  0x87, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFD,
  0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x0F, 0x3E, 0x03, 0xEF,
  0x80, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x78, 0x7F,
  0xE1, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x79, 0xE3,
  0xF1, 0xE7, 0x8F, 0xCF, 0x9F, 0x7F, 0x3E, 0x7D, 0xFE, 0xF9, 0xF7, 0xFB,
  0xE7, 0xDF, 0xEF, 0x0F, 0x7F, 0xBC, 0x3D, 0xFE, 0xF0, 0xFF, 0x7F, 0xC3,
  0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8,
  0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C,
  0x00, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x3E,
  0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x1F, 0x87, 0xE7, 0xC0, 0xF8, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xC7,
  0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0x78, 0x0F, 0x7C,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0xFF, 0xFF, 0xFF, 0x1E, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF8, 0x77, 0x1E, 0xE3, 0x9E, 0x71, 0xDE, 0x3B, 0xC7, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0xC1,
  0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0x00, 0x7C, 0x03, 0xE3, 0xFF, 0x3F,
  0xFB, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x3E, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0xF8, 0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF,
  0x7F, 0xFB, 0xFF, 0x9E, 0xF8, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF1,
  0xFF, 0x8F, 0xBF, 0xF9, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xCF, 0x3F, 0x7B,
  0xFF, 0xDF, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF7, 0xFF, 0xBF, 0xFC, 0xFD, 0xE3, 0xCF,
  0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xEF, 0x87,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x7C, 0x31, 0xFF,
  0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x03, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F,
  0x0F, 0x83, 0xE3, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x1F, 0x7C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x7D, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01, 0xF0, 0x07, 0xC4, 0x3E, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFF, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x3C, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x39, 0xEF, 0xDF,
  0x78, 0x00, 0x1E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x0E, 0x1E, 0x3F, 0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x7E,
  0xF1, 0xF3, 0xCF, 0xCF, 0x3E, 0x3D, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xBE, 0x3C, 0xF8, 0xF1, 0xF3, 0xC7,
  0xCF, 0x0F, 0xBC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F,
  0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1,
  0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xF0, 0xF9,
  0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x78, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xFC, 0xFB,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xFC, 0xF9, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0xF7, 0xC7, 0xFF,
  0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0xF7,
  0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x1E, 0x79, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF,
  0xE7, 0xFF, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xF7, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x83, 0xFE, 0x7F,
  0xFF, 0xDF, 0xF8, 0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03,
  0xFF, 0x1F, 0xF0, 0xFF, 0xDF, 0x7F, 0xF3, 0xFE, 0x1F, 0x80, 0x3E, 0x1F,
  0x0F, 0x87, 0xCF, 0xFF, 0xFF, 0xFE, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xC7, 0xE3, 0xF0, 0xF8, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF7, 0xCF, 0xBF, 0xFD, 0xFF, 0xE7, 0xEF,
  0x1E, 0x78, 0xF8, 0x7D, 0xF1, 0xF7, 0xC7, 0x9F, 0x1E, 0x3C, 0xF8, 0xF3,
  0xE3, 0xEF, 0x0F, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x78, 0xF1, 0xF7, 0x8F,
  0x1E, 0x78, 0xF1, 0xE7, 0xCF, 0x1E, 0x7D, 0xFB, 0xE3, 0xDF, 0xBE, 0x3D,
  0xFB, 0xC3, 0xDF, 0xBC, 0x3F, 0xFF, 0xC3, 0xFD, 0xFC, 0x1F, 0x9F, 0xC1,
  0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0x7C, 0x7D, 0xF1, 0xE3, 0xEF, 0x8F, 0xBC, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0xFB, 0xE3, 0xCF, 0x9F, 0x1F, 0x7C, 0x7C, 0xF8, 0x7D, 0xF1,
  0xF7, 0xC7, 0xDF, 0x3E, 0x7C, 0xF8, 0xF3, 0xE3, 0xEF, 0x0F, 0xBC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x0E, 0x1F, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xF8, 0xF8, 0xF0, 0xF8, 0x78, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1F, 0x0E, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40,
  0xE0, 0xF0, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3E, 0x1F, 0x0F, 0x1F, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0xF0, 0xE0, 0x40, 0x1E, 0x00, 0x7E, 0x1D, 0xFE, 0x7B,
  0xFF, 0xF7, 0x3F, 0xDE, 0x3F, 0x80, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 8, 2, -23 },
  { 16, 8, 9, 10, 1, -24 },
  { 25, 15, 23, 17, 1, -23 },
  { 69, 14, 29, 16, 1, -26 },
  { 120, 18, 23, 21, 1, -23 },
  { 172, 17, 23, 19, 1, -23 },
  { 221, 3, 9, 5, 1, -24 },
  { 225, 8, 32, 10, 2, -25 },
  { 257, 8, 32, 10, 1, -25 },
  { 289, 15, 14, 15, 0, -23 },
  { 316, 13, 16, 15, 1, -19 },
  { 342, 5, 10, 8, 1, -4 },
  { 349, 8, 4, 13, 2, -12 },
  { 353, 5, 5, 10, 2, -5 },
  { 357, 10, 25, 10, 0, -23 },
  { 389, 14, 23, 16, 1, -23 },
  { 430, 9, 23, 16, 2, -23 },
  { 456, 14, 23, 16, 1, -23 },
  { 497, 14, 23, 16, 1, -23 },
  { 538, 14, 23, 16, 1, -23 },
  { 579, 14, 23, 16, 1, -23 },
  { 620, 14, 23, 16, 1, -23 },
  { 661, 14, 23, 16, 1, -23 },
  { 702, 14, 23, 16, 1, -23 },
  { 743, 14, 23, 16, 1, -23 },
  { 784, 5, 18, 9, 2, -18 },
  { 796, 6, 24, 9, 1, -18 },
  { 814, 11, 15, 14, 1, -17 },
  { 835, 12, 10, 16, 2, -15 },
  { 850, 11, 15, 14, 2, -17 },
  { 871, 12, 23, 15, 1, -23 },
  { 906, 22, 29, 25, 1, -22 },
  { 986, 19, 23, 19, 0, -23 },
  { 1041, 15, 23, 18, 2, -23 },
  { 1085, 16, 23, 18, 1, -23 },
  { 1131, 15, 23, 18, 2, -23 },
  { 1175, 13, 23, 16, 2, -23 },
  { 1213, 12, 23, 15, 2, -23 },
  { 1248, 16, 23, 19, 1, -23 },
  { 1294, 16, 23, 20, 2, -23 },
  { 1340, 5, 23, 9, 2, -23 },
  { 1355, 13, 23, 16, 1, -23 },
  { 1393, 16, 23, 18, 2, -23 },
  { 1439, 13, 23, 15, 2, -23 },
  { 1477, 21, 23, 24, 2, -23 },
  { 1538, 16, 23, 20, 2, -23 },
  { 1584, 17, 23, 19, 1, -23 },
  { 1633, 15, 23, 18, 2, -23 },
  { 1677, 17, 27, 19, 1, -23 },
  { 1735, 15, 23, 18, 2, -23 },
  { 1779, 15, 23, 17, 1, -23 },
  { 1823, 16, 23, 18, 1, -23 },
  { 1869, 15, 23, 18, 2, -23 },
  { 1913, 18, 23, 19, 0, -23 },
  { 1965, 22, 23, 24, 1, -23 },
  { 2029, 18, 23, 18, 0, -23 },
  { 2081, 17, 23, 18, 0, -23 },
  { 2130, 15, 23, 17, 1, -23 },
  { 2174, 6, 32, 9, 2, -27 },
  { 2198, 13, 25, 12, 0, -23 },
  { 2239, 6, 32, 9, 1, -27 },
  { 2263, 11, 11, 13, 1, -23 },
  { 2279, 12, 4, 13, 0, 0 },
  { 2285, 8, 5, 11, 1, -24 },
  { 2290, 13, 17, 15, 1, -17 },
  { 2318, 13, 24, 16, 2, -24 },
  { 2357, 13, 17, 15, 1, -17 },
  { 2385, 13, 24, 16, 1, -24 },
  { 2424, 14, 17, 15, 1, -17 },
  { 2454, 10, 24, 11, 0, -24 },
  { 2484, 14, 24, 16, 1, -17 },
  { 2526, 13, 24, 16, 1, -24 },
  { 2565, 6, 24, 8, 1, -24 },
  { 2583, 8, 31, 8, -1, -24 },
  { 2614, 14, 24, 16, 2, -24 },
  { 2656, 4, 24, 8, 2, -24 },
  { 2668, 20, 17, 24, 2, -17 },
  { 2711, 13, 17, 16, 1, -17 },
  { 2739, 14, 17, 16, 1, -17 },
  { 2769, 13, 24, 16, 2, -17 },
  { 2808, 13, 24, 16, 1, -17 },
  { 2847, 8, 17, 11, 2, -17 },
  { 2864, 12, 17, 15, 1, -17 },
  { 2890, 9, 21, 10, 0, -21 },
  { 2914, 13, 17, 16, 1, -17 },
  { 2942, 14, 17, 15, 0, -17 },
  { 2972, 20, 17, 20, 0, -17 },
  { 3015, 14, 17, 15, 0, -17 },
  { 3045, 14, 24, 15, 0, -17 },
  { 3087, 12, 17, 15, 1, -17 },
  { 3113, 8, 31, 9, 1, -25 },
  { 3144, 3, 27, 8, 3, -23 },
  { 3155, 8, 31, 9, 1, -25 },
  { 3186, 15, 7, 18, 1, -13 },
};

const GFXfont RobotoCondensed_ExtraBold32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_EXTRABOLD32PT7B_H_
