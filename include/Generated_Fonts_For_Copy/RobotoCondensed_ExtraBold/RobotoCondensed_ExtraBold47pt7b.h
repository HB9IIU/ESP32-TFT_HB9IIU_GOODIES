#ifndef _ROBOTOCONDENSED_EXTRABOLD47PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0x9F, 0x00, 0x00, 0x01,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xDF, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D,
  0xE1, 0xEF, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x9F,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x78, 0xF8, 0x30, 0x3E, 0x3E, 0x1E, 0x0F, 0x8F, 0x87, 0x83, 0xE3, 0xE3,
  0xC0, 0xF8, 0xF9, 0xF0, 0x3E, 0x3E, 0x78, 0x0F, 0x8F, 0xBE, 0x01, 0xE3,
  0xEF, 0x00, 0x7F, 0xF7, 0xC0, 0x1F, 0xFD, 0xE0, 0x03, 0xFE, 0xF0, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xDF,
  0xF0, 0x01, 0xF7, 0xFE, 0x00, 0x7B, 0xFF, 0x80, 0x3E, 0xF9, 0xF0, 0x0F,
  0x7C, 0x7C, 0x07, 0x9F, 0x1F, 0x01, 0xE7, 0xC3, 0xC0, 0xF1, 0xF0, 0xF0,
  0x3C, 0x7C, 0x7C, 0x1E, 0x1F, 0x1F, 0x07, 0x83, 0xE7, 0xC0, 0x40, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0x07, 0xFF, 0x0F, 0xC3, 0xFF, 0xE3,
  0xF0, 0xFF, 0xFC, 0xFC, 0x7F, 0x7F, 0xFF, 0x1F, 0xCF, 0xFF, 0x87, 0xF3,
  0xFF, 0xE3, 0xFC, 0x7F, 0xF8, 0xFF, 0x0F, 0xFC, 0x1F, 0xC3, 0xFF, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x38, 0x0F,
  0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0x80,
  0x10, 0x60, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x78, 0x07, 0x00, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x04, 0x0F, 0x02, 0x78, 0xF0, 0xEF, 0xEF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0x9E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0xFC, 0x0E, 0x07, 0x00,
  0x40, 0x20, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E,
  0x7C, 0xFC, 0xF8, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x7E,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x18,
  0x07, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x1F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFB, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFB, 0xF8, 0x07,
  0xDF, 0xC0, 0x7C, 0xFE, 0x03, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF1, 0xFC,
  0x1F, 0x8F, 0xE0, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE7, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0x1F, 0xE0, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFE, 0xFF, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF3, 0xE0, 0x7E, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0x1F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF1, 0xFE,
  0x7F, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0x1F, 0xE7, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0,
  0xFF, 0x7F, 0xDF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7E, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x1F, 0x0F,
  0xE3, 0xF8, 0xFF, 0x3F, 0x8F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF0, 0x7C, 0x06, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x0F,
  0xFF, 0xC1, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x1E, 0x3C, 0x07, 0xFC, 0x1E, 0x7C, 0x0F,
  0xFF, 0x1F, 0x7C, 0x1F, 0xFE, 0x0F, 0x78, 0x3F, 0x1E, 0x0F, 0xF8, 0x3E,
  0x1E, 0x0F, 0xF8, 0x7E, 0x1E, 0x0F, 0xF8, 0x7C, 0x3E, 0x0F, 0xF8, 0x7C,
  0x3E, 0x0F, 0xF0, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8,
  0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8,
  0x3E, 0x1E, 0xF0, 0xF8, 0x3E, 0x1E, 0xF0, 0xFC, 0x7E, 0x3E, 0xF8, 0x7E,
  0xFE, 0x3C, 0xF8, 0x7F, 0xFF, 0xFC, 0xF8, 0x7F, 0xDF, 0xF8, 0x78, 0x3F,
  0x8F, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xDF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x01,
  0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xBF,
  0xC0, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F,
  0xC1, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0xC0, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x1F, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xE0, 0xFF, 0x9F, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF,
  0x7E, 0x1F, 0x7F, 0xFE, 0xFC, 0x7E, 0xFF, 0xFC, 0xF8, 0xFD, 0xFF, 0xF9,
  0xF9, 0xF3, 0xFF, 0xF3, 0xF3, 0xE7, 0xFF, 0xF3, 0xEF, 0xCF, 0xFF, 0xE7,
  0xDF, 0x9F, 0xFF, 0xCF, 0xFE, 0x3F, 0xFF, 0x9F, 0xFC, 0x7F, 0xFF, 0x1F,
  0xF8, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xF8, 0x7F,
  0x87, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xC1, 0xF8,
  0x3F, 0xFF, 0x83, 0xF0, 0x7F, 0xFF, 0x07, 0xE0, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0x7C, 0x7F, 0xFF, 0x7E, 0x7F, 0xFF, 0x7E, 0x7F,
  0xFF, 0x3F, 0x7F, 0xFF, 0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x80, 0xFE,
  0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0x7F,
  0x80, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F,
  0x80, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x01,
  0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F,
  0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x3F, 0xDF, 0xE0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFE,
  0x0F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x80,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xEF,
  0xE0, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0xC3, 0xF9,
  0xFC, 0x3F, 0xE1, 0xFC, 0xFE, 0x1F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF8, 0x7F,
  0x1F, 0xC7, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0x3F, 0x87, 0xF3, 0xFF, 0x9F,
  0xC3, 0xF9, 0xFF, 0xCF, 0xE1, 0xFC, 0xFF, 0xE7, 0xF0, 0xFE, 0x7F, 0xF3,
  0xF8, 0x3F, 0x3F, 0xF9, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xBF,
  0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0x81, 0xFF, 0xF3,
  0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0,
  0x3F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xFB, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF1,
  0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F,
  0xE3, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3E, 0xF0, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F, 0x8F, 0x07, 0xC7, 0xC3, 0xE3,
  0xE3, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF9,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0x0F, 0xE7, 0xF3, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFE, 0xFE, 0x07, 0xC7,
  0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x7E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xEF, 0xF8, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F,
  0x7F, 0x07, 0xEF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xEF, 0xE0, 0xFD,
  0xFC, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE7, 0xF0, 0xFF, 0x7F, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x3F, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x0E, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x03,
  0xF3, 0xF8, 0x7F, 0xDF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xE1,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0x7F, 0x03, 0xE3, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0xC0, 0x7F, 0x07, 0xDF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0xF8, 0x7F, 0x7F, 0x8F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF7,
  0xFE, 0xFF, 0xDF, 0xF3, 0xFE, 0x7F, 0x8F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83,
  0xFD, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0x7F, 0x1F, 0xE3, 0xF9, 0xFE, 0x1F,
  0xCF, 0xF0, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x0F, 0xF7, 0xF0,
  0x7F, 0xBF, 0x81, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x3E, 0x07, 0xE3, 0xFB, 0xFE, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE,
  0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0x87,
  0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF,
  0xF8, 0x3F, 0x87, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE,
  0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x83,
  0xF8, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xE0, 0xFE,
  0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x0F, 0xE1, 0xFC, 0xFE, 0x3E, 0x1F,
  0xDF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x3F, 0x9F, 0xE1, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x7E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xEF, 0xF8, 0xFE, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0xFF, 0x3F,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x7F, 0x03, 0xE7, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xBF, 0x8F, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0x7F, 0x0F, 0xC7, 0xE0, 0x7F, 0x07, 0xFB, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0,
  0x1F, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0xFC, 0x1F, 0x07, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xEF,
  0xE1, 0xF8, 0x7E, 0x7E, 0x3F, 0x8F, 0xE7, 0xE3, 0xF8, 0xFE, 0x7E, 0x3F,
  0xCF, 0xE7, 0xE3, 0xFC, 0xFC, 0x7F, 0x7F, 0xCF, 0xC3, 0xF7, 0xFC, 0xFC,
  0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF, 0x83, 0xFF,
  0xBF, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x1F,
  0xE3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFB, 0xF8, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFB, 0xF8,
  0x3F, 0xDF, 0xC1, 0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x40, 0x1E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F,
  0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x07, 0x80, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0x01, 0xF3, 0xFE, 0x0F, 0xCF, 0xFC, 0x3E,
  0x7F, 0xF8, 0xF9, 0xFF, 0xFF, 0xEF, 0xC7, 0xFF, 0xBF, 0x0F, 0xFC, 0xF8,
  0x3F, 0xF3, 0xE0, 0x7F, 0x80, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 33, 12, 3, -33 },
  { 30, 13, 13, 15, 1, -35 },
  { 52, 22, 33, 24, 1, -33 },
  { 143, 20, 43, 24, 2, -38 },
  { 251, 26, 33, 30, 2, -33 },
  { 359, 26, 33, 28, 1, -33 },
  { 467, 5, 13, 7, 1, -35 },
  { 476, 11, 47, 15, 3, -37 },
  { 541, 12, 47, 15, 1, -37 },
  { 612, 20, 20, 22, 1, -33 },
  { 662, 20, 24, 22, 1, -28 },
  { 722, 8, 14, 12, 1, -6 },
  { 736, 12, 6, 18, 3, -18 },
  { 745, 8, 7, 14, 3, -7 },
  { 752, 14, 36, 15, 0, -33 },
  { 815, 20, 33, 24, 2, -33 },
  { 898, 13, 33, 24, 4, -33 },
  { 952, 20, 33, 24, 2, -33 },
  { 1035, 21, 33, 24, 1, -33 },
  { 1122, 21, 33, 24, 1, -33 },
  { 1209, 20, 33, 24, 2, -33 },
  { 1292, 20, 33, 24, 2, -33 },
  { 1375, 21, 33, 24, 1, -33 },
  { 1462, 20, 33, 24, 2, -33 },
  { 1545, 20, 33, 24, 2, -33 },
  { 1628, 8, 26, 13, 3, -26 },
  { 1654, 10, 34, 13, 1, -26 },
  { 1697, 17, 22, 21, 1, -25 },
  { 1744, 18, 16, 24, 3, -23 },
  { 1780, 17, 22, 21, 3, -25 },
  { 1827, 19, 33, 21, 1, -33 },
  { 1906, 32, 42, 36, 2, -32 },
  { 2074, 28, 33, 28, 0, -33 },
  { 2190, 22, 33, 27, 2, -33 },
  { 2281, 24, 33, 27, 2, -33 },
  { 2380, 22, 33, 26, 2, -33 },
  { 2471, 20, 33, 23, 2, -33 },
  { 2554, 19, 33, 22, 2, -33 },
  { 2633, 24, 33, 28, 2, -33 },
  { 2732, 24, 33, 29, 2, -33 },
  { 2831, 7, 33, 13, 3, -33 },
  { 2860, 20, 33, 23, 1, -33 },
  { 2943, 24, 33, 26, 2, -33 },
  { 3042, 19, 33, 22, 2, -33 },
  { 3121, 31, 33, 36, 2, -33 },
  { 3249, 24, 33, 29, 2, -33 },
  { 3348, 24, 33, 28, 2, -33 },
  { 3447, 23, 33, 27, 2, -33 },
  { 3542, 24, 39, 28, 2, -33 },
  { 3659, 23, 33, 26, 2, -33 },
  { 3754, 22, 33, 26, 2, -33 },
  { 3845, 24, 33, 26, 1, -33 },
  { 3944, 23, 33, 27, 2, -33 },
  { 4039, 27, 33, 27, 0, -33 },
  { 4151, 33, 33, 35, 1, -33 },
  { 4288, 25, 33, 26, 1, -33 },
  { 4392, 25, 33, 26, 0, -33 },
  { 4496, 22, 33, 25, 2, -33 },
  { 4587, 10, 47, 12, 2, -39 },
  { 4646, 19, 36, 18, 0, -33 },
  { 4732, 9, 47, 12, 1, -39 },
  { 4785, 17, 17, 19, 1, -33 },
  { 4822, 18, 5, 19, 0, 0 },
  { 4834, 13, 7, 16, 1, -35 },
  { 4846, 20, 25, 22, 1, -25 },
  { 4909, 20, 35, 23, 2, -35 },
  { 4997, 19, 25, 22, 1, -25 },
  { 5057, 20, 35, 23, 1, -35 },
  { 5145, 19, 25, 23, 2, -25 },
  { 5205, 14, 35, 15, 1, -35 },
  { 5267, 21, 35, 24, 1, -25 },
  { 5359, 19, 35, 23, 2, -35 },
  { 5443, 8, 35, 12, 2, -35 },
  { 5478, 11, 45, 12, -1, -35 },
  { 5540, 21, 35, 23, 2, -35 },
  { 5632, 7, 35, 12, 3, -35 },
  { 5663, 30, 25, 35, 2, -25 },
  { 5757, 19, 25, 23, 2, -25 },
  { 5817, 21, 25, 23, 1, -25 },
  { 5883, 20, 35, 23, 2, -25 },
  { 5971, 20, 35, 23, 1, -25 },
  { 6059, 13, 25, 16, 2, -25 },
  { 6100, 19, 25, 21, 1, -25 },
  { 6160, 13, 31, 15, 1, -31 },
  { 6211, 19, 25, 23, 2, -25 },
  { 6271, 21, 25, 21, 0, -25 },
  { 6337, 28, 25, 30, 1, -25 },
  { 6425, 20, 25, 21, 1, -25 },
  { 6488, 21, 35, 21, 0, -25 },
  { 6580, 18, 25, 21, 2, -25 },
  { 6637, 12, 45, 14, 1, -37 },
  { 6705, 4, 39, 12, 4, -33 },
  { 6725, 12, 45, 14, 1, -37 },
  { 6793, 22, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBold47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_EXTRABOLD47PT7B_H_
