#ifndef _ROBOTOCONDENSED_EXTRABOLD40PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFD,
  0xF3, 0xC0, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xBC, 0xF7,
  0x9E, 0xF3, 0xDC, 0x7B, 0x8F, 0x00, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x0E, 0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xF7, 0xE1,
  0xFB, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFD, 0xF8, 0x3E,
  0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0x8F, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x40, 0xF1, 0xE3, 0xC3, 0xC7, 0x8E, 0x0F, 0x1E, 0x78, 0x3C, 0x79, 0xC0,
  0xF1, 0xEF, 0x03, 0xFF, 0x38, 0x07, 0xFD, 0xE0, 0x1F, 0xEF, 0x00, 0x1F,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0xE7,
  0xF0, 0x07, 0xBF, 0xE0, 0x1D, 0xF7, 0x80, 0xF7, 0x8F, 0x03, 0x9E, 0x3C,
  0x1E, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0x87, 0x8F, 0x0E, 0x1F, 0x78, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0xFC, 0x03,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x1F,
  0x0F, 0xFE, 0x7C, 0x7F, 0xF9, 0xF1, 0xFF, 0xF7, 0xCF, 0xCF, 0xFF, 0x3F,
  0x1F, 0xF8, 0xFC, 0x3F, 0xE3, 0xF8, 0xFF, 0x87, 0xE1, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xF8, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x60, 0x3C, 0x1F, 0x0F,
  0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x18, 0x02, 0x40, 0x18, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x06, 0x01, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C, 0x07, 0x8E, 0x3B, 0xF7,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xF7, 0x81, 0xF1, 0xE0, 0xF0, 0xF8, 0x38, 0x38, 0x08, 0x18, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x3E, 0x7D, 0xF3, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F,
  0x7E, 0x0F, 0xBF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xDF, 0x87, 0xEF,
  0xC3, 0xF7, 0xE1, 0xF9, 0xF8, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x8F, 0xE7, 0xE1, 0xFB,
  0xF0, 0x7E, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x8F,
  0xE7, 0xE1, 0xFB, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x07,
  0xEF, 0xE1, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xEF,
  0xC0, 0xFB, 0xF0, 0x3C, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0xC3, 0xE3, 0xF0,
  0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xF7, 0xF8, 0x60,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF,
  0xC3, 0xF7, 0xE1, 0xFB, 0xF8, 0xFD, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFD, 0xF8, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xBF, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x1E, 0x00,
  0x7C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFF, 0xFB, 0xF7, 0xE7, 0x80, 0x3E, 0x7F, 0x7F, 0x7F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0x30, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0xF0, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x01,
  0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0,
  0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1C, 0x1E, 0x07, 0xC1, 0xE3, 0xC0, 0xFF,
  0x0E, 0x3C, 0x1F, 0xF8, 0xE3, 0xC3, 0xFF, 0x8F, 0x78, 0x7C, 0x78, 0xF7,
  0x87, 0x87, 0x8F, 0x78, 0xF8, 0xF0, 0xF7, 0x8F, 0x0F, 0x07, 0x78, 0xF0,
  0xF0, 0x77, 0x0F, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x0F,
  0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x0E, 0x70, 0xF0, 0xF0, 0xE7, 0x8F,
  0x9F, 0x1E, 0x78, 0xFF, 0xFB, 0xC7, 0x87, 0xFF, 0xFC, 0x78, 0x7F, 0x7F,
  0x87, 0x81, 0xE3, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD,
  0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0xFE, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF,
  0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0x7F, 0x3F, 0x07, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x3F, 0xBF, 0x0F, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFE,
  0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xF7, 0xE1, 0xFB, 0xF9, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F,
  0xEF, 0xC1, 0xFC, 0xFC, 0x3F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xC7,
  0xF0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFD, 0xFC, 0x0F, 0xDF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x7C, 0x7B, 0xFF, 0xDF, 0x3E, 0xFF,
  0xF7, 0xCF, 0xBF, 0xFC, 0xF3, 0xEF, 0xFF, 0x3E, 0xF3, 0xFF, 0xCF, 0xFC,
  0xFF, 0xF3, 0xFF, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xE3, 0xFF, 0xC7,
  0xF8, 0xFF, 0xF0, 0xFE, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC1, 0xF0, 0xFF, 0xF0, 0x78, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xDE, 0x3F,
  0xFD, 0xF3, 0xFF, 0xCF, 0x3F, 0xFC, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7F,
  0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x87,
  0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x03, 0xF9, 0xFC, 0x3F, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC,
  0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0x01, 0xF8,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0xC3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x7E, 0x7E, 0x3F, 0x87,
  0xE7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7E, 0x7E,
  0x3F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7C, 0x3E, 0x7F, 0xCF, 0xC3, 0xF7, 0xFE,
  0xFC, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xFE, 0xFC, 0x3F, 0x7F, 0xEF, 0xC3,
  0xFF, 0xBE, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9,
  0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x01, 0xFD,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7F,
  0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x81, 0xFC, 0x7E,
  0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F,
  0xC0, 0x7F, 0xFE, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xC0,
  0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x87,
  0x9E, 0x1E, 0xF8, 0x7B, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1,
  0xF9, 0xF8, 0xFC, 0x00, 0x7E, 0x07, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF,
  0xE7, 0xE7, 0xE3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFF, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xF1, 0xF8, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7E,
  0xFC, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xBF, 0xC7, 0xCF,
  0xC0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x87, 0xCF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7E, 0x3F,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7C, 0xFC, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD,
  0xF8, 0x7E, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x08, 0xFE, 0x0C, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0xFF, 0x1F,
  0xF1, 0xFF, 0x3F, 0xF3, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x07, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7D, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x30, 0x3F, 0x1F, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xBF, 0xDF, 0xCF, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xEF, 0xC7, 0xF3,
  0xF3, 0xF8, 0xFC, 0xFE, 0x3F, 0x7F, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0xBF, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0xF8, 0x3C, 0x3F, 0xFF, 0x3F,
  0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0x1F,
  0xC7, 0xEF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF,
  0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F,
  0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F,
  0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC,
  0x3F, 0x0F, 0xC0, 0xF8, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x07, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xF9, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD,
  0xF8, 0x3E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xDF, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F,
  0x8F, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xF9, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFF, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0x3F, 0x7E, 0x1F, 0xDF,
  0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x7C, 0x3E,
  0xFC, 0x7C, 0x3E, 0xFC, 0x7C, 0x7E, 0xFC, 0x7C, 0x7E, 0x7C, 0xFE, 0x7E,
  0x7C, 0xFE, 0x7C, 0x7C, 0xFE, 0x7C, 0x7C, 0xFE, 0x7C, 0x7C, 0xFF, 0x7C,
  0x3F, 0xFF, 0xFC, 0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8,
  0x3F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF0,
  0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0,
  0xFC, 0x3F, 0x7F, 0x1F, 0x9F, 0x9F, 0x8F, 0xCF, 0xC3, 0xF7, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0x7E,
  0x3F, 0x3F, 0x1F, 0x8F, 0xDF, 0x87, 0xEF, 0xC3, 0xF8, 0xFE, 0x1F, 0xDF,
  0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0xE0,
  0x78, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x83, 0xF0, 0xFC, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x1E, 0x03, 0x80, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0x1C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x3F, 0x1F, 0xC7, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE0, 0x70,
  0x10, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0xF7, 0xFC, 0x3D, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xEF, 0x0F, 0xFB, 0xC1, 0xFC, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 11, 11, 13, 1, -30 },
  { 42, 18, 28, 21, 1, -28 },
  { 105, 17, 36, 20, 2, -32 },
  { 182, 22, 28, 26, 2, -28 },
  { 259, 22, 28, 24, 1, -28 },
  { 336, 4, 11, 6, 1, -30 },
  { 342, 10, 40, 13, 2, -31 },
  { 392, 10, 40, 13, 1, -31 },
  { 442, 17, 17, 18, 1, -28 },
  { 479, 17, 21, 19, 1, -24 },
  { 524, 7, 12, 10, 1, -5 },
  { 535, 10, 5, 16, 3, -15 },
  { 542, 7, 6, 12, 2, -6 },
  { 548, 12, 30, 13, 0, -28 },
  { 593, 17, 28, 20, 2, -28 },
  { 653, 11, 28, 20, 3, -28 },
  { 692, 18, 28, 20, 1, -28 },
  { 755, 18, 28, 20, 1, -28 },
  { 818, 18, 28, 20, 1, -28 },
  { 881, 17, 28, 20, 2, -28 },
  { 941, 17, 28, 20, 2, -28 },
  { 1001, 18, 28, 20, 1, -28 },
  { 1064, 16, 28, 20, 2, -28 },
  { 1120, 16, 28, 20, 2, -28 },
  { 1176, 7, 22, 11, 2, -22 },
  { 1196, 8, 29, 11, 1, -22 },
  { 1225, 15, 20, 18, 1, -22 },
  { 1263, 15, 13, 20, 3, -19 },
  { 1288, 15, 20, 18, 2, -22 },
  { 1326, 16, 28, 18, 1, -28 },
  { 1382, 28, 37, 31, 1, -28 },
  { 1512, 24, 28, 24, 0, -28 },
  { 1596, 19, 28, 23, 2, -28 },
  { 1663, 20, 28, 23, 2, -28 },
  { 1733, 19, 28, 23, 2, -28 },
  { 1800, 17, 28, 20, 2, -28 },
  { 1860, 16, 28, 19, 2, -28 },
  { 1916, 20, 28, 24, 2, -28 },
  { 1986, 20, 28, 24, 2, -28 },
  { 2056, 7, 28, 11, 2, -28 },
  { 2081, 17, 28, 20, 1, -28 },
  { 2141, 20, 28, 22, 2, -28 },
  { 2211, 16, 28, 19, 2, -28 },
  { 2267, 26, 28, 30, 2, -28 },
  { 2358, 20, 28, 24, 2, -28 },
  { 2428, 20, 28, 24, 2, -28 },
  { 2498, 19, 28, 23, 2, -28 },
  { 2565, 21, 33, 24, 2, -28 },
  { 2652, 20, 28, 22, 2, -28 },
  { 2722, 19, 28, 22, 1, -28 },
  { 2789, 20, 28, 22, 1, -28 },
  { 2859, 19, 28, 23, 2, -28 },
  { 2926, 23, 28, 23, 0, -28 },
  { 3007, 28, 28, 30, 1, -28 },
  { 3105, 22, 28, 22, 0, -28 },
  { 3182, 22, 28, 22, 0, -28 },
  { 3259, 19, 28, 21, 1, -28 },
  { 3326, 8, 40, 11, 2, -33 },
  { 3366, 16, 30, 15, 0, -28 },
  { 3426, 7, 40, 11, 1, -33 },
  { 3461, 14, 14, 16, 1, -28 },
  { 3486, 15, 5, 16, 0, 0 },
  { 3496, 10, 6, 13, 1, -30 },
  { 3504, 17, 21, 19, 1, -21 },
  { 3549, 17, 30, 20, 2, -30 },
  { 3613, 16, 21, 18, 1, -21 },
  { 3655, 17, 30, 20, 1, -30 },
  { 3719, 17, 21, 19, 1, -21 },
  { 3764, 12, 30, 13, 1, -30 },
  { 3809, 17, 29, 20, 1, -21 },
  { 3871, 16, 30, 20, 2, -30 },
  { 3931, 6, 29, 10, 2, -29 },
  { 3953, 9, 37, 10, -1, -29 },
  { 3995, 18, 30, 19, 2, -30 },
  { 4063, 6, 30, 10, 2, -30 },
  { 4086, 26, 21, 30, 2, -21 },
  { 4155, 16, 21, 20, 2, -21 },
  { 4197, 18, 21, 20, 1, -21 },
  { 4245, 17, 29, 20, 2, -21 },
  { 4307, 17, 29, 20, 1, -21 },
  { 4369, 11, 21, 14, 2, -21 },
  { 4398, 16, 21, 18, 1, -21 },
  { 4440, 12, 26, 12, 0, -26 },
  { 4479, 16, 21, 20, 2, -21 },
  { 4521, 18, 21, 18, 0, -21 },
  { 4569, 24, 21, 25, 1, -21 },
  { 4632, 17, 21, 18, 1, -21 },
  { 4677, 18, 29, 18, 0, -21 },
  { 4743, 16, 21, 18, 1, -21 },
  { 4785, 10, 38, 12, 1, -31 },
  { 4833, 4, 33, 10, 3, -28 },
  { 4850, 10, 38, 12, 1, -31 },
  { 4898, 18, 9, 22, 2, -16 },
};

const GFXfont RobotoCondensed_ExtraBold40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_EXTRABOLD40PT7B_H_
