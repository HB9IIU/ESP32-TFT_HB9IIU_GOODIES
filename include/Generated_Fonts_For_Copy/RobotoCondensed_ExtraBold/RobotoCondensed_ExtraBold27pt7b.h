#ifndef _ROBOTOCONDENSED_EXTRABOLD27PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0x7B,
  0xDC, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x00, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x1D, 0xC1, 0xDC, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98, 0x19,
  0x8F, 0xFE, 0xFF, 0xE3, 0xB8, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x77,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8, 0x3F, 0xC7, 0xFE, 0x79, 0xE7,
  0x9E, 0x78, 0xF7, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0x1E, 0xF1, 0xEF, 0x1E, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xB8, 0xC7, 0x39, 0x8E, 0x77,
  0x1C, 0xEC, 0x3B, 0xB8, 0x3F, 0x60, 0x3D, 0x80, 0x07, 0x00, 0x0C, 0xE0,
  0x3F, 0xE0, 0x6E, 0xE1, 0xD9, 0xC3, 0x31, 0x8E, 0x67, 0x18, 0xEE, 0x01,
  0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xFE, 0x03, 0xFC, 0x1E, 0xF0, 0x79, 0xC1,
  0xE7, 0x07, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0xE7, 0xF3, 0xBF, 0xEE,
  0xF7, 0xFB, 0xCF, 0xEF, 0x1F, 0x3E, 0xFC, 0x7F, 0xF9, 0xFF, 0xE1, 0xF7,
  0xC0, 0xFF, 0xFD, 0xB0, 0x08, 0x71, 0xCE, 0x71, 0xC7, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x0E, 0x1C, 0x70,
  0x80, 0x83, 0x0E, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xCF, 0x38, 0xE7, 0x1C, 0xE3, 0x08, 0x00, 0x07, 0x00,
  0x70, 0x07, 0x04, 0x71, 0x7E, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x1F, 0x83,
  0x9C, 0x38, 0xE1, 0x08, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00,
  0x77, 0x77, 0x7F, 0xE4, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x0F, 0x03, 0xFC, 0x7F, 0xC7, 0x9E,
  0x79, 0xEF, 0x1E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xEF, 0x1E, 0x79, 0xE7, 0x9E, 0x7F, 0xC3, 0xFC, 0x1F, 0x00, 0x03,
  0x1F, 0x7F, 0xFF, 0xFF, 0xCF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0xBE,
  0xF1, 0xEF, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x07, 0xFC, 0x7F, 0xEF, 0xBE, 0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0x1E, 0x01, 0xEF, 0x1F, 0xF1, 0xEF, 0xBE, 0x7F,
  0xE3, 0xFC, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0xC3, 0xBC, 0x3B, 0xC7, 0xBC, 0x73, 0xCF, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE7, 0x80, 0x78, 0x07, 0x00, 0x77, 0x87, 0xFC, 0x7F, 0xE3, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xFF, 0x1E, 0xF1, 0xE7, 0x9E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x00, 0x03, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0x7F,
  0x8F, 0xFC, 0xFF, 0xEF, 0x9E, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79,
  0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x00,
  0x1F, 0x07, 0xF9, 0xFF, 0xBC, 0xF7, 0x9E, 0xF3, 0xDE, 0x7B, 0xCF, 0x3F,
  0xC7, 0xF1, 0xFF, 0x3C, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0x7F, 0xE7,
  0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xF1, 0xFF, 0x3D, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xEF, 0x3D, 0xFF, 0x9F, 0xF1, 0xFE, 0x03, 0xC0, 0xF0,
  0x7E, 0x1F, 0x83, 0xE0, 0x70, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x7F, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xEF,
  0x73, 0xB8, 0x80, 0x00, 0xC0, 0xF0, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F, 0x03,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x70, 0x3E, 0x1F,
  0xC7, 0xF8, 0xFC, 0x1E, 0x3F, 0x7F, 0xFF, 0x3E, 0x1C, 0x08, 0x00, 0x3F,
  0x1F, 0xEF, 0xFF, 0xCF, 0xF3, 0xC0, 0xF0, 0x3C, 0x1F, 0x0F, 0x83, 0xC1,
  0xE0, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x7C, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60,
  0x03, 0x9C, 0x3C, 0x33, 0x8F, 0xE6, 0x63, 0xDC, 0xDC, 0x73, 0x9F, 0x9C,
  0x63, 0xF3, 0x8C, 0x7E, 0x71, 0x8F, 0xCE, 0x31, 0xB9, 0xCE, 0x37, 0x39,
  0xCE, 0xE7, 0xF9, 0x9C, 0x7F, 0xF1, 0x8F, 0x3C, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xEE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8,
  0x1F, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x1E, 0xFF, 0xF7, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xBF, 0xF0, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x1F, 0x7E, 0x78, 0x7B, 0xE1, 0xEF, 0x07, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xC1, 0xF7, 0x87, 0x9F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xF7,
  0xEF, 0x8F, 0x7C, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xDF, 0x7E, 0xFF, 0xE7, 0xFE, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0xBE, 0x78, 0x7F, 0xE0, 0xFF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xE0, 0xF7, 0x83, 0xDF,
  0x9F, 0x3F, 0xFC, 0x7F, 0xE0, 0xFE, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xE3, 0xFC, 0xFF,
  0xFE, 0xFF, 0xCF, 0xF0, 0x7C, 0x00, 0xF8, 0x7F, 0xE3, 0xEF, 0x8F, 0xBE,
  0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xE7, 0x8F, 0x9F, 0x3E, 0x3C, 0xF8, 0xFB,
  0xE1, 0xEF, 0x87, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xF7, 0x3F, 0xFD, 0xCE, 0xFF, 0x7B, 0xBF, 0xCE, 0xEF, 0xF3, 0xFB,
  0xFE, 0xFC, 0xFF, 0xBF, 0x3F, 0xE7, 0xCF, 0xF9, 0xE3, 0xFE, 0x78, 0xFF,
  0x8E, 0x3C, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xEE, 0xFF, 0xBB, 0xFE, 0xFF, 0xF9,
  0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xC0,
  0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xF7, 0x87, 0xDF, 0xBE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFD, 0xF3, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF9,
  0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0x8F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFF, 0x3E, 0x7E, 0xF8, 0x7B, 0xE1, 0xEF, 0x87, 0xBE, 0x1E, 0xF9, 0xF3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFB, 0xE3, 0xE7, 0x8F, 0x9F, 0x3E, 0x3C,
  0xF8, 0xFB, 0xE3, 0xEF, 0x87, 0x80, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB,
  0xEF, 0x8F, 0x7C, 0x7F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x3E, 0x7F, 0xF1, 0xFF, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0xBF, 0x7F, 0xF1,
  0xFF, 0x03, 0xF0, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0,
  0xF7, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0xF1, 0xE3, 0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF1,
  0xEF, 0x3F, 0x3D, 0xE7, 0xE7, 0x9E, 0xFC, 0xE3, 0xDF, 0xBC, 0x7B, 0xF7,
  0x8F, 0x7F, 0xF1, 0xFF, 0xFE, 0x1F, 0xDF, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78,
  0x00, 0x78, 0x3C, 0xF8, 0xF8, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x83, 0xDE,
  0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01,
  0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1E, 0x3C, 0x7C, 0x7C, 0xF8, 0xF9, 0xE0,
  0xF8, 0xF8, 0x3C, 0xF0, 0x79, 0xE1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E,
  0x07, 0xBC, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0xFF, 0xFF,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x0F, 0x87, 0xC7,
  0x63, 0xB9, 0xDD, 0xCE, 0xE3, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF0, 0xF0, 0xE0, 0x1F, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x3C, 0x07, 0x87,
  0xF3, 0xFE, 0xFB, 0xDE, 0x7B, 0xCF, 0x79, 0xEF, 0xFC, 0xFF, 0xCF, 0x78,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x8F, 0xFC,
  0xFF, 0xEF, 0x9E, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF1, 0xEF, 0x9E, 0xFF, 0xEF, 0xFC, 0xF7, 0x80, 0x1F, 0x0F, 0xF1, 0xFF,
  0x7D, 0xEF, 0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xFD,
  0xF7, 0xFC, 0xFF, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xCF, 0x7B, 0xFF, 0x7F, 0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x7D, 0xFF, 0xBF, 0xF3, 0xDE, 0x1F, 0x07,
  0xF9, 0xFF, 0x7C, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xC0, 0x7C, 0x67, 0xFE, 0x7F, 0xC7, 0xE0, 0x07, 0x8F, 0xC7, 0xE7, 0xC3,
  0xC1, 0xE3, 0xFD, 0xFE, 0xFF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1E, 0xEF, 0xFD, 0xFF, 0xFC,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFC, 0xF7,
  0xFE, 0xFF, 0xC7, 0x78, 0x0F, 0x21, 0xEF, 0xFD, 0xFF, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xFF,
  0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1E, 0x77, 0xFE, 0xE0, 0x03, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x0F,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x7E, 0xF9, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF1, 0xFF, 0x3E, 0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF1,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF7, 0x8F, 0x3F, 0xF7, 0xEF, 0xFF, 0xFB, 0xEF, 0xDE, 0xF1, 0xE3, 0xFC,
  0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3C, 0xF7, 0x9F,
  0xFB, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x78, 0x1F, 0x03, 0xFC, 0x7F, 0xCF,
  0xBE, 0xF1, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF,
  0x9E, 0x7F, 0xC3, 0xFC, 0x1F, 0x00, 0xF7, 0x8F, 0xFC, 0xFF, 0xEF, 0x9E,
  0xF1, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x9E,
  0xFF, 0xEF, 0xFC, 0xF7, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x3D, 0xEF, 0xFD, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xFD, 0xF7, 0xFE, 0xFF, 0xCF, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x1F, 0xEF, 0xFF, 0xCF,
  0xF0, 0x3E, 0x07, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF,
  0xE3, 0xF0, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFD,
  0xF7, 0xFE, 0xFF, 0xCF, 0x78, 0xF8, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x79,
  0xE3, 0x9E, 0x3D, 0xC3, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0x71, 0xC7, 0x38, 0xE7, 0x9E, 0x73, 0xCF, 0x7D,
  0xE7, 0xBE, 0xF3, 0xDF, 0x78, 0xEF, 0xB8, 0x7E, 0xDC, 0x3F, 0x7E, 0x1F,
  0xBF, 0x0F, 0xDF, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x78, 0xF7, 0x9E, 0x3D, 0xE3, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x7D, 0xE7, 0x9E, 0x78, 0xF0, 0xF8,
  0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0xDE, 0x3F, 0xC3, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xE0, 0x3C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0C, 0x73, 0xCE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xBC, 0xE3, 0xC7, 0x1E,
  0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8F, 0x1C, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC3, 0x8F, 0x1C, 0x71, 0xE7, 0x9E, 0x79,
  0xE7, 0x8F, 0x1C, 0xF3, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0xE3,
  0x00, 0x3C, 0x3B, 0xF3, 0xDF, 0xDD, 0xEF, 0xEE, 0x3E, 0x00, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 7, 7, 9, 1, -20 },
  { 20, 12, 19, 14, 1, -19 },
  { 49, 12, 25, 14, 1, -22 },
  { 87, 15, 19, 17, 1, -19 },
  { 123, 14, 19, 16, 1, -19 },
  { 157, 3, 7, 4, 1, -20 },
  { 160, 6, 27, 9, 2, -21 },
  { 181, 6, 27, 9, 1, -21 },
  { 202, 12, 12, 12, 0, -19 },
  { 220, 11, 14, 13, 1, -16 },
  { 240, 4, 8, 7, 1, -3 },
  { 244, 7, 3, 11, 2, -10 },
  { 247, 4, 4, 8, 2, -4 },
  { 249, 8, 21, 9, 0, -19 },
  { 270, 12, 19, 14, 1, -19 },
  { 299, 8, 19, 14, 2, -19 },
  { 318, 12, 19, 14, 1, -19 },
  { 347, 12, 19, 14, 1, -19 },
  { 376, 12, 19, 14, 1, -19 },
  { 405, 12, 19, 14, 1, -19 },
  { 434, 12, 19, 14, 1, -19 },
  { 463, 12, 19, 14, 1, -19 },
  { 492, 11, 19, 14, 1, -19 },
  { 519, 11, 19, 14, 1, -19 },
  { 546, 4, 15, 8, 2, -15 },
  { 554, 5, 20, 7, 1, -15 },
  { 567, 10, 13, 12, 1, -15 },
  { 584, 10, 9, 14, 2, -13 },
  { 596, 9, 13, 12, 2, -15 },
  { 611, 10, 19, 12, 1, -19 },
  { 635, 19, 25, 21, 1, -19 },
  { 695, 16, 19, 16, 0, -19 },
  { 733, 13, 19, 15, 1, -19 },
  { 764, 14, 19, 15, 1, -19 },
  { 798, 13, 19, 15, 1, -19 },
  { 829, 12, 19, 13, 1, -19 },
  { 858, 11, 19, 13, 1, -19 },
  { 885, 14, 19, 16, 1, -19 },
  { 919, 14, 19, 17, 1, -19 },
  { 953, 4, 19, 7, 2, -19 },
  { 963, 11, 19, 13, 1, -19 },
  { 990, 14, 19, 15, 1, -19 },
  { 1024, 11, 19, 13, 1, -19 },
  { 1051, 18, 19, 20, 1, -19 },
  { 1094, 14, 19, 16, 1, -19 },
  { 1128, 14, 19, 16, 1, -19 },
  { 1162, 13, 19, 15, 1, -19 },
  { 1193, 14, 22, 16, 1, -19 },
  { 1232, 14, 19, 15, 1, -19 },
  { 1266, 13, 19, 15, 1, -19 },
  { 1297, 13, 19, 15, 1, -19 },
  { 1328, 13, 19, 16, 1, -19 },
  { 1359, 15, 19, 16, 0, -19 },
  { 1395, 19, 19, 20, 1, -19 },
  { 1441, 15, 19, 15, 0, -19 },
  { 1477, 15, 19, 15, 0, -19 },
  { 1513, 13, 19, 14, 1, -19 },
  { 1544, 6, 27, 7, 1, -22 },
  { 1565, 11, 21, 10, 0, -19 },
  { 1594, 6, 27, 7, 0, -22 },
  { 1615, 9, 10, 11, 1, -19 },
  { 1627, 10, 3, 11, 0, 0 },
  { 1631, 7, 4, 9, 1, -20 },
  { 1635, 11, 15, 13, 1, -15 },
  { 1656, 12, 21, 13, 1, -21 },
  { 1688, 11, 15, 12, 1, -15 },
  { 1709, 11, 21, 13, 1, -21 },
  { 1738, 11, 15, 13, 1, -15 },
  { 1759, 9, 21, 9, 0, -21 },
  { 1783, 11, 20, 14, 1, -15 },
  { 1811, 11, 21, 13, 1, -21 },
  { 1840, 5, 21, 7, 1, -21 },
  { 1854, 7, 26, 7, -1, -21 },
  { 1877, 12, 21, 13, 1, -21 },
  { 1909, 4, 21, 7, 1, -21 },
  { 1920, 18, 15, 20, 1, -15 },
  { 1954, 11, 15, 13, 1, -15 },
  { 1975, 12, 15, 13, 1, -15 },
  { 1998, 12, 20, 13, 1, -15 },
  { 2028, 11, 20, 13, 1, -15 },
  { 2056, 8, 15, 9, 1, -15 },
  { 2071, 10, 15, 12, 1, -15 },
  { 2090, 8, 18, 8, 0, -18 },
  { 2108, 11, 15, 13, 1, -15 },
  { 2129, 12, 15, 12, 0, -15 },
  { 2152, 17, 15, 17, 0, -15 },
  { 2184, 12, 15, 12, 0, -15 },
  { 2207, 12, 20, 12, 0, -15 },
  { 2237, 10, 15, 12, 1, -15 },
  { 2256, 6, 26, 8, 1, -21 },
  { 2276, 3, 23, 7, 2, -19 },
  { 2285, 6, 26, 8, 1, -21 },
  { 2305, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBold27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_EXTRABOLD27PT7B_H_
