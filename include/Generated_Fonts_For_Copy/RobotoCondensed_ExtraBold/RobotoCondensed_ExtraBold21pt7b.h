#ifndef _ROBOTOCONDENSED_EXTRABOLD21PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x00, 0x6F, 0x60, 0xEF, 0xBE, 0xF3,
  0xCF, 0x30, 0x1B, 0x0D, 0x84, 0xC6, 0x4F, 0xFF, 0xFC, 0xD8, 0x6C, 0x36,
  0x7F, 0xFF, 0xED, 0x86, 0xC3, 0x61, 0xB0, 0x08, 0x04, 0x0F, 0x8F, 0xE7,
  0xF7, 0xBF, 0xCE, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xFE, 0x3F, 0x1F, 0xFC,
  0xFE, 0x3E, 0x04, 0x02, 0x00, 0x78, 0x0F, 0x80, 0xCC, 0x8C, 0xD8, 0xCF,
  0x0F, 0xB0, 0x7E, 0x00, 0x60, 0x0D, 0xC0, 0xFE, 0x1B, 0x61, 0xB3, 0x33,
  0x60, 0x3E, 0x01, 0xC0, 0x3C, 0x0F, 0xC1, 0xFC, 0x3B, 0x87, 0x70, 0xFC,
  0x0F, 0x03, 0xEE, 0xFD, 0xDD, 0xFB, 0xBF, 0x73, 0xCF, 0xF8, 0xFF, 0x8F,
  0x78, 0xFF, 0xF0, 0x08, 0xCE, 0x67, 0x31, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x8C, 0x63, 0x8C, 0x71, 0x84, 0x86, 0x38, 0xC7, 0x38, 0xC6, 0x39, 0xCE,
  0x73, 0x9C, 0xC6, 0x73, 0x99, 0xCC, 0x40, 0x0C, 0x03, 0x04, 0xCB, 0xFE,
  0x3F, 0x87, 0x83, 0xE0, 0xCC, 0x22, 0x00, 0x38, 0x38, 0x38, 0x38, 0xFF,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x77, 0x77, 0x66, 0xFF, 0xFF, 0xC0,
  0xFF, 0x60, 0x0C, 0x30, 0xC7, 0x18, 0x63, 0x8C, 0x30, 0xC7, 0x18, 0x61,
  0x8E, 0x30, 0x3C, 0x3F, 0x9F, 0xDC, 0xEE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0xE7, 0xF3, 0xF8, 0xF0, 0x0D, 0xFF, 0xFF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x3E, 0x3F, 0xBF, 0xDC, 0xEE,
  0x78, 0x38, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3C, 0x3F, 0xBF, 0xDC, 0xE0, 0x78, 0x38, 0x3C, 0x3C, 0x1F, 0x03, 0x80,
  0xFC, 0x7F, 0xF7, 0xF8, 0xF0, 0x0F, 0x07, 0x87, 0xC3, 0xE3, 0xF1, 0xB9,
  0xDC, 0xCE, 0xE7, 0x7F, 0xFF, 0xFF, 0xF0, 0x70, 0x38, 0x1C, 0x7F, 0x3F,
  0x9F, 0xCC, 0x0E, 0x07, 0xF3, 0xFD, 0xCE, 0x07, 0x81, 0xC0, 0xFC, 0xFF,
  0xF3, 0xF8, 0xF0, 0x0E, 0x1F, 0x0F, 0x8E, 0x0F, 0x07, 0x73, 0xFD, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0xF3, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x83, 0xC1,
  0xC0, 0x3C, 0x3F, 0x9F, 0xDC, 0xEE, 0x77, 0x39, 0xFC, 0x7C, 0x7F, 0x73,
  0xB8, 0xFC, 0xFF, 0xF3, 0xF8, 0xF8, 0x3C, 0x3F, 0x3F, 0xDC, 0xEE, 0x3F,
  0x1F, 0x8F, 0xEF, 0x7F, 0x9F, 0x81, 0xC0, 0xE3, 0xE1, 0xE0, 0xE0, 0xFF,
  0x60, 0x00, 0x00, 0x7F, 0x60, 0xEF, 0x60, 0x00, 0x00, 0x66, 0x66, 0xEC,
  0x02, 0x1C, 0xFF, 0xEF, 0x1E, 0x3F, 0x1F, 0x0E, 0x04, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x7E, 0x0F, 0x0F, 0x7E,
  0xF8, 0xE0, 0x80, 0x3E, 0x3F, 0x9F, 0xFE, 0x70, 0x38, 0x38, 0x3C, 0x1C,
  0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x70, 0x07, 0xC0, 0x7F, 0xC3,
  0x83, 0x9C, 0x06, 0x63, 0xCD, 0x9F, 0x3C, 0xEC, 0xF3, 0x33, 0xCC, 0xCF,
  0x33, 0x3D, 0xCC, 0xF3, 0x33, 0xCF, 0xFB, 0x1D, 0xCE, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xDC, 0x1D, 0xC3, 0xDC, 0x39, 0xC3, 0xFE, 0x3F, 0xE7, 0xFE,
  0x70, 0xF7, 0x07, 0xF0, 0x70, 0xFE, 0x3F, 0xEF, 0xFB, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3B, 0xFC, 0xFF, 0xB8, 0xFE, 0x1F, 0x87, 0xFF, 0xFF, 0xEF, 0xF0,
  0x1F, 0x1F, 0xE7, 0xFF, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x1F, 0xC7, 0x7F, 0xDF, 0xE1, 0xF0, 0xFE, 0x3F, 0xCF, 0xFB, 0x8E,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xFF, 0xBF,
  0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xFF,
  0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x07, 0x03, 0xFD, 0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x1F, 0x1F, 0xE7, 0xFF, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF8,
  0x7E, 0x1F, 0xC7, 0x7F, 0xDF, 0xF1, 0xF0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFC,
  0xEE, 0x77, 0xFB, 0xF8, 0x78, 0xE1, 0xDC, 0x7B, 0x9E, 0x73, 0xCE, 0xF1,
  0xDC, 0x3F, 0x87, 0xF0, 0xFF, 0x1E, 0xE3, 0xDE, 0x73, 0xCE, 0x3D, 0xC7,
  0xB8, 0x78, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xF0, 0x3F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCD, 0xFB, 0x37, 0xED, 0xDF, 0xBF,
  0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x31, 0xC0, 0xF0, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF,
  0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x78, 0x1F, 0x07, 0xF1, 0xFF, 0x78,
  0xEE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF8, 0xE7,
  0xFC, 0xFF, 0x07, 0xC0, 0xFF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0xFF, 0xFF, 0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F,
  0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0xF8, 0xE7, 0xFC, 0x7F, 0x07, 0xE0, 0x1E, 0x01, 0xC0, 0x10,
  0xFF, 0x3F, 0xEF, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0xFE, 0xFF, 0xBF,
  0xCE, 0x73, 0x9E, 0xE3, 0xB8, 0xFE, 0x1C, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E,
  0xE3, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xEE, 0x3F, 0x8F, 0xFF, 0x9F,
  0xE3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xFF, 0xDF, 0xE3, 0xF0, 0xF0, 0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0x79, 0xE3,
  0x9E, 0x39, 0xC3, 0x9C, 0x1D, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF3, 0x8E, 0xE7, 0x1D, 0xCF, 0x3B, 0x9E, 0x77, 0x3D,
  0xCE, 0xFB, 0x8F, 0xF7, 0x1F, 0xFE, 0x3F, 0xFC, 0x7D, 0xF8, 0xFB, 0xE1,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x00, 0x70, 0xE7, 0x9E, 0x39,
  0xC3, 0x9C, 0x3F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3F,
  0x83, 0xBC, 0x79, 0xC7, 0x9E, 0xF0, 0xE0, 0xF0, 0xEE, 0x3D, 0xC7, 0x1C,
  0xE3, 0xB8, 0x77, 0x07, 0xE0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xF0, 0xE0, 0x70,
  0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F,
  0x07, 0x07, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F,
  0xF0, 0x1C, 0x3C, 0x3C, 0x3E, 0x76, 0x66, 0x67, 0xFF, 0xFF, 0xE3, 0x8E,
  0x3C, 0x7E, 0xEF, 0xE7, 0x7F, 0xFF, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xFE, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0xFB, 0xFD, 0xDC, 0x3C, 0x7E, 0xFF, 0xE7, 0xE0, 0xE0, 0xE0,
  0xE7, 0xFF, 0x7E, 0x3C, 0x07, 0x07, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xFF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x7B, 0x3E, 0x3F, 0xBF, 0xDC,
  0xEF, 0xFF, 0xFF, 0x81, 0xC0, 0xFF, 0x3F, 0x8F, 0x80, 0x1E, 0x7C, 0xF9,
  0xC3, 0x9F, 0xBF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3B,
  0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xBF, 0xCF, 0xE0,
  0xF6, 0xF3, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xEE, 0xFF, 0xFF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3F, 0xBD, 0xDC, 0xFE,
  0x7E, 0x3F, 0x1F, 0xCE, 0xE7, 0x3B, 0x9D, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0x73, 0xFF, 0xEF, 0xFF, 0xB9, 0xCE, 0xE7, 0x3F, 0x9C,
  0xFE, 0x73, 0xF9, 0xCF, 0xE7, 0x3F, 0x9C, 0xFE, 0x73, 0xC0, 0xEE, 0xFF,
  0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x3F, 0xBF,
  0xDC, 0xFE, 0x3F, 0x1F, 0x8F, 0xCF, 0xFF, 0x3F, 0x8F, 0x00, 0xEE, 0x7F,
  0xBF, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xFF, 0x7F, 0xBB, 0x9C, 0x0E,
  0x07, 0x03, 0x80, 0x7B, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xEF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x00, 0x3C, 0xFE, 0xEF, 0xE0, 0xF8, 0x7E, 0x1F, 0xC7, 0xE7,
  0xFE, 0x7C, 0x79, 0xE7, 0xBF, 0xFD, 0xE7, 0x9E, 0x79, 0xE7, 0x8F, 0x3C,
  0x70, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x7F,
  0xF3, 0xB9, 0xDC, 0xEE, 0xE7, 0x71, 0xF8, 0xFC, 0x7C, 0x1E, 0x0F, 0x07,
  0x00, 0xE7, 0x3B, 0xB9, 0xDD, 0xCC, 0xEE, 0xE7, 0xFF, 0x3E, 0xF8, 0xF7,
  0xC7, 0xBC, 0x3D, 0xE1, 0xC7, 0x0E, 0x38, 0x73, 0xBB, 0xCF, 0xC7, 0xE3,
  0xE0, 0xF0, 0xF8, 0x7E, 0x7F, 0x3B, 0xDC, 0xE0, 0xF3, 0xB9, 0xDD, 0xEE,
  0xE7, 0x71, 0xF8, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x03, 0x87, 0xC3, 0xC1,
  0xC0, 0xFF, 0xFF, 0xFE, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xFF, 0xFF, 0xFF,
  0x11, 0xDC, 0xE7, 0x39, 0xCE, 0xE7, 0x38, 0xC7, 0x39, 0xCE, 0x73, 0x8E,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x86, 0x38, 0xC6, 0x31, 0x8C, 0x71,
  0xCE, 0xE6, 0x31, 0x8C, 0x67, 0x31, 0x00, 0x31, 0xDE, 0x6F, 0xFB, 0x3E,
  0xC7, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 6, 6, 7, 0, -16 },
  { 14, 9, 15, 11, 1, -15 },
  { 31, 9, 19, 11, 1, -17 },
  { 53, 12, 15, 13, 1, -15 },
  { 76, 11, 15, 12, 1, -15 },
  { 97, 2, 6, 3, 1, -16 },
  { 99, 5, 22, 7, 1, -17 },
  { 113, 5, 22, 7, 1, -17 },
  { 127, 10, 9, 10, 0, -15 },
  { 139, 8, 11, 10, 1, -13 },
  { 150, 4, 6, 5, 0, -3 },
  { 153, 6, 3, 8, 1, -8 },
  { 156, 4, 3, 6, 1, -3 },
  { 158, 6, 16, 7, 0, -15 },
  { 170, 9, 15, 11, 1, -15 },
  { 187, 6, 15, 11, 2, -15 },
  { 199, 9, 15, 11, 1, -15 },
  { 216, 9, 15, 11, 1, -15 },
  { 233, 9, 15, 11, 1, -15 },
  { 250, 9, 15, 11, 1, -15 },
  { 267, 9, 15, 11, 1, -15 },
  { 284, 9, 15, 11, 1, -15 },
  { 301, 9, 15, 11, 1, -15 },
  { 318, 9, 15, 11, 1, -15 },
  { 335, 4, 11, 6, 1, -11 },
  { 341, 4, 14, 6, 1, -11 },
  { 348, 7, 10, 9, 1, -11 },
  { 357, 8, 8, 11, 1, -11 },
  { 365, 8, 10, 10, 1, -11 },
  { 375, 9, 15, 10, 0, -15 },
  { 392, 14, 19, 16, 1, -14 },
  { 426, 12, 15, 13, 0, -15 },
  { 449, 10, 15, 12, 1, -15 },
  { 468, 10, 15, 12, 1, -15 },
  { 487, 10, 15, 12, 1, -15 },
  { 506, 9, 15, 10, 1, -15 },
  { 523, 9, 15, 10, 1, -15 },
  { 540, 10, 15, 12, 1, -15 },
  { 559, 11, 15, 13, 1, -15 },
  { 580, 4, 15, 6, 1, -15 },
  { 588, 9, 15, 10, 0, -15 },
  { 605, 11, 15, 12, 1, -15 },
  { 626, 9, 15, 10, 1, -15 },
  { 643, 14, 15, 16, 1, -15 },
  { 670, 11, 15, 13, 1, -15 },
  { 691, 11, 15, 13, 1, -15 },
  { 712, 10, 15, 12, 1, -15 },
  { 731, 11, 18, 13, 1, -15 },
  { 756, 10, 15, 12, 1, -15 },
  { 775, 10, 15, 11, 1, -15 },
  { 794, 10, 15, 12, 1, -15 },
  { 813, 10, 15, 12, 1, -15 },
  { 832, 12, 15, 12, 0, -15 },
  { 855, 15, 15, 16, 0, -15 },
  { 884, 12, 15, 12, 0, -15 },
  { 907, 11, 15, 12, 0, -15 },
  { 928, 10, 15, 11, 1, -15 },
  { 947, 4, 21, 6, 1, -17 },
  { 958, 8, 16, 8, 0, -15 },
  { 974, 4, 21, 6, 0, -17 },
  { 985, 8, 7, 8, 0, -15 },
  { 992, 8, 2, 8, 0, 0 },
  { 994, 5, 3, 7, 1, -16 },
  { 996, 8, 11, 10, 1, -11 },
  { 1007, 9, 16, 10, 1, -16 },
  { 1025, 8, 11, 10, 1, -11 },
  { 1036, 8, 16, 10, 1, -16 },
  { 1052, 9, 11, 10, 1, -11 },
  { 1065, 7, 16, 7, 0, -16 },
  { 1079, 9, 15, 11, 1, -11 },
  { 1096, 8, 16, 10, 1, -16 },
  { 1112, 3, 15, 5, 1, -15 },
  { 1118, 5, 19, 5, -1, -15 },
  { 1130, 9, 16, 10, 1, -16 },
  { 1148, 3, 16, 5, 1, -16 },
  { 1154, 14, 11, 16, 1, -11 },
  { 1174, 8, 11, 10, 1, -11 },
  { 1185, 9, 11, 10, 1, -11 },
  { 1198, 9, 15, 10, 1, -11 },
  { 1215, 8, 15, 10, 1, -11 },
  { 1230, 6, 11, 7, 1, -11 },
  { 1239, 8, 11, 10, 1, -11 },
  { 1250, 6, 14, 7, 0, -14 },
  { 1261, 8, 11, 10, 1, -11 },
  { 1272, 9, 11, 10, 0, -11 },
  { 1285, 13, 11, 13, 0, -11 },
  { 1303, 9, 11, 10, 0, -11 },
  { 1316, 9, 15, 10, 0, -11 },
  { 1333, 8, 11, 10, 1, -11 },
  { 1344, 5, 20, 6, 1, -16 },
  { 1357, 2, 18, 5, 2, -15 },
  { 1362, 5, 20, 6, 1, -16 },
  { 1375, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBold21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_EXTRABOLD21PT7B_H_
