#ifndef _ROBOTOCONDENSED_EXTRABOLD26PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xCF, 0x9F, 0x3E, 0x6C, 0xD9, 0xB3, 0x00, 0x0C, 0xC0, 0xCC, 0x0D,
  0xC1, 0xDC, 0x1D, 0x81, 0xD8, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0xB8, 0x3B,
  0x8F, 0xFE, 0xFF, 0xE3, 0x30, 0x33, 0x03, 0x30, 0x37, 0x07, 0x70, 0x77,
  0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0x83, 0xFC, 0xFF, 0x9E, 0x7B, 0xCF,
  0x79, 0xEF, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xF1,
  0xFE, 0x3F, 0xE7, 0xBF, 0xE3, 0xFC, 0x3E, 0x01, 0x80, 0x30, 0x3C, 0x00,
  0xFC, 0x03, 0xB8, 0x87, 0x33, 0x8E, 0x66, 0x1C, 0xDC, 0x3B, 0xB0, 0x3F,
  0xE0, 0x3D, 0x80, 0x07, 0x00, 0x0D, 0xE0, 0x3F, 0xE0, 0x6C, 0xC1, 0xB9,
  0x83, 0x73, 0x8C, 0xE6, 0x18, 0xCC, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0x00,
  0xFE, 0x03, 0xF8, 0x1E, 0xF0, 0x79, 0xC1, 0xE7, 0x07, 0xB8, 0x0F, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xF7, 0xBF, 0xFE, 0xF7, 0xFB, 0xCF, 0xCF, 0x3F,
  0x3C, 0x78, 0xFF, 0xF1, 0xFF, 0xE1, 0xF7, 0x80, 0xFF, 0xED, 0xB0, 0x08,
  0x73, 0x8E, 0x71, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x20, 0x83, 0x0E, 0x1C, 0x70, 0xE3,
  0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xF3, 0x8E, 0x39, 0xC7,
  0x38, 0xC2, 0x00, 0x06, 0x00, 0x60, 0x06, 0x06, 0x66, 0x7F, 0xF3, 0xFE,
  0x0F, 0x01, 0xF8, 0x39, 0xC3, 0x9C, 0x10, 0x80, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x00, 0x39, 0xCE, 0x73, 0xB9, 0xCC, 0xFF, 0xFF, 0xC0, 0xEF, 0xFE, 0x07,
  0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x1F, 0x07, 0xF1, 0xFF,
  0x3D, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xDC, 0x7B, 0xDE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x02,
  0x3D, 0xFF, 0xFF, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x1F, 0x07, 0xF9, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x0F, 0xF1, 0xFF, 0x79,
  0xFF, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x1F, 0xC3, 0xF0, 0x7F, 0x00, 0xF0,
  0x1E, 0x03, 0xFC, 0x7F, 0x9F, 0xFF, 0xCF, 0xF0, 0x7C, 0x00, 0x03, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF1, 0xDE, 0x3B, 0xCE, 0x79,
  0xCF, 0x79, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xFE,
  0xFF, 0xC6, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFC, 0x7F, 0xDF, 0x7F,
  0xC7, 0xF0, 0x7C, 0x00, 0x03, 0x81, 0xF0, 0x7E, 0x1F, 0x07, 0x80, 0xF0,
  0x1D, 0xE7, 0xFE, 0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDC,
  0x7B, 0xCF, 0x7F, 0xC7, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07,
  0xF1, 0xFF, 0x3D, 0xE7, 0x1E, 0xE3, 0xDC, 0x7B, 0xDE, 0x3F, 0xC7, 0xF1,
  0xFF, 0x3C, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xDF, 0x7F, 0xC7, 0xF8, 0x7C,
  0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFF, 0x3D, 0xFF, 0xBF, 0xF1, 0xDE, 0x03, 0x80, 0xF0, 0x7C, 0x3F,
  0x87, 0xC0, 0xF0, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x77,
  0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x77, 0x10, 0x00,
  0x81, 0xC3, 0xE7, 0xFF, 0xE7, 0xC3, 0xE1, 0xFC, 0x3F, 0x87, 0xC0, 0xE0,
  0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x0F, 0xC3, 0xFC, 0x1F, 0xC1, 0xF0, 0x7C, 0x7F, 0xFF, 0x3F, 0x0F,
  0x03, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xDF, 0xE3, 0xC0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x07, 0xC1, 0xE0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x07,
  0x81, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0xE0, 0x70, 0x1C, 0x38,
  0x03, 0x9C, 0x3C, 0x67, 0x1F, 0x99, 0x8E, 0xE7, 0xE7, 0x39, 0xF9, 0xCE,
  0x3E, 0x73, 0x8F, 0x9C, 0xE3, 0xC6, 0x39, 0xF1, 0x8E, 0x7E, 0x73, 0x9B,
  0x9D, 0xEE, 0xE7, 0xFF, 0x38, 0xE7, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0xCC, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0x78, 0x1E,
  0x70, 0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF,
  0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x78, 0xFF, 0x87, 0xFF, 0x3F,
  0xFD, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xFF, 0xE7, 0xFE,
  0x3F, 0xFD, 0xE1, 0xEF, 0x0F, 0x78, 0x7F, 0xC3, 0xDE, 0x3E, 0xFF, 0xF7,
  0xFF, 0x3F, 0xF0, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF9, 0xE7, 0x87, 0xF8,
  0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x3D, 0xE1, 0xEF, 0x9F, 0x7F, 0xF1, 0xFF, 0x03, 0xF0, 0xFF, 0x07,
  0xFE, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x7E,
  0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x0F,
  0xC1, 0xFF, 0x0F, 0xFC, 0xF9, 0xF7, 0x87, 0xF8, 0x3F, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xF8, 0x3D, 0xE1, 0xEF,
  0x9F, 0x3F, 0xF9, 0xFF, 0x83, 0xF0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0x9F,
  0xE1, 0xE0, 0xF0, 0xFB, 0xC3, 0xEF, 0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xCF,
  0x0F, 0x7C, 0x3D, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFB,
  0xC3, 0xEF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xEF, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x77, 0xFF, 0x3B, 0xFB, 0x9D,
  0xFD, 0xDF, 0xFE, 0xEE, 0xFF, 0x3F, 0x7F, 0x9F, 0xBF, 0xCF, 0x9F, 0xE7,
  0xCF, 0xF1, 0xE7, 0xF8, 0xF3, 0xFC, 0x71, 0xE0, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0xF7, 0x3F, 0xBD,
  0xFC, 0xEF, 0xE7, 0x7F, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x83, 0xFC, 0x1E, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x7B,
  0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC1, 0xE7, 0x87, 0x9F, 0x3E, 0x3F, 0xF0, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xC0, 0xFF, 0x83,
  0xFF, 0x1F, 0x3E, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xE7, 0x87, 0x9F, 0x3E,
  0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x40, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF1, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x9E,
  0x3E, 0xF0, 0xF7, 0x87, 0xBC, 0x3E, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xF3, 0xFE, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x03,
  0xE0, 0xF8, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xC7, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x1C, 0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x80,
  0xEE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x78, 0xE1, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0xF9, 0xE7, 0x9F,
  0x3C, 0xF3, 0xE7, 0x8E, 0x7E, 0xF1, 0xEF, 0xDE, 0x3F, 0xFB, 0x87, 0xFF,
  0x70, 0xFE, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3C, 0x7C, 0x00, 0x78,
  0x7D, 0xF1, 0xF3, 0xC7, 0x8F, 0x3E, 0x3E, 0xF0, 0x7B, 0xC1, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7B, 0xC3,
  0xEF, 0x0F, 0x3E, 0x7C, 0x79, 0xE1, 0xF7, 0x87, 0xC0, 0xF8, 0x3D, 0xE1,
  0xE7, 0x87, 0x8F, 0x1E, 0x3C, 0xF0, 0xF3, 0xC1, 0xEE, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDF, 0xFF, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E, 0x0F, 0x07, 0xC7, 0x63, 0xBB, 0x9D,
  0xCE, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0xC7, 0x1F, 0x0F,
  0xF3, 0xFF, 0x79, 0xE0, 0x3C, 0x7F, 0x9F, 0xF7, 0x9E, 0xF3, 0xDE, 0x7B,
  0xCF, 0x7F, 0xE7, 0xFC, 0x77, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0xFF, 0x7B, 0xC0, 0x1F, 0x1F,
  0xE7, 0xFF, 0xCF, 0xF1, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x7F, 0x3D,
  0xFF, 0x7F, 0x87, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xCF, 0x7B, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF3, 0xFF, 0xFD, 0xFF, 0x9E, 0xF0, 0x1F, 0x0F, 0xF1, 0xFF,
  0x78, 0xEF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xE3, 0x3F,
  0xE3, 0xFC, 0x3F, 0x00, 0x0F, 0x1F, 0x3F, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF,
  0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3D, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xFE, 0x7B, 0xC0, 0x79, 0x1F, 0x7F, 0xCF,
  0xF0, 0xFC, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D,
  0xE7, 0xFE, 0xFF, 0xDE, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x7F, 0xF7, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xF3, 0xC7, 0x00, 0x03, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xEF, 0x3C,
  0xF7, 0xCF, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x78,
  0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9E, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0x7C,
  0xFF, 0x1E, 0x7F, 0x8F, 0x3F, 0xC7, 0x9F, 0xE3, 0xCF, 0xF1, 0xE7, 0xF8,
  0xF3, 0xFC, 0x79, 0xFE, 0x3C, 0xFF, 0x1E, 0x7F, 0x8F, 0x3C, 0xF7, 0x9F,
  0xFB, 0xFF, 0x79, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x1F, 0x0F, 0xF1, 0xFF, 0x79, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xBF, 0xE7, 0xF8,
  0x3E, 0x00, 0xF7, 0x9F, 0xFB, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFF, 0xEF, 0xFD, 0xEF, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3D, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xFF, 0xF7, 0xFE, 0x7B,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF7, 0xFF, 0xFF, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x3F, 0x1F, 0xEF,
  0xFF, 0xCF, 0xF0, 0x3E, 0x07, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE, 0x3F, 0xFF,
  0x7F, 0x8F, 0x80, 0x3C, 0x3C, 0x3C, 0xFE, 0xFE, 0xFE, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xBF,
  0xF7, 0xFE, 0x7B, 0xC0, 0xF1, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC3,
  0xBC, 0x3F, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00,
  0xF0, 0x71, 0xCF, 0x73, 0xCF, 0x73, 0xCE, 0x7B, 0xCE, 0x7B, 0xEE, 0x7B,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E,
  0x7C, 0x1E, 0x3C, 0x1E, 0x38, 0x79, 0xE7, 0x9E, 0x3F, 0xC3, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xC7, 0x9C, 0x79,
  0xE7, 0x9E, 0xF1, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xC3, 0xBC, 0x3F,
  0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x08, 0x73, 0xCE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x3C, 0xE3, 0xC7,
  0x1E, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0xC7, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x8F, 0x1C,
  0xF7, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x38, 0xC0, 0x38, 0x77, 0xE7,
  0x7E, 0x7F, 0x7E, 0xE3, 0xEE, 0x1C,
};

const GFXglyph RobotoCondensed_ExtraBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 7, 7, 8, 1, -20 },
  { 20, 12, 19, 14, 1, -19 },
  { 49, 11, 24, 13, 1, -22 },
  { 82, 15, 19, 17, 1, -19 },
  { 118, 14, 19, 15, 1, -19 },
  { 152, 3, 7, 4, 1, -20 },
  { 155, 6, 26, 8, 2, -20 },
  { 175, 6, 26, 8, 1, -20 },
  { 195, 12, 11, 12, 0, -19 },
  { 212, 10, 13, 12, 1, -15 },
  { 229, 5, 8, 7, 0, -3 },
  { 234, 6, 3, 10, 2, -9 },
  { 237, 4, 4, 8, 2, -4 },
  { 239, 8, 21, 8, 0, -19 },
  { 260, 11, 19, 13, 1, -19 },
  { 287, 7, 19, 13, 2, -19 },
  { 304, 11, 19, 13, 1, -19 },
  { 331, 11, 19, 13, 1, -19 },
  { 358, 11, 19, 13, 1, -19 },
  { 385, 11, 19, 13, 1, -19 },
  { 412, 11, 19, 13, 1, -19 },
  { 439, 11, 19, 13, 1, -19 },
  { 466, 11, 19, 13, 1, -19 },
  { 493, 11, 19, 13, 1, -19 },
  { 520, 4, 14, 7, 2, -14 },
  { 527, 5, 19, 7, 1, -14 },
  { 539, 9, 12, 12, 1, -14 },
  { 553, 10, 8, 13, 2, -12 },
  { 563, 10, 12, 12, 1, -14 },
  { 578, 10, 19, 12, 1, -19 },
  { 602, 18, 24, 20, 1, -18 },
  { 656, 15, 19, 16, 0, -19 },
  { 692, 13, 19, 15, 1, -19 },
  { 723, 13, 19, 15, 1, -19 },
  { 754, 13, 19, 15, 1, -19 },
  { 785, 11, 19, 13, 1, -19 },
  { 812, 11, 19, 12, 1, -19 },
  { 839, 13, 19, 15, 1, -19 },
  { 870, 14, 19, 16, 1, -19 },
  { 904, 4, 19, 7, 2, -19 },
  { 914, 10, 19, 13, 1, -19 },
  { 938, 14, 19, 14, 1, -19 },
  { 972, 11, 19, 12, 1, -19 },
  { 999, 17, 19, 20, 1, -19 },
  { 1040, 13, 19, 16, 1, -19 },
  { 1071, 14, 19, 16, 1, -19 },
  { 1105, 13, 19, 15, 1, -19 },
  { 1136, 14, 22, 16, 1, -19 },
  { 1175, 13, 19, 15, 1, -19 },
  { 1206, 12, 19, 14, 1, -19 },
  { 1235, 13, 19, 14, 1, -19 },
  { 1266, 13, 19, 15, 1, -19 },
  { 1297, 15, 19, 15, 0, -19 },
  { 1333, 19, 19, 19, 0, -19 },
  { 1379, 14, 19, 15, 0, -19 },
  { 1413, 14, 19, 14, 0, -19 },
  { 1447, 12, 19, 14, 1, -19 },
  { 1476, 5, 26, 7, 1, -22 },
  { 1493, 10, 21, 10, 0, -19 },
  { 1520, 6, 26, 7, 0, -22 },
  { 1540, 9, 9, 10, 1, -19 },
  { 1551, 10, 3, 10, 0, 0 },
  { 1555, 6, 4, 9, 1, -20 },
  { 1558, 11, 14, 12, 1, -14 },
  { 1578, 11, 20, 13, 1, -20 },
  { 1606, 10, 14, 12, 1, -14 },
  { 1624, 11, 20, 13, 1, -20 },
  { 1652, 11, 14, 13, 1, -14 },
  { 1672, 8, 20, 9, 0, -20 },
  { 1692, 11, 19, 13, 1, -14 },
  { 1719, 11, 20, 13, 1, -20 },
  { 1747, 4, 20, 7, 1, -20 },
  { 1757, 6, 25, 7, -1, -20 },
  { 1776, 12, 20, 13, 1, -20 },
  { 1806, 4, 20, 7, 1, -20 },
  { 1816, 17, 14, 19, 1, -14 },
  { 1846, 11, 14, 13, 1, -14 },
  { 1866, 11, 14, 13, 1, -14 },
  { 1886, 11, 19, 13, 1, -14 },
  { 1913, 11, 19, 13, 1, -14 },
  { 1940, 7, 14, 9, 1, -14 },
  { 1953, 10, 14, 12, 1, -14 },
  { 1971, 8, 17, 8, 0, -17 },
  { 1988, 11, 14, 13, 1, -14 },
  { 2008, 12, 14, 12, 0, -14 },
  { 2029, 16, 14, 16, 0, -14 },
  { 2057, 12, 14, 12, 0, -14 },
  { 2078, 12, 19, 12, 0, -14 },
  { 2107, 10, 14, 12, 1, -14 },
  { 2125, 6, 25, 8, 1, -20 },
  { 2144, 2, 22, 7, 2, -19 },
  { 2150, 6, 25, 8, 1, -20 },
  { 2169, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBold26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_EXTRABOLD26PT7B_H_
