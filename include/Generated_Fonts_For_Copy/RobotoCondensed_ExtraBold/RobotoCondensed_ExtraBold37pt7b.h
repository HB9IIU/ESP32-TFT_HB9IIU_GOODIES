#ifndef _ROBOTOCONDENSED_EXTRABOLD37PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3B, 0x8E, 0xE3, 0xB8, 0xE0, 0x03, 0x9E,
  0x01, 0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x3C, 0xE0, 0x1C,
  0x70, 0x0E, 0x78, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xE7, 0x00,
  0xF3, 0x80, 0x71, 0xC0, 0x39, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x87, 0x9C, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x39,
  0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7E, 0xFC, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xFD, 0xFD, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF,
  0x80, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x38, 0x20, 0xE3, 0xC7, 0x0E, 0x3C,
  0xF0, 0xE3, 0xCE, 0x0E, 0x3D, 0xE0, 0xF3, 0x9C, 0x0F, 0xFB, 0xC0, 0x7F,
  0x38, 0x03, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE7, 0x80,
  0x1D, 0xFE, 0x03, 0xDF, 0xE0, 0x3B, 0xCF, 0x07, 0xBC, 0xF0, 0x73, 0xC7,
  0x0F, 0x3C, 0x70, 0xE3, 0xCF, 0x1C, 0x3C, 0xF0, 0x41, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E,
  0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x3E, 0x3F, 0xF3, 0xE7, 0xFF, 0x3C, 0x7D, 0xFF, 0xCF, 0xCF, 0xFC,
  0xFC, 0xFF, 0xCF, 0xC7, 0xF8, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x01, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x3E,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x10, 0x40, 0x70, 0x3C, 0x0F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x1C, 0x04,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x06, 0x1C, 0x13,
  0xCE, 0x79, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xFC,
  0x01, 0xEF, 0x01, 0xE3, 0xC0, 0xF1, 0xF0, 0x70, 0x70, 0x00, 0x10, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0xF3, 0xCF, 0x3D, 0xF7, 0xDE, 0xFB, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0xFB, 0xF7, 0xE7, 0xCF, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0xC7, 0xCF, 0xDF, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x00,
  0xC0, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3F,
  0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x07, 0xFC,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0x7C,
  0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7D, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F,
  0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0,
  0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF9, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFE, 0xFE, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3E, 0xFC, 0x7E, 0x7E, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7E, 0xF8, 0xF9, 0xFB, 0xF1, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0x1F, 0xFF,
  0x7E, 0x3E, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF,
  0xDF, 0xDF, 0xFF, 0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0xDF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x1E, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x38, 0xFB,
  0xF7, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x7D, 0xFF, 0xFB, 0xE3, 0x80, 0x1C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x3E, 0x79, 0xF0, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x3E, 0x00,
  0xE0, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0x81, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x1E, 0x3C, 0x0F, 0x83, 0x8E, 0x07, 0xF8, 0xE7, 0x83,
  0xFE, 0x3D, 0xE1, 0xF7, 0x8F, 0x78, 0xF1, 0xE3, 0xDC, 0x3C, 0x78, 0x77,
  0x0F, 0x1E, 0x1F, 0xC7, 0x87, 0x87, 0xF1, 0xE1, 0xE1, 0xFC, 0x78, 0x78,
  0xFF, 0x1E, 0x1C, 0x3F, 0xC7, 0x87, 0x0E, 0xF1, 0xE3, 0xC3, 0xBC, 0x78,
  0xF1, 0xE7, 0x1F, 0x7E, 0x71, 0xC3, 0xFF, 0xFC, 0x78, 0xFE, 0xFE, 0x1E,
  0x0E, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xFB, 0xF8, 0x03, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xF8,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0xBF, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE1,
  0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xF7, 0xFF, 0xFB, 0xFF,
  0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x83, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xDF, 0x83,
  0xFB, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F,
  0x87, 0xE7, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0xDF, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0xDF, 0x81, 0xF8, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB,
  0xE7, 0xDF, 0xFB, 0xE7, 0xDF, 0xF9, 0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xFD,
  0xFF, 0x9F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC,
  0xFF, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC,
  0x3C, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xDE, 0x7F,
  0xFB, 0xEF, 0xFF, 0x3D, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0xBF, 0x03, 0xF7,
  0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0x7E, 0x07, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0xBF, 0x03,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x7E, 0x07, 0xE7, 0xE1, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x07, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xBF,
  0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8,
  0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x3E, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0xC3, 0xF0, 0xFB, 0xF0, 0xFC,
  0x3E, 0xFC, 0x3F, 0x0F, 0x9F, 0x1F, 0xC7, 0xE7, 0xC7, 0xF1, 0xF9, 0xF9,
  0xFE, 0x7E, 0x7E, 0x7F, 0x9F, 0x1F, 0x9F, 0xE7, 0xC3, 0xEF, 0xF9, 0xF0,
  0xFB, 0xFE, 0x7C, 0x3E, 0xFF, 0xFF, 0x0F, 0xBF, 0xFF, 0xC3, 0xFF, 0x7F,
  0xE0, 0xFF, 0xDF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF,
  0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x03, 0xF7, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8, 0xFE, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x07, 0xDF, 0x00,
  0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xDF,
  0x80, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xE3, 0xF0,
  0x7E, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0x81,
  0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1E, 0xE0, 0xF7, 0x87, 0xBC, 0x79, 0xE3,
  0xC7, 0x9E, 0x3D, 0xE1, 0xEF, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0xC0, 0x1F, 0x80,
  0x3F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xF9, 0xF0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF9, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xE7, 0xCF, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x87, 0xDF, 0x0F, 0xBF, 0xFF, 0x7F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F,
  0xBF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x0F, 0x9F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7C, 0x3E, 0x7C, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x04, 0x7F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xE1, 0xFC, 0x7F, 0x9F,
  0xF3, 0xFA, 0x7E, 0x0F, 0x81, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE3,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0x9F,
  0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7C, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x10, 0x3F, 0x1C, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xE1, 0xF7,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xF0, 0x33,
  0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0F, 0x87, 0xE3,
  0xF1, 0xF0, 0x70, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7D, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0xFE, 0xF8, 0xFC, 0xF9,
  0xF8, 0xFB, 0xF8, 0xFB, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF9, 0xF8, 0xF8,
  0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0xF8, 0xFB, 0xF9, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x3E,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0x7C, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0xF9, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xEF, 0xE7,
  0xCF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x9F, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xBF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF,
  0x8F, 0xBF, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x7F, 0xFC, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF8, 0xF3, 0xF0, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0xF8, 0x78, 0xFF, 0xE3, 0xE3,
  0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0xF8, 0xFC, 0xF9, 0xF7, 0xF3, 0xE7,
  0xDF, 0xDF, 0x1F, 0x7F, 0x7C, 0x7D, 0xFD, 0xF1, 0xF7, 0x7F, 0xC3, 0xFD,
  0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE,
  0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0x87, 0xEF, 0xC1, 0xF7,
  0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0xF8,
  0x3F, 0x7E, 0x1F, 0x1F, 0x1F, 0x8F, 0xCF, 0xC3, 0xE0, 0xFC, 0x1F, 0x3E,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8,
  0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x03, 0x83, 0xE3,
  0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC1, 0xC0,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x40, 0x38, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xE3, 0xF3,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF8, 0x7C, 0x7C, 0x1C, 0x08, 0x00, 0x1E, 0x00, 0x3F, 0x83, 0xDF, 0xE3,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0x8F, 0xFB, 0xC3, 0xF8, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 10, 10, 12, 1, -28 },
  { 34, 17, 26, 19, 1, -26 },
  { 90, 15, 34, 19, 2, -30 },
  { 154, 20, 26, 24, 2, -26 },
  { 219, 20, 26, 22, 1, -26 },
  { 284, 4, 10, 6, 1, -28 },
  { 289, 9, 37, 12, 2, -29 },
  { 331, 9, 37, 12, 1, -29 },
  { 373, 17, 16, 17, 0, -26 },
  { 407, 15, 19, 17, 1, -22 },
  { 443, 6, 11, 10, 1, -5 },
  { 452, 9, 4, 14, 3, -13 },
  { 457, 7, 6, 11, 2, -6 },
  { 463, 11, 28, 12, 0, -26 },
  { 502, 15, 26, 19, 2, -26 },
  { 551, 10, 26, 19, 3, -26 },
  { 584, 16, 26, 19, 1, -26 },
  { 636, 16, 26, 19, 1, -26 },
  { 688, 16, 26, 19, 1, -26 },
  { 740, 16, 26, 19, 1, -26 },
  { 792, 16, 26, 19, 2, -26 },
  { 844, 16, 26, 19, 1, -26 },
  { 896, 15, 26, 19, 2, -26 },
  { 945, 15, 26, 19, 2, -26 },
  { 994, 7, 21, 10, 2, -21 },
  { 1013, 7, 27, 10, 1, -21 },
  { 1037, 13, 18, 17, 1, -20 },
  { 1067, 14, 12, 19, 2, -17 },
  { 1088, 14, 18, 17, 2, -20 },
  { 1120, 14, 26, 17, 1, -26 },
  { 1166, 26, 34, 28, 1, -26 },
  { 1277, 22, 26, 22, 0, -26 },
  { 1349, 17, 26, 21, 2, -26 },
  { 1405, 18, 26, 21, 2, -26 },
  { 1464, 17, 26, 21, 2, -26 },
  { 1520, 15, 26, 18, 2, -26 },
  { 1569, 15, 26, 18, 2, -26 },
  { 1618, 18, 26, 22, 2, -26 },
  { 1677, 19, 26, 23, 2, -26 },
  { 1739, 6, 26, 10, 2, -26 },
  { 1759, 15, 26, 18, 1, -26 },
  { 1808, 19, 26, 21, 2, -26 },
  { 1870, 15, 26, 18, 2, -26 },
  { 1919, 24, 26, 28, 2, -26 },
  { 1997, 19, 26, 23, 2, -26 },
  { 2059, 19, 26, 22, 2, -26 },
  { 2121, 18, 26, 21, 2, -26 },
  { 2180, 19, 31, 22, 2, -26 },
  { 2254, 18, 26, 21, 2, -26 },
  { 2313, 18, 26, 20, 1, -26 },
  { 2372, 18, 26, 20, 1, -26 },
  { 2431, 17, 26, 21, 2, -26 },
  { 2487, 21, 26, 22, 0, -26 },
  { 2556, 26, 26, 28, 1, -26 },
  { 2641, 20, 26, 21, 0, -26 },
  { 2706, 20, 26, 20, 0, -26 },
  { 2771, 18, 26, 20, 1, -26 },
  { 2830, 7, 37, 10, 2, -31 },
  { 2863, 15, 28, 14, 0, -26 },
  { 2916, 7, 37, 10, 1, -31 },
  { 2949, 13, 13, 15, 1, -26 },
  { 2971, 14, 4, 15, 0, 0 },
  { 2978, 10, 6, 12, 1, -28 },
  { 2986, 15, 20, 17, 1, -20 },
  { 3024, 15, 28, 18, 2, -28 },
  { 3077, 15, 20, 17, 1, -20 },
  { 3115, 16, 28, 18, 1, -28 },
  { 3171, 16, 20, 18, 1, -20 },
  { 3211, 11, 28, 12, 1, -28 },
  { 3250, 16, 28, 19, 1, -20 },
  { 3306, 15, 28, 18, 2, -28 },
  { 3359, 6, 28, 10, 2, -28 },
  { 3380, 9, 36, 9, -1, -28 },
  { 3421, 16, 28, 18, 2, -28 },
  { 3477, 6, 28, 10, 2, -28 },
  { 3498, 24, 20, 27, 2, -20 },
  { 3558, 15, 20, 18, 2, -20 },
  { 3596, 16, 20, 18, 1, -20 },
  { 3636, 15, 28, 18, 2, -20 },
  { 3689, 16, 28, 18, 1, -20 },
  { 3745, 10, 20, 13, 2, -20 },
  { 3770, 15, 20, 17, 1, -20 },
  { 3808, 11, 24, 11, 0, -24 },
  { 3841, 15, 20, 18, 2, -20 },
  { 3879, 16, 20, 17, 0, -20 },
  { 3919, 22, 20, 23, 1, -20 },
  { 3974, 17, 20, 17, 0, -20 },
  { 4017, 17, 28, 17, 0, -20 },
  { 4077, 14, 20, 17, 1, -20 },
  { 4112, 9, 36, 11, 1, -29 },
  { 4153, 3, 31, 9, 3, -26 },
  { 4165, 9, 36, 11, 1, -29 },
  { 4206, 17, 8, 20, 2, -15 },
};

const GFXfont RobotoCondensed_ExtraBold37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_EXTRABOLD37PT7B_H_
