#ifndef _ROBOTOCONDENSED_EXTRABOLD31PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x03,
  0xBD, 0xFF, 0x38, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0x07,
  0x70, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0x87, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFC, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC3, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0x19, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x60, 0x39, 0x80,
  0xEE, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x81, 0xFE, 0x1F, 0xF9,
  0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xE3, 0xDF, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0xF7, 0xCF,
  0xBF, 0xFC, 0xFF, 0xC7, 0xFE, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC2, 0x1E, 0x71, 0x8E, 0x39, 0xC7, 0x1C,
  0xC3, 0xCE, 0xE0, 0xFE, 0x60, 0x7F, 0x70, 0x0F, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1D, 0xE0, 0x1D, 0xFC, 0x0F, 0xFE, 0x0E, 0xE7, 0x06, 0x71,
  0x87, 0x38, 0xC3, 0x1C, 0xE1, 0x8F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF1,
  0xC7, 0xFD, 0xE3, 0xFE, 0xF3, 0xEF, 0xF9, 0xF3, 0xFC, 0xF9, 0xFC, 0x7C,
  0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFC, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE0, 0x02, 0x1C, 0x78, 0xE3, 0xC7, 0x1E, 0x3C, 0x71, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x78,
  0x70, 0xF0, 0xE1, 0xE1, 0xC0, 0x80, 0x40, 0xE0, 0xF0, 0x70, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE0,
  0x40, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x10, 0xE0, 0x7B, 0xBD, 0xFF, 0xF3,
  0xFF, 0x81, 0xE0, 0x0F, 0xC0, 0x7B, 0x81, 0xCF, 0x0E, 0x1C, 0x08, 0x20,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x7B, 0xDE, 0xF7, 0xBD, 0xDE, 0xE3, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0xFF, 0xF7, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0x0F,
  0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xBC, 0x7D, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF,
  0x0F, 0x78, 0xFB, 0xE7, 0xDF, 0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x01,
  0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFC,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xC7, 0xFF, 0xFE, 0xFF, 0xE3,
  0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1D, 0xF0, 0xF7, 0xC3, 0xDF, 0x1E, 0x7C,
  0x79, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x78, 0x7F, 0xE3, 0xFF, 0x9F, 0x7E,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0x0F, 0xF8, 0x7B, 0xE7, 0xDF,
  0xFE, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x07,
  0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0xF8, 0x7F, 0xF3, 0xFF, 0xEF,
  0xFF, 0xBE, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE, 0x1F, 0x78, 0x7D,
  0xF3, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xBC, 0x7D, 0xE3, 0xEF, 0x1F, 0x7C, 0xF9,
  0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFF, 0x3E, 0x7D, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7B, 0xE7, 0xDF, 0xFE, 0xFF, 0xE3, 0xFF, 0x07, 0xE0, 0x0F, 0x80, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xBC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xDF, 0x3E, 0xFF, 0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x70, 0x39, 0xF7, 0xDF, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x39, 0xE7, 0x9E, 0x73,
  0xC6, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFF, 0xFF, 0x3F, 0x87,
  0x80, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3E, 0x01, 0xC0, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x7F,
  0xC3, 0xF8, 0x1F, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20,
  0x00, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0xFF, 0xF9, 0xFF, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0xF0,
  0xF0, 0x01, 0xC3, 0x83, 0xC3, 0x9E, 0x3F, 0xCE, 0x70, 0xFF, 0x39, 0xC7,
  0x1C, 0x67, 0x3C, 0x71, 0xB8, 0xF3, 0xC7, 0xE3, 0x8F, 0x1F, 0x8E, 0x38,
  0x7E, 0x38, 0xE1, 0xB8, 0xE3, 0x8E, 0xE3, 0x8E, 0x3B, 0x8E, 0x78, 0xEE,
  0x3F, 0xFF, 0x1C, 0x7D, 0xF8, 0x70, 0xE3, 0xC1, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x03,
  0xEF, 0x00, 0xF3, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0xC1, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC0, 0xF9, 0xF0, 0x1F,
  0x7C, 0x07, 0xFF, 0x01, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC7, 0xEF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0,
  0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xEF,
  0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E,
  0x1F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF0, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xBF, 0xFC,
  0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0xF0, 0x7F, 0xE0, 0xFB, 0xC3, 0xF7, 0x87,
  0xCF, 0x1F, 0x9E, 0x3E, 0x3C, 0xF8, 0x79, 0xF0, 0xF7, 0xC1, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0xF8, 0xF1,
  0xF9, 0xE1, 0xF3, 0xC3, 0xF7, 0x83, 0xEF, 0x07, 0xFE, 0x0F, 0xC0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xF7, 0x9F, 0xFF,
  0x79, 0xDF, 0xF7, 0xBD, 0xFF, 0x3B, 0xDF, 0xF3, 0xFD, 0xFF, 0x3F, 0x9F,
  0xF3, 0xF9, 0xFF, 0x1F, 0x9F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF0, 0xF1,
  0xFF, 0x0F, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x1F, 0xEF, 0x3F, 0xDE, 0x7F,
  0x9E, 0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x7D, 0xE0, 0xFB,
  0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x04, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x0F,
  0xDE, 0x0F, 0xBC, 0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xE1, 0xFB, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3C, 0x7C, 0x78, 0xF8, 0xF1, 0xF1, 0xE1,
  0xF3, 0xC3, 0xE7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0xDE, 0x0F, 0xBE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0xFD, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF,
  0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xF0, 0xF8, 0x7B, 0xE3, 0xE1, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E,
  0x3E, 0xF8, 0xF8, 0xF9, 0xE3, 0xF3, 0xE7, 0x9F, 0xCF, 0x1E, 0x7F, 0x3C,
  0x7D, 0xFC, 0xF1, 0xF7, 0xF7, 0xC7, 0xDF, 0xFF, 0x0F, 0xF7, 0xFC, 0x3F,
  0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F,
  0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xC0,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xBF, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1,
  0xF3, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC3, 0xE7, 0xC1, 0xF3,
  0xE0, 0xFC, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xC7, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x77, 0x1C, 0xE3, 0x9C, 0x73, 0xDE, 0x3B, 0x87, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x81,
  0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0x9F, 0x00, 0xF8, 0x07, 0xC3, 0xFE, 0x7F,
  0xF3, 0xFF, 0xBE, 0x7D, 0xF3, 0xEF, 0x9F, 0x7F, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3E, 0xF8, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xEF, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFB, 0xEF, 0x80, 0x0F, 0x83, 0xFE, 0x7F, 0xF7, 0xFF, 0xF8, 0xFF,
  0x8F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0xF8, 0xF7,
  0xFF, 0x7F, 0xE3, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x7B, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3E, 0xFF, 0xF7, 0xFF, 0x9F, 0xBC, 0x79, 0xE0, 0x0F, 0xC1, 0xFF, 0x1F,
  0xFC, 0xFF, 0xE7, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x07, 0x82, 0x3F, 0xF9, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0,
  0x07, 0xC3, 0xF1, 0xFC, 0x7F, 0x3E, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x8F, 0xBF, 0xFD, 0xFF, 0xE7, 0xFF, 0x1E, 0x78, 0x07, 0xC0, 0x3E,
  0x7F, 0xF7, 0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xEF, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xE0, 0x33, 0xFE, 0xF7,
  0x80, 0x0F, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x0C, 0x3C, 0xF8, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7F, 0xFF,
  0xFF, 0xDF, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x8F, 0xBE, 0x7E, 0xF9, 0xF3, 0xEF, 0x8F, 0xBE, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xE7, 0x8F, 0x9F,
  0x3E, 0x7C, 0xF8, 0xFB, 0xE3, 0xEF, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xE3, 0xCF, 0xFF,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8,
  0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF,
  0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F,
  0xF8, 0xF8, 0xF0, 0xFB, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xF8, 0x0F, 0x81, 0xFF, 0x1F, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0xFB,
  0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFE, 0xFB, 0xC7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x00, 0x1E, 0x79, 0xFB, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xBF, 0xFD,
  0xFF, 0xE7, 0xFF, 0x1E, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x9F, 0xF9, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0x9F, 0x7F, 0xE3, 0xFE, 0x1F,
  0x80, 0x3E, 0x1F, 0x0F, 0x9F, 0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x9F, 0xC7, 0xE1, 0xF0,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF,
  0xE7, 0xEF, 0x1E, 0x78, 0xF8, 0x7D, 0xE1, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x78, 0xE3,
  0xEF, 0x1E, 0x7D, 0xE3, 0xCF, 0xBC, 0xF9, 0xE7, 0x9F, 0x3C, 0x7B, 0xF7,
  0x8F, 0x7E, 0xF1, 0xFF, 0xDE, 0x3F, 0xFF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x78,
  0x0F, 0x0F, 0x00, 0x7C, 0x79, 0xF3, 0xE3, 0xCF, 0x8F, 0xBC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0xF0, 0xFB, 0xC3, 0xCF, 0x9F, 0x3E, 0x78, 0x7C, 0xF8, 0x7D, 0xE1,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF3, 0xC3, 0xDF, 0x0F, 0xFC, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x1C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF3, 0xE7, 0x9F, 0x3C, 0x7C, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0x78, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x41, 0xC3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xE3,
  0xE3, 0xC3, 0x9F, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3,
  0xC7, 0x04, 0x00, 0x1E, 0x00, 0x7E, 0x3D, 0xFE, 0x73, 0xFF, 0xE7, 0x3F,
  0xDE, 0x3F, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 22, 8, 2, -22 },
  { 15, 8, 8, 10, 1, -23 },
  { 23, 14, 22, 16, 1, -22 },
  { 62, 13, 28, 16, 1, -25 },
  { 108, 17, 22, 20, 1, -22 },
  { 155, 17, 22, 18, 1, -22 },
  { 202, 3, 9, 5, 1, -23 },
  { 206, 7, 31, 10, 2, -24 },
  { 234, 8, 31, 10, 1, -24 },
  { 265, 14, 13, 14, 0, -22 },
  { 288, 13, 16, 15, 1, -18 },
  { 314, 5, 10, 8, 1, -4 },
  { 321, 8, 4, 12, 2, -12 },
  { 325, 5, 5, 9, 2, -5 },
  { 329, 10, 24, 10, 0, -22 },
  { 359, 13, 22, 16, 1, -22 },
  { 395, 9, 22, 16, 2, -22 },
  { 420, 14, 22, 16, 1, -22 },
  { 459, 13, 22, 16, 1, -22 },
  { 495, 14, 22, 16, 1, -22 },
  { 534, 13, 22, 16, 1, -22 },
  { 570, 14, 22, 16, 1, -22 },
  { 609, 13, 22, 16, 1, -22 },
  { 645, 13, 22, 16, 1, -22 },
  { 681, 13, 22, 16, 1, -22 },
  { 717, 5, 17, 9, 2, -17 },
  { 728, 6, 23, 8, 1, -17 },
  { 746, 11, 15, 14, 1, -17 },
  { 767, 12, 11, 16, 2, -15 },
  { 784, 11, 15, 14, 2, -17 },
  { 805, 12, 22, 14, 1, -22 },
  { 838, 22, 28, 24, 1, -21 },
  { 915, 18, 22, 19, 0, -22 },
  { 965, 14, 22, 18, 2, -22 },
  { 1004, 16, 22, 18, 1, -22 },
  { 1048, 14, 22, 17, 2, -22 },
  { 1087, 12, 22, 15, 2, -22 },
  { 1120, 12, 22, 15, 2, -22 },
  { 1153, 16, 22, 18, 1, -22 },
  { 1197, 15, 22, 19, 2, -22 },
  { 1239, 5, 22, 9, 2, -22 },
  { 1253, 13, 22, 15, 1, -22 },
  { 1289, 15, 22, 17, 2, -22 },
  { 1331, 12, 22, 15, 2, -22 },
  { 1364, 20, 22, 24, 2, -22 },
  { 1419, 15, 22, 19, 2, -22 },
  { 1461, 16, 22, 19, 1, -22 },
  { 1505, 15, 22, 18, 2, -22 },
  { 1547, 16, 26, 19, 1, -22 },
  { 1599, 15, 22, 17, 2, -22 },
  { 1641, 15, 22, 17, 1, -22 },
  { 1683, 15, 22, 17, 1, -22 },
  { 1725, 14, 22, 18, 2, -22 },
  { 1764, 18, 22, 18, 0, -22 },
  { 1814, 22, 22, 23, 1, -22 },
  { 1875, 17, 22, 17, 0, -22 },
  { 1922, 17, 22, 17, 0, -22 },
  { 1969, 15, 22, 17, 1, -22 },
  { 2011, 6, 31, 8, 2, -26 },
  { 2035, 12, 24, 12, 0, -22 },
  { 2071, 6, 31, 8, 1, -26 },
  { 2095, 11, 11, 12, 1, -22 },
  { 2111, 12, 4, 12, 0, 0 },
  { 2117, 8, 5, 10, 1, -24 },
  { 2122, 13, 17, 15, 1, -17 },
  { 2150, 13, 23, 15, 1, -23 },
  { 2188, 12, 17, 14, 1, -17 },
  { 2214, 13, 23, 15, 1, -23 },
  { 2252, 13, 17, 15, 1, -17 },
  { 2280, 10, 23, 10, 0, -23 },
  { 2309, 13, 23, 16, 1, -17 },
  { 2347, 13, 23, 15, 1, -23 },
  { 2385, 5, 24, 8, 1, -24 },
  { 2400, 7, 30, 8, -1, -24 },
  { 2427, 14, 23, 15, 1, -23 },
  { 2468, 4, 23, 8, 2, -23 },
  { 2480, 20, 17, 23, 1, -17 },
  { 2523, 13, 17, 15, 1, -17 },
  { 2551, 13, 17, 15, 1, -17 },
  { 2579, 13, 23, 15, 1, -17 },
  { 2617, 13, 23, 15, 1, -17 },
  { 2655, 9, 17, 10, 1, -17 },
  { 2675, 12, 17, 14, 1, -17 },
  { 2701, 9, 20, 10, 0, -20 },
  { 2724, 13, 17, 15, 1, -17 },
  { 2752, 14, 17, 14, 0, -17 },
  { 2782, 19, 17, 20, 0, -17 },
  { 2823, 14, 17, 14, 0, -17 },
  { 2853, 14, 23, 14, 0, -17 },
  { 2894, 12, 17, 14, 1, -17 },
  { 2920, 7, 29, 9, 1, -24 },
  { 2946, 2, 26, 8, 3, -22 },
  { 2953, 7, 29, 9, 1, -24 },
  { 2979, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_ExtraBold31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_EXTRABOLD31PT7B_H_
