#ifndef _ROBOTOCONDENSED_EXTRABOLD18PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0xDE, 0xF7, 0xBD, 0x80, 0x36, 0x34,
  0x34, 0xFF, 0xFF, 0x2C, 0x6C, 0x6C, 0xFE, 0xFE, 0x68, 0x58, 0x58, 0x18,
  0x30, 0xF3, 0xFE, 0xFC, 0xF8, 0x38, 0x3C, 0x3C, 0x3E, 0x3E, 0xFF, 0xCF,
  0x08, 0x10, 0x70, 0x3E, 0x0D, 0xB3, 0x68, 0xFE, 0x1D, 0x00, 0xC0, 0x6E,
  0x1F, 0xCD, 0xB2, 0x6C, 0x9F, 0x03, 0x80, 0x38, 0x3E, 0x1B, 0x0D, 0x86,
  0xC3, 0xC1, 0xEF, 0xF6, 0xDF, 0x67, 0xBB, 0x9F, 0xE7, 0xB8, 0xFF, 0xC0,
  0x13, 0x36, 0x6E, 0xCC, 0xCC, 0xCC, 0xE6, 0x63, 0x31, 0x43, 0x18, 0x63,
  0x1C, 0xE3, 0x18, 0xC6, 0x73, 0x98, 0xCC, 0x62, 0x00, 0x18, 0x18, 0x49,
  0xFF, 0x1C, 0x3C, 0x66, 0x24, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18,
  0x30, 0x77, 0x76, 0x64, 0xFF, 0xC0, 0x7F, 0x80, 0x18, 0x61, 0x86, 0x30,
  0xC3, 0x0C, 0x61, 0x86, 0x18, 0xC3, 0x00, 0x38, 0xFB, 0xBF, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0xCF, 0xBB, 0xE3, 0x80, 0x0B, 0xFF, 0xB1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x80, 0x3D, 0xFF, 0xBE, 0x70, 0xE1, 0xC7, 0x0E, 0x38,
  0xE3, 0x87, 0xFF, 0xE0, 0x7D, 0xFF, 0xB8, 0x30, 0xE7, 0x8F, 0x07, 0x07,
  0x8F, 0xBF, 0xF7, 0x80, 0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x6E, 0xEE, 0xCE,
  0xFF, 0xFF, 0x0E, 0x0E, 0x0E, 0x7F, 0xFF, 0x87, 0x0F, 0xDF, 0xD3, 0x83,
  0x07, 0x8F, 0xBB, 0xF3, 0x80, 0x1C, 0x3C, 0x70, 0xE0, 0xFC, 0xFE, 0xEE,
  0xC7, 0xC7, 0xE6, 0xEE, 0x7E, 0x3C, 0xFF, 0xFC, 0x38, 0x70, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xC3, 0x87, 0x00, 0x3C, 0xFF, 0xBF, 0x7E, 0xEF, 0x9F,
  0x77, 0xE7, 0xCF, 0xBF, 0xF3, 0xC0, 0x38, 0xFB, 0xBF, 0x3C, 0x7C, 0xFB,
  0xFF, 0x7E, 0x1C, 0x73, 0xC7, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0xFD, 0x00, 0x02, 0x1C, 0xFF, 0xCE, 0x1F, 0x0F, 0x87, 0x02,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC3, 0xE1, 0xF0, 0xE7, 0xFE, 0x70,
  0x80, 0x3C, 0xFD, 0x9F, 0x30, 0x61, 0xC7, 0x0C, 0x18, 0x00, 0x61, 0xC1,
  0x80, 0x0F, 0x83, 0xDC, 0x70, 0x66, 0x02, 0xC7, 0x3C, 0xFB, 0xD9, 0xB9,
  0x9B, 0x99, 0x39, 0xB3, 0xDF, 0xEC, 0xDC, 0xC0, 0x06, 0x00, 0x3F, 0x01,
  0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xB0, 0x76, 0x0E, 0xE1, 0x9C,
  0x3F, 0x8F, 0xF9, 0xC7, 0x30, 0xEE, 0x0E, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7,
  0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0x3E, 0x3F, 0xB9, 0xDC,
  0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0xF9, 0xEF, 0xE3, 0xE0, 0xFC,
  0xFE, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0xFE, 0xFC,
  0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0xFF, 0xE0,
  0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x00,
  0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x07, 0x03, 0xBF, 0xDF, 0xE3, 0xF1, 0xFC,
  0xEF, 0xF3, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xE7, 0x77, 0x7E, 0x3C,
  0xE7, 0xF3, 0xBB, 0xDD, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xEE, 0x77, 0x39,
  0xDC, 0xEE, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0xFF, 0xE0, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF9, 0xFF, 0x9F,
  0xFB, 0xFF, 0xB7, 0xEF, 0x7E, 0xF7, 0xEE, 0x7E, 0xE7, 0xE6, 0x70, 0xE3,
  0xF1, 0xFC, 0xFE, 0x7F, 0xBF, 0xDF, 0xFF, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC,
  0x7E, 0x38, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xFD, 0xEF, 0xE3, 0xE0, 0xFC, 0x7F, 0xB9, 0xDC, 0x6E, 0x3F, 0x1F,
  0x9D, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xBD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xE3, 0xF0, 0x1C,
  0x04, 0xFE, 0x7F, 0xB9, 0xDC, 0xEE, 0x77, 0x3B, 0xF9, 0xFC, 0xEE, 0x77,
  0x39, 0xDC, 0xEE, 0x38, 0x3C, 0x7E, 0xE7, 0xE7, 0xE0, 0x78, 0x3E, 0x0F,
  0x07, 0xC7, 0xE7, 0xFF, 0x3C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x3E, 0xE1, 0xDC, 0x77,
  0x1D, 0xCE, 0x73, 0x8C, 0xE3, 0xB8, 0xEC, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x0E, 0x00, 0xE7, 0x3B, 0x39, 0xD9, 0xCE, 0xEF, 0x67, 0x7B, 0x3B, 0xD9,
  0xFF, 0xC7, 0xBE, 0x3D, 0xF1, 0xEF, 0x0F, 0x38, 0x79, 0xC3, 0xCE, 0x00,
  0x71, 0xDC, 0xE7, 0x38, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x0F,
  0xC7, 0x39, 0xCE, 0xF3, 0xC0, 0xE1, 0xDC, 0xE7, 0x38, 0xCC, 0x3F, 0x0F,
  0x81, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFF, 0xFF,
  0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0E,
  0x1C, 0x18, 0x38, 0x70, 0x60, 0xE1, 0xC0, 0xFF, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0xFF, 0x38, 0x70, 0xA3, 0x66, 0xCC, 0xC0, 0xFF, 0xFC,
  0x71, 0x86, 0x79, 0xFB, 0x38, 0x77, 0xFF, 0xF3, 0xE7, 0xFE, 0xFC, 0xE1,
  0xC3, 0x87, 0x0F, 0xDF, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x7F, 0xFB, 0x80,
  0x79, 0xFB, 0xBE, 0x7C, 0x18, 0x33, 0xF7, 0xFC, 0xF0, 0x0E, 0x1C, 0x38,
  0x77, 0xFF, 0xFB, 0xE7, 0xCF, 0x9F, 0x3F, 0x7F, 0xEE, 0xC0, 0x7D, 0xFB,
  0xBE, 0x3F, 0xFF, 0xF0, 0x72, 0xFE, 0x78, 0x1C, 0xF7, 0x1C, 0xFF, 0xF7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x77, 0xFF, 0xBE, 0x3C, 0x78, 0xF1,
  0xF7, 0xFE, 0xEC, 0x1A, 0x7F, 0xEF, 0x00, 0xC1, 0x83, 0x06, 0x0D, 0xDF,
  0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xC0, 0xDF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x31, 0xCC, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0xF7, 0x00, 0xE0, 0xE0, 0xE0, 0xE0, 0xEE, 0xEE, 0xFC, 0xF8, 0xF8, 0xFC,
  0xFC, 0xEE, 0xEE, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDD, 0xDF,
  0xFF, 0xB9, 0xF7, 0x3E, 0xE7, 0xDC, 0xFB, 0x9F, 0x73, 0xEE, 0x7D, 0xCC,
  0xDD, 0xFF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9C, 0x79, 0xFF, 0xBE,
  0x3C, 0x78, 0xF1, 0xF7, 0xFE, 0xF0, 0xDD, 0xFF, 0xBF, 0x3E, 0x7C, 0xF9,
  0xF7, 0xFF, 0xFB, 0x87, 0x0E, 0x1C, 0x00, 0x77, 0xFF, 0xBE, 0x7C, 0xF9,
  0xF3, 0xF7, 0xFE, 0xFC, 0x38, 0x70, 0xE1, 0xC0, 0xDF, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x3C, 0x7E, 0x67, 0x70, 0x7C, 0x3E, 0x0F, 0x67, 0x7E,
  0x3C, 0x73, 0xBF, 0xF7, 0x39, 0xCE, 0x73, 0x9E, 0x70, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xF7, 0xFE, 0xEC, 0xE7, 0x67, 0x66, 0x76, 0x7E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x1C, 0xE6, 0xED, 0xDD, 0xBB, 0xB7, 0x66, 0xFC, 0xF7,
  0x8E, 0xF1, 0xDE, 0x39, 0x87, 0x30, 0x67, 0x76, 0x7E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7E, 0x76, 0xE7, 0xE7, 0x67, 0x66, 0x7E, 0x7E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x18, 0x18, 0x38, 0x78, 0x70, 0xFF, 0xF1, 0xC6, 0x39, 0xC7, 0x38,
  0xFF, 0xF0, 0x11, 0xCC, 0x63, 0x19, 0xDC, 0xE3, 0x8C, 0x63, 0x18, 0xC7,
  0x10, 0xFF, 0xFE, 0x43, 0x1C, 0xE7, 0x38, 0xC7, 0x39, 0x9C, 0xE7, 0x39,
  0x8C, 0x40, 0x73, 0xFB, 0xDF, 0xCE,
};

const GFXglyph RobotoCondensed_ExtraBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 5, 5, 6, 0, -14 },
  { 10, 8, 13, 9, 1, -13 },
  { 23, 7, 17, 9, 1, -15 },
  { 38, 10, 13, 12, 1, -13 },
  { 55, 9, 13, 11, 1, -13 },
  { 70, 2, 5, 3, 0, -14 },
  { 72, 4, 18, 6, 1, -14 },
  { 81, 5, 18, 6, 0, -14 },
  { 93, 8, 8, 8, 0, -13 },
  { 101, 7, 9, 8, 1, -10 },
  { 109, 4, 6, 5, 0, -2 },
  { 112, 5, 2, 7, 1, -6 },
  { 114, 3, 3, 5, 1, -3 },
  { 116, 6, 14, 6, 0, -13 },
  { 127, 7, 13, 9, 1, -13 },
  { 139, 5, 13, 9, 1, -13 },
  { 148, 7, 13, 9, 1, -13 },
  { 160, 7, 13, 9, 1, -13 },
  { 172, 8, 13, 9, 1, -13 },
  { 185, 7, 13, 9, 1, -13 },
  { 197, 8, 13, 9, 1, -13 },
  { 210, 7, 13, 9, 1, -13 },
  { 222, 7, 13, 9, 1, -13 },
  { 234, 7, 13, 9, 1, -13 },
  { 246, 3, 10, 5, 1, -10 },
  { 250, 3, 14, 5, 1, -10 },
  { 256, 7, 9, 8, 0, -10 },
  { 264, 7, 5, 9, 1, -8 },
  { 269, 7, 9, 8, 1, -10 },
  { 277, 7, 13, 8, 0, -13 },
  { 289, 12, 16, 14, 1, -12 },
  { 313, 11, 13, 11, 0, -13 },
  { 331, 8, 13, 10, 1, -13 },
  { 344, 9, 13, 10, 1, -13 },
  { 359, 8, 13, 10, 1, -13 },
  { 372, 7, 13, 9, 1, -13 },
  { 384, 7, 13, 9, 1, -13 },
  { 396, 9, 13, 11, 1, -13 },
  { 411, 9, 13, 11, 1, -13 },
  { 426, 3, 13, 5, 1, -13 },
  { 431, 8, 13, 9, 0, -13 },
  { 444, 9, 13, 10, 1, -13 },
  { 459, 7, 13, 9, 1, -13 },
  { 471, 12, 13, 14, 1, -13 },
  { 491, 9, 13, 11, 1, -13 },
  { 506, 9, 13, 11, 1, -13 },
  { 521, 9, 13, 10, 1, -13 },
  { 536, 9, 15, 11, 1, -13 },
  { 553, 9, 13, 10, 1, -13 },
  { 568, 8, 13, 10, 1, -13 },
  { 581, 9, 13, 10, 0, -13 },
  { 596, 8, 13, 10, 1, -13 },
  { 609, 10, 13, 10, 0, -13 },
  { 626, 13, 13, 13, 0, -13 },
  { 648, 10, 13, 10, 0, -13 },
  { 665, 10, 13, 10, 0, -13 },
  { 682, 8, 13, 10, 1, -13 },
  { 695, 3, 18, 5, 1, -15 },
  { 702, 7, 14, 7, 0, -13 },
  { 715, 4, 18, 5, 0, -15 },
  { 724, 7, 6, 7, 0, -13 },
  { 730, 7, 2, 7, 0, 0 },
  { 732, 5, 3, 6, 0, -14 },
  { 734, 7, 10, 8, 1, -10 },
  { 743, 7, 14, 9, 1, -14 },
  { 756, 7, 10, 8, 1, -10 },
  { 765, 7, 14, 9, 1, -14 },
  { 778, 7, 10, 9, 1, -10 },
  { 787, 6, 14, 6, 0, -14 },
  { 798, 7, 14, 9, 1, -10 },
  { 811, 7, 14, 9, 1, -14 },
  { 824, 3, 14, 5, 1, -14 },
  { 830, 5, 18, 5, -1, -14 },
  { 842, 8, 14, 9, 1, -14 },
  { 856, 3, 14, 5, 1, -14 },
  { 862, 11, 10, 13, 1, -10 },
  { 876, 7, 10, 9, 1, -10 },
  { 885, 7, 10, 9, 1, -10 },
  { 894, 7, 14, 9, 1, -10 },
  { 907, 7, 14, 9, 1, -10 },
  { 920, 5, 10, 6, 1, -10 },
  { 927, 8, 10, 8, 0, -10 },
  { 937, 5, 12, 6, 0, -12 },
  { 945, 7, 10, 9, 1, -10 },
  { 954, 8, 10, 8, 0, -10 },
  { 964, 11, 10, 11, 0, -10 },
  { 978, 8, 10, 8, 0, -10 },
  { 988, 8, 14, 8, 0, -10 },
  { 1002, 6, 10, 8, 1, -10 },
  { 1010, 5, 17, 5, 0, -14 },
  { 1021, 1, 15, 5, 2, -13 },
  { 1023, 5, 17, 5, 0, -14 },
  { 1034, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBold18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_EXTRABOLD18PT7B_H_
