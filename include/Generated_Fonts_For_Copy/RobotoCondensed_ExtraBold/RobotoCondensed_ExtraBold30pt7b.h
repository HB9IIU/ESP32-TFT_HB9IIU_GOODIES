#ifndef _ROBOTOCONDENSED_EXTRABOLD30PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC6, 0xC6, 0xC6, 0x06, 0x70, 0x39, 0xC0,
  0xE6, 0x03, 0x98, 0x0E, 0xE0, 0x3B, 0x87, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC,
  0x73, 0x01, 0xCC, 0x07, 0x70, 0x1D, 0xC3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x39, 0xC0, 0xE6, 0x03, 0x98, 0x0E, 0xE0, 0x3B, 0x80, 0xCE, 0x00, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF, 0x9F,
  0x78, 0xFB, 0xC7, 0xDF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xFE, 0x3F, 0xF1, 0xF7, 0x8F, 0xBF, 0xF9, 0xFF,
  0xC7, 0xFC, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1C, 0xE3, 0x8E, 0x39, 0x87, 0x1D, 0xC3, 0x9C, 0xC0,
  0xFE, 0xE0, 0x7F, 0x60, 0x1E, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x19,
  0xE0, 0x1D, 0xF8, 0x0D, 0xFE, 0x0E, 0xE7, 0x0E, 0x73, 0x87, 0x39, 0xC7,
  0x1C, 0xE1, 0x8F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3C, 0xF0, 0x78, 0xF0, 0x3C, 0xE0, 0x3D, 0xE0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x9E, 0x7F, 0x9E, 0xFF, 0xDE,
  0xFB, 0xFE, 0xF1, 0xFC, 0xF9, 0xFC, 0xF8, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0x04, 0x1C, 0x78, 0xE3, 0x87,
  0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x8F, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE1, 0xE1, 0xC1, 0x00, 0x81,
  0xC3, 0x83, 0x87, 0x87, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x71, 0xE3, 0x8E,
  0x1C, 0x20, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x10, 0xC2, 0x73, 0x39,
  0xFF, 0xE3, 0xFF, 0x01, 0xE0, 0x0F, 0xC0, 0x77, 0x83, 0xCE, 0x0E, 0x1C,
  0x08, 0x40, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x7B, 0xDE, 0xF7, 0xBB, 0xDC, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0x77, 0xFF, 0xF7, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C,
  0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x1E, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0x0F, 0x80, 0xFF, 0x0F, 0xF8,
  0xFF, 0xE7, 0x8F, 0x3C, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0x78, 0xFB, 0xC7,
  0x9F, 0xFC, 0x7F, 0xC1, 0xFE, 0x07, 0xC0, 0x01, 0x83, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xFF, 0xEF, 0x8F, 0x7C, 0x7F, 0xC3, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xFF, 0xEF, 0x8F, 0x7C, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x7F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1D, 0xF1, 0xEF,
  0x8E, 0x7C, 0xF3, 0xE7, 0x9F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xF1, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF,
  0x9E, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xF8, 0xFF,
  0xC7, 0x9F, 0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x01, 0xC0, 0x3E, 0x03,
  0xF0, 0x3F, 0x83, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x78, 0x7F, 0xE7, 0xFF,
  0xBF, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x78, 0x7B,
  0xC7, 0xDF, 0xFC, 0x7F, 0xE1, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0x0F,
  0xFC, 0xFF, 0xE7, 0xCF, 0x3C, 0x79, 0xE3, 0xEF, 0x1E, 0x7C, 0xF1, 0xFF,
  0x87, 0xF8, 0x3F, 0xC3, 0xFF, 0x3E, 0x79, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xDF, 0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE7, 0x8F, 0x3C, 0x7B, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xDE, 0x3E, 0xFB, 0xF7, 0xFF, 0x9F, 0xFC, 0x7B, 0xC0, 0x1E, 0x01, 0xF0,
  0x1F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x70, 0x31, 0xE7, 0xDF, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0xF1, 0x80,
  0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xF7, 0xFD, 0xFE, 0x3E, 0x07, 0xC0, 0xFF,
  0x0F, 0xF8, 0x7F, 0x83, 0xF0, 0x0E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x3F, 0xC1, 0xF8, 0x3F, 0x1F,
  0xFF, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00, 0x1F, 0x0F, 0xF9, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1E,
  0x03, 0x81, 0xC0, 0x0E, 0x1E, 0x00, 0x38, 0xE1, 0xF1, 0xCE, 0x1F, 0xC6,
  0x71, 0xFE, 0x33, 0x8E, 0x71, 0xD8, 0xE3, 0x8F, 0xC7, 0x1C, 0x7E, 0x38,
  0xE3, 0xF1, 0xC7, 0x1F, 0x9E, 0x38, 0xFC, 0xF1, 0xC6, 0xE7, 0x8E, 0x37,
  0x1C, 0xF3, 0xB8, 0xFF, 0xF9, 0xC7, 0xFF, 0xC7, 0x1E, 0x78, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1F, 0x1E, 0x07, 0x87,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0xBE, 0x01, 0xF0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC7,
  0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xFB, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF, 0x07, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x0F, 0x78, 0x3E, 0xF8, 0x7D, 0xFF, 0xF9, 0xFF, 0xE1,
  0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF0,
  0xFB, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0xFB, 0xC3, 0xEF,
  0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF7, 0xC3, 0xEF, 0x83,
  0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x07, 0xFC, 0x0F, 0x7C, 0x1E, 0xF8, 0x3C, 0xFF,
  0xF9, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F,
  0xF1, 0xFF, 0x9F, 0xFF, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0xF0, 0x7F, 0xE1,
  0xFB, 0xC3, 0xE7, 0x8F, 0xCF, 0x1F, 0x1E, 0x7C, 0x3C, 0xF8, 0x7B, 0xE0,
  0xF7, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E,
  0xF8, 0x7C, 0xF8, 0xF1, 0xF1, 0xE3, 0xF3, 0xC3, 0xE7, 0x87, 0xEF, 0x07,
  0xDE, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xBF,
  0xDC, 0x77, 0xFB, 0x9E, 0xFF, 0x7B, 0xDF, 0xEF, 0x73, 0xFC, 0xEE, 0x7F,
  0x9F, 0xCF, 0xF3, 0xF1, 0xFE, 0x7E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF,
  0x1E, 0x1F, 0xE1, 0xC3, 0xC0, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0x3F, 0xEE, 0x7F,
  0xDE, 0xFF, 0x9D, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x0C, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1,
  0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xE3, 0xFF, 0x8F, 0x3E, 0x3C, 0x7C, 0xF1, 0xF3, 0xC7, 0xCF, 0x0F, 0xBC,
  0x3E, 0xF0, 0x7F, 0xC1, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xF7, 0xFF, 0xDF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x78, 0x3E, 0xF8, 0x79,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xF8, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C,
  0x7C, 0x1E, 0x3E, 0x0F, 0x1F, 0x07, 0xCF, 0x03, 0xE7, 0x80, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xF0, 0xF0, 0xFF, 0x87, 0x87,
  0xFE, 0x3E, 0x3D, 0xF1, 0xF1, 0xEF, 0x9F, 0x8F, 0x3C, 0xFC, 0xF9, 0xE7,
  0xE7, 0xCF, 0x3F, 0x3E, 0x79, 0xFD, 0xE3, 0xEF, 0xEF, 0x1F, 0xFF, 0x78,
  0x7F, 0xFB, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x7C, 0x1F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x1E, 0x3C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x1F, 0x7C,
  0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E,
  0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xFF, 0xFC, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDF,
  0xFF, 0xFC, 0x1E, 0x07, 0x83, 0xE0, 0xFC, 0x3F, 0x1F, 0xC7, 0x39, 0xCE,
  0xF3, 0xBC, 0xFE, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C,
  0x3C, 0x1E, 0x1E, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x9F, 0xF9, 0xF0, 0x1F,
  0x1F, 0xF7, 0xFF, 0x7F, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xFB, 0xFF, 0xFF,
  0x7F, 0xF3, 0xCF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x78, 0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xEF,
  0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0xF8,
  0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0x8F, 0x7F,
  0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x7F,
  0xF7, 0xFF, 0x1E, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F,
  0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x47,
  0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xF8, 0x07, 0xC3, 0xF1, 0xFC, 0x7F, 0x3E,
  0x0F, 0x83, 0xE3, 0xFE, 0xFF, 0xBF, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1E,
  0x79, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3,
  0xDF, 0x00, 0xF8, 0x07, 0xCF, 0xFC, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xBC, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0x23, 0xFE,
  0xF7, 0x00, 0x0F, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xE0, 0x0C, 0x3C, 0xF9, 0xF1, 0xC0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0xFF,
  0xFF, 0xEF, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0xBE, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0x9E,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE3, 0xEF, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFB, 0xC7, 0xCF, 0xFE,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F,
  0xFB, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xF7, 0xFF, 0x3F, 0xF8, 0xFF,
  0x81, 0xF0, 0xFB, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0x7F,
  0xFB, 0xFF, 0x9F, 0x78, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0x7F,
  0xF1, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x1F, 0x07, 0xFC, 0x7F, 0xEF, 0x9E, 0xF1,
  0xFF, 0x80, 0x7E, 0x07, 0xF8, 0x3F, 0xE0, 0x7E, 0x01, 0xFF, 0x1F, 0xF9,
  0xE7, 0xFE, 0x7F, 0xC1, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F,
  0x9F, 0xC7, 0xE1, 0xF0, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF1, 0xEF, 0xF8, 0xFB, 0xC7, 0xDE, 0x3E, 0xF9, 0xE3, 0xCF,
  0x1E, 0x78, 0xF7, 0xC7, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x78, 0xE3, 0xDE, 0x38, 0xF7, 0x9F,
  0x3D, 0xE7, 0xCF, 0x79, 0xF7, 0xCE, 0x7D, 0xE3, 0xFF, 0x78, 0xFE, 0xFE,
  0x3F, 0xBF, 0x8F, 0xEF, 0xE1, 0xFB, 0xF0, 0x7C, 0xFC, 0x1F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x38, 0x78, 0x78, 0xFB, 0xE7, 0xCF, 0x3C, 0x7F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF8,
  0x7F, 0xC3, 0xFF, 0x1E, 0x79, 0xF3, 0xEF, 0x1F, 0xF8, 0x7B, 0xC7, 0xDE,
  0x3E, 0xF9, 0xE7, 0xCF, 0x1E, 0xF8, 0xF7, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x1C, 0x79, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0x7C, 0x78, 0x70, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0x78, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x41, 0xC3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC3, 0xC3, 0xC7, 0x9F, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79,
  0xE3, 0x82, 0x00, 0x1C, 0x00, 0xFC, 0x77, 0xF1, 0xDF, 0xFF, 0xF3, 0xFB,
  0xC7, 0xE0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 10, 1, -23 },
  { 20, 14, 22, 16, 1, -22 },
  { 59, 13, 28, 15, 1, -25 },
  { 105, 17, 22, 19, 1, -22 },
  { 152, 16, 22, 18, 1, -22 },
  { 196, 3, 8, 5, 1, -23 },
  { 199, 7, 31, 10, 2, -24 },
  { 227, 7, 31, 10, 1, -24 },
  { 255, 14, 13, 14, 0, -22 },
  { 278, 12, 16, 14, 1, -18 },
  { 302, 5, 9, 8, 1, -4 },
  { 308, 8, 4, 12, 2, -11 },
  { 312, 5, 5, 9, 2, -5 },
  { 316, 9, 24, 10, 0, -22 },
  { 343, 13, 22, 15, 1, -22 },
  { 379, 9, 22, 15, 2, -22 },
  { 404, 13, 22, 15, 1, -22 },
  { 440, 13, 22, 15, 1, -22 },
  { 476, 13, 22, 15, 1, -22 },
  { 512, 13, 22, 15, 1, -22 },
  { 548, 13, 22, 15, 1, -22 },
  { 584, 13, 22, 15, 1, -22 },
  { 620, 13, 22, 15, 1, -22 },
  { 656, 13, 22, 15, 1, -22 },
  { 692, 5, 17, 8, 2, -17 },
  { 703, 6, 22, 8, 1, -17 },
  { 720, 11, 14, 13, 1, -16 },
  { 740, 11, 11, 15, 2, -15 },
  { 756, 11, 14, 14, 2, -16 },
  { 776, 11, 22, 14, 1, -22 },
  { 807, 21, 28, 23, 1, -21 },
  { 881, 18, 22, 18, 0, -22 },
  { 931, 14, 22, 17, 2, -22 },
  { 970, 15, 22, 17, 1, -22 },
  { 1012, 14, 22, 17, 2, -22 },
  { 1051, 12, 22, 15, 2, -22 },
  { 1084, 12, 22, 14, 2, -22 },
  { 1117, 15, 22, 18, 1, -22 },
  { 1159, 15, 22, 18, 2, -22 },
  { 1201, 4, 22, 8, 2, -22 },
  { 1212, 12, 22, 15, 1, -22 },
  { 1245, 15, 22, 17, 2, -22 },
  { 1287, 12, 22, 14, 2, -22 },
  { 1320, 19, 22, 23, 2, -22 },
  { 1373, 15, 22, 18, 2, -22 },
  { 1415, 16, 22, 18, 1, -22 },
  { 1459, 14, 22, 17, 2, -22 },
  { 1498, 16, 26, 18, 1, -22 },
  { 1550, 14, 22, 17, 2, -22 },
  { 1589, 14, 22, 16, 1, -22 },
  { 1628, 15, 22, 16, 1, -22 },
  { 1670, 15, 22, 17, 1, -22 },
  { 1712, 17, 22, 17, 0, -22 },
  { 1759, 21, 22, 22, 1, -22 },
  { 1817, 16, 22, 17, 0, -22 },
  { 1861, 16, 22, 16, 0, -22 },
  { 1905, 14, 22, 16, 1, -22 },
  { 1944, 5, 30, 8, 2, -25 },
  { 1963, 12, 24, 12, 0, -22 },
  { 1999, 5, 30, 8, 1, -25 },
  { 2018, 10, 11, 12, 1, -22 },
  { 2032, 12, 4, 12, 0, 0 },
  { 2038, 8, 5, 10, 1, -23 },
  { 2043, 12, 16, 14, 1, -16 },
  { 2067, 13, 23, 15, 1, -23 },
  { 2105, 12, 16, 14, 1, -16 },
  { 2129, 12, 23, 15, 1, -23 },
  { 2164, 13, 16, 14, 1, -16 },
  { 2190, 10, 23, 10, 0, -23 },
  { 2219, 13, 22, 15, 1, -16 },
  { 2255, 12, 23, 15, 1, -23 },
  { 2290, 5, 23, 8, 1, -23 },
  { 2305, 7, 29, 8, -1, -23 },
  { 2331, 14, 23, 15, 1, -23 },
  { 2372, 4, 23, 8, 2, -23 },
  { 2384, 20, 16, 22, 1, -16 },
  { 2424, 12, 16, 15, 1, -16 },
  { 2448, 13, 16, 15, 1, -16 },
  { 2474, 13, 22, 15, 1, -16 },
  { 2510, 12, 22, 15, 1, -16 },
  { 2543, 9, 16, 10, 1, -16 },
  { 2561, 12, 16, 14, 1, -16 },
  { 2585, 9, 20, 9, 0, -20 },
  { 2608, 12, 16, 15, 1, -16 },
  { 2632, 13, 16, 14, 0, -16 },
  { 2658, 18, 16, 19, 0, -16 },
  { 2694, 13, 16, 14, 0, -16 },
  { 2720, 13, 22, 14, 0, -16 },
  { 2756, 11, 16, 14, 1, -16 },
  { 2778, 7, 28, 9, 1, -23 },
  { 2803, 2, 26, 8, 3, -22 },
  { 2810, 7, 28, 9, 1, -23 },
  { 2835, 14, 7, 17, 1, -12 },
};

const GFXfont RobotoCondensed_ExtraBold30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_EXTRABOLD30PT7B_H_
