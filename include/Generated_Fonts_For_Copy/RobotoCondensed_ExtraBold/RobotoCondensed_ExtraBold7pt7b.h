#ifndef _ROBOTOCONDENSED_EXTRABOLD7PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xA8, 0xC0, 0xF0, 0x7D, 0xF4, 0x0F, 0xBA, 0xC0, 0xCE, 0x27, 0x70,
  0x66, 0x4B, 0xF0, 0xC0, 0x1A, 0xA4, 0x25, 0x58, 0x5E, 0x80, 0x5D, 0x20,
  0xC0, 0xC0, 0xC0, 0x56, 0x80, 0x76, 0xD6, 0xFF, 0xC0, 0x74, 0xAE, 0x65,
  0x9E, 0x2D, 0xF2, 0x73, 0x96, 0x7B, 0xD6, 0xE4, 0xA4, 0x75, 0xD6, 0x77,
  0x94, 0xC3, 0xC0, 0x80, 0x39, 0x80, 0x7C, 0x8D, 0xC0, 0xE5, 0x04, 0x32,
  0x6F, 0xBB, 0xA0, 0x80, 0x66, 0x67, 0x90, 0xEB, 0xE9, 0xE0, 0x69, 0x89,
  0x60, 0xE9, 0x99, 0xE0, 0xF3, 0xCE, 0xF3, 0xC8, 0x69, 0xB9, 0x70, 0x99,
  0xF9, 0x90, 0xFF, 0xC0, 0x24, 0x9E, 0xBA, 0xEE, 0xB0, 0x92, 0x4E, 0xDE,
  0xF7, 0x5A, 0x80, 0xDD, 0xBB, 0x90, 0x69, 0x99, 0x60, 0xE9, 0xF8, 0x80,
  0x69, 0x99, 0x61, 0xE9, 0xEA, 0xB0, 0x6B, 0x6B, 0x60, 0xF4, 0x44, 0x40,
  0x99, 0x99, 0x60, 0x9F, 0x66, 0x60, 0xAD, 0x5E, 0xA5, 0x00, 0xF6, 0x66,
  0xF0, 0xB6, 0x64, 0x40, 0xF2, 0x44, 0xF0, 0xEA, 0xAC, 0x99, 0x26, 0xFE,
  0x5A, 0x80, 0xE0, 0x40, 0x67, 0xF0, 0x9E, 0xDE, 0x76, 0x30, 0x2E, 0xDE,
  0x77, 0xB0, 0x75, 0x40, 0x76, 0xF6, 0x9E, 0xDA, 0xF8, 0xFC, 0x97, 0xFA,
  0xF8, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x76, 0xB0, 0xF6, 0xF8, 0x76, 0xF2,
  0xEA, 0x71, 0xF0, 0xFF, 0x40, 0xB6, 0xF0, 0xB5, 0x20, 0xBB, 0x75, 0xAD,
  0x50, 0xB5, 0x24, 0x00, 0xED, 0x70, 0x59, 0x50, 0x78, 0xA5, 0xA0, 0x5A,
};

const GFXglyph RobotoCondensed_ExtraBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 0, -5 },
  { 4, 3, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 0, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 3, 0, -3 },
  { 26, 2, 1, 2, 0, -1 },
  { 27, 2, 5, 2, 0, -5 },
  { 29, 3, 5, 4, 0, -5 },
  { 31, 2, 5, 4, 1, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 0, -5 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 2, 5, 2, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 2, 4, 0, -3 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 5, 3, 0, -5 },
  { 59, 5, 7, 5, 0, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 3, 5, 3, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 2, 5, 2, 0, -5 },
  { 88, 3, 5, 3, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 3, 5, 3, 0, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 6, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 5, 5, 5, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 2, 7, 2, 0, -6 },
  { 141, 3, 5, 3, 0, -5 },
  { 143, 1, 7, 2, 0, -6 },
  { 144, 3, 3, 3, 0, -5 },
  { 146, 3, 1, 3, 0, 0 },
  { 147, 2, 1, 2, 0, -5 },
  { 148, 3, 4, 3, 0, -4 },
  { 150, 3, 5, 3, 0, -5 },
  { 152, 3, 4, 3, 0, -4 },
  { 154, 3, 5, 3, 0, -5 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 2, 5, 2, 0, -5 },
  { 160, 3, 5, 4, 0, -4 },
  { 162, 3, 5, 3, 0, -5 },
  { 164, 1, 5, 2, 0, -5 },
  { 165, 1, 7, 2, 0, -5 },
  { 166, 3, 5, 3, 0, -5 },
  { 168, 1, 5, 2, 0, -5 },
  { 169, 5, 4, 5, 0, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 3, 4, 3, 0, -4 },
  { 176, 3, 5, 3, 0, -4 },
  { 178, 3, 5, 3, 0, -4 },
  { 180, 2, 4, 2, 0, -4 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 2, 5, 2, 0, -5 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 6, 3, 0, -4 },
  { 196, 3, 4, 3, 0, -4 },
  { 198, 2, 6, 2, 0, -5 },
  { 200, 1, 6, 2, 0, -5 },
  { 201, 2, 6, 2, 0, -5 },
  { 203, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_ExtraBold7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_EXTRABOLD7PT7B_H_
