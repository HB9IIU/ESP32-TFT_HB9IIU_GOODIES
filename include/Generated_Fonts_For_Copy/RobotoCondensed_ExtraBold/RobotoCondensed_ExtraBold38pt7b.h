#ifndef _ROBOTOCONDENSED_EXTRABOLD38PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xE0, 0x03,
  0xCE, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x01, 0xE7,
  0x00, 0x79, 0xC0, 0x1E, 0x70, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x1C, 0xF0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x9C,
  0x01, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCE, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3F,
  0x7C, 0x3F, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x86, 0x0F, 0x3C, 0x78, 0x71,
  0xE3, 0x83, 0x8F, 0x3C, 0x1C, 0x79, 0xC0, 0xF3, 0xDE, 0x07, 0x9E, 0xE0,
  0x1F, 0xEF, 0x00, 0xFF, 0x70, 0x01, 0xE7, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x9F, 0x00, 0x3D, 0xFC, 0x01, 0xDF, 0xF0, 0x1E, 0xF7, 0x80, 0xEF, 0x1E,
  0x0F, 0x78, 0xF0, 0x73, 0xC7, 0x87, 0x9E, 0x3C, 0x38, 0xF1, 0xE1, 0xC3,
  0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF1, 0xF0, 0xFF, 0xCF,
  0x8F, 0xFE, 0x7C, 0x7D, 0xFB, 0xE7, 0xEF, 0xFF, 0x3F, 0x3F, 0xF1, 0xF8,
  0xFF, 0x8F, 0xC3, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xF8, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x01, 0xC1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x38, 0x08, 0x40, 0x30, 0x3C, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x06, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x03, 0xCF, 0x19, 0xFF, 0x7E, 0xFF, 0xFF, 0x1F, 0xFF, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF8, 0x78, 0x38,
  0x38, 0x04, 0x08, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDF,
  0x7B, 0xEF, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0xFB, 0xFF,
  0xF7, 0xC7, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0x60, 0x7C, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x3E,
  0xFC, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF1, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xDF, 0x83, 0xEF, 0xC1, 0xE7, 0xE1, 0xF3, 0xF0, 0xF1, 0xF8, 0xF8,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFC, 0xFE, 0x08, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFD, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7C, 0x7F, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0xFC, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0x7C, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3F, 0xFC, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x0F, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x38,
  0xFB, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x7D, 0xFF, 0xFB, 0xE3, 0xC0, 0x3C, 0x7E, 0x7E, 0x7F, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x30, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0,
  0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x1F,
  0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xE0, 0x3E,
  0x00, 0xE0, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF,
  0xEF, 0xFF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x3C,
  0x0F, 0x83, 0xC7, 0x83, 0xFC, 0x38, 0xE0, 0xFF, 0xC7, 0x3C, 0x3F, 0xF8,
  0xE7, 0x87, 0x8F, 0x1E, 0xF1, 0xE1, 0xC3, 0xDC, 0x3C, 0x38, 0x7F, 0x87,
  0x8F, 0x0F, 0xF1, 0xF1, 0xE1, 0xFE, 0x3C, 0x3C, 0x3B, 0xC7, 0x87, 0x87,
  0x78, 0xF0, 0xF0, 0xEF, 0x1F, 0x1E, 0x3C, 0xE3, 0xE7, 0xC7, 0x9C, 0x3F,
  0xF9, 0xE3, 0xC7, 0xFF, 0xF8, 0x78, 0x7E, 0xFF, 0x0F, 0x07, 0x8F, 0x80,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFC, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF0, 0xFF, 0xF0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xBF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xFE, 0x03, 0xEF, 0xC0, 0xFC,
  0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E,
  0xFC, 0x1F, 0xBF, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x1F, 0xCF,
  0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF9, 0xF8, 0x7E,
  0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFC,
  0x1F, 0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0xF0, 0x7F, 0xFF, 0x7C, 0x7F, 0xFF,
  0xBE, 0x3D, 0xFF, 0xFF, 0x1E, 0xFF, 0xF7, 0x9F, 0x7F, 0xFB, 0xEF, 0xBF,
  0xFD, 0xF7, 0x9F, 0xFE, 0x7B, 0xCF, 0xFF, 0x3F, 0xE7, 0xFF, 0x9F, 0xF3,
  0xFF, 0xCF, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1, 0xFC, 0x7F, 0xF8, 0xFC,
  0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xE0, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xDE, 0x7F, 0xFB, 0xEF, 0xFF, 0x3D, 0xFF, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F,
  0xBF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFE,
  0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0x08, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x3F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xF7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x07, 0xFF, 0x87, 0xE0, 0xFB, 0xF0, 0xFC, 0x3F, 0x7E,
  0x1F, 0x87, 0xEF, 0xC3, 0xF0, 0xFC, 0xF8, 0x7F, 0x1F, 0x9F, 0x9F, 0xE3,
  0xF3, 0xF3, 0xFC, 0x7C, 0x7E, 0x7F, 0x8F, 0x8F, 0xCF, 0xF3, 0xF0, 0xF9,
  0xFF, 0x7E, 0x1F, 0x3F, 0xEF, 0xC3, 0xEF, 0xFD, 0xF0, 0x7F, 0xFF, 0xBE,
  0x0F, 0xFE, 0xF7, 0xC1, 0xFF, 0xDF, 0xF8, 0x1F, 0xF3, 0xFF, 0x03, 0xFE,
  0x7F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x03, 0xF3,
  0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xF3, 0xF8, 0x1F, 0x9F, 0x80, 0xFE, 0xFE, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0x81, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x87, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7, 0x87, 0xBC,
  0x78, 0xF3, 0xC7, 0x9E, 0x3D, 0xF0, 0xFF, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xBE, 0x1F, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9,
  0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB,
  0xF8, 0xF9, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xEF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x87, 0xDF, 0x0F, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F,
  0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F,
  0xBF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xDF, 0x0F, 0x9F, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x04, 0x7F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0x0F, 0xFC, 0x03, 0xF0, 0x03, 0xE1, 0xFC, 0x7F, 0x8F,
  0xF3, 0xFE, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x0F,
  0x9F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x7E, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x10, 0x3F, 0x1E, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF3, 0xE3, 0xEF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xE0, 0x73, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFE, 0xFF,
  0x7F, 0xBF, 0x9F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x3F, 0xBE, 0x3F, 0x9F, 0x1F, 0x8F, 0x9F, 0xC7, 0xCF, 0xC3, 0xEF, 0xC1,
  0xF7, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xF7, 0xE1, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3F, 0x3E,
  0x1F, 0x9F, 0x0F, 0xEF, 0x83, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xF0, 0x78, 0xFB, 0xF9, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7D, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9,
  0xF8, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0xF9, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC,
  0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x9F, 0x3F,
  0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F,
  0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xC7, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x7F, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x07, 0xE0, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFD, 0xFE, 0xF8, 0xF9, 0xF0, 0x7C, 0x1F, 0xBF,
  0x0F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xFC, 0xF8,
  0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x8F, 0x87,
  0xFE, 0x3F, 0x3F, 0x7C, 0xFC, 0xF9, 0xF3, 0xF3, 0xE7, 0xDF, 0xCF, 0x9F,
  0x7F, 0xBE, 0x7D, 0xFE, 0xF9, 0xF7, 0xFF, 0xC3, 0xDF, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xC1, 0xF0, 0xFC,
  0x3F, 0xFC, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xFC, 0x7E, 0x7C, 0x7C, 0x7E, 0xFC,
  0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE3,
  0xE3, 0xF1, 0xF1, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBE,
  0x07, 0xDF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x03, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8,
  0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E,
  0x7E, 0x3E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x40, 0x38, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3,
  0xE1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x0E, 0x04, 0x00, 0x1E, 0x00, 0x1F,
  0x83, 0xDF, 0xE1, 0xEF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFB, 0xC3, 0xFD,
  0xE0, 0xFC, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 10, 10, 12, 1, -29 },
  { 35, 18, 27, 20, 1, -27 },
  { 96, 16, 35, 19, 2, -31 },
  { 166, 21, 27, 24, 2, -27 },
  { 237, 21, 27, 22, 1, -27 },
  { 308, 4, 10, 6, 1, -29 },
  { 313, 9, 38, 12, 2, -30 },
  { 356, 9, 38, 12, 1, -30 },
  { 399, 17, 17, 17, 0, -27 },
  { 436, 16, 19, 18, 1, -22 },
  { 474, 6, 12, 10, 1, -5 },
  { 483, 9, 5, 15, 3, -14 },
  { 489, 7, 6, 11, 2, -6 },
  { 495, 12, 29, 12, 0, -27 },
  { 539, 16, 27, 19, 2, -27 },
  { 593, 11, 27, 19, 3, -27 },
  { 631, 17, 27, 19, 1, -27 },
  { 689, 17, 27, 19, 1, -27 },
  { 747, 17, 27, 19, 1, -27 },
  { 805, 16, 27, 19, 2, -27 },
  { 859, 16, 27, 19, 2, -27 },
  { 913, 17, 27, 19, 1, -27 },
  { 971, 16, 27, 19, 2, -27 },
  { 1025, 16, 27, 19, 2, -27 },
  { 1079, 7, 21, 11, 2, -21 },
  { 1098, 8, 28, 10, 1, -21 },
  { 1126, 14, 18, 17, 1, -20 },
  { 1158, 15, 14, 19, 2, -19 },
  { 1185, 14, 18, 17, 2, -20 },
  { 1217, 15, 27, 17, 1, -27 },
  { 1268, 27, 34, 29, 1, -26 },
  { 1383, 23, 27, 23, 0, -27 },
  { 1461, 18, 27, 21, 2, -27 },
  { 1522, 19, 27, 22, 2, -27 },
  { 1587, 18, 27, 21, 2, -27 },
  { 1648, 16, 27, 19, 2, -27 },
  { 1702, 15, 27, 18, 2, -27 },
  { 1753, 19, 27, 22, 2, -27 },
  { 1818, 19, 27, 23, 2, -27 },
  { 1883, 6, 27, 10, 2, -27 },
  { 1904, 16, 27, 19, 1, -27 },
  { 1958, 19, 27, 21, 2, -27 },
  { 2023, 15, 27, 18, 2, -27 },
  { 2074, 25, 27, 29, 2, -27 },
  { 2159, 19, 27, 23, 2, -27 },
  { 2224, 19, 27, 23, 2, -27 },
  { 2289, 18, 27, 22, 2, -27 },
  { 2350, 19, 32, 23, 2, -27 },
  { 2426, 18, 27, 21, 2, -27 },
  { 2487, 18, 27, 21, 1, -27 },
  { 2548, 19, 27, 21, 1, -27 },
  { 2613, 18, 27, 22, 2, -27 },
  { 2674, 22, 27, 22, 0, -27 },
  { 2749, 27, 27, 28, 1, -27 },
  { 2841, 21, 27, 21, 0, -27 },
  { 2912, 21, 27, 21, 0, -27 },
  { 2983, 18, 27, 20, 1, -27 },
  { 3044, 7, 38, 10, 2, -32 },
  { 3078, 15, 29, 15, 0, -27 },
  { 3133, 7, 38, 10, 1, -32 },
  { 3167, 13, 13, 15, 1, -27 },
  { 3189, 15, 4, 15, 0, 0 },
  { 3197, 10, 6, 13, 1, -29 },
  { 3205, 16, 20, 18, 1, -20 },
  { 3245, 16, 29, 19, 2, -29 },
  { 3303, 15, 20, 17, 1, -20 },
  { 3341, 16, 29, 19, 1, -29 },
  { 3399, 16, 20, 18, 1, -20 },
  { 3439, 11, 29, 13, 1, -29 },
  { 3479, 16, 28, 19, 1, -20 },
  { 3535, 15, 29, 19, 2, -29 },
  { 3590, 6, 28, 10, 2, -28 },
  { 3611, 9, 36, 10, -1, -28 },
  { 3652, 17, 29, 18, 2, -29 },
  { 3714, 6, 29, 10, 2, -29 },
  { 3736, 24, 20, 28, 2, -20 },
  { 3796, 15, 20, 19, 2, -20 },
  { 3834, 17, 20, 19, 1, -20 },
  { 3877, 16, 28, 19, 2, -20 },
  { 3933, 16, 28, 19, 1, -20 },
  { 3989, 10, 20, 13, 2, -20 },
  { 4014, 15, 20, 17, 1, -20 },
  { 4052, 11, 25, 12, 0, -25 },
  { 4087, 15, 20, 19, 2, -20 },
  { 4125, 17, 20, 17, 0, -20 },
  { 4168, 22, 20, 24, 1, -20 },
  { 4223, 16, 20, 17, 1, -20 },
  { 4263, 17, 28, 17, 0, -20 },
  { 4323, 15, 20, 17, 1, -20 },
  { 4361, 9, 37, 11, 1, -30 },
  { 4403, 4, 32, 10, 3, -27 },
  { 4419, 9, 37, 11, 1, -30 },
  { 4461, 17, 9, 21, 2, -16 },
};

const GFXfont RobotoCondensed_ExtraBold38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_EXTRABOLD38PT7B_H_
