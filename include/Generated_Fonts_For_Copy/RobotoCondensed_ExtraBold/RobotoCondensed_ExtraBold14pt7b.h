#ifndef _ROBOTOCONDENSED_EXTRABOLD14PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDD, 0xDD, 0x14, 0x78, 0xF3, 0xF2, 0x85, 0x3F,
  0x14, 0x68, 0xF0, 0x21, 0xCF, 0xB6, 0xC3, 0xC3, 0x86, 0xDB, 0xE7, 0x08,
  0xE1, 0x4A, 0xA5, 0x4F, 0x03, 0xCA, 0x95, 0x4A, 0x1C, 0x38, 0x7C, 0x6C,
  0x6C, 0x38, 0x7A, 0x7E, 0xEE, 0x7E, 0x3F, 0xFF, 0x2D, 0x6D, 0xB6, 0xDB,
  0x26, 0x40, 0x44, 0x62, 0x33, 0x33, 0x33, 0x26, 0x44, 0x10, 0x4F, 0xCC,
  0x69, 0x20, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x6D, 0x60, 0xFC, 0xF0,
  0x13, 0x32, 0x26, 0x64, 0x4C, 0xC0, 0x73, 0xED, 0xB6, 0xDF, 0x7D, 0xB6,
  0xF9, 0xC0, 0x1F, 0xF3, 0x33, 0x33, 0x33, 0x38, 0xFB, 0xB0, 0x60, 0xC3,
  0x0E, 0x38, 0x7E, 0xFC, 0x38, 0xF9, 0xB0, 0x63, 0xC7, 0x83, 0x76, 0x7C,
  0x70, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x9F, 0xBF, 0x0C, 0x18, 0xFB, 0xEC,
  0x3C, 0xF8, 0x61, 0xF6, 0xF9, 0xC0, 0x31, 0xCC, 0x3E, 0xFB, 0x7C, 0xF7,
  0xF9, 0xC0, 0xFF, 0xF8, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0xE0, 0x77,
  0xF7, 0xBF, 0xFF, 0x7B, 0xFB, 0x80, 0x77, 0xF7, 0xBD, 0xFD, 0xE3, 0x73,
  0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x78, 0x08, 0xDF, 0x87, 0x8C, 0x20,
  0xFF, 0xC1, 0xFF, 0x80, 0x87, 0x1E, 0x37, 0xF2, 0x00, 0x79, 0xFC, 0xC3,
  0x18, 0xC3, 0x00, 0x30, 0xC0, 0x0F, 0x0C, 0x62, 0x0D, 0xB9, 0x4B, 0x56,
  0x95, 0xA5, 0x69, 0x5A, 0xD3, 0xE6, 0x00, 0xC0, 0x1E, 0x00, 0x18, 0x1C,
  0x3C, 0x3C, 0x36, 0x36, 0x7E, 0x7F, 0x63, 0xE3, 0xFB, 0xFC, 0xF3, 0xFF,
  0xFC, 0xF3, 0xFF, 0xE0, 0x79, 0xFB, 0x36, 0x7C, 0x18, 0x30, 0x67, 0xFC,
  0xF0, 0xF3, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xC0, 0xFF, 0xFC, 0x30,
  0xFB, 0xEC, 0x30, 0xFF, 0xF0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC6, 0x00,
  0x79, 0xFB, 0x3E, 0x0D, 0xFB, 0xF3, 0xE7, 0xFE, 0xF8, 0xC7, 0x8F, 0x1E,
  0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C, 0xFF, 0xFF, 0xF0, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFB, 0x7D, 0xE0, 0xCF, 0xBB, 0x67, 0xCF, 0x1F, 0x36, 0x6E,
  0xCD, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE3, 0xF1, 0xF9,
  0xFC, 0xFF, 0x7F, 0xAF, 0x77, 0xBB, 0xD9, 0xEC, 0xC0, 0xC7, 0xCF, 0x9F,
  0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x9C, 0x79, 0xFB, 0x3E, 0x3C, 0x78, 0xF1,
  0xE7, 0xFC, 0xF0, 0xFB, 0xFC, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x00, 0x79,
  0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE7, 0xFC, 0xF8, 0x38, 0x20, 0xF9, 0xFB,
  0x36, 0x6F, 0xDF, 0x36, 0x6E, 0xCD, 0x98, 0x3C, 0xFD, 0x9B, 0x07, 0x83,
  0xC1, 0xB3, 0x7E, 0x78, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0, 0xE3, 0x67, 0x66,
  0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x3C, 0x18, 0xCC, 0xDB, 0x36, 0xED, 0xBB,
  0x7F, 0x9F, 0xE7, 0xB8, 0xEE, 0x33, 0x8C, 0xE0, 0xE6, 0x66, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x7E, 0x66, 0xE6, 0xE6, 0x66, 0x6E, 0x3C, 0x3C, 0x38,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0x61, 0x87, 0x0C, 0x30, 0x7E,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x86, 0x18, 0x70, 0xC3, 0x0E, 0x18,
  0x61, 0x80, 0xFD, 0xB6, 0xDB, 0x6D, 0xBF, 0xC0, 0x31, 0x9C, 0xBC, 0x80,
  0xFF, 0xC0, 0x63, 0x39, 0xF0, 0xDF, 0x6F, 0xB7, 0xDF, 0xC3, 0x0C, 0x3E,
  0xFB, 0x6D, 0xF7, 0xDB, 0xEF, 0x80, 0x39, 0xF6, 0xF8, 0xE1, 0xB7, 0xCE,
  0x0C, 0x30, 0xDF, 0x7F, 0xBC, 0xF3, 0xED, 0xF7, 0xC0, 0x39, 0xF6, 0xDB,
  0xFD, 0x87, 0xCF, 0x37, 0x6F, 0xF6, 0x66, 0x66, 0x60, 0x7D, 0xF6, 0xFB,
  0xED, 0xB7, 0xCF, 0x0D, 0xF7, 0x80, 0xC6, 0x31, 0xFF, 0xEF, 0x7B, 0xDE,
  0xF6, 0xF3, 0xFF, 0xFC, 0x6C, 0x36, 0xDB, 0x6D, 0xBF, 0x80, 0xC3, 0x0C,
  0x36, 0xFB, 0xCF, 0x3C, 0xFB, 0x6D, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F,
  0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B,
  0x38, 0xF9, 0xB7, 0x6E, 0xCD, 0x9F, 0x1C, 0xFB, 0xED, 0xB7, 0xDF, 0x6F,
  0xBE, 0xC3, 0x0C, 0x00, 0x7D, 0xFE, 0xF3, 0xCF, 0xB7, 0xDF, 0x0C, 0x30,
  0xC0, 0xFF, 0x6D, 0xB6, 0x79, 0xF6, 0x1C, 0x3C, 0x37, 0xDE, 0x6F, 0xF6,
  0x66, 0x67, 0x30, 0xDE, 0xF7, 0xBD, 0xEF, 0xFF, 0xCD, 0xB6, 0xDE, 0x78,
  0xE3, 0x8C, 0xC9, 0x6D, 0x9F, 0xCF, 0xE7, 0x73, 0xB9, 0xD8, 0x6C, 0xED,
  0xF7, 0x8E, 0x39, 0xE7, 0xFB, 0xCF, 0xB6, 0xDE, 0x78, 0xE3, 0x8C, 0x31,
  0xC6, 0x00, 0xFF, 0xCC, 0xC6, 0x63, 0xFF, 0x32, 0x66, 0x66, 0xC6, 0x66,
  0x62, 0x30, 0xFF, 0xF0, 0x46, 0x66, 0x67, 0x36, 0x66, 0x66, 0x40, 0xE7,
  0xF9, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 4, 0, -11 },
  { 6, 7, 10, 7, 0, -10 },
  { 15, 6, 12, 7, 1, -11 },
  { 24, 7, 10, 9, 1, -10 },
  { 33, 8, 10, 8, 0, -10 },
  { 43, 2, 4, 2, 0, -11 },
  { 44, 3, 14, 5, 1, -11 },
  { 50, 4, 14, 5, 0, -11 },
  { 57, 6, 6, 6, 0, -10 },
  { 62, 6, 8, 7, 0, -9 },
  { 68, 3, 4, 4, 0, -2 },
  { 70, 3, 2, 5, 1, -5 },
  { 71, 2, 2, 4, 1, -2 },
  { 72, 4, 11, 4, 0, -10 },
  { 78, 6, 10, 7, 1, -10 },
  { 86, 4, 10, 7, 1, -10 },
  { 91, 7, 10, 7, 0, -10 },
  { 100, 7, 10, 7, 0, -10 },
  { 109, 7, 10, 7, 0, -10 },
  { 118, 6, 10, 7, 1, -10 },
  { 126, 6, 10, 7, 1, -10 },
  { 134, 7, 10, 7, 0, -10 },
  { 143, 5, 10, 7, 1, -10 },
  { 150, 5, 10, 7, 1, -10 },
  { 157, 2, 8, 4, 1, -8 },
  { 159, 3, 10, 4, 0, -8 },
  { 163, 5, 7, 6, 0, -8 },
  { 168, 5, 5, 7, 1, -7 },
  { 172, 5, 7, 6, 1, -8 },
  { 177, 6, 10, 6, 0, -10 },
  { 185, 10, 13, 11, 0, -10 },
  { 202, 8, 10, 8, 0, -10 },
  { 212, 6, 10, 8, 1, -10 },
  { 220, 7, 10, 8, 1, -10 },
  { 229, 6, 10, 8, 1, -10 },
  { 237, 6, 10, 7, 1, -10 },
  { 245, 5, 10, 7, 1, -10 },
  { 252, 7, 10, 8, 1, -10 },
  { 261, 7, 10, 9, 1, -10 },
  { 270, 2, 10, 4, 1, -10 },
  { 273, 6, 10, 7, 0, -10 },
  { 281, 7, 10, 8, 1, -10 },
  { 290, 5, 10, 7, 1, -10 },
  { 297, 9, 10, 11, 1, -10 },
  { 309, 7, 10, 9, 1, -10 },
  { 318, 7, 10, 8, 1, -10 },
  { 327, 6, 10, 8, 1, -10 },
  { 335, 7, 12, 8, 1, -10 },
  { 346, 7, 10, 8, 1, -10 },
  { 355, 7, 10, 8, 0, -10 },
  { 364, 7, 10, 8, 0, -10 },
  { 373, 6, 10, 8, 1, -10 },
  { 381, 8, 10, 8, 0, -10 },
  { 391, 10, 10, 10, 0, -10 },
  { 404, 8, 10, 8, 0, -10 },
  { 414, 8, 10, 8, 0, -10 },
  { 424, 7, 10, 7, 0, -10 },
  { 433, 2, 14, 4, 1, -12 },
  { 437, 6, 11, 5, 0, -10 },
  { 446, 3, 14, 4, 0, -12 },
  { 452, 5, 5, 6, 0, -10 },
  { 456, 5, 2, 6, 0, 0 },
  { 458, 4, 2, 5, 0, -10 },
  { 459, 6, 8, 7, 0, -8 },
  { 465, 6, 11, 7, 1, -11 },
  { 474, 6, 8, 6, 0, -8 },
  { 480, 6, 11, 7, 0, -11 },
  { 489, 6, 8, 7, 0, -8 },
  { 495, 4, 11, 5, 0, -11 },
  { 501, 6, 11, 7, 0, -8 },
  { 510, 5, 11, 7, 1, -11 },
  { 517, 2, 11, 4, 1, -11 },
  { 520, 3, 14, 4, 0, -11 },
  { 526, 6, 11, 7, 1, -11 },
  { 535, 2, 11, 4, 1, -11 },
  { 538, 9, 8, 10, 1, -8 },
  { 547, 5, 8, 7, 1, -8 },
  { 552, 7, 8, 7, 0, -8 },
  { 559, 6, 11, 7, 1, -8 },
  { 568, 6, 11, 7, 0, -8 },
  { 577, 3, 8, 5, 1, -8 },
  { 580, 6, 8, 6, 0, -8 },
  { 586, 4, 9, 4, 0, -9 },
  { 591, 5, 8, 7, 1, -8 },
  { 596, 6, 8, 6, 0, -8 },
  { 602, 9, 8, 9, 0, -8 },
  { 611, 6, 8, 6, 0, -8 },
  { 617, 6, 11, 6, 0, -8 },
  { 626, 5, 8, 6, 1, -8 },
  { 631, 4, 13, 4, 0, -11 },
  { 638, 1, 12, 4, 1, -10 },
  { 640, 4, 13, 4, 0, -11 },
  { 647, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_ExtraBold14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_EXTRABOLD14PT7B_H_
