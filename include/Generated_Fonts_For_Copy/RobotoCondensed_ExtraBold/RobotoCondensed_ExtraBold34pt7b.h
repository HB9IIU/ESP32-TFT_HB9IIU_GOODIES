#ifndef _ROBOTOCONDENSED_EXTRABOLD34PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x78,
  0x00, 0xEF, 0xFF, 0xEE, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCE, 0xE7, 0x00, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x39, 0xC0, 0x39,
  0xC0, 0x39, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x3F, 0x01, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x3F, 0x3E, 0x7C, 0x7E, 0xF8, 0x7D, 0xF0, 0xFB,
  0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01,
  0xF8, 0x01, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x9F, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0x9E, 0x38, 0xE7, 0x8E, 0x39,
  0xE7, 0x0E, 0x7B, 0xC3, 0x9E, 0xE0, 0xFF, 0x70, 0x1F, 0xDC, 0x03, 0xCE,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x77, 0xC0, 0x3B, 0xF8, 0x0E, 0xFF,
  0x07, 0x79, 0xC3, 0xDC, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x79, 0xC2,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x3E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF9, 0xE0,
  0x3E, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xC7, 0x9F,
  0xF9, 0xE7, 0xFE, 0xFB, 0xE7, 0xFE, 0xF9, 0xFF, 0x3E, 0x3F, 0xCF, 0x87,
  0xF3, 0xF1, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0x3F,
  0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x02, 0x07, 0x0F, 0x0E, 0x1E, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E,
  0x0E, 0x0F, 0x07, 0x02, 0x40, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xE0, 0x40, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x06, 0x18,
  0x6F, 0xB3, 0xDF, 0xFF, 0x8F, 0xFE, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0,
  0xF3, 0x83, 0xC7, 0x83, 0x87, 0x02, 0x04, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0xBC, 0xF1, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1F,
  0xFC, 0xFC, 0xFB, 0xE3, 0xEF, 0x87, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE3, 0xEF, 0x8F, 0xBF, 0x3E, 0x7F, 0xF1, 0xFF, 0xC3, 0xFE, 0x03, 0xE0,
  0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xCF,
  0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xCF, 0xDF, 0x8F, 0xBE,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xE7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x3D, 0xF0, 0x7B, 0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x9F, 0x1E,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xE1, 0x87, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0xF0, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF, 0x07,
  0xFC, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0x81,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFF, 0x3E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1F,
  0xFE, 0xFC, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF9, 0xF3, 0xE7,
  0xFF, 0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x8F, 0xBE, 0x3E, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xEF, 0xCF, 0x8F, 0x9F,
  0x1F, 0x7E, 0x1F, 0xFC, 0x3F, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xF7, 0xFF,
  0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x7B, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x3C,
  0xFD, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x3C, 0x10, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7F, 0x1F, 0xF7, 0xFE, 0xFF, 0x0F, 0xC0, 0xFC, 0x0F, 0xF0, 0x7F,
  0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0x03, 0xF0, 0xFF, 0x3F, 0xEF, 0xF8, 0xFE, 0x0F, 0x80, 0xE0,
  0x08, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F,
  0xE3, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x1C,
  0x00, 0x1E, 0x3C, 0x1F, 0x0E, 0x38, 0x7F, 0x8E, 0x78, 0xFF, 0x8E, 0x70,
  0xF3, 0x87, 0x71, 0xE3, 0x87, 0x71, 0xE3, 0x87, 0xF1, 0xC3, 0x87, 0xF3,
  0xC3, 0x87, 0xF3, 0xC3, 0x87, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x8E, 0xF3,
  0xC7, 0x8E, 0xF1, 0xEF, 0x9C, 0xF1, 0xFF, 0xFC, 0x70, 0xFB, 0xF8, 0x70,
  0x71, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x81, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xDE,
  0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x1F, 0x0F, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0xFE,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF3,
  0xFB, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0xE7, 0xF3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0x3F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFD,
  0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFC, 0xFC, 0x7F, 0x3F,
  0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xE0, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF,
  0x7E, 0x7F, 0xF9, 0xFF, 0xC3, 0xFE, 0x03, 0xF0, 0xF8, 0x3F, 0xFC, 0x1F,
  0xBE, 0x1F, 0x9F, 0x0F, 0xCF, 0x8F, 0xC7, 0xC7, 0xE3, 0xE7, 0xE1, 0xF3,
  0xE0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFD, 0xF8, 0x7C, 0x7E, 0x3E, 0x3F,
  0x1F, 0x0F, 0xCF, 0x87, 0xE7, 0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xDF, 0xFB,
  0xCF, 0x7F, 0xEF, 0x3D, 0xFF, 0xBD, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFE,
  0x7F, 0xE7, 0xF9, 0xFF, 0x9F, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F,
  0xE3, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFE, 0xF3, 0xFF, 0x79, 0xFF, 0x9E, 0xFF,
  0xCF, 0x7F, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x3F, 0x9F, 0x83,
  0xE7, 0xC0, 0xFD, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0x03, 0xF7, 0xE0, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0x3F, 0x9F, 0x83, 0xE7, 0xC0, 0xFD, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xF7, 0xE0, 0xF8,
  0xFC, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x08, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0,
  0xFF, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E,
  0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0xFC,
  0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3,
  0xE0, 0xFC, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x1F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7E, 0x3E, 0xFC,
  0x7E, 0x3E, 0x7C, 0xFE, 0x3E, 0x7C, 0xFE, 0x3E, 0x7C, 0xFE, 0x7C, 0x7C,
  0xFE, 0x7C, 0x7C, 0xFF, 0x7C, 0x7C, 0xFF, 0x7C, 0x3F, 0xFF, 0x7C, 0x3F,
  0xEF, 0x7C, 0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xE7, 0xF8, 0x1F,
  0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F,
  0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3F,
  0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x07, 0xDF, 0x03,
  0xF7, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x83,
  0xBC, 0x3B, 0xC7, 0x9C, 0x79, 0xE7, 0x1E, 0xF0, 0xEF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x0F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFB, 0xE3, 0xE0, 0x0F, 0x83,
  0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xCF, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF,
  0xFF, 0x9F, 0xFE, 0x7F, 0x7C, 0x79, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFB, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xEF, 0xFF, 0xBF,
  0xFE, 0xF7, 0xF3, 0xCF, 0x80, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x1F, 0xF8, 0x7D, 0xF3, 0xE7, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x3F,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x1F, 0x7C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7C, 0xF0, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7F, 0xF1, 0xFF, 0x83, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0xE7,
  0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x03, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0x3E, 0x7F, 0xFD, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xFF, 0xBF,
  0xFF, 0x3F, 0xBE, 0x1E, 0x7C, 0x01, 0xF8, 0x03, 0xE1, 0x07, 0xC7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFD, 0xF3, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF1, 0xF0, 0xF7, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x1F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F,
  0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0xFD, 0xF3, 0xF3, 0xE7,
  0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xBF, 0x1F, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0xF8, 0xFD, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xE1,
  0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xCF, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xC0, 0xF9, 0xF3,
  0xEF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7, 0xCF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xF0, 0x0F, 0x80, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8,
  0xFB, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0xFF, 0xE3, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xEF, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1,
  0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0xF3, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x03,
  0xFF, 0x8F, 0xFC, 0x7F, 0xFF, 0xEF, 0xFE, 0x3F, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xFC, 0x7F,
  0x1F, 0xC1, 0xF0, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0x7C, 0x7D, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0xFC,
  0x3E, 0xF8, 0xFD, 0xF1, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E,
  0x1F, 0x7C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0xF0, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF9, 0xF1, 0xEF, 0x9F, 0x3E, 0xF9, 0xF3, 0xE7, 0x9F, 0xBE,
  0x7B, 0xFB, 0xE7, 0xBF, 0xBC, 0x7F, 0xFB, 0xC7, 0xFB, 0xFC, 0x3F, 0xBF,
  0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x81, 0xF1,
  0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF0, 0x7C, 0x3E, 0xFC, 0xF8, 0xF9, 0xF1,
  0xF7, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xBF, 0x1F, 0x3E,
  0x7C, 0x7C, 0xF8, 0x7C, 0xFC, 0x3E, 0xF8, 0xFD, 0xF1, 0xF3, 0xE3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x8F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x0F, 0x1F,
  0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFC,
  0xF8, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3F, 0x1F, 0x0F, 0x1F, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0xF0,
  0xF0, 0x40, 0x3C, 0x00, 0xFC, 0x3D, 0xFC, 0x7F, 0xFC, 0xFF, 0x3F, 0xFC,
  0x7F, 0xB8, 0x7E, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 9, 9, 11, 1, -26 },
  { 27, 16, 24, 18, 1, -24 },
  { 75, 15, 30, 17, 1, -27 },
  { 132, 18, 24, 22, 2, -24 },
  { 186, 18, 24, 20, 1, -24 },
  { 240, 4, 9, 5, 1, -26 },
  { 245, 8, 35, 11, 2, -27 },
  { 280, 8, 35, 11, 1, -27 },
  { 315, 15, 15, 16, 0, -24 },
  { 344, 14, 18, 16, 1, -20 },
  { 376, 6, 10, 9, 1, -4 },
  { 384, 9, 4, 13, 2, -12 },
  { 389, 6, 5, 10, 2, -5 },
  { 393, 10, 26, 11, 0, -24 },
  { 426, 14, 24, 17, 2, -24 },
  { 468, 9, 24, 17, 3, -24 },
  { 495, 15, 24, 17, 1, -24 },
  { 540, 15, 24, 17, 1, -24 },
  { 585, 15, 24, 17, 1, -24 },
  { 630, 15, 24, 17, 1, -24 },
  { 675, 14, 24, 17, 2, -24 },
  { 717, 15, 24, 17, 1, -24 },
  { 762, 14, 24, 17, 2, -24 },
  { 804, 15, 24, 17, 1, -24 },
  { 849, 6, 18, 10, 2, -18 },
  { 863, 7, 24, 9, 1, -18 },
  { 884, 12, 16, 15, 1, -18 },
  { 908, 13, 11, 17, 2, -16 },
  { 926, 12, 16, 15, 2, -18 },
  { 950, 13, 24, 15, 1, -24 },
  { 989, 24, 31, 26, 1, -23 },
  { 1082, 20, 24, 20, 0, -24 },
  { 1142, 16, 24, 19, 2, -24 },
  { 1190, 17, 24, 19, 1, -24 },
  { 1241, 16, 24, 19, 2, -24 },
  { 1289, 14, 24, 17, 2, -24 },
  { 1331, 13, 24, 16, 2, -24 },
  { 1370, 18, 24, 20, 1, -24 },
  { 1424, 17, 24, 21, 2, -24 },
  { 1475, 5, 24, 9, 2, -24 },
  { 1490, 14, 24, 17, 1, -24 },
  { 1532, 17, 24, 19, 2, -24 },
  { 1583, 13, 24, 16, 2, -24 },
  { 1622, 22, 24, 26, 2, -24 },
  { 1688, 17, 24, 21, 2, -24 },
  { 1739, 18, 24, 21, 1, -24 },
  { 1793, 16, 24, 19, 2, -24 },
  { 1841, 18, 28, 21, 1, -24 },
  { 1904, 16, 24, 19, 2, -24 },
  { 1952, 16, 24, 19, 1, -24 },
  { 2000, 17, 24, 19, 1, -24 },
  { 2051, 16, 24, 20, 2, -24 },
  { 2099, 20, 24, 20, 0, -24 },
  { 2159, 24, 24, 25, 1, -24 },
  { 2231, 19, 24, 19, 0, -24 },
  { 2288, 18, 24, 19, 0, -24 },
  { 2342, 16, 24, 18, 1, -24 },
  { 2390, 6, 34, 9, 2, -28 },
  { 2416, 14, 26, 13, 0, -24 },
  { 2462, 6, 34, 9, 1, -28 },
  { 2488, 12, 12, 13, 1, -24 },
  { 2506, 13, 4, 14, 0, 0 },
  { 2513, 9, 5, 11, 1, -25 },
  { 2519, 14, 18, 16, 1, -18 },
  { 2551, 14, 26, 17, 2, -26 },
  { 2597, 14, 18, 16, 1, -18 },
  { 2629, 14, 26, 17, 1, -26 },
  { 2675, 14, 18, 16, 1, -18 },
  { 2707, 11, 26, 11, 0, -26 },
  { 2743, 15, 25, 17, 1, -18 },
  { 2790, 14, 26, 17, 1, -26 },
  { 2836, 5, 25, 9, 2, -25 },
  { 2852, 8, 32, 9, -1, -25 },
  { 2884, 15, 26, 16, 2, -26 },
  { 2933, 5, 26, 9, 2, -26 },
  { 2950, 21, 18, 25, 2, -18 },
  { 2998, 14, 18, 17, 1, -18 },
  { 3030, 15, 18, 17, 1, -18 },
  { 3064, 14, 25, 17, 2, -18 },
  { 3108, 14, 25, 17, 1, -18 },
  { 3152, 9, 18, 11, 2, -18 },
  { 3173, 13, 18, 15, 1, -18 },
  { 3203, 10, 22, 11, 0, -22 },
  { 3231, 14, 18, 17, 1, -18 },
  { 3263, 15, 18, 15, 0, -18 },
  { 3297, 20, 18, 21, 1, -18 },
  { 3342, 15, 18, 15, 0, -18 },
  { 3376, 15, 25, 15, 0, -18 },
  { 3423, 13, 18, 15, 1, -18 },
  { 3453, 8, 33, 10, 1, -27 },
  { 3486, 3, 28, 9, 3, -24 },
  { 3497, 8, 33, 10, 1, -27 },
  { 3530, 15, 8, 19, 2, -14 },
};

const GFXfont RobotoCondensed_ExtraBold34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_EXTRABOLD34PT7B_H_
