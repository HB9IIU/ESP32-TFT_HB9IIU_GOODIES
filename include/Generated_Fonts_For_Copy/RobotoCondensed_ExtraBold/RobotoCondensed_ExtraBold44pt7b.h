#ifndef _ROBOTOCONDENSED_EXTRABOLD44PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x00, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x83, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFB, 0xFD, 0xFC, 0x7F, 0x7F, 0x0F, 0xDF, 0x83,
  0xF7, 0xF0, 0xFD, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xF7, 0xF3, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF9,
  0xF0, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF0, 0xF1, 0xE0, 0xF0,
  0xF3, 0xC0, 0xF0, 0xF3, 0x80, 0xF9, 0xF7, 0x80, 0x7F, 0xEF, 0x00, 0x7F,
  0xEF, 0x00, 0x3F, 0xDE, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x7B, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xF7, 0xFF, 0x01,
  0xE7, 0x8F, 0x01, 0xEF, 0x8F, 0x03, 0xCF, 0x8F, 0x03, 0xCF, 0x8F, 0x07,
  0x8F, 0x8F, 0x07, 0x8F, 0x8F, 0x0F, 0x07, 0x8F, 0x03, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xDF, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x8F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x3F,
  0xFC, 0x7C, 0x7F, 0xFE, 0xFC, 0x7E, 0xFF, 0xFC, 0x7E, 0x7F, 0xFC, 0xFE,
  0x3F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F,
  0x9F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFE, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x80, 0x60, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x06, 0x00, 0x80, 0x40, 0x0E,
  0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x01, 0xE0, 0x38, 0x04, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xC1, 0xC1, 0xBE, 0x38, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x78, 0x07, 0xCF, 0x81,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0x81, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7C, 0xF8, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xEF, 0xE7, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x7F,
  0x7E, 0x1F, 0xDF, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFB, 0xFE, 0x7F, 0x0F,
  0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0x7F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7F, 0x0F,
  0xEF, 0xF7, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF8, 0x0F, 0x9F, 0x80,
  0xF9, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0x81, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xEF, 0xFF, 0xF9, 0xF0, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xEF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF9, 0xFE, 0xFE, 0x1F, 0xDF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x1F, 0xCF, 0xF7, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xEF, 0xE7, 0xF1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF,
  0x87, 0xF7, 0xE1, 0xFD, 0xFC, 0x7E, 0x7F, 0xBF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF1, 0xFB, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0xEF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x3F,
  0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xEF, 0xE7, 0xE1, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFD, 0xFC,
  0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x07, 0xDF,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x79,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x1E, 0x1F, 0x8F, 0xEF,
  0xF3, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF0, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFF,
  0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x78, 0x78, 0x1F, 0xF0,
  0xF1, 0xF0, 0x7F, 0xF1, 0xE3, 0xC1, 0xFF, 0xE1, 0xE7, 0x87, 0xE7, 0xC3,
  0xDF, 0x0F, 0x8F, 0x87, 0xBC, 0x1E, 0x1F, 0x0F, 0x78, 0x7C, 0x3E, 0x1E,
  0xF0, 0xF8, 0x78, 0x3D, 0xE1, 0xF0, 0xF0, 0x7B, 0xC3, 0xC1, 0xE0, 0xF7,
  0x8F, 0x83, 0xC1, 0xEF, 0x1F, 0x07, 0x83, 0xDE, 0x3E, 0x0F, 0x07, 0x3C,
  0x7C, 0x3E, 0x1E, 0x78, 0x7C, 0x7C, 0x3C, 0xF0, 0xF9, 0xF8, 0xF1, 0xE1,
  0xFF, 0xFF, 0xE3, 0xC1, 0xFF, 0xFF, 0x87, 0xC3, 0xF9, 0xFE, 0x07, 0x81,
  0xE1, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F,
  0xBF, 0x80, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0x81, 0xFD,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF,
  0x80, 0x7E, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x81, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xDF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0xE7, 0xF0,
  0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F,
  0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xFB, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x7F, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xDF, 0xFF, 0xFC, 0x3E, 0xFF, 0xFF, 0xE3, 0xF7,
  0xFF, 0xDF, 0x1F, 0x3F, 0xFE, 0xF8, 0xF9, 0xFF, 0xF7, 0xE7, 0xDF, 0xFF,
  0x9F, 0x7E, 0xFF, 0xFC, 0xFB, 0xE7, 0xFF, 0xE7, 0xDF, 0x3F, 0xFF, 0x1F,
  0xF9, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC, 0x7F, 0xFE, 0x3F, 0xE3,
  0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x87, 0xFF,
  0xE0, 0xFC, 0x3F, 0xFF, 0x07, 0xC1, 0xFF, 0xF8, 0x3E, 0x0F, 0xE0, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xDF, 0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0x3E, 0x7F, 0xFE, 0x7E, 0xFF,
  0xFC, 0x7D, 0xFF, 0xF8, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFE, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x3F,
  0x80, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xBF, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFD,
  0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x07, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F,
  0xCF, 0xC1, 0xFC, 0x3F, 0x9F, 0xC7, 0xF8, 0x7F, 0x3F, 0x8F, 0xF8, 0xFE,
  0x7F, 0x1F, 0xF1, 0xFC, 0x7E, 0x3F, 0xE3, 0xF0, 0xFC, 0x7F, 0xC7, 0xE1,
  0xF9, 0xFF, 0x8F, 0xC3, 0xF3, 0xFF, 0xBF, 0x87, 0xF7, 0xFF, 0x7F, 0x0F,
  0xEF, 0xFE, 0xFC, 0x0F, 0xDF, 0x7D, 0xF8, 0x1F, 0xFE, 0xFB, 0xF0, 0x3F,
  0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x81, 0xFF,
  0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF9,
  0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8,
  0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE3,
  0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xFD, 0xF8, 0x7F, 0x00, 0x1F,
  0xC0, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xF7,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xF8, 0xFC, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE7, 0xC3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF7, 0xFC, 0xFC, 0x7C, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xEF,
  0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0xDF, 0xEF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0x3F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFC, 0xFF, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0xCF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0x3F, 0x07, 0xC7, 0xE0, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xCF, 0xEF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x03,
  0x3F, 0xE3, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE7, 0xE1, 0xFE,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x3F, 0xDF, 0xC1,
  0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x07,
  0xEF, 0xF3, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xEF,
  0xC1, 0xF9, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE1, 0x01, 0xFC, 0x38, 0x7F,
  0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC7,
  0xC3, 0xF7, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFE,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xC0, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0xFF, 0x1F, 0xEF, 0xE3, 0xF9, 0xFC, 0xFE, 0x3F, 0xBF,
  0xC7, 0xF7, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F,
  0xBF, 0x87, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x7C, 0x0F, 0x8F, 0xCF, 0xF3, 0xFC, 0xFD, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0xFE, 0x1F,
  0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F,
  0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3,
  0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE,
  0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xF0, 0xFC, 0x7C,
  0x3F, 0x7F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xEF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0xFF, 0x3F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x3F,
  0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xE7,
  0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xC7, 0xE3,
  0xFE, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x3F, 0xDF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x7E,
  0x0F, 0xEF, 0xF3, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0xFC, 0x7F, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1F, 0xFF, 0x87, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xE0,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFB, 0xF0, 0xF8, 0xFC, 0x7E, 0x07, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF,
  0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x3E, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0xC3, 0xF1, 0xFB, 0xF0, 0xFC, 0x7E,
  0x7E, 0x7F, 0x1F, 0x9F, 0x9F, 0xC7, 0xE7, 0xE7, 0xF9, 0xF9, 0xF9, 0xFE,
  0x7C, 0x7E, 0x7F, 0xBF, 0x0F, 0xBF, 0xEF, 0xC3, 0xEF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF7, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0,
  0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC,
  0x0F, 0x80, 0xFE, 0x1F, 0xCF, 0xC3, 0xF9, 0xFC, 0x7E, 0x3F, 0x9F, 0xC3,
  0xFB, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0xFC, 0x3F,
  0x9F, 0xC7, 0xF1, 0xF9, 0xFC, 0x3F, 0xBF, 0x83, 0xF0, 0xFE, 0x07, 0xF7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC,
  0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xF8, 0x1F, 0xBF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x78, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x07, 0xE3, 0xF8, 0x7F, 0x0F, 0x81, 0xF8, 0x3F, 0x81, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x01, 0xC0,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0F, 0x01, 0xF0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7F, 0x87, 0xF0,
  0x3E, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC,
  0x3F, 0x03, 0xE0, 0x70, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x1F, 0x3F,
  0xE1, 0xF7, 0xFF, 0x1F, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xF8, 0x7F, 0xEF,
  0x87, 0xFC, 0xF8, 0x3F, 0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 31, 12, 2, -31 },
  { 29, 12, 12, 14, 1, -33 },
  { 47, 20, 31, 23, 1, -31 },
  { 125, 18, 40, 22, 2, -36 },
  { 215, 24, 31, 28, 2, -31 },
  { 308, 24, 31, 26, 1, -31 },
  { 401, 5, 12, 7, 1, -33 },
  { 409, 10, 45, 14, 3, -35 },
  { 466, 11, 45, 14, 1, -35 },
  { 528, 19, 19, 20, 1, -31 },
  { 574, 18, 23, 21, 1, -26 },
  { 626, 8, 14, 11, 1, -5 },
  { 640, 11, 5, 17, 3, -16 },
  { 647, 7, 7, 13, 3, -7 },
  { 654, 14, 34, 14, 0, -31 },
  { 714, 18, 31, 22, 2, -31 },
  { 784, 13, 31, 22, 3, -31 },
  { 835, 20, 31, 22, 1, -31 },
  { 913, 19, 31, 22, 1, -31 },
  { 987, 20, 31, 22, 1, -31 },
  { 1065, 18, 31, 22, 2, -31 },
  { 1135, 19, 31, 22, 2, -31 },
  { 1209, 20, 31, 22, 1, -31 },
  { 1287, 18, 31, 22, 2, -31 },
  { 1357, 18, 31, 22, 2, -31 },
  { 1427, 7, 24, 12, 3, -24 },
  { 1448, 9, 33, 12, 1, -24 },
  { 1486, 16, 21, 20, 1, -24 },
  { 1528, 16, 14, 22, 3, -21 },
  { 1556, 15, 21, 20, 3, -24 },
  { 1596, 17, 31, 20, 1, -31 },
  { 1662, 31, 40, 34, 1, -30 },
  { 1817, 26, 31, 26, 0, -31 },
  { 1918, 21, 31, 25, 2, -31 },
  { 2000, 22, 31, 25, 2, -31 },
  { 2086, 21, 31, 25, 2, -31 },
  { 2168, 19, 31, 22, 2, -31 },
  { 2242, 18, 31, 21, 2, -31 },
  { 2312, 22, 31, 26, 2, -31 },
  { 2398, 23, 31, 27, 2, -31 },
  { 2488, 6, 31, 12, 3, -31 },
  { 2512, 18, 31, 22, 1, -31 },
  { 2582, 23, 31, 24, 2, -31 },
  { 2672, 18, 31, 21, 2, -31 },
  { 2742, 29, 31, 33, 2, -31 },
  { 2855, 23, 31, 27, 2, -31 },
  { 2945, 23, 31, 27, 2, -31 },
  { 3035, 21, 31, 25, 2, -31 },
  { 3117, 23, 37, 27, 2, -31 },
  { 3224, 22, 31, 25, 2, -31 },
  { 3310, 20, 31, 24, 2, -31 },
  { 3388, 22, 31, 24, 1, -31 },
  { 3474, 21, 31, 25, 2, -31 },
  { 3556, 25, 31, 26, 0, -31 },
  { 3653, 31, 31, 33, 1, -31 },
  { 3774, 23, 31, 25, 1, -31 },
  { 3864, 24, 31, 24, 0, -31 },
  { 3957, 21, 31, 23, 1, -31 },
  { 4039, 9, 44, 12, 2, -37 },
  { 4089, 18, 34, 17, 0, -31 },
  { 4166, 8, 44, 12, 1, -37 },
  { 4210, 16, 16, 17, 1, -31 },
  { 4242, 17, 5, 18, 0, 0 },
  { 4253, 12, 7, 15, 1, -33 },
  { 4264, 18, 23, 21, 1, -23 },
  { 4316, 18, 33, 22, 2, -33 },
  { 4391, 18, 23, 20, 1, -23 },
  { 4443, 19, 33, 22, 1, -33 },
  { 4522, 18, 23, 21, 2, -23 },
  { 4574, 13, 33, 15, 1, -33 },
  { 4628, 19, 32, 22, 1, -23 },
  { 4704, 18, 33, 22, 2, -33 },
  { 4779, 7, 33, 11, 2, -33 },
  { 4808, 10, 42, 11, -1, -33 },
  { 4861, 19, 33, 21, 2, -33 },
  { 4940, 7, 33, 11, 2, -33 },
  { 4969, 28, 23, 33, 2, -23 },
  { 5050, 18, 23, 22, 2, -23 },
  { 5102, 19, 23, 22, 1, -23 },
  { 5157, 18, 32, 22, 2, -23 },
  { 5229, 19, 32, 22, 1, -23 },
  { 5305, 12, 23, 15, 2, -23 },
  { 5340, 18, 23, 20, 1, -23 },
  { 5392, 12, 29, 14, 1, -29 },
  { 5436, 18, 23, 22, 2, -23 },
  { 5488, 19, 23, 20, 0, -23 },
  { 5543, 26, 23, 28, 1, -23 },
  { 5618, 19, 23, 20, 1, -23 },
  { 5673, 20, 32, 20, 0, -23 },
  { 5753, 16, 23, 20, 2, -23 },
  { 5799, 11, 42, 13, 1, -34 },
  { 5857, 4, 37, 11, 4, -31 },
  { 5876, 11, 42, 13, 1, -34 },
  { 5934, 20, 10, 24, 2, -18 },
};

const GFXfont RobotoCondensed_ExtraBold44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_EXTRABOLD44PT7B_H_
