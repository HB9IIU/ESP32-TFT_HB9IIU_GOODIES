#ifndef _ROBOTOCONDENSED_EXTRABOLD50PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3C, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xEF,
  0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB,
  0xC3, 0xE0, 0x00, 0xF8, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x81, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x81, 0xF1, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00,
  0x3C, 0x78, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1F,
  0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0x9F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC1, 0xFD, 0xFE,
  0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFB, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7E, 0xF8, 0x18, 0x07, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F,
  0x87, 0xC3, 0xC0, 0xF8, 0x7C, 0x78, 0x0F, 0x87, 0xCF, 0x80, 0xF8, 0x7C,
  0xF0, 0x07, 0x87, 0xDF, 0x00, 0x7C, 0xF9, 0xE0, 0x07, 0xFF, 0xBE, 0x00,
  0x3F, 0xF3, 0xC0, 0x01, 0xFE, 0x7C, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1E, 0x7F,
  0x80, 0x03, 0xEF, 0xFC, 0x00, 0x7D, 0xFF, 0xE0, 0x07, 0x9F, 0xBE, 0x00,
  0xFB, 0xE1, 0xF0, 0x0F, 0x3E, 0x1F, 0x01, 0xF3, 0xE1, 0xF0, 0x1E, 0x3E,
  0x1F, 0x03, 0xE3, 0xE1, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0xC3, 0xF1, 0xF0,
  0x38, 0x1F, 0xBE, 0x00, 0x81, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0xFC, 0x3F, 0xFE,
  0x3F, 0x1F, 0xFF, 0xCF, 0xCF, 0xFF, 0xFB, 0xF3, 0xF9, 0xFF, 0xFC, 0xFE,
  0x3F, 0xFF, 0x3F, 0x87, 0xFF, 0xCF, 0xE1, 0xFF, 0xE3, 0xF8, 0x3F, 0xF8,
  0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0xF8, 0x1F,
  0xF8, 0xFF, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xBE, 0xFB, 0xE0, 0x00, 0x20, 0x0E, 0x01, 0xE0, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1E, 0x00, 0xE0, 0x02, 0x20, 0x03, 0x80, 0x1E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x0F, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x07,
  0x83, 0x3F, 0x1E, 0x3E, 0xFF, 0x7B, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x81, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xF7, 0xC0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC1,
  0xF8, 0x0E, 0x03, 0x80, 0x00, 0x04, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xC0, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x3F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xF9, 0xFC, 0x78, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFE, 0x3F,
  0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFB,
  0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x1F, 0xC7,
  0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC1, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7,
  0xFC, 0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF,
  0x7F, 0x83, 0xFD, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x7F,
  0x80, 0xFD, 0xFE, 0x03, 0xE7, 0xF8, 0x1F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83,
  0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7E, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x87, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0x01,
  0xFD, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xF7,
  0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0x3F, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xF0, 0xFE, 0x7F,
  0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFE, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F,
  0x3F, 0xC3, 0xF8, 0xFF, 0x3F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07,
  0xF7, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xFB, 0xFC, 0x3F,
  0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x7C, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3,
  0xFB, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0xC7, 0xC0, 0x1E, 0x1F, 0x9F, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x9F,
  0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x0F, 0xC0, 0xF8,
  0xF8, 0x0F, 0xFC, 0x1E, 0x3E, 0x07, 0xFF, 0x87, 0x8F, 0x83, 0xFF, 0xE1,
  0xF7, 0xC0, 0xFF, 0xF8, 0x7D, 0xF0, 0x7E, 0x3E, 0x0F, 0x7C, 0x1F, 0x0F,
  0x83, 0xFE, 0x0F, 0x83, 0xE0, 0xFF, 0x83, 0xE0, 0xF8, 0x3F, 0xE0, 0xF8,
  0x3E, 0x0F, 0xF8, 0x7E, 0x0F, 0x83, 0xFE, 0x1F, 0x83, 0xE0, 0xFF, 0x87,
  0xC0, 0xF8, 0x3F, 0xE1, 0xF0, 0x7C, 0x0F, 0xF8, 0x7C, 0x1F, 0x03, 0xFE,
  0x1F, 0x07, 0xC0, 0xFF, 0x87, 0xC1, 0xF0, 0x7F, 0xE1, 0xF0, 0x7C, 0x1E,
  0xF8, 0x7C, 0x1F, 0x07, 0xBE, 0x1F, 0x8F, 0xC3, 0xEF, 0x87, 0xE3, 0xF0,
  0xF3, 0xE0, 0xFF, 0xFF, 0xFC, 0x7C, 0x3F, 0xFF, 0xFE, 0x1F, 0x07, 0xF9,
  0xFF, 0x07, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x08, 0x03, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0x01, 0xFF, 0xDF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xBF, 0x83, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F,
  0xBF, 0x87, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xCF, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF1, 0xFF,
  0x9F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0x8F, 0xFE, 0x7F, 0x03, 0xFE, 0xFE, 0x03, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x7F, 0xDF, 0xC3, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC7, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xBF,
  0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFC, 0x07, 0xF9,
  0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x3F, 0xEF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0x9F,
  0xC0, 0x7F, 0xCF, 0xE0, 0x7F, 0xC7, 0xF0, 0x3F, 0xE3, 0xF8, 0x3F, 0xE1,
  0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0,
  0x1F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF8, 0x07, 0xF7, 0xFC, 0x03, 0xFB, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x7F, 0x8F, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xE3,
  0xF8, 0x1F, 0xF1, 0xFC, 0x07, 0xFC, 0xFE, 0x03, 0xFE, 0x7F, 0x00, 0xFF,
  0xBF, 0x80, 0x7F, 0xDF, 0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F,
  0x7F, 0xFE, 0xFC, 0x3E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7E,
  0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7C, 0x7F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0,
  0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xF1, 0xFF,
  0xFD, 0xF8, 0xFF, 0xFE, 0x7E, 0x7F, 0xFF, 0x3F, 0x3F, 0xFF, 0x9F, 0xDF,
  0xFF, 0xC7, 0xEF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xE7, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x01,
  0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFC,
  0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFE, 0x07, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xF8, 0xFE, 0x07, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0xF8, 0x7F, 0xDF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0xE3, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xE3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xBF, 0x81, 0xFE,
  0x0F, 0xF7, 0xF0, 0x3F, 0xC1, 0xFE, 0xFE, 0x0F, 0xF8, 0x3F, 0x9F, 0xE1,
  0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0xE0, 0xFE, 0x7F, 0x87, 0xFC, 0x3F, 0xC7,
  0xF0, 0xFF, 0xC7, 0xF8, 0xFE, 0x3F, 0xF8, 0xFF, 0x1F, 0xC7, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFF, 0xE3, 0xF8, 0x7F, 0x9F, 0xFC, 0x7F, 0x0F, 0xF3, 0xFF,
  0xCF, 0xE0, 0xFE, 0x7F, 0xFB, 0xFC, 0x1F, 0xDF, 0xFF, 0x7F, 0x83, 0xFB,
  0xFF, 0xEF, 0xE0, 0x7F, 0x7E, 0xFD, 0xFC, 0x0F, 0xFF, 0xDF, 0xBF, 0x81,
  0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF,
  0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F,
  0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8,
  0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xE0,
  0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x9F, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xFC, 0x3E, 0x1F,
  0x0F, 0x87, 0xC7, 0xE1, 0xF9, 0xF0, 0x7E, 0x7C, 0x0F, 0xBF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x1F, 0xEF, 0xF0, 0xFE,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xEF, 0xF0, 0xFC, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF3, 0xF0, 0x7F, 0xBF, 0xE3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFD, 0xFF, 0xCF, 0xE7, 0xFC, 0x7F, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xEF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x3F, 0x87, 0xFD, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF0,
  0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81,
  0xFD, 0xFC, 0x0F, 0xEF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xBF, 0x81, 0xF8, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF9, 0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x30,
  0xFF, 0x03, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE3, 0xF8,
  0xFF, 0xDF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x3F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x8E, 0x07, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x3F, 0x0F, 0xF7, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x18, 0x7E, 0x7F, 0xFF, 0xFF,
  0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x01, 0x80, 0x7E, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xEF, 0xF1, 0xFF,
  0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xE3, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F,
  0xDF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xBF, 0x83, 0xFE, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x1F, 0x01, 0xF0, 0x7F, 0xBF, 0xE3, 0xFE, 0x3F, 0xFF,
  0xFB, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0xE3, 0xFD, 0xFE, 0x1F, 0xE0, 0xFE, 0xFF,
  0x07, 0xF0, 0x7F, 0x7F, 0x83, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xFF,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x83, 0xF8,
  0x3F, 0xC0, 0xFE, 0x1F, 0x0F, 0xE7, 0xFC, 0xFE, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xFB, 0xFE,
  0x3F, 0xDF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x07, 0xF3, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x7F, 0xC7, 0xF9, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB,
  0xF8, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xF9, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0xDF, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0, 0x7C, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFD, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF9,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0x83, 0xFF, 0xF8, 0x3F, 0x0F,
  0xEF, 0xE0, 0xFC, 0x3F, 0xBF, 0x87, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF9,
  0xFC, 0x7F, 0x8F, 0xE7, 0xF1, 0xFE, 0x3F, 0x1F, 0xCF, 0xF9, 0xFC, 0x7F,
  0x3F, 0xE7, 0xF0, 0xFC, 0xFF, 0x9F, 0xC3, 0xF3, 0xFF, 0x7F, 0x0F, 0xFF,
  0xFD, 0xF8, 0x3F, 0xFD, 0xF7, 0xE0, 0x7F, 0xF7, 0xDF, 0x81, 0xFF, 0xDF,
  0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFF, 0x07, 0xFB, 0xF8, 0x3F,
  0x9F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F,
  0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83,
  0xFD, 0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0xCF, 0xF1, 0xFE, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F,
  0xDF, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x0F,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0x87, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x20, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3E, 0x01, 0xE0, 0x04, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x7C,
  0xFF, 0xC0, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7, 0xEF, 0xFF, 0xFF, 0xDF,
  0x9F, 0xFF, 0x7E, 0x1F, 0xFE, 0xFC, 0x1F, 0xF9, 0xF8, 0x1F, 0xE0, 0x00,
  0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 36, 13, 3, -36 },
  { 37, 14, 14, 16, 1, -38 },
  { 62, 23, 36, 26, 1, -36 },
  { 166, 21, 46, 25, 2, -41 },
  { 287, 28, 36, 32, 2, -36 },
  { 413, 26, 37, 29, 2, -36 },
  { 534, 6, 14, 8, 1, -38 },
  { 545, 12, 50, 16, 3, -39 },
  { 620, 13, 50, 16, 1, -39 },
  { 702, 22, 22, 23, 1, -36 },
  { 763, 21, 26, 23, 1, -29 },
  { 832, 9, 15, 13, 1, -6 },
  { 849, 13, 6, 20, 3, -18 },
  { 859, 9, 8, 15, 3, -8 },
  { 868, 15, 39, 16, 0, -36 },
  { 942, 21, 36, 25, 2, -36 },
  { 1037, 14, 36, 25, 4, -36 },
  { 1100, 21, 36, 25, 2, -36 },
  { 1195, 22, 36, 25, 1, -36 },
  { 1294, 22, 36, 25, 2, -36 },
  { 1393, 21, 36, 25, 2, -36 },
  { 1488, 22, 36, 25, 2, -36 },
  { 1587, 21, 36, 25, 2, -36 },
  { 1682, 21, 36, 25, 2, -36 },
  { 1777, 21, 36, 25, 2, -36 },
  { 1872, 9, 28, 14, 3, -28 },
  { 1904, 9, 37, 13, 2, -28 },
  { 1946, 18, 24, 22, 1, -27 },
  { 2000, 19, 17, 25, 3, -24 },
  { 2041, 18, 24, 23, 3, -27 },
  { 2095, 20, 36, 23, 1, -36 },
  { 2185, 34, 46, 38, 2, -35 },
  { 2381, 30, 36, 30, 0, -36 },
  { 2516, 23, 36, 28, 3, -36 },
  { 2620, 25, 36, 29, 2, -36 },
  { 2733, 23, 36, 28, 3, -36 },
  { 2837, 20, 36, 24, 3, -36 },
  { 2927, 20, 36, 24, 3, -36 },
  { 3017, 25, 36, 29, 2, -36 },
  { 3130, 25, 36, 31, 3, -36 },
  { 3243, 8, 36, 14, 3, -36 },
  { 3279, 21, 36, 25, 1, -36 },
  { 3374, 25, 36, 28, 3, -36 },
  { 3487, 20, 36, 24, 3, -36 },
  { 3577, 32, 36, 38, 3, -36 },
  { 3721, 25, 36, 31, 3, -36 },
  { 3834, 26, 36, 30, 2, -36 },
  { 3951, 24, 36, 29, 3, -36 },
  { 4059, 26, 42, 30, 2, -36 },
  { 4196, 24, 36, 28, 3, -36 },
  { 4304, 23, 36, 27, 2, -36 },
  { 4408, 25, 36, 27, 1, -36 },
  { 4521, 24, 36, 29, 2, -36 },
  { 4629, 29, 36, 29, 0, -36 },
  { 4760, 35, 36, 37, 1, -36 },
  { 4918, 26, 36, 28, 1, -36 },
  { 5035, 27, 36, 27, 0, -36 },
  { 5157, 23, 36, 27, 2, -36 },
  { 5261, 9, 50, 13, 3, -42 },
  { 5318, 20, 39, 19, 0, -36 },
  { 5416, 10, 50, 13, 1, -42 },
  { 5479, 18, 18, 20, 1, -36 },
  { 5520, 19, 6, 20, 0, 0 },
  { 5535, 13, 8, 17, 1, -38 },
  { 5548, 20, 26, 23, 2, -26 },
  { 5613, 21, 38, 25, 2, -38 },
  { 5713, 20, 26, 23, 2, -26 },
  { 5778, 21, 38, 25, 1, -38 },
  { 5878, 21, 26, 24, 2, -26 },
  { 5947, 15, 39, 16, 1, -39 },
  { 6021, 21, 36, 25, 2, -26 },
  { 6116, 20, 38, 25, 2, -38 },
  { 6211, 8, 37, 13, 2, -37 },
  { 6248, 12, 47, 13, -2, -37 },
  { 6319, 22, 38, 24, 2, -38 },
  { 6424, 7, 38, 13, 3, -38 },
  { 6458, 33, 26, 37, 2, -26 },
  { 6566, 20, 26, 25, 2, -26 },
  { 6631, 21, 26, 25, 2, -26 },
  { 6700, 21, 36, 25, 2, -26 },
  { 6795, 21, 36, 25, 1, -26 },
  { 6890, 14, 26, 17, 2, -26 },
  { 6936, 20, 26, 23, 1, -26 },
  { 7001, 14, 33, 15, 1, -33 },
  { 7059, 20, 26, 25, 2, -26 },
  { 7124, 21, 26, 23, 1, -26 },
  { 7193, 30, 26, 31, 1, -26 },
  { 7291, 21, 26, 23, 1, -26 },
  { 7360, 22, 36, 23, 0, -26 },
  { 7459, 19, 26, 23, 2, -26 },
  { 7521, 12, 48, 15, 1, -39 },
  { 7593, 5, 43, 13, 4, -36 },
  { 7620, 13, 48, 15, 1, -39 },
  { 7698, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBold50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_EXTRABOLD50PT7B_H_
