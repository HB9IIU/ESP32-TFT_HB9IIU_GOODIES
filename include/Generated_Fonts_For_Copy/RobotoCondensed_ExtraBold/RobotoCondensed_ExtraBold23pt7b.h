#ifndef _ROBOTOCONDENSED_EXTRABOLD23PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x70, 0x06, 0xFF, 0x60, 0xEF, 0xDF,
  0xBF, 0x7E, 0xDD, 0x80, 0x19, 0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x3F, 0xFF,
  0xFC, 0xCC, 0x33, 0x0D, 0xCF, 0xFB, 0xFE, 0x36, 0x0D, 0x86, 0x61, 0x98,
  0x6E, 0x00, 0x0C, 0x03, 0x01, 0xE0, 0xFE, 0x7F, 0x9C, 0xF7, 0x3D, 0xC0,
  0x78, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0x80, 0xFE, 0x3F, 0xCF, 0xFF, 0x9F,
  0xE1, 0xE0, 0x30, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x33, 0x11, 0x99, 0x8C,
  0xDC, 0x66, 0xC1, 0xFE, 0x0F, 0x60, 0x06, 0x00, 0x37, 0x03, 0x7C, 0x1B,
  0x71, 0xB9, 0x8C, 0xCC, 0xC6, 0xE0, 0x3E, 0x00, 0xE0, 0x1E, 0x03, 0xF0,
  0x7F, 0x07, 0x38, 0x73, 0x87, 0x70, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0xEE,
  0xEF, 0xEE, 0xFE, 0xE7, 0xEF, 0x3C, 0xFF, 0xC7, 0xFE, 0x3E, 0xF0, 0xFF,
  0xF0, 0x08, 0x71, 0x8E, 0x31, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0xE3, 0x86,
  0x18, 0x71, 0xC3, 0x0E, 0x18, 0x70, 0x80, 0x86, 0x38, 0xC7, 0x18, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0x9C, 0xCE, 0x62, 0x00, 0x0E, 0x03,
  0x00, 0xC1, 0x93, 0xFF, 0xC3, 0xC1, 0xE0, 0xEC, 0x33, 0x84, 0x40, 0x1C,
  0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0x39, 0xCC, 0x67, 0x39, 0x80, 0xFF, 0xFE, 0x2F, 0xF7, 0x06, 0x1C,
  0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x30,
  0xE1, 0x80, 0x1E, 0x0F, 0xC7, 0xFB, 0xCE, 0xF3, 0xB8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xBC, 0xE7, 0xF8, 0xFC, 0x1E, 0x00,
  0x04, 0xFF, 0xFF, 0xDC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x3E, 0x1F, 0xCF, 0xFB, 0xCE, 0xE3, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x1F, 0xCF, 0xFB, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x7E, 0x1E, 0x07, 0xE0,
  0x38, 0x0F, 0xE3, 0xF8, 0xFF, 0xF9, 0xFC, 0x3E, 0x00, 0x07, 0x83, 0xE0,
  0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF9, 0xDE, 0x77, 0xB9, 0xEF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0,
  0x70, 0x1C, 0x0F, 0xE3, 0xFE, 0xFF, 0x80, 0xE0, 0x3C, 0x0F, 0xE3, 0xFC,
  0xE7, 0xF9, 0xFC, 0x1E, 0x00, 0x07, 0x07, 0xC3, 0xF1, 0xE0, 0x70, 0x1C,
  0x0F, 0xF3, 0xFE, 0xFF, 0xBC, 0xFE, 0x3F, 0x87, 0xF3, 0xDC, 0xF7, 0xF8,
  0xFE, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x00, 0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xF3, 0xBC, 0xE7, 0x39, 0xFE, 0x3E,
  0x1F, 0xEF, 0x3B, 0xCF, 0xE3, 0xFC, 0xFF, 0xF9, 0xFE, 0x3E, 0x00, 0x1E,
  0x1F, 0xC7, 0xFB, 0xCE, 0xF3, 0xB8, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF, 0xF3,
  0xF8, 0x0E, 0x03, 0x81, 0xC3, 0xF0, 0xF8, 0x38, 0x00, 0x27, 0xF7, 0x00,
  0x00, 0x02, 0x7F, 0x70, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x77, 0x77, 0x6E,
  0xC0, 0x01, 0x07, 0x1F, 0x7E, 0xF8, 0xE0, 0xF8, 0x7F, 0x1F, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3C, 0x7E, 0xFC, 0xF8, 0x70, 0x20, 0x00, 0x1E, 0x0F,
  0xE7, 0xF9, 0xCE, 0x73, 0xC0, 0xE0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xE0,
  0x70, 0x00, 0x03, 0x01, 0xE0, 0x78, 0x0C, 0x00, 0x03, 0xE0, 0x0F, 0xF8,
  0x1C, 0x1C, 0x38, 0x0C, 0x70, 0x06, 0x61, 0xC6, 0x63, 0xE6, 0xE7, 0x63,
  0xCE, 0x63, 0xCE, 0x63, 0xCE, 0x63, 0xCC, 0x63, 0xCE, 0x66, 0xCE, 0xE6,
  0xCF, 0xFC, 0xE7, 0x38, 0x60, 0x00, 0x70, 0x00, 0x38, 0x20, 0x1F, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFE, 0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0xCF, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xE7, 0x87, 0x9C, 0x1E, 0xF0, 0x3C, 0xFF, 0x1F, 0xFB, 0xFF,
  0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x77, 0x9E, 0xFF, 0x9F, 0xFB, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0x03, 0xFC, 0x7F,
  0xE7, 0x1E, 0xF0, 0xEF, 0x0E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x0E, 0xF0, 0xE7, 0x1E, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0xFE, 0x1F,
  0xF3, 0xFF, 0x79, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xBF, 0xF7, 0xFC, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0, 0xEF,
  0x0E, 0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF7,
  0x0F, 0x7F, 0xF3, 0xFE, 0x1F, 0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x73, 0xDC, 0xF7, 0xF8,
  0xFE, 0x1E, 0x00, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x78,
  0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x78, 0xF3, 0xCF, 0x3C,
  0xF1, 0xEF, 0x1E, 0xF1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFB, 0x1F, 0xFF, 0x37, 0xFE, 0x6F, 0xFD, 0xDF, 0xDB, 0xBF, 0xBE, 0x7F,
  0x7C, 0xFE, 0xF9, 0xFC, 0xF3, 0xF9, 0xC7, 0xF3, 0x8E, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x8F, 0xFC, 0xFF, 0xCF, 0xFE, 0xFF, 0xEF, 0xF6, 0xFF, 0x7F,
  0xF7, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F,
  0x03, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x1E, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0xFF, 0x1F, 0xFB, 0xFF, 0x78, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xFF, 0xFF, 0xFB, 0xFC, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x1E, 0x7F, 0xE3,
  0xFC, 0x1F, 0xC0, 0x1F, 0x00, 0xE0, 0x04, 0xFF, 0x1F, 0xFB, 0xFF, 0x78,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xDF, 0xF3, 0xFE, 0x7B, 0xCF,
  0x3D, 0xE7, 0xBC, 0x77, 0x8F, 0xF1, 0xE0, 0x1F, 0x0F, 0xF1, 0xFF, 0x78,
  0xEF, 0x1F, 0xE0, 0x1E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0xFE,
  0x1F, 0xE3, 0xFF, 0xF3, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xDF, 0xF3, 0xFE, 0x1F, 0x00, 0xF0, 0x7B, 0x83, 0xDE, 0x1E,
  0xF0, 0xE7, 0x8F, 0x1C, 0x78, 0xE3, 0x87, 0x9C, 0x3D, 0xE0, 0xEF, 0x07,
  0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x71,
  0xC7, 0xB8, 0xE3, 0x9C, 0x79, 0xCE, 0x7C, 0xE7, 0xBE, 0x73, 0xDF, 0x78,
  0xEF, 0xBC, 0x77, 0xDC, 0x3B, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF,
  0xC1, 0xF7, 0xE0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x00,
  0x78, 0xF3, 0xC7, 0x8E, 0x38, 0x7B, 0xC3, 0xDE, 0x0E, 0xE0, 0x7F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3B, 0x83, 0xDE, 0x1E, 0xF1, 0xE3,
  0x8F, 0x1E, 0xF8, 0xF0, 0xF0, 0xF7, 0x0F, 0x78, 0xE3, 0x8E, 0x39, 0xE3,
  0xDC, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0xFF, 0xE0, 0xF0, 0x78, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xFF, 0xFF, 0xE0, 0x38, 0x38, 0x7C,
  0x6C, 0x6C, 0xEE, 0xE6, 0xC6, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xC3, 0x8E,
  0x3E, 0x3F, 0xBF, 0xFC, 0xF0, 0x79, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0xFF,
  0xEF, 0x70, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF3, 0xFE,
  0xFF, 0xBC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF, 0xBB,
  0xC0, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE3, 0xFF,
  0xDF, 0xC7, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xEE, 0xFF,
  0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0x7F, 0x9D, 0xC0,
  0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x7F, 0xDF,
  0xE7, 0xE0, 0x0E, 0x3C, 0xF9, 0xC3, 0x87, 0x3F, 0xFF, 0xFE, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x3F, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFF, 0xF7, 0xFC, 0xFF, 0x03, 0xC0, 0xE7,
  0xF9, 0xFC, 0x3E, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xBD,
  0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xC0, 0x0F, 0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF3,
  0xC6, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xFE, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x3F,
  0xDE, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0x73, 0xDE, 0xF3,
  0xBC, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0x39, 0xFF, 0xFB, 0xFF, 0xFF, 0x9C, 0xFF, 0x39, 0xFE, 0x73, 0xFC, 0xE7,
  0xF9, 0xCF, 0xF3, 0x9F, 0xE7, 0x3F, 0xCE, 0x7F, 0x9C, 0xF0, 0xEF, 0x7F,
  0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70,
  0x3E, 0x1F, 0xCF, 0xFB, 0xCE, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xBF,
  0xE7, 0xF0, 0xF8, 0xEF, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFF, 0xEF, 0xFB, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x3B, 0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF,
  0xDF, 0xE7, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xEF, 0xFF, 0xFC,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0x3E, 0x3F, 0xBD, 0xDC, 0xFF, 0x03,
  0xF0, 0xFC, 0x1F, 0xE7, 0xFB, 0xDF, 0xC7, 0xC0, 0x38, 0x70, 0xE7, 0xFF,
  0xFF, 0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xE7, 0xC7, 0x80, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xDF, 0xE7, 0x70,
  0xF3, 0xDC, 0xF7, 0x39, 0xCE, 0x7B, 0x8E, 0xE3, 0xF0, 0xFC, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0xF3, 0x9D, 0xCE, 0x77, 0x7B, 0xDD, 0xEE, 0x77, 0xB9,
  0xDF, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0x1C,
  0x73, 0xDE, 0xE3, 0xB8, 0xFC, 0x1F, 0x07, 0x81, 0xF0, 0xFC, 0x3F, 0x9E,
  0xE7, 0xBD, 0xCF, 0xF1, 0xDC, 0xF7, 0x3D, 0xEE, 0x7B, 0x8F, 0xE3, 0xF0,
  0xFC, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x0E, 0x07, 0x07, 0xC1, 0xF0, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x7F,
  0xFF, 0xFF, 0xF0, 0x19, 0xCE, 0xE7, 0x39, 0xCE, 0x77, 0xB9, 0xC7, 0x39,
  0xCE, 0x73, 0x9C, 0x73, 0x8C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x38,
  0xE7, 0x39, 0xCE, 0x73, 0xCE, 0x77, 0x39, 0xCE, 0x73, 0x9D, 0xCE, 0x40,
  0x38, 0xEF, 0x9B, 0xFF, 0x73, 0xEE, 0x38,
};

const GFXglyph RobotoCondensed_ExtraBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 7, 6, 7, 0, -17 },
  { 16, 10, 17, 12, 1, -17 },
  { 38, 10, 21, 12, 1, -19 },
  { 65, 13, 17, 15, 1, -17 },
  { 93, 12, 17, 14, 1, -17 },
  { 119, 2, 6, 4, 1, -17 },
  { 121, 6, 23, 7, 1, -18 },
  { 139, 5, 23, 7, 1, -18 },
  { 154, 10, 10, 11, 0, -17 },
  { 167, 9, 12, 11, 1, -13 },
  { 181, 5, 7, 6, 0, -3 },
  { 186, 5, 3, 9, 2, -9 },
  { 188, 4, 4, 7, 1, -4 },
  { 190, 7, 18, 7, 0, -17 },
  { 206, 10, 17, 12, 1, -17 },
  { 228, 6, 17, 12, 2, -17 },
  { 241, 10, 17, 12, 1, -17 },
  { 263, 10, 17, 12, 1, -17 },
  { 285, 10, 17, 12, 1, -17 },
  { 307, 10, 17, 12, 1, -17 },
  { 329, 10, 17, 12, 1, -17 },
  { 351, 10, 17, 12, 1, -17 },
  { 373, 10, 17, 12, 1, -17 },
  { 395, 10, 17, 12, 1, -17 },
  { 417, 4, 13, 6, 1, -13 },
  { 424, 4, 17, 6, 1, -13 },
  { 433, 8, 11, 10, 1, -12 },
  { 444, 9, 8, 12, 1, -11 },
  { 453, 9, 11, 10, 1, -12 },
  { 466, 10, 17, 10, 0, -17 },
  { 488, 16, 21, 18, 1, -16 },
  { 530, 14, 17, 14, 0, -17 },
  { 560, 11, 17, 13, 1, -17 },
  { 584, 12, 17, 13, 1, -17 },
  { 610, 11, 17, 13, 1, -17 },
  { 634, 10, 17, 11, 1, -17 },
  { 656, 9, 17, 11, 1, -17 },
  { 676, 12, 17, 14, 1, -17 },
  { 702, 12, 17, 14, 1, -17 },
  { 728, 4, 17, 6, 1, -17 },
  { 737, 10, 17, 11, 0, -17 },
  { 759, 12, 17, 13, 1, -17 },
  { 785, 9, 17, 11, 1, -17 },
  { 805, 15, 17, 17, 1, -17 },
  { 837, 12, 17, 14, 1, -17 },
  { 863, 12, 17, 14, 1, -17 },
  { 889, 11, 17, 13, 1, -17 },
  { 913, 12, 20, 14, 1, -17 },
  { 943, 11, 17, 13, 1, -17 },
  { 967, 11, 17, 13, 1, -17 },
  { 991, 11, 17, 13, 1, -17 },
  { 1015, 11, 17, 13, 1, -17 },
  { 1039, 13, 17, 13, 0, -17 },
  { 1067, 17, 17, 17, 0, -17 },
  { 1104, 13, 17, 13, 0, -17 },
  { 1132, 12, 17, 13, 0, -17 },
  { 1158, 11, 17, 12, 1, -17 },
  { 1182, 5, 23, 6, 1, -19 },
  { 1197, 9, 18, 9, 0, -17 },
  { 1218, 5, 23, 6, 0, -19 },
  { 1233, 8, 8, 9, 1, -17 },
  { 1241, 9, 3, 9, 0, 0 },
  { 1245, 6, 4, 8, 1, -18 },
  { 1248, 9, 12, 11, 1, -12 },
  { 1262, 10, 18, 11, 1, -18 },
  { 1285, 9, 12, 11, 1, -12 },
  { 1299, 9, 18, 11, 1, -18 },
  { 1320, 9, 12, 11, 1, -12 },
  { 1334, 7, 18, 8, 0, -18 },
  { 1350, 10, 17, 12, 1, -12 },
  { 1372, 9, 18, 11, 1, -18 },
  { 1393, 4, 17, 6, 1, -17 },
  { 1402, 6, 22, 6, -1, -17 },
  { 1419, 10, 18, 11, 1, -18 },
  { 1442, 4, 18, 6, 1, -18 },
  { 1451, 15, 12, 17, 1, -12 },
  { 1474, 9, 12, 11, 1, -12 },
  { 1488, 10, 12, 11, 1, -12 },
  { 1503, 10, 17, 11, 1, -12 },
  { 1525, 9, 17, 11, 1, -12 },
  { 1545, 6, 12, 8, 1, -12 },
  { 1554, 9, 12, 10, 1, -12 },
  { 1568, 7, 15, 7, 0, -15 },
  { 1582, 9, 12, 11, 1, -12 },
  { 1596, 10, 12, 10, 0, -12 },
  { 1611, 14, 12, 14, 0, -12 },
  { 1632, 10, 12, 10, 0, -12 },
  { 1647, 10, 17, 10, 0, -12 },
  { 1669, 9, 12, 10, 1, -12 },
  { 1683, 5, 22, 7, 1, -18 },
  { 1697, 2, 20, 6, 2, -17 },
  { 1702, 5, 22, 7, 1, -18 },
  { 1716, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBold23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_EXTRABOLD23PT7B_H_
