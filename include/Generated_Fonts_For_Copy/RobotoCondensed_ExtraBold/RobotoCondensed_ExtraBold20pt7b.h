#ifndef _ROBOTOCONDENSED_EXTRABOLD20PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xEF, 0xBC, 0xF3, 0xCC, 0x12,
  0x09, 0x0D, 0x86, 0xCF, 0xFF, 0xFC, 0xD8, 0x48, 0xFF, 0x7F, 0x9B, 0x0D,
  0x86, 0xC3, 0x60, 0x08, 0x08, 0x3C, 0x7E, 0x77, 0xE7, 0xE7, 0x70, 0x7C,
  0x1E, 0x0F, 0xE7, 0xE7, 0xF7, 0x7F, 0x3C, 0x18, 0x18, 0x70, 0x1F, 0x03,
  0x66, 0x6C, 0x8D, 0xB1, 0xFC, 0x1D, 0x80, 0x6E, 0x0F, 0xE3, 0x6C, 0x49,
  0x99, 0xB0, 0x3E, 0x03, 0x80, 0x3C, 0x1F, 0x87, 0xE1, 0x98, 0x66, 0x1F,
  0x83, 0x81, 0xF7, 0xFD, 0xBB, 0xEE, 0xFB, 0xBE, 0xFF, 0x9F, 0x70, 0xFF,
  0xE0, 0x08, 0xCC, 0xE6, 0x33, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x71,
  0x86, 0x10, 0x86, 0x38, 0xC7, 0x38, 0xC6, 0x31, 0xCE, 0x63, 0x19, 0xCE,
  0x67, 0x31, 0x00, 0x0C, 0x06, 0x03, 0x3F, 0xF3, 0xF0, 0xE0, 0xD8, 0xE6,
  0x22, 0x00, 0x38, 0x38, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38,
  0x38, 0x77, 0x77, 0x64, 0xFF, 0xC0, 0xEF, 0x60, 0x0C, 0x31, 0x86, 0x18,
  0x63, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x0C, 0x00, 0x3C, 0x7E, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x0B, 0xFF,
  0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7,
  0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xF0, 0xFF, 0xFF, 0x3C, 0x7E, 0xEF,
  0xE7, 0x07, 0x0F, 0x3E, 0x3E, 0x07, 0x07, 0xE7, 0xEF, 0xFE, 0x3C, 0x0E,
  0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x6E, 0xEE, 0xEE, 0xFF, 0xFF, 0x0E, 0x0E,
  0x0E, 0x7F, 0x7F, 0x60, 0xE0, 0xE0, 0xFE, 0xFF, 0x67, 0x07, 0x07, 0xE7,
  0xFF, 0x7E, 0x3C, 0x0E, 0x1F, 0x1F, 0x0E, 0x0E, 0x07, 0xF3, 0xFD, 0xEE,
  0xE7, 0x71, 0xF9, 0xDE, 0xE7, 0xF1, 0xE0, 0xFF, 0xFF, 0x07, 0x07, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x3C, 0x7E, 0xFF,
  0xE7, 0xE7, 0x7F, 0x7E, 0x7E, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x3C, 0x3C,
  0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0x7F, 0x3F, 0x07, 0x0E, 0x3E, 0x3C,
  0x30, 0xEF, 0x60, 0x00, 0x00, 0x6F, 0x60, 0xFD, 0x80, 0x00, 0x0D, 0xBF,
  0xB0, 0x02, 0x1C, 0xFF, 0xEF, 0x1E, 0x3F, 0x1F, 0x0E, 0x04, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x81, 0xC3, 0xE3, 0xF1, 0xE3, 0xDF, 0xFC, 0xE1,
  0x00, 0x3E, 0x7F, 0x77, 0xE7, 0x07, 0x0F, 0x0E, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x1C, 0x18, 0x07, 0xC0, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x63, 0x9B,
  0x1F, 0x2C, 0xCC, 0xB3, 0x33, 0xDC, 0xCF, 0x73, 0x2D, 0x98, 0xB7, 0x66,
  0xCF, 0xF3, 0x3B, 0xC6, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x19, 0x83, 0x9C, 0x3F,
  0xC3, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0xEF, 0x0F, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0xFD, 0xFF, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x7E, 0x1D, 0xFE, 0x7F, 0x8F, 0x80, 0xFC, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x1F, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x9F,
  0xE7, 0xF8, 0x7E, 0x1D, 0xFF, 0x7F, 0xC7, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFC, 0xEF, 0xE7, 0xF1, 0xF0,
  0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0xEE, 0x3F, 0x8F, 0xC3, 0xF8, 0xFE, 0x3D,
  0xCE, 0x73, 0x9E, 0xE3, 0xB8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xF7, 0xFD, 0xB7, 0xED, 0xBF, 0x7D,
  0xFB, 0xEF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C, 0xE1, 0xFC, 0x7F, 0x1F, 0xE7,
  0xF9, 0xFF, 0x7E, 0xDF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8,
  0x70, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1D, 0xFF, 0x7F, 0x87, 0x80, 0xFE, 0x3F, 0xEF, 0xFB, 0x8F,
  0xE1, 0xF8, 0xFF, 0xFB, 0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1D, 0xFE, 0x7F, 0x87, 0xE0, 0x3C, 0x07, 0x00, 0x80, 0xFE,
  0x3F, 0xEF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEF, 0xFB, 0xFC, 0xFE, 0x39, 0xCE,
  0x73, 0x9E, 0xE3, 0xB8, 0xF0, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x07, 0xC1,
  0xF8, 0x3E, 0x07, 0xF1, 0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFF, 0xF7, 0xF9, 0xF0, 0xF0, 0xEE, 0x1D, 0xC7, 0xB8,
  0xE7, 0x9C, 0x73, 0x8E, 0x71, 0xDC, 0x1B, 0x83, 0xF0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1E, 0x00, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x7D,
  0xCE, 0xFB, 0x8D, 0xF6, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1,
  0xE7, 0xC1, 0xC7, 0x03, 0x8E, 0x00, 0x71, 0xEE, 0x38, 0xEF, 0x1D, 0xC3,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0x70, 0xEE, 0x3D, 0xE7, 0x1D,
  0xE3, 0xC0, 0xF1, 0xEE, 0x39, 0xC7, 0x1D, 0xC3, 0xB8, 0x76, 0x07, 0xC0,
  0xF8, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF,
  0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E,
  0x0E, 0x0F, 0x07, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0xFF, 0x18, 0x3C, 0x3C, 0x3C, 0x66, 0x66, 0x66, 0xFF, 0xFF, 0xE3, 0x8C,
  0x3C, 0xFE, 0xEE, 0x0E, 0x7E, 0xFE, 0xEE, 0xEE, 0xEE, 0xFF, 0x77, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xF7,
  0xFF, 0xFE, 0x3C, 0x7E, 0xEE, 0xE7, 0xE0, 0xE0, 0xE0, 0xE7, 0xEE, 0x7E,
  0x3C, 0x07, 0x07, 0x07, 0x07, 0x77, 0xFF, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xEF, 0xFF, 0x77, 0x3C, 0x7E, 0xE7, 0xE7, 0xFF, 0xFF, 0xE0, 0xE0,
  0xF6, 0x7F, 0x3E, 0x1C, 0xF3, 0x8E, 0xFF, 0xF3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x80, 0x7F, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xF7,
  0xFF, 0x7F, 0x07, 0x4F, 0x7E, 0x7C, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x77, 0x7B, 0xB9, 0xF8,
  0xFC, 0x7E, 0x3F, 0x9D, 0xCE, 0xF7, 0x3B, 0x9E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xEE, 0xF7, 0xFF, 0xBF, 0xDF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F,
  0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCE, 0xEE, 0xFF, 0xEF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xEF, 0x7E, 0x3C, 0xFE, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xF7, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0xEF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x3E, 0x7F, 0x77, 0x70, 0x78,
  0x3E, 0x0F, 0x07, 0x77, 0x7F, 0x3E, 0x71, 0xCF, 0xFF, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x8F, 0x3C, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xEF, 0xFF, 0x77, 0xE3, 0xBB, 0x9D, 0xCE, 0xE7, 0x71, 0xB0, 0xF8, 0x7C,
  0x3E, 0x0E, 0x07, 0x00, 0xE6, 0x76, 0x77, 0x67, 0x77, 0xF7, 0x7F, 0x67,
  0xFE, 0x3D, 0xE3, 0xDE, 0x39, 0xE3, 0x9C, 0x38, 0xC0, 0x73, 0xBB, 0x9F,
  0xC7, 0xC3, 0xE0, 0xE0, 0xF8, 0x7C, 0x77, 0x3B, 0x9C, 0xE0, 0xE3, 0xBB,
  0xDD, 0xCE, 0xE7, 0x71, 0xB0, 0xF8, 0x7C, 0x1E, 0x0E, 0x07, 0x03, 0x83,
  0x83, 0xC1, 0xC0, 0xFF, 0xFC, 0x38, 0xE1, 0xC7, 0x1C, 0x38, 0xE1, 0xFF,
  0xF8, 0x13, 0x76, 0x66, 0x66, 0xEC, 0xCE, 0x66, 0x66, 0x67, 0x31, 0xFF,
  0xFF, 0x80, 0x8C, 0xEE, 0x66, 0x66, 0x73, 0x76, 0x66, 0x66, 0xEE, 0xC8,
  0x71, 0xBC, 0xFF, 0xF9, 0xEC, 0x70,
};

const GFXglyph RobotoCondensed_ExtraBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 6, 0, -15 },
  { 11, 9, 14, 10, 1, -14 },
  { 27, 8, 18, 10, 1, -16 },
  { 45, 11, 14, 13, 1, -14 },
  { 65, 10, 14, 12, 1, -14 },
  { 83, 2, 6, 3, 1, -15 },
  { 85, 5, 20, 6, 1, -16 },
  { 98, 5, 20, 6, 1, -16 },
  { 111, 9, 9, 9, 0, -14 },
  { 122, 8, 11, 9, 1, -12 },
  { 133, 4, 6, 5, 0, -2 },
  { 136, 5, 2, 8, 1, -7 },
  { 138, 4, 3, 6, 1, -3 },
  { 140, 6, 15, 6, 0, -14 },
  { 152, 8, 14, 10, 1, -14 },
  { 166, 5, 14, 10, 2, -14 },
  { 175, 8, 14, 10, 1, -14 },
  { 189, 8, 14, 10, 1, -14 },
  { 203, 8, 14, 10, 1, -14 },
  { 217, 8, 14, 10, 1, -14 },
  { 231, 9, 14, 10, 1, -14 },
  { 247, 8, 14, 10, 1, -14 },
  { 261, 8, 14, 10, 1, -14 },
  { 275, 8, 14, 10, 1, -14 },
  { 289, 4, 11, 6, 1, -11 },
  { 295, 3, 15, 5, 1, -11 },
  { 301, 7, 10, 9, 1, -11 },
  { 310, 8, 6, 10, 1, -9 },
  { 316, 7, 10, 9, 1, -11 },
  { 325, 8, 14, 9, 0, -14 },
  { 339, 14, 18, 15, 1, -14 },
  { 371, 12, 14, 12, 0, -14 },
  { 392, 9, 14, 11, 1, -14 },
  { 408, 10, 14, 11, 1, -14 },
  { 426, 9, 14, 11, 1, -14 },
  { 442, 8, 14, 10, 1, -14 },
  { 456, 8, 14, 10, 1, -14 },
  { 470, 10, 14, 12, 1, -14 },
  { 488, 10, 14, 12, 1, -14 },
  { 506, 3, 14, 6, 1, -14 },
  { 512, 9, 14, 10, 0, -14 },
  { 528, 10, 14, 11, 1, -14 },
  { 546, 8, 14, 10, 1, -14 },
  { 560, 13, 14, 15, 1, -14 },
  { 583, 10, 14, 12, 1, -14 },
  { 601, 10, 14, 12, 1, -14 },
  { 619, 10, 14, 11, 1, -14 },
  { 637, 10, 17, 12, 1, -14 },
  { 659, 10, 14, 11, 1, -14 },
  { 677, 9, 14, 11, 1, -14 },
  { 693, 10, 14, 11, 0, -14 },
  { 711, 9, 14, 11, 1, -14 },
  { 727, 11, 14, 12, 0, -14 },
  { 747, 15, 14, 15, 0, -14 },
  { 774, 11, 14, 11, 0, -14 },
  { 794, 11, 14, 11, 0, -14 },
  { 814, 9, 14, 11, 1, -14 },
  { 830, 4, 20, 5, 1, -17 },
  { 840, 8, 15, 8, 0, -14 },
  { 855, 4, 20, 5, 0, -17 },
  { 865, 8, 7, 8, 0, -14 },
  { 872, 8, 2, 8, 0, 0 },
  { 874, 5, 3, 7, 1, -15 },
  { 876, 8, 11, 9, 1, -11 },
  { 887, 8, 15, 10, 1, -15 },
  { 902, 8, 11, 9, 1, -11 },
  { 913, 8, 15, 10, 1, -15 },
  { 928, 8, 11, 10, 1, -11 },
  { 939, 6, 15, 7, 0, -15 },
  { 951, 8, 15, 10, 1, -11 },
  { 966, 8, 15, 10, 1, -15 },
  { 981, 3, 15, 5, 1, -15 },
  { 987, 5, 19, 5, -1, -15 },
  { 999, 9, 15, 10, 1, -15 },
  { 1016, 3, 15, 5, 1, -15 },
  { 1022, 13, 11, 15, 1, -11 },
  { 1040, 8, 11, 10, 1, -11 },
  { 1051, 8, 11, 10, 1, -11 },
  { 1062, 8, 15, 10, 1, -11 },
  { 1077, 8, 15, 10, 1, -11 },
  { 1092, 5, 11, 7, 1, -11 },
  { 1099, 8, 11, 9, 0, -11 },
  { 1110, 6, 13, 6, 0, -13 },
  { 1120, 8, 11, 10, 1, -11 },
  { 1131, 9, 11, 9, 0, -11 },
  { 1144, 12, 11, 13, 0, -11 },
  { 1161, 9, 11, 9, 0, -11 },
  { 1174, 9, 15, 9, 0, -11 },
  { 1191, 7, 11, 9, 1, -11 },
  { 1201, 4, 20, 6, 1, -16 },
  { 1211, 1, 17, 5, 2, -14 },
  { 1214, 4, 20, 6, 1, -16 },
  { 1224, 9, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBold20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_EXTRABOLD20PT7B_H_
