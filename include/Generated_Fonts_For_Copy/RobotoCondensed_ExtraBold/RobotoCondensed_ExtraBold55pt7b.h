#ifndef _ROBOTOCONDENSED_EXTRABOLD55PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20,
  0xFC, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xF9, 0xF8, 0x10, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x0F,
  0xBE, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFF, 0x3F,
  0xC1, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0xC1, 0xFE, 0x7F, 0xE3, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x30, 0x0F, 0x87, 0xC0, 0xF0, 0x3E, 0x1F, 0x07, 0xC0, 0xF8,
  0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x0F, 0x87, 0xC3, 0xE0, 0x3E, 0x1F,
  0x1F, 0x00, 0xF8, 0x7C, 0x78, 0x03, 0xF3, 0xF3, 0xE0, 0x0F, 0xFF, 0xDF,
  0x00, 0x1F, 0xFE, 0x7C, 0x00, 0x3F, 0xF3, 0xE0, 0x00, 0x7F, 0x8F, 0x80,
  0x00, 0x20, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x20, 0x00, 0x07, 0xCF, 0xF0, 0x00,
  0x3E, 0x7F, 0xF0, 0x00, 0xFB, 0xFF, 0xC0, 0x07, 0xCF, 0xFF, 0x80, 0x1F,
  0x7F, 0x7E, 0x00, 0xF9, 0xF8, 0xFC, 0x03, 0xC7, 0xC3, 0xF0, 0x1F, 0x1F,
  0x07, 0xC0, 0xF8, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xF0, 0x7C, 0x1F, 0x8F, 0xC0, 0xE0, 0x7F, 0x7E, 0x01, 0x80, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x87, 0xF0, 0xFF,
  0xFE, 0x3F, 0x87, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF, 0xCF, 0xE7, 0xFD, 0xFF,
  0x7F, 0x3F, 0xCF, 0xFF, 0xF9, 0xFE, 0x3F, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC,
  0x7F, 0x83, 0xFF, 0xE3, 0xFC, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF,
  0x81, 0xFF, 0x07, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F,
  0xC0, 0x7F, 0xE1, 0xFF, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x18, 0x00, 0x40, 0x20, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x78,
  0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x60,
  0x3C, 0x00, 0x78, 0x3C, 0x1E, 0x7F, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x0F,
  0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x07,
  0x00, 0xE0, 0x02, 0x00, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFC, 0x7F, 0x1F, 0x8F, 0xE1, 0xF0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x1F, 0xE7, 0xFB,
  0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xE7, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03,
  0xFF, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC, 0xFF,
  0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC, 0xFF,
  0x83, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x83, 0xFE, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xF7, 0xF8, 0x03, 0xF7, 0xF8, 0x07, 0xF7, 0xF8, 0x07,
  0xE7, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F,
  0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0x7F,
  0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x9F, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x87, 0xFE, 0x07,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x7F,
  0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xBF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F,
  0xE3, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xF7, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFE, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFE,
  0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFE, 0x1F, 0xF7, 0xFE,
  0x7F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFB, 0xFC, 0x07, 0xC7, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x1F, 0xE7, 0xFB,
  0xFF, 0xFF, 0xDF, 0xE7, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF1, 0xFE, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x1F,
  0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3, 0xFC, 0x7E, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x07, 0xC0,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xEF, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xF3, 0xFE, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xFF, 0xC0, 0xF8, 0xFC,
  0x07, 0xFF, 0x83, 0xE3, 0xE0, 0x3F, 0xFF, 0x0F, 0x8F, 0x81, 0xFF, 0xFC,
  0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0x7D, 0xF0, 0x3F, 0x0F, 0xC1, 0xF7, 0xC0,
  0xF8, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xE0,
  0x7F, 0xF0, 0x7E, 0x0F, 0x81, 0xFF, 0xC3, 0xF0, 0x3E, 0x07, 0xFE, 0x0F,
  0xC0, 0xF8, 0x1F, 0xF8, 0x3F, 0x03, 0xE0, 0x7F, 0xE0, 0xFC, 0x0F, 0x81,
  0xFF, 0x83, 0xF0, 0x3E, 0x07, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0xF8, 0x3F,
  0x07, 0xE0, 0x7B, 0xE0, 0xFC, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x7E, 0x0F,
  0xBF, 0x0F, 0xC1, 0xF8, 0x3C, 0xFC, 0x3F, 0x8F, 0xE1, 0xF3, 0xF0, 0x7F,
  0xFF, 0x8F, 0xC7, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0x07, 0xFF, 0xFF, 0xF0,
  0x7E, 0x0F, 0xF9, 0xFF, 0x81, 0xF8, 0x1F, 0xC3, 0xFC, 0x03, 0xF0, 0x08,
  0x01, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFC,
  0x07, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF,
  0xF0, 0x1F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xFC, 0xFF, 0x01, 0xFF,
  0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF3,
  0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0xEF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x00,
  0xFF, 0xCF, 0xF0, 0x0F, 0xFC, 0xFF, 0x01, 0xFF, 0x8F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0xCF,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0x8F, 0xF0,
  0x1F, 0xF8, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0x7F,
  0xEF, 0xF0, 0x07, 0xFE, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFE, 0x07, 0xEF,
  0xFF, 0xF7, 0xE0, 0xFE, 0xFF, 0xFF, 0x7F, 0x0F, 0xEF, 0xFF, 0xF7, 0xF0,
  0xFC, 0xFF, 0xFF, 0x7F, 0x0F, 0xCF, 0xFF, 0xF3, 0xF1, 0xFC, 0xFF, 0xFF,
  0x3F, 0x9F, 0x8F, 0xFF, 0xF3, 0xF9, 0xF8, 0xFF, 0xFF, 0x1F, 0xBF, 0x8F,
  0xFF, 0xF1, 0xFB, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0x07, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xFF,
  0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF7, 0xE1, 0xFF,
  0xFF, 0x7F, 0x1F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0x3F, 0x9F, 0xFF, 0xF3,
  0xF9, 0xFF, 0xFF, 0x1F, 0xDF, 0xFF, 0xF1, 0xFD, 0xFF, 0xFF, 0x0F, 0xDF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xBF, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00,
  0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xEF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFC, 0x07, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xBF, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xEF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x02,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7,
  0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x3F,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF8,
  0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0x80,
  0x7F, 0xCF, 0xF0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xC7, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xFD,
  0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF,
  0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB,
  0xFE, 0x03, 0xFE, 0x7F, 0xF7, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFB, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE7, 0xF8, 0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x3F, 0xC3, 0xFF, 0x87,
  0xFC, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xF8, 0x7F, 0x87, 0xFC, 0xFF, 0xF8,
  0xFF, 0x07, 0xF9, 0xFF, 0xF3, 0xFC, 0x0F, 0xF3, 0xFF, 0xE7, 0xF8, 0x1F,
  0xE7, 0xFF, 0xCF, 0xF0, 0x3F, 0xCF, 0xFF, 0x9F, 0xE0, 0x7F, 0x9F, 0xBF,
  0xBF, 0xC0, 0xFF, 0x7F, 0x7F, 0x7F, 0x80, 0xFF, 0xFE, 0xFE, 0xFE, 0x01,
  0xFF, 0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xF3,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0x9F,
  0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x01, 0xF9, 0xF8, 0x1F, 0x9F,
  0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x87,
  0xFB, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE,
  0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFB, 0xFC, 0x3F, 0xCF, 0xF0, 0x08,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF3, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0xF7, 0xF8, 0x1F, 0xEF,
  0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0xBF, 0xFC, 0x7F, 0x7F, 0xF0, 0xFE, 0x3F, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF1,
  0xFE, 0xFF, 0x83, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xBF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF,
  0x07, 0xF9, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0x83, 0xFD, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0C,
  0x3F, 0xF0, 0x7C, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFC,
  0x3F, 0xFB, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xBF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xE0, 0xFF, 0x3F, 0xC0, 0x10, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x18, 0x07, 0xFC, 0x3E, 0x7F, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x10, 0x0F, 0xF9, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xF7, 0xFC,
  0x1F, 0xEF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFE, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFE, 0xFF, 0x07, 0xFC, 0xFF,
  0x0F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF,
  0x3F, 0xE0, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xBF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF,
  0x07, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x10, 0x1F, 0xC7, 0xF8, 0x3F, 0xC3, 0xF9, 0xFF,
  0x8F, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xF1, 0xFF,
  0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF,
  0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF,
  0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0xC7, 0xFB, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFE,
  0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x83,
  0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x83, 0xFB, 0xFF, 0x87, 0xF7, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFE,
  0xFF, 0x07, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0,
  0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xE7, 0xF8, 0x3F, 0xC1, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x7F, 0xF7, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF,
  0x7F, 0xC0, 0x20, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x09, 0xFC,
  0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFE,
  0xFF, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF,
  0x7F, 0xEF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0x02, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xF1, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xEF, 0xF0, 0xFF, 0x1F, 0xE0, 0x10, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xE0,
  0x7F, 0xFF, 0x83, 0xF0, 0x3F, 0xBF, 0xC1, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE,
  0x1F, 0xE7, 0xF0, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0x87, 0xF9, 0xFE, 0x3F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xF1, 0xFC, 0x3F, 0x9F, 0xF8, 0xFE, 0x1F, 0xCF,
  0xFC, 0xFF, 0x0F, 0xE7, 0xFF, 0x7F, 0x87, 0xF3, 0xFF, 0xBF, 0x83, 0xF9,
  0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xFD, 0xF7, 0xF0, 0x3F,
  0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x03,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x7F, 0x83, 0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFC, 0x3F, 0xE7, 0xF8,
  0x1F, 0xE7, 0xF8, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xE7, 0xF8, 0x3F, 0xC7, 0xF8,
  0x7F, 0xC7, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F,
  0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF9, 0xFF, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10,
  0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x03, 0x80, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xF8, 0x0F, 0xCF, 0xFE, 0x07, 0xEF, 0xFF, 0x87, 0xF7, 0xFF, 0xE3,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0xFC, 0x1F,
  0xFE, 0x7E, 0x07, 0xFE, 0x3E, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 40, 14, 3, -39 },
  { 46, 15, 15, 18, 1, -41 },
  { 75, 25, 39, 29, 2, -39 },
  { 197, 24, 52, 28, 2, -46 },
  { 353, 30, 41, 35, 3, -40 },
  { 507, 29, 41, 32, 2, -40 },
  { 656, 7, 15, 9, 1, -41 },
  { 670, 13, 55, 18, 3, -43 },
  { 760, 14, 55, 18, 1, -43 },
  { 857, 24, 24, 25, 1, -39 },
  { 929, 22, 28, 26, 2, -32 },
  { 1006, 10, 17, 14, 1, -7 },
  { 1028, 13, 7, 21, 4, -20 },
  { 1040, 10, 9, 16, 3, -8 },
  { 1052, 17, 42, 18, 0, -39 },
  { 1142, 24, 41, 28, 2, -40 },
  { 1265, 16, 39, 28, 4, -39 },
  { 1343, 24, 40, 28, 2, -40 },
  { 1463, 24, 41, 28, 2, -40 },
  { 1586, 24, 39, 28, 2, -39 },
  { 1703, 24, 40, 28, 2, -39 },
  { 1823, 24, 40, 28, 2, -39 },
  { 1943, 24, 39, 28, 2, -39 },
  { 2060, 22, 41, 28, 3, -40 },
  { 2173, 23, 40, 28, 2, -40 },
  { 2288, 10, 31, 16, 3, -30 },
  { 2327, 10, 40, 15, 2, -30 },
  { 2377, 19, 27, 25, 2, -30 },
  { 2442, 21, 19, 28, 3, -27 },
  { 2492, 20, 27, 25, 3, -30 },
  { 2560, 22, 41, 25, 1, -40 },
  { 2673, 38, 50, 42, 2, -38 },
  { 2911, 33, 39, 33, 0, -39 },
  { 3072, 26, 39, 31, 3, -39 },
  { 3199, 28, 41, 31, 2, -40 },
  { 3343, 26, 39, 31, 3, -39 },
  { 3470, 23, 39, 27, 3, -39 },
  { 3583, 22, 39, 26, 3, -39 },
  { 3691, 28, 41, 32, 2, -40 },
  { 3835, 28, 39, 34, 3, -39 },
  { 3972, 9, 39, 15, 3, -39 },
  { 4016, 23, 40, 27, 1, -39 },
  { 4131, 28, 39, 31, 3, -39 },
  { 4268, 22, 39, 26, 3, -39 },
  { 4376, 36, 39, 42, 3, -39 },
  { 4552, 28, 39, 34, 3, -39 },
  { 4689, 29, 41, 33, 2, -40 },
  { 4838, 26, 39, 31, 3, -39 },
  { 4965, 29, 47, 33, 2, -40 },
  { 5136, 27, 39, 31, 3, -39 },
  { 5268, 26, 41, 30, 2, -40 },
  { 5402, 28, 39, 30, 1, -39 },
  { 5539, 26, 40, 32, 3, -39 },
  { 5669, 32, 39, 32, 0, -39 },
  { 5825, 39, 39, 41, 1, -39 },
  { 6016, 29, 39, 31, 1, -39 },
  { 6158, 30, 39, 30, 0, -39 },
  { 6305, 26, 39, 29, 2, -39 },
  { 6432, 11, 55, 15, 3, -46 },
  { 6508, 22, 42, 21, 0, -39 },
  { 6624, 11, 55, 15, 1, -46 },
  { 6700, 20, 20, 22, 1, -39 },
  { 6750, 20, 6, 22, 1, 0 },
  { 6765, 15, 8, 18, 1, -41 },
  { 6780, 22, 31, 26, 2, -30 },
  { 6866, 23, 42, 27, 3, -41 },
  { 6987, 22, 31, 25, 2, -30 },
  { 7073, 23, 42, 27, 2, -41 },
  { 7194, 23, 31, 26, 2, -30 },
  { 7284, 17, 42, 18, 1, -42 },
  { 7374, 23, 41, 28, 2, -30 },
  { 7492, 23, 41, 27, 2, -41 },
  { 7610, 8, 40, 14, 3, -40 },
  { 7650, 13, 51, 14, -2, -40 },
  { 7733, 24, 41, 27, 3, -41 },
  { 7856, 8, 41, 14, 3, -41 },
  { 7897, 35, 30, 41, 3, -30 },
  { 8029, 23, 30, 27, 2, -30 },
  { 8116, 24, 31, 27, 2, -30 },
  { 8209, 23, 41, 27, 3, -30 },
  { 8327, 23, 41, 27, 2, -30 },
  { 8445, 15, 30, 19, 3, -30 },
  { 8502, 22, 31, 25, 1, -30 },
  { 8588, 15, 37, 17, 1, -36 },
  { 8658, 23, 30, 27, 2, -29 },
  { 8745, 23, 29, 25, 1, -29 },
  { 8829, 33, 29, 35, 1, -29 },
  { 8949, 24, 29, 25, 1, -29 },
  { 9036, 25, 40, 25, 0, -29 },
  { 9161, 21, 29, 25, 2, -29 },
  { 9238, 14, 53, 16, 1, -43 },
  { 9331, 4, 46, 14, 5, -39 },
  { 9354, 13, 53, 16, 2, -43 },
  { 9441, 25, 12, 30, 3, -22 },
};

const GFXfont RobotoCondensed_ExtraBold55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_EXTRABOLD55PT7B_H_
