#ifndef _ROBOTOCONDENSED_EXTRABOLD8PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF0, 0x46, 0xF6, 0x66, 0x06, 0x74, 0x2D, 0x60, 0x45,
  0x98, 0x66, 0x8C, 0x63, 0x18, 0xEB, 0x38, 0xC0, 0x56, 0x94, 0x95, 0x56,
  0x0C, 0x62, 0x44, 0xF4, 0x60, 0xC0, 0xC0, 0x15, 0xA0, 0x67, 0xDD, 0xF6,
  0x75, 0x50, 0x6F, 0x32, 0x4F, 0x6F, 0x26, 0x96, 0x22, 0x66, 0xF2, 0x74,
  0xE3, 0xD6, 0x24, 0xED, 0xD6, 0xF3, 0x22, 0x44, 0x6F, 0x66, 0xF6, 0x6F,
  0xF7, 0x26, 0x41, 0xC1, 0x40, 0x79, 0x80, 0xF0, 0xF0, 0xC7, 0x80, 0x74,
  0xA0, 0x80, 0x21, 0x27, 0x6D, 0xB6, 0xE4, 0x0C, 0x23, 0x14, 0xA7, 0x6C,
  0xED, 0xDF, 0xDF, 0x65, 0xCC, 0xD7, 0xED, 0xDD, 0xDE, 0xFC, 0xCE, 0xCF,
  0xFC, 0xCE, 0xCC, 0x75, 0xCF, 0xD7, 0xDD, 0xDF, 0xDD, 0xFF, 0xF0, 0x33,
  0x33, 0xB6, 0xDF, 0xEE, 0xFD, 0xCC, 0xCC, 0xCF, 0xCF, 0x3F, 0x7F, 0xFF,
  0xF0, 0xDD, 0xFF, 0xDD, 0x65, 0xDD, 0xD7, 0xED, 0xDF, 0xCC, 0x62, 0xB5,
  0xBD, 0x38, 0x40, 0xED, 0xDF, 0xFD, 0x6D, 0x43, 0xD7, 0xF2, 0x22, 0x22,
  0xDD, 0xDD, 0xD7, 0x9E, 0x94, 0xA6, 0x10, 0xB7, 0xF7, 0x9E, 0x79, 0xE0,
  0xD5, 0x66, 0x7D, 0x95, 0x66, 0x22, 0xF3, 0x26, 0x4F, 0xFF, 0xFF, 0x99,
  0x26, 0x40, 0xD5, 0x57, 0x4A, 0x80, 0xE0, 0x40, 0xE6, 0xAE, 0xCC, 0xFD,
  0xDE, 0xF2, 0x30, 0x33, 0xFB, 0xB7, 0x6F, 0xC7, 0x6B, 0x24, 0x80, 0xFB,
  0xB7, 0x36, 0xCC, 0xEF, 0xFF, 0xCF, 0xF0, 0xCF, 0xFE, 0xCC, 0xEE, 0xEF,
  0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0x69, 0x96, 0xFD, 0xDE, 0xCC,
  0xFB, 0xB7, 0x33, 0xFB, 0x60, 0xF8, 0xF0, 0x75, 0x40, 0xFF, 0xF7, 0xA6,
  0x66, 0xAF, 0x54, 0xA0, 0xE6, 0x6E, 0xA6, 0x66, 0x44, 0xED, 0x70, 0x56,
  0x54, 0x7E, 0x95, 0x58, 0x70,
};

const GFXglyph RobotoCondensed_ExtraBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 1, 0, -6 },
  { 20, 2, 8, 3, 0, -6 },
  { 22, 2, 8, 3, 0, -6 },
  { 24, 4, 4, 4, 0, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 2, 2, 2, 0, -1 },
  { 29, 2, 1, 3, 1, -3 },
  { 30, 2, 1, 2, 0, -1 },
  { 31, 2, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 3, 6, 4, 0, -6 },
  { 74, 6, 8, 6, 0, -6 },
  { 80, 5, 6, 5, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 4, 6, 5, 0, -6 },
  { 105, 2, 6, 2, 0, -6 },
  { 107, 4, 6, 4, 0, -6 },
  { 110, 4, 6, 4, 0, -6 },
  { 113, 4, 6, 4, 0, -6 },
  { 116, 6, 6, 6, 0, -6 },
  { 121, 4, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 0, -6 },
  { 130, 5, 7, 5, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 5, 0, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 6, 6, 6, 0, -6 },
  { 156, 4, 6, 5, 0, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 2, 8, 2, 0, -7 },
  { 167, 3, 6, 3, 0, -6 },
  { 170, 2, 8, 2, 0, -7 },
  { 172, 3, 3, 3, 0, -6 },
  { 174, 3, 1, 3, 0, 0 },
  { 175, 2, 1, 3, 0, -6 },
  { 176, 4, 4, 4, 0, -4 },
  { 178, 4, 6, 4, 0, -6 },
  { 181, 3, 4, 4, 0, -4 },
  { 183, 4, 6, 4, 0, -6 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 3, 6, 3, 0, -6 },
  { 191, 4, 6, 4, 0, -4 },
  { 194, 4, 6, 4, 0, -6 },
  { 197, 2, 6, 2, 0, -6 },
  { 199, 2, 8, 2, 0, -6 },
  { 201, 4, 6, 4, 0, -6 },
  { 204, 2, 6, 2, 0, -6 },
  { 206, 6, 4, 6, 0, -4 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 4, 6, 4, 0, -4 },
  { 219, 3, 4, 3, 0, -4 },
  { 221, 3, 4, 4, 0, -4 },
  { 223, 2, 5, 2, 0, -5 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 4, 4, 0, -4 },
  { 229, 5, 4, 5, 0, -4 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 4, 6, 4, 0, -4 },
  { 237, 3, 4, 4, 0, -4 },
  { 239, 2, 7, 2, 0, -6 },
  { 241, 1, 7, 2, 1, -6 },
  { 242, 2, 7, 2, 0, -6 },
  { 244, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_ExtraBold8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_EXTRABOLD8PT7B_H_
