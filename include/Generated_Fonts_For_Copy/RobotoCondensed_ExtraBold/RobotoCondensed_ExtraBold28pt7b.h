#ifndef _ROBOTOCONDENSED_EXTRABOLD28PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x73,
  0xDE, 0xE0, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0x0E, 0xE0, 0x77,
  0x03, 0x38, 0x19, 0x80, 0xCC, 0x06, 0x61, 0xFF, 0xEF, 0xFF, 0x1D, 0xC0,
  0xCE, 0x06, 0x60, 0x33, 0x0F, 0xFF, 0x7F, 0xF8, 0xEE, 0x07, 0x70, 0x33,
  0x81, 0x98, 0x0C, 0xC0, 0x66, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0xF8,
  0x3F, 0xC3, 0xFE, 0x7D, 0xF7, 0x8F, 0x78, 0xF7, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0xDF,
  0x7F, 0xE3, 0xFC, 0x0F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0x7E,
  0x00, 0xFF, 0x10, 0xE7, 0x38, 0xE7, 0x30, 0xE7, 0x70, 0xFF, 0x60, 0x7E,
  0xE0, 0x3C, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xBC, 0x07, 0x7E, 0x06,
  0xFE, 0x0E, 0xE7, 0x0C, 0xE7, 0x1C, 0xE7, 0x18, 0xFE, 0x00, 0x7E, 0x00,
  0x3C, 0x0F, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xEF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x70, 0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xFC, 0xF3, 0xFD, 0xEF,
  0x7F, 0xDE, 0x7F, 0x3C, 0xFE, 0x78, 0xFC, 0xFB, 0xF0, 0xFF, 0xF1, 0xFF,
  0xF0, 0xF9, 0xF0, 0xFF, 0xFF, 0xFE, 0x04, 0x31, 0xCE, 0x39, 0xC7, 0x3C,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x0E,
  0x38, 0x70, 0xC1, 0x81, 0xC3, 0x83, 0x87, 0x87, 0x0E, 0x1E, 0x1C, 0x38,
  0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x3C,
  0x71, 0xC3, 0x84, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xCE, 0x27, 0xBF,
  0x7F, 0xFC, 0x3F, 0x01, 0xF0, 0x1D, 0xC1, 0xEE, 0x0E, 0x38, 0x20, 0x80,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x7B, 0xDE, 0xE7, 0x3B,
  0xDC, 0x40, 0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x0F, 0x83, 0xFC, 0x3F,
  0xE7, 0xDE, 0x79, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x9F, 0x7F, 0xE3, 0xFE, 0x3F,
  0xC0, 0xF8, 0x03, 0x0F, 0x7F, 0xFF, 0xFF, 0xCF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0xFE, 0xF9, 0xFF, 0x1F, 0xF1, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xBE, 0xF1, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC1, 0xF0, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xE3,
  0xBE, 0x7B, 0xE7, 0x3E, 0xF3, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x71, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0xF8, 0x03, 0xC0,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3C, 0x07, 0x80, 0x78, 0x07, 0xBC, 0xFF, 0xEF,
  0xFE, 0xFD, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x7D, 0xF3,
  0xFE, 0x3F, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0xFE, 0x79, 0xF7, 0x9F, 0x79, 0xE7, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0xE7, 0x9E, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7,
  0xFE, 0x3F, 0xC1, 0xF8, 0x0F, 0x03, 0xFC, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x9F, 0x7F, 0xF3, 0xFF, 0x1E, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x1F, 0xC1, 0xF8, 0x1F, 0x01, 0xC0, 0xF7, 0xBC,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x79, 0xC0, 0x7B, 0xDE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0x7B, 0x9D, 0xC6, 0x00, 0x00, 0x40,
  0x70, 0x7C, 0x7F, 0xFF, 0xBF, 0x0F, 0x03, 0xF0, 0xFF, 0x87, 0xF0, 0x7C,
  0x07, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x3C,
  0x7F, 0x7F, 0xBF, 0x8F, 0x83, 0x80, 0x80, 0x00, 0x1F, 0x0F, 0xF3, 0xFF,
  0x7F, 0xEF, 0x3F, 0xE7, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x06, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x7E, 0x0F, 0x01, 0xC3, 0x80, 0x1C,
  0x70, 0x01, 0x9C, 0x1E, 0x3B, 0x8F, 0xE3, 0x63, 0xFC, 0x7C, 0x73, 0x8F,
  0x8E, 0x71, 0xF3, 0x8E, 0x3E, 0x71, 0xC7, 0xCE, 0x38, 0xF9, 0xC7, 0x3F,
  0x39, 0xE7, 0xE7, 0xFD, 0xDC, 0x7F, 0xF1, 0xC7, 0x3C, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xEF, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7C, 0x1F,
  0x3C, 0x0F, 0x9E, 0x03, 0xDF, 0x01, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x7B, 0xE1, 0xEF, 0x87, 0xBE, 0x3E, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFF, 0xBE, 0x1E, 0xF8, 0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F,
  0xFE, 0x78, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x83, 0xDE, 0x1F, 0x7F, 0xF8,
  0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC,
  0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xEF, 0x87, 0xBE, 0x3E, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x78,
  0x7D, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF8, 0x3F, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0x81, 0xF8, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFC, 0x7F,
  0x8F, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0x80, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3,
  0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3C, 0x3E, 0xF8, 0x7F, 0xE0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xBE, 0x3E, 0x7C, 0x7C,
  0x78, 0xF8, 0xF9, 0xF1, 0xF3, 0xE1, 0xF7, 0xC3, 0xE0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xF7, 0x1D,
  0xFF, 0xE3, 0xBF, 0xFE, 0xF7, 0xFD, 0xDC, 0xFF, 0xBB, 0x9F, 0xF7, 0xF7,
  0xFE, 0xFE, 0xFF, 0xCF, 0x9F, 0xF9, 0xF3, 0xFF, 0x3E, 0x7F, 0xE3, 0xCF,
  0xFC, 0x71, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0xBF, 0xF7, 0x7F, 0xEE, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xE7, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x3C, 0x3E, 0x7F,
  0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x3C, 0x3E,
  0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x00, 0x04, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7B,
  0xE1, 0xEF, 0x87, 0xFE, 0x1E, 0xF8, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xE3, 0xE7, 0x8F, 0x9F, 0x3E, 0x3C, 0xF8, 0xFB, 0xE3, 0xEF, 0x87,
  0xFE, 0x1F, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x87, 0xFC, 0x3F,
  0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFF, 0x0F, 0x7F, 0xFB, 0xFF, 0x8F, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xDE, 0x1E, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3E,
  0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0xF1, 0xE1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF, 0x9F,
  0x3F, 0xF3, 0xE7, 0x9E, 0xFC, 0xF3, 0xDF, 0xDE, 0x7B, 0xFB, 0xCF, 0x7F,
  0x79, 0xEE, 0xEF, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xCF,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x80, 0x7C, 0x3E, 0xF8, 0x7C, 0xF1, 0xF1, 0xF3, 0xE1, 0xE7, 0x83, 0xDF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFF, 0x03, 0xFE, 0x07, 0xBE, 0x1F, 0x3C, 0x3E, 0x7C, 0xF8, 0xF9, 0xF0,
  0xFB, 0xC1, 0xF0, 0xF8, 0x3E, 0xF0, 0x7D, 0xF0, 0xF1, 0xE3, 0xE3, 0xC7,
  0x87, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xFF, 0xFF, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xFF, 0x1C, 0x07, 0x83, 0xE0, 0xF8, 0x37, 0x1D, 0xC7, 0x73,
  0xCE, 0xE3, 0xB8, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0xF0, 0xF0,
  0xF0, 0x1F, 0x0F, 0xF9, 0xFF, 0x7D, 0xFF, 0x1E, 0x03, 0xC7, 0xFB, 0xFF,
  0xF9, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0xFE, 0xFF, 0xCF, 0x78, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0xCF, 0xFE, 0xFF, 0xEF,
  0xDF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFE, 0xF7, 0xC0, 0x1F, 0x07, 0xF9, 0xFF, 0x7D, 0xFF,
  0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xFD, 0xF7, 0xFE,
  0x7F, 0x87, 0xC0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x3D, 0xF7, 0xFF, 0x7F, 0xFF, 0xBF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xBF, 0x7F, 0xF7, 0xEF, 0x3C, 0xF0, 0x1F,
  0x83, 0xFC, 0x7F, 0xE7, 0xBE, 0xF1, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xDE, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0x07, 0x8F,
  0xC7, 0xE7, 0xE3, 0xC1, 0xE3, 0xFF, 0xFF, 0xFF, 0x9E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1E, 0xF7,
  0xFF, 0x7F, 0xFF, 0xDF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x1E, 0xF0, 0x0F, 0x01, 0xF3,
  0x1E, 0x7F, 0xE7, 0xFC, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF3, 0x8F, 0xFE, 0xFF, 0xEF, 0xBE, 0xF1, 0xEF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xF0, 0x77, 0xFE, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x07, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF,
  0x9F, 0xFD, 0xFB, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE7, 0xDF, 0x7C, 0xFB, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFB, 0xC7, 0xDF, 0x3E, 0x79, 0xF3,
  0xEF, 0x8F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF3, 0xCF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF9,
  0xE3, 0xFE, 0x78, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x78,
  0xFF, 0x9E, 0x3C, 0xF3, 0xCF, 0xFE, 0xFF, 0xEF, 0xBE, 0xF1, 0xEF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xBE, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0xF7, 0x8F, 0xFE, 0xFF, 0xEF, 0xDF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xDF, 0xFF, 0xEF, 0xFE, 0xF7, 0x8F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0xF7, 0xEF,
  0x7F, 0xFF, 0xBF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0xBF, 0x7F, 0xF7, 0xFF, 0x3D, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xF7, 0xF7, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x0F, 0xF9, 0xFF,
  0x79, 0xFF, 0x1F, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFC, 0xFF, 0x87, 0xC0, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3F, 0x1F, 0x0F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0xBF, 0x7F, 0xF7, 0xEF, 0x3C, 0xF0, 0xF8, 0xF7,
  0x8F, 0x78, 0xF7, 0x9E, 0x79, 0xE3, 0xDE, 0x3D, 0xE3, 0xDC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x71, 0xC7, 0xBC,
  0xF3, 0xDE, 0x79, 0xEF, 0x3C, 0xE7, 0xBE, 0x71, 0xDF, 0x78, 0xEF, 0xFC,
  0x77, 0xFE, 0x3F, 0x7F, 0x1F, 0xBF, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3,
  0xE0, 0xF1, 0xF0, 0x78, 0x70, 0x78, 0xF7, 0xDF, 0x3D, 0xE3, 0xDE, 0x1F,
  0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0xC3, 0xDE, 0x3D,
  0xE7, 0x9F, 0x78, 0xF0, 0xF8, 0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xE7, 0xDE,
  0x1E, 0xF0, 0xF7, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x04, 0x38, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1C,
  0x3C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC3, 0xC3,
  0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xE3, 0xCF, 0x9C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xC3, 0x00, 0x3C, 0x3B, 0xF1,
  0xDF, 0xFF, 0xEF, 0xEE, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 7, 1, -20 },
  { 14, 7, 8, 9, 1, -21 },
  { 21, 13, 20, 15, 1, -20 },
  { 54, 12, 26, 14, 1, -23 },
  { 93, 16, 20, 18, 1, -20 },
  { 133, 15, 20, 16, 1, -20 },
  { 171, 3, 8, 4, 1, -21 },
  { 174, 6, 28, 9, 2, -22 },
  { 195, 7, 28, 9, 1, -22 },
  { 220, 13, 12, 13, 0, -20 },
  { 240, 11, 14, 13, 1, -16 },
  { 260, 5, 9, 7, 1, -3 },
  { 266, 7, 3, 11, 2, -10 },
  { 269, 4, 4, 8, 2, -4 },
  { 271, 9, 22, 9, 0, -20 },
  { 296, 12, 20, 14, 1, -20 },
  { 326, 8, 20, 14, 2, -20 },
  { 346, 12, 20, 14, 1, -20 },
  { 376, 12, 20, 14, 1, -20 },
  { 406, 12, 20, 14, 1, -20 },
  { 436, 12, 20, 14, 1, -20 },
  { 466, 12, 20, 14, 1, -20 },
  { 496, 12, 20, 14, 1, -20 },
  { 526, 12, 20, 14, 1, -20 },
  { 556, 12, 20, 14, 1, -20 },
  { 586, 5, 15, 8, 2, -15 },
  { 596, 5, 21, 7, 1, -15 },
  { 610, 10, 13, 13, 1, -15 },
  { 627, 10, 9, 14, 2, -13 },
  { 639, 10, 13, 13, 2, -15 },
  { 656, 11, 20, 13, 1, -20 },
  { 684, 19, 25, 21, 1, -19 },
  { 744, 17, 20, 17, 0, -20 },
  { 787, 14, 20, 16, 1, -20 },
  { 822, 14, 20, 16, 1, -20 },
  { 857, 14, 20, 16, 1, -20 },
  { 892, 12, 20, 14, 1, -20 },
  { 922, 12, 20, 13, 1, -20 },
  { 952, 14, 20, 16, 1, -20 },
  { 987, 15, 20, 17, 1, -20 },
  { 1025, 4, 20, 8, 2, -20 },
  { 1035, 11, 20, 14, 1, -20 },
  { 1063, 15, 20, 16, 1, -20 },
  { 1101, 12, 20, 13, 1, -20 },
  { 1131, 19, 20, 21, 1, -20 },
  { 1179, 15, 20, 17, 1, -20 },
  { 1217, 15, 20, 17, 1, -20 },
  { 1255, 14, 20, 16, 1, -20 },
  { 1290, 15, 24, 17, 1, -20 },
  { 1335, 14, 20, 16, 1, -20 },
  { 1370, 13, 20, 15, 1, -20 },
  { 1403, 14, 20, 15, 1, -20 },
  { 1438, 14, 20, 16, 1, -20 },
  { 1473, 16, 20, 16, 0, -20 },
  { 1513, 19, 20, 21, 1, -20 },
  { 1561, 15, 20, 16, 0, -20 },
  { 1599, 15, 20, 15, 0, -20 },
  { 1637, 13, 20, 15, 1, -20 },
  { 1670, 6, 28, 7, 1, -23 },
  { 1691, 11, 22, 11, 0, -20 },
  { 1722, 6, 28, 7, 0, -23 },
  { 1743, 10, 10, 11, 1, -20 },
  { 1756, 11, 3, 11, 0, 0 },
  { 1761, 7, 4, 9, 1, -21 },
  { 1765, 11, 15, 13, 1, -15 },
  { 1786, 12, 21, 14, 1, -21 },
  { 1818, 11, 15, 13, 1, -15 },
  { 1839, 12, 21, 14, 1, -21 },
  { 1871, 12, 15, 13, 1, -15 },
  { 1894, 9, 21, 9, 0, -21 },
  { 1918, 12, 21, 14, 1, -15 },
  { 1950, 12, 21, 14, 1, -21 },
  { 1982, 5, 21, 7, 1, -21 },
  { 1996, 7, 27, 7, -1, -21 },
  { 2020, 13, 21, 14, 1, -21 },
  { 2055, 5, 21, 7, 1, -21 },
  { 2069, 18, 15, 21, 1, -15 },
  { 2103, 12, 15, 14, 1, -15 },
  { 2126, 12, 15, 14, 1, -15 },
  { 2149, 12, 21, 14, 1, -15 },
  { 2181, 12, 21, 14, 1, -15 },
  { 2213, 8, 15, 9, 1, -15 },
  { 2228, 11, 15, 13, 1, -15 },
  { 2249, 8, 18, 9, 0, -18 },
  { 2267, 12, 15, 14, 1, -15 },
  { 2290, 12, 15, 13, 0, -15 },
  { 2313, 17, 15, 18, 0, -15 },
  { 2345, 12, 15, 13, 0, -15 },
  { 2368, 13, 21, 13, 0, -15 },
  { 2403, 11, 15, 13, 1, -15 },
  { 2424, 7, 27, 8, 1, -22 },
  { 2448, 3, 24, 7, 2, -20 },
  { 2457, 7, 27, 8, 1, -22 },
  { 2481, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBold28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_EXTRABOLD28PT7B_H_
