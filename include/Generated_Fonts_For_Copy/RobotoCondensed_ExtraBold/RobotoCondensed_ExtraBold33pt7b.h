#ifndef _ROBOTOCONDENSED_EXTRABOLD33PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1D, 0xFF, 0xFD, 0xC0, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x77, 0x3B, 0x9D,
  0xCE, 0xE7, 0x00, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x77,
  0x01, 0xCE, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1C, 0xE0, 0x39, 0xC0,
  0x77, 0x01, 0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x39,
  0xC0, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0x9F,
  0x9F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0x7D,
  0xF1, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0x9C, 0x30, 0xE7,
  0x1C, 0x39, 0xC6, 0x0E, 0x73, 0x83, 0x9D, 0xC0, 0xFF, 0x70, 0x1F, 0xB8,
  0x03, 0xCE, 0x00, 0x07, 0x00, 0x01, 0xDE, 0x00, 0xEF, 0xE0, 0x77, 0xF8,
  0x1D, 0xCF, 0x0E, 0x73, 0xC3, 0x9C, 0x71, 0xC7, 0x3C, 0x71, 0xCF, 0x08,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x3C, 0x3F, 0xCF, 0x1F,
  0xFB, 0xCF, 0xBF, 0xF3, 0xE7, 0xFC, 0xF8, 0xFF, 0x3E, 0x3F, 0x8F, 0xC7,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xF8, 0xF8, 0xFF, 0xFE,
  0xEE, 0xEE, 0xE0, 0x02, 0x06, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0x06, 0x02,
  0x40, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xE0, 0x40, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x02, 0x1C, 0x07, 0x38, 0xCF, 0xBF, 0xDF, 0xFF, 0x87, 0xF8,
  0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC0, 0xE3, 0xC1, 0xC3, 0x81, 0x04, 0x00,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x7B, 0xDE, 0xF7, 0xBD, 0xFE, 0xF3, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xEF, 0xFE, 0x78, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7C, 0xFD, 0xF1, 0xF7,
  0xC7, 0xDE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xDE, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xCF, 0xCF, 0xFE,
  0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x01, 0x87, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x07, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9F, 0xFE, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xE1, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0xDF, 0xFF,
  0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1E, 0xF8, 0x3D,
  0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x18,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF7, 0xC7, 0xDF,
  0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x83, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7D, 0xE0,
  0xF7, 0xF1, 0xFF, 0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xFE, 0x0F, 0xBC,
  0x1F, 0x7C, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xFD, 0xFF, 0xEF, 0x9F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xF3, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC7, 0xFF, 0x7C, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF,
  0xC7, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0x07, 0xC0,
  0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x7C, 0xF9, 0xF1, 0xF7, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xC3, 0xDF, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x07, 0xFC, 0x1F, 0xE0, 0x7E,
  0x01, 0xE0, 0x00, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xBF, 0xF9, 0xE0, 0x3D, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xCF, 0x3C, 0xF3, 0xDF, 0x79, 0xEF, 0x08, 0x00,
  0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xF7, 0xFC, 0xFF, 0x0F, 0xC0, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0xFF, 0x7F, 0xEF, 0xF8, 0xFE,
  0x0F, 0x80, 0xE0, 0x08, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF,
  0x9F, 0xFC, 0x7F, 0xE3, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x07, 0x80, 0xE0, 0x07, 0x83, 0x80, 0x07,
  0x0F, 0x00, 0x07, 0x1C, 0x1F, 0x0E, 0x78, 0x7F, 0x9C, 0xE1, 0xFF, 0x1D,
  0xC3, 0x8E, 0x3B, 0x8F, 0x3C, 0x7F, 0x1C, 0x78, 0xFE, 0x78, 0xF1, 0xF8,
  0xF1, 0xE3, 0xF1, 0xE3, 0x87, 0xE3, 0xC7, 0x0F, 0xC7, 0x8E, 0x1F, 0x8F,
  0x1C, 0x77, 0x9E, 0x78, 0xE7, 0x1F, 0xFF, 0x8E, 0x3F, 0x7E, 0x1C, 0x3C,
  0x78, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x04,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xBE, 0x00, 0x79, 0xE0, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7C,
  0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xE3, 0xF3, 0xE0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x8F, 0xC7, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF,
  0xCF, 0x8F, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0xC7, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8,
  0xFB, 0xE3, 0xEF, 0xCF, 0xBF, 0xFE, 0x7F, 0xF0, 0xFF, 0x80, 0xF8, 0x00,
  0xF8, 0x3F, 0x7C, 0x3F, 0xBE, 0x1F, 0x9F, 0x1F, 0x8F, 0x8F, 0xC7, 0xCF,
  0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0xCF, 0x87, 0xE7, 0xC1, 0xFB, 0xE0,
  0xFC, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0x7F, 0xBC, 0x7B, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xBD,
  0xEF, 0xFD, 0xEF, 0x7F, 0xEF, 0x7B, 0xFF, 0x7B, 0x9F, 0xF9, 0xFC, 0xFF,
  0xCF, 0xE7, 0xFE, 0x7F, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C,
  0x7F, 0xE1, 0xC3, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0x9F,
  0xFB, 0xDF, 0xFB, 0xDF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x3F, 0x1F, 0x07, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE3, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x3F, 0x9F, 0x07, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F,
  0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE3, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xF9,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8,
  0x3E, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E,
  0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xFF,
  0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xEF, 0x80, 0xFD,
  0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0x8F, 0x80,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC7,
  0xE3, 0xEF, 0x8F, 0xC7, 0xCF, 0x9F, 0x8F, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F,
  0x3E, 0x7C, 0xFE, 0x7C, 0xFB, 0xFD, 0xF1, 0xF7, 0xFB, 0xE1, 0xEF, 0xFF,
  0xC3, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x0F, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8,
  0x1F, 0xCF, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xDF,
  0x83, 0xE3, 0xE1, 0xF8, 0xFC, 0x7C, 0x1F, 0x1F, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xBE, 0x07,
  0xCF, 0x81, 0xF3, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x9F, 0x83, 0xE7, 0xC0,
  0xFC, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC3, 0xF8, 0x77, 0x0E, 0xF3, 0xDE, 0x71, 0xCE, 0x3F,
  0xC7, 0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C,
  0x3E, 0x1F, 0x0F, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xF8, 0xFB,
  0xE3, 0xE0, 0x0F, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x8F, 0xBE, 0x3E,
  0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x1E, 0xF8, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF3, 0xC7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xDE, 0xFE,
  0xF3, 0xC0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xFF, 0x8F, 0xBF,
  0xFD, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x7C, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0x7C, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x7F, 0xE1,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x7C,
  0x31, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x03, 0xE1, 0xFC, 0x7F,
  0x8F, 0xF1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x1F, 0x3C, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F,
  0x7C, 0x01, 0xF0, 0x07, 0xC4, 0x3F, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF9, 0xE3, 0xEF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0xF7, 0xFF, 0xF7,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3F, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xFB, 0xC7,
  0xEF, 0x3F, 0x3C, 0xF8, 0xF7, 0xE3, 0xDF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFE, 0x3E, 0xF8, 0xF3, 0xF3, 0xC7, 0xCF, 0x1F, 0xBC,
  0x3E, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF3, 0xC3, 0xC7, 0xBF, 0xBF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x9F, 0x9F, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F,
  0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F,
  0x1F, 0xF8, 0xF8, 0xF8, 0xF9, 0xE3, 0xEF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFC,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0x7D, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFC, 0x0F, 0xC0, 0xF3, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xDE, 0xFE, 0xF3, 0xC7, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x7C, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x0F, 0x81, 0xFF,
  0x1F, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0xE1, 0xFF, 0x8F, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC, 0x1F,
  0xC0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x3F, 0xEF, 0xFB, 0xFE, 0xFF,
  0x8F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0x7C, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0xFC,
  0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE3, 0xC7, 0x87, 0xDF, 0x0F, 0xBE,
  0x1F, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0xE3, 0xFE, 0x3C, 0x7F,
  0xE7, 0xCF, 0xFC, 0xF9, 0xFF, 0x9F, 0x3C, 0xF7, 0xE7, 0x9E, 0xFE, 0xF3,
  0xDF, 0xFE, 0x7B, 0xBF, 0xCF, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0x9F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x0F, 0x00,
  0x7C, 0x7C, 0xF8, 0xF8, 0xFB, 0xE1, 0xF7, 0xC1, 0xFF, 0x03, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF,
  0x87, 0xDF, 0x0F, 0xBE, 0x3E, 0x3E, 0x7C, 0x7C, 0xFC, 0x7E, 0xF8, 0xF9,
  0xF1, 0xF3, 0xE3, 0xE3, 0xCF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1E,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x0E, 0x1F,
  0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xF8,
  0xF8, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x1E, 0x1F, 0x0E, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x40, 0xF0, 0xF0, 0x78, 0x78, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F, 0x0F, 0x1F, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0x40,
  0x3C, 0x00, 0xFE, 0x3F, 0xFE, 0x77, 0xFF, 0xEF, 0x3F, 0xDC, 0x3F, 0x00,
  0x3C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 9, 9, 11, 1, -25 },
  { 27, 15, 23, 17, 1, -23 },
  { 71, 14, 29, 17, 1, -26 },
  { 122, 18, 23, 21, 2, -23 },
  { 174, 18, 23, 19, 1, -23 },
  { 226, 4, 9, 5, 1, -25 },
  { 231, 8, 33, 11, 2, -26 },
  { 264, 8, 33, 11, 1, -26 },
  { 297, 15, 14, 15, 0, -23 },
  { 324, 13, 16, 16, 1, -19 },
  { 350, 5, 10, 8, 1, -4 },
  { 357, 8, 4, 13, 2, -12 },
  { 361, 6, 5, 10, 2, -5 },
  { 365, 10, 25, 11, 0, -23 },
  { 397, 14, 23, 17, 1, -23 },
  { 438, 9, 23, 17, 3, -23 },
  { 464, 14, 23, 17, 1, -23 },
  { 505, 14, 23, 17, 1, -23 },
  { 546, 15, 23, 17, 1, -23 },
  { 590, 14, 23, 17, 1, -23 },
  { 631, 15, 23, 17, 1, -23 },
  { 675, 14, 23, 17, 1, -23 },
  { 716, 13, 23, 17, 2, -23 },
  { 754, 14, 23, 17, 1, -23 },
  { 795, 6, 18, 9, 2, -18 },
  { 809, 6, 24, 9, 1, -18 },
  { 827, 12, 16, 15, 1, -18 },
  { 851, 13, 11, 17, 2, -16 },
  { 869, 12, 16, 15, 2, -18 },
  { 893, 13, 23, 15, 1, -23 },
  { 931, 23, 30, 25, 1, -23 },
  { 1018, 20, 23, 20, 0, -23 },
  { 1076, 15, 23, 19, 2, -23 },
  { 1120, 17, 23, 19, 1, -23 },
  { 1169, 15, 23, 19, 2, -23 },
  { 1213, 13, 23, 16, 2, -23 },
  { 1251, 13, 23, 16, 2, -23 },
  { 1289, 17, 23, 19, 1, -23 },
  { 1338, 16, 23, 20, 2, -23 },
  { 1384, 5, 23, 9, 2, -23 },
  { 1399, 14, 23, 16, 1, -23 },
  { 1440, 17, 23, 18, 2, -23 },
  { 1489, 13, 23, 16, 2, -23 },
  { 1527, 21, 23, 25, 2, -23 },
  { 1588, 16, 23, 20, 2, -23 },
  { 1634, 18, 23, 20, 1, -23 },
  { 1686, 16, 23, 19, 2, -23 },
  { 1732, 18, 27, 20, 1, -23 },
  { 1793, 16, 23, 18, 2, -23 },
  { 1839, 16, 23, 18, 1, -23 },
  { 1885, 16, 23, 18, 1, -23 },
  { 1931, 15, 23, 19, 2, -23 },
  { 1975, 19, 23, 19, 0, -23 },
  { 2030, 23, 23, 25, 1, -23 },
  { 2097, 18, 23, 19, 0, -23 },
  { 2149, 18, 23, 18, 0, -23 },
  { 2201, 16, 23, 18, 1, -23 },
  { 2247, 6, 33, 9, 2, -27 },
  { 2272, 13, 25, 13, 0, -23 },
  { 2313, 6, 33, 9, 1, -27 },
  { 2338, 11, 12, 13, 1, -23 },
  { 2355, 13, 4, 13, 0, 0 },
  { 2362, 8, 5, 11, 1, -25 },
  { 2367, 14, 17, 15, 1, -17 },
  { 2397, 13, 25, 16, 2, -25 },
  { 2438, 13, 17, 15, 1, -17 },
  { 2466, 14, 25, 16, 1, -25 },
  { 2510, 14, 17, 16, 1, -17 },
  { 2540, 11, 25, 11, 0, -25 },
  { 2575, 14, 24, 17, 1, -17 },
  { 2617, 14, 25, 16, 1, -25 },
  { 2661, 5, 24, 8, 2, -24 },
  { 2676, 8, 31, 8, -1, -24 },
  { 2707, 14, 25, 16, 2, -25 },
  { 2751, 5, 25, 8, 2, -25 },
  { 2767, 21, 17, 24, 2, -17 },
  { 2812, 14, 17, 16, 1, -17 },
  { 2842, 14, 17, 16, 1, -17 },
  { 2872, 13, 24, 16, 2, -17 },
  { 2911, 14, 24, 16, 1, -17 },
  { 2953, 9, 17, 11, 2, -17 },
  { 2973, 13, 17, 15, 1, -17 },
  { 3001, 10, 22, 10, 0, -22 },
  { 3029, 14, 17, 16, 1, -17 },
  { 3059, 15, 17, 15, 0, -17 },
  { 3091, 19, 17, 21, 1, -17 },
  { 3132, 15, 17, 15, 0, -17 },
  { 3164, 15, 24, 15, 0, -17 },
  { 3209, 13, 17, 15, 1, -17 },
  { 3237, 8, 32, 10, 1, -26 },
  { 3269, 3, 27, 8, 3, -23 },
  { 3280, 8, 32, 10, 1, -26 },
  { 3312, 15, 7, 18, 2, -13 },
};

const GFXfont RobotoCondensed_ExtraBold33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_EXTRABOLD33PT7B_H_
