#ifndef _ROBOTOCONDENSED_EXTRABOLD39PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x00,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0,
  0x0F, 0x38, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF,
  0x00, 0x73, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xF7,
  0x86, 0x0F, 0x3C, 0x38, 0x78, 0xE3, 0xC3, 0xC7, 0x1C, 0x1E, 0x39, 0xE0,
  0xF3, 0xCE, 0x07, 0xDE, 0xF0, 0x1F, 0xF7, 0x00, 0xFF, 0x78, 0x01, 0xF3,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x78, 0x01, 0xEF, 0xF0,
  0x0E, 0xFF, 0x80, 0xF7, 0xFE, 0x07, 0x3C, 0xF0, 0x79, 0xC3, 0x83, 0x8E,
  0x1C, 0x3C, 0x79, 0xE1, 0xC3, 0xCF, 0x0E, 0x1F, 0x78, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0x78, 0x07,
  0xC3, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC7, 0xC7, 0xFE, 0x3E, 0x7F,
  0xF9, 0xF3, 0xEF, 0xFF, 0x3F, 0x3F, 0xF9, 0xF8, 0xFF, 0xCF, 0xC7, 0xFE,
  0x7E, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x07, 0xFE, 0xFC, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x38, 0x02, 0x40, 0x18, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0,
  0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0,
  0xF8, 0x3C, 0x06, 0x01, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x17, 0x8E, 0x3B, 0xF7, 0x7D, 0xFF, 0xFF, 0x3F, 0xFE,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0xF3, 0xE0, 0xF0,
  0xF0, 0x30, 0x38, 0x08, 0x10, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x79, 0xF3, 0xC1, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7C, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xEF, 0xC1, 0xF7, 0xE0, 0xF3, 0xF0, 0xF9,
  0xF8, 0x7C, 0xFC, 0x7C, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFD,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0xFE, 0x18, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x78, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC,
  0x1F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF7, 0xE1, 0xF9,
  0xF8, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE,
  0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7E, 0x7E, 0x7F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xBE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1E, 0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFB, 0xF3, 0xC0,
  0x3E, 0x7E, 0x7F, 0x7F, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x7C, 0x78, 0xF8, 0x30, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07,
  0xFC, 0x7F, 0xF7, 0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x3F,
  0xC3, 0xFF, 0x3F, 0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0x80,
  0x08, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x1E,
  0x07, 0xC1, 0xC7, 0x83, 0xFC, 0x3C, 0xF0, 0xFF, 0xC7, 0xBC, 0x1F, 0xF8,
  0x77, 0x87, 0x8F, 0x0E, 0xF0, 0xF1, 0xE1, 0xDE, 0x3C, 0x3C, 0x3B, 0x87,
  0x87, 0x87, 0x70, 0xF0, 0xF0, 0xFE, 0x3E, 0x1E, 0x1F, 0xC7, 0xC3, 0xC3,
  0xF8, 0xF8, 0x78, 0x7F, 0x1F, 0x0E, 0x1F, 0xE3, 0xE3, 0xC3, 0x9C, 0x3C,
  0x78, 0x73, 0x87, 0xFF, 0x9E, 0x78, 0xFF, 0xFF, 0x8F, 0x0F, 0xCF, 0xE1,
  0xE0, 0xF0, 0xF8, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0x00, 0x0F, 0xFB, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F,
  0xBF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xDF, 0x83, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0xC1, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFD,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x7E, 0x0F, 0xE7, 0xF0,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F,
  0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3D, 0xFF, 0xFE, 0x1E, 0xFF, 0xEF, 0x1F, 0x7F,
  0xF7, 0xCF, 0xBF, 0xFB, 0xE7, 0x9F, 0xFD, 0xF7, 0xCF, 0xFE, 0x7B, 0xE7,
  0xFF, 0x3F, 0xF3, 0xFF, 0x9F, 0xF1, 0xFF, 0xC7, 0xF8, 0xFF, 0xE3, 0xFC,
  0x7F, 0xF1, 0xFC, 0x3F, 0xF8, 0xFE, 0x1F, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F,
  0x87, 0xFF, 0x0F, 0x83, 0xFF, 0x87, 0xC1, 0xF0, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFD, 0xF3, 0xFF, 0xDF, 0x3F, 0xFC, 0xF3, 0xFF, 0xCF, 0xBF,
  0xFC, 0x7B, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0xFE, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xE0,
  0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7,
  0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x3F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xC1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0xC3, 0xFB,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBE, 0x00,
  0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7E,
  0x1F, 0xFE, 0x1F, 0xC3, 0xF7, 0xC3, 0xF8, 0x7E, 0xFC, 0x7F, 0x0F, 0x9F,
  0x8F, 0xE3, 0xF3, 0xF1, 0xFC, 0x7E, 0x7E, 0x7F, 0xCF, 0xCF, 0xCF, 0xF9,
  0xF8, 0xF9, 0xFF, 0x3F, 0x1F, 0x3F, 0xE7, 0xC3, 0xF7, 0xFC, 0xF8, 0x7E,
  0xF7, 0xFF, 0x0F, 0xFE, 0xFF, 0xE1, 0xFF, 0xDF, 0xFC, 0x1F, 0xFB, 0xFF,
  0x83, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x7F, 0x0F,
  0xE1, 0xF8, 0x7E, 0x0F, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0,
  0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0,
  0xFE, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0xC0, 0xFC,
  0x7E, 0x0F, 0xE3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF1,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x83, 0xDE, 0x0F, 0x78, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x1E,
  0xF8, 0x7B, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F,
  0x00, 0x3F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x3F, 0x7E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xBF, 0x0F, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC,
  0xF9, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x0C, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0x80, 0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0xF3, 0xFE, 0x7E, 0x0F,
  0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x07, 0xCF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x79, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x30, 0x7F, 0x1F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC,
  0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xBF, 0xDF, 0xCF, 0x80, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x7F, 0x7E, 0x3F, 0xBF, 0x3F, 0x9F, 0x9F,
  0x8F, 0xDF, 0xC7, 0xEF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xF3, 0xF1,
  0xF9, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x3F, 0x1F, 0xDF, 0x87, 0xEF, 0xC3,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0xF0, 0x7C, 0x7D, 0xFE, 0x7F, 0x3F, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1, 0xF8, 0x7F, 0xF8, 0xFC, 0x3F,
  0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x87, 0xC3,
  0xFF, 0xC3, 0xE1, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C,
  0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x87,
  0xC3, 0xFF, 0xC3, 0xE1, 0xF8, 0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x03,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xF9,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0xFB, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFD, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF9, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xF7, 0xE7, 0xEF, 0x8F, 0xDF, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xBF, 0x1F, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF,
  0xC3, 0xE3, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x1F, 0x3E,
  0x0F, 0xBF, 0x07, 0xDF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xF8, 0x78, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1, 0xF1, 0xF7, 0xE7,
  0xE3, 0xEF, 0xCF, 0xC7, 0xCF, 0x9F, 0x8F, 0x9F, 0x3F, 0xBF, 0x3E, 0x7F,
  0x7C, 0x7D, 0xFE, 0xF8, 0xFB, 0xFD, 0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F,
  0xC3, 0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x00,
  0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0xFC, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E,
  0xFC, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF,
  0x0F, 0xDF, 0x87, 0xEF, 0xC7, 0xE3, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC,
  0x7E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x83, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x7E, 0x3E,
  0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x40, 0x1C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07,
  0xF0, 0xFC, 0x3F, 0x1F, 0xC7, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x81, 0xC0, 0x40,
  0x00, 0x1E, 0x00, 0x0F, 0xE1, 0xF7, 0xFC, 0x7D, 0xFF, 0x1E, 0xFF, 0xFF,
  0xBE, 0x7F, 0xEF, 0x0F, 0xF3, 0xC1, 0xFC, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 10, 11, 12, 1, -29 },
  { 36, 18, 28, 20, 1, -28 },
  { 99, 16, 36, 20, 2, -32 },
  { 171, 21, 28, 25, 2, -28 },
  { 245, 21, 28, 23, 1, -28 },
  { 319, 4, 11, 6, 1, -29 },
  { 325, 10, 40, 13, 2, -31 },
  { 375, 10, 40, 13, 1, -31 },
  { 425, 17, 17, 18, 1, -28 },
  { 462, 16, 20, 18, 1, -22 },
  { 502, 7, 12, 10, 1, -5 },
  { 513, 9, 5, 15, 3, -15 },
  { 519, 7, 6, 12, 2, -6 },
  { 525, 12, 30, 13, 0, -28 },
  { 570, 16, 28, 20, 2, -28 },
  { 626, 11, 28, 20, 3, -28 },
  { 665, 17, 28, 20, 1, -28 },
  { 725, 17, 28, 20, 1, -28 },
  { 785, 17, 28, 20, 1, -28 },
  { 845, 16, 28, 20, 2, -28 },
  { 901, 17, 28, 20, 2, -28 },
  { 961, 17, 28, 20, 1, -28 },
  { 1021, 16, 28, 20, 2, -28 },
  { 1077, 16, 28, 20, 2, -28 },
  { 1133, 7, 21, 11, 2, -21 },
  { 1152, 8, 28, 10, 1, -21 },
  { 1180, 14, 19, 17, 1, -21 },
  { 1214, 15, 14, 20, 2, -19 },
  { 1241, 14, 19, 18, 2, -21 },
  { 1275, 15, 28, 18, 1, -28 },
  { 1328, 27, 36, 30, 1, -27 },
  { 1450, 23, 28, 23, 0, -28 },
  { 1531, 18, 28, 22, 2, -28 },
  { 1594, 19, 28, 22, 2, -28 },
  { 1661, 18, 28, 22, 2, -28 },
  { 1724, 16, 28, 19, 2, -28 },
  { 1780, 16, 28, 19, 2, -28 },
  { 1836, 19, 28, 23, 2, -28 },
  { 1903, 20, 28, 24, 2, -28 },
  { 1973, 6, 28, 11, 2, -28 },
  { 1994, 16, 28, 19, 1, -28 },
  { 2050, 20, 28, 22, 2, -28 },
  { 2120, 16, 28, 19, 2, -28 },
  { 2176, 25, 28, 30, 2, -28 },
  { 2264, 20, 28, 24, 2, -28 },
  { 2334, 20, 28, 24, 2, -28 },
  { 2404, 19, 28, 22, 2, -28 },
  { 2471, 20, 33, 24, 2, -28 },
  { 2554, 19, 28, 22, 2, -28 },
  { 2621, 19, 28, 21, 1, -28 },
  { 2688, 19, 28, 21, 1, -28 },
  { 2755, 18, 28, 22, 2, -28 },
  { 2818, 22, 28, 23, 0, -28 },
  { 2895, 27, 28, 29, 1, -28 },
  { 2990, 21, 28, 22, 0, -28 },
  { 3064, 21, 28, 21, 0, -28 },
  { 3138, 19, 28, 21, 1, -28 },
  { 3205, 8, 39, 10, 2, -32 },
  { 3244, 16, 30, 15, 0, -28 },
  { 3304, 7, 39, 10, 1, -32 },
  { 3339, 14, 14, 15, 1, -28 },
  { 3364, 15, 5, 16, 0, 0 },
  { 3374, 10, 6, 13, 1, -29 },
  { 3382, 16, 21, 18, 1, -21 },
  { 3424, 16, 29, 19, 2, -29 },
  { 3482, 16, 21, 18, 1, -21 },
  { 3524, 16, 29, 19, 1, -29 },
  { 3582, 17, 21, 19, 1, -21 },
  { 3627, 11, 29, 13, 1, -29 },
  { 3667, 17, 29, 20, 1, -21 },
  { 3729, 16, 29, 19, 2, -29 },
  { 3787, 6, 29, 10, 2, -29 },
  { 3809, 9, 37, 10, -1, -29 },
  { 3851, 17, 29, 19, 2, -29 },
  { 3913, 6, 29, 10, 2, -29 },
  { 3935, 25, 21, 29, 2, -21 },
  { 4001, 16, 21, 19, 2, -21 },
  { 4043, 17, 21, 19, 1, -21 },
  { 4088, 16, 29, 19, 2, -21 },
  { 4146, 16, 29, 19, 1, -21 },
  { 4204, 10, 21, 13, 2, -21 },
  { 4231, 15, 21, 18, 1, -21 },
  { 4271, 11, 26, 12, 0, -26 },
  { 4307, 16, 21, 19, 2, -21 },
  { 4349, 17, 21, 18, 0, -21 },
  { 4394, 23, 21, 25, 1, -21 },
  { 4455, 16, 21, 18, 1, -21 },
  { 4497, 17, 29, 18, 0, -21 },
  { 4559, 15, 21, 18, 1, -21 },
  { 4599, 9, 37, 12, 1, -30 },
  { 4641, 4, 33, 10, 3, -28 },
  { 4658, 10, 37, 12, 1, -30 },
  { 4705, 18, 9, 21, 2, -16 },
};

const GFXfont RobotoCondensed_ExtraBold39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_EXTRABOLD39PT7B_H_
