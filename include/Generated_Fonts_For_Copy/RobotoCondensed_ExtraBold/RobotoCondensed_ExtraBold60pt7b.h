#ifndef _ROBOTOCONDENSED_EXTRABOLD60PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7,
  0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x8F, 0xC0, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0,
  0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xC0,
  0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF0, 0x7F, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x08, 0x03, 0xF1, 0xFC, 0x0F, 0x01,
  0xF8, 0x7E, 0x07, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xE3, 0xF0, 0x0F, 0xC3, 0xF1, 0xF0,
  0x07, 0xE1, 0xF9, 0xF8, 0x03, 0xF0, 0xFC, 0xF8, 0x01, 0xFF, 0xFC, 0xFC,
  0x00, 0x7F, 0xFE, 0x7C, 0x00, 0x3F, 0xFE, 0x7E, 0x00, 0x0F, 0xFE, 0x3E,
  0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x03, 0xE7, 0xFF, 0x00, 0x03,
  0xE7, 0xFF, 0xC0, 0x01, 0xF3, 0xFF, 0xF0, 0x01, 0xF3, 0xFF, 0xF8, 0x01,
  0xF9, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x3F, 0x00, 0xFC, 0x7C, 0x1F, 0x80,
  0x7C, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x83, 0xF0,
  0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0xFC,
  0x03, 0x80, 0xFF, 0xFE, 0x00, 0x40, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x83,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xF3,
  0xFC, 0x7F, 0xFF, 0xF3, 0xF8, 0xFF, 0x9F, 0xFB, 0xF8, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBE, 0xF8, 0x00, 0x08, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x40, 0x40, 0x00, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xC0,
  0x7C, 0x06, 0x7E, 0x1F, 0x0F, 0x9F, 0xE7, 0xCF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x03, 0x00, 0x70, 0x00, 0x40, 0x08,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0x3C, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3E, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F,
  0x02, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0xDF, 0xF0,
  0x3F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0,
  0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F, 0xF0,
  0x7F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xBF, 0xF0, 0x3F,
  0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xFE, 0xFF, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xBF, 0xE0, 0x0F, 0xEF, 0xF8, 0x03,
  0xFB, 0xFE, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0x3F, 0xE0, 0x3F, 0x8F, 0xF8,
  0x0F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x3F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0xF8, 0x06, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x7F, 0xDF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x87, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0xFC, 0x01, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xCF, 0xFC, 0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0x9F, 0xE0, 0x3F, 0xE7, 0xFC, 0x1F, 0xF9, 0xFF, 0x8F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xE3,
  0xFE, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xEF, 0xF8,
  0x1F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x7F,
  0xC1, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xF8, 0x3F,
  0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xEF, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1,
  0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC,
  0x07, 0xFB, 0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFD, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x0F, 0xCF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xC1, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xE3, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0xFC, 0x07, 0xC1, 0xF8, 0x07, 0xFF, 0xC1, 0xF0, 0xFC,
  0x03, 0xFF, 0xF8, 0x7E, 0x3F, 0x01, 0xFF, 0xFE, 0x0F, 0x8F, 0xC0, 0xFF,
  0x3F, 0x03, 0xE7, 0xE0, 0x3F, 0x0F, 0xC0, 0xF9, 0xF8, 0x1F, 0xC3, 0xF0,
  0x3E, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x3F, 0x03, 0xF7,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF0, 0x7F, 0x03, 0xF0, 0x3E, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xBF, 0x07, 0xE0, 0x3F, 0x03, 0xEF, 0xC1, 0xF8, 0x0F, 0xC0, 0xFB, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xCF, 0xC1, 0xFC, 0x3F, 0x83, 0xF1, 0xF0, 0x7F, 0x9F, 0xF0,
  0xF8, 0x7E, 0x0F, 0xFF, 0xFE, 0xFE, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x7F, 0xF7, 0xFF, 0x81, 0xFC, 0x0F, 0xF9, 0xFF, 0xC0, 0x3F, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0x08, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xEF, 0xF8, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03,
  0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xCF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0,
  0x7F, 0xEF, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0x00,
  0x7F, 0xFB, 0xFE, 0x00, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0x8F, 0xF8, 0x07,
  0xFF, 0x1F, 0xF0, 0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x01,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07,
  0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x1F, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F,
  0xFB, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFD,
  0xFF, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xFD,
  0xFC, 0x1F, 0xCF, 0xFF, 0xFB, 0xF8, 0x3F, 0x9F, 0xFF, 0xF7, 0xF8, 0x7F,
  0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFF, 0xFF, 0xCF, 0xE3, 0xF9, 0xFF, 0xFF,
  0x9F, 0xC7, 0xF3, 0xFF, 0xFF, 0x3F, 0xCF, 0xE7, 0xFF, 0xFE, 0x3F, 0x9F,
  0xCF, 0xFF, 0xFC, 0x7F, 0x7F, 0x1F, 0xFF, 0xF8, 0xFE, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0xFB, 0xFC, 0x7F, 0xFF, 0xE7, 0xF1, 0xFF, 0xFF,
  0x9F, 0xE7, 0xFF, 0xFE, 0x3F, 0x9F, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xE1,
  0xFD, 0xFF, 0xFF, 0x87, 0xF7, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0,
  0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC,
  0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0,
  0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0,
  0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xBF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xC0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F,
  0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF,
  0xF0, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFC, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3,
  0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0,
  0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFF, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xFC, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFF, 0xF1, 0xFF, 0x03, 0xFE,
  0x7F, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xFF, 0xE7, 0xF8, 0x0F, 0xF9, 0xFF,
  0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xF7, 0xF7,
  0xFC, 0x03, 0xFF, 0xFE, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0x3F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x7E, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xE1,
  0xFF, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7,
  0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFE,
  0x7F, 0xC1, 0xFF, 0x3F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFB, 0xFE, 0x07, 0xF9,
  0xFF, 0x80, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x03, 0xFE, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFC, 0x1F, 0xF7, 0xFC,
  0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xF7, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xDF, 0xFF, 0x1F, 0xE7, 0xFF, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xFB, 0xFE, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0xCF, 0xF0, 0x3F, 0xC7, 0xF8, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x7F, 0xE1, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x0C, 0x3F, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xC3, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xBF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0x03, 0xFC,
  0x7F, 0x80, 0x10, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x40,
  0x1F, 0xF8, 0x78, 0x1F, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0xFF, 0xBF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x3E, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF,
  0xFF, 0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xEF,
  0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x7F, 0xEF, 0xF8, 0x3F, 0xFB, 0xFE, 0x1F, 0xFC, 0xFF,
  0x87, 0xFE, 0x3F, 0xE3, 0xFF, 0x0F, 0xF8, 0xFF, 0xC3, 0xFE, 0x7F, 0xE0,
  0xFF, 0x9F, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0x7F, 0xEF,
  0xF8, 0x1F, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xF8, 0xFF,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F, 0xF0,
  0x3F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0x7F,
  0xC0, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x3F, 0xCF, 0xFE, 0x1F, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF,
  0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0xFF,
  0x81, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0x7F, 0xF0,
  0xFF, 0x9F, 0xE0, 0x7F, 0xC1, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC3,
  0xFF, 0x9F, 0xE3, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF,
  0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0x03, 0xFC, 0xFF,
  0x80, 0x20, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x10,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF,
  0x00, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F,
  0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC,
  0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFE, 0xFF, 0x83, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F,
  0xC3, 0xFE, 0x7F, 0x87, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0xE3, 0xFC, 0x3F,
  0xC7, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xE3, 0xFC, 0x3F, 0xCF, 0xFE, 0x3F,
  0xC3, 0xFC, 0xFF, 0xF3, 0xFC, 0x3F, 0xCF, 0xFF, 0x7F, 0x81, 0xFC, 0xFF,
  0xF7, 0xF8, 0x1F, 0xDF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xF7, 0xF8, 0x1F,
  0xFF, 0xBF, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF,
  0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFC, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x7F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F,
  0xE7, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8,
  0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1,
  0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80,
  0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x01, 0xE0,
  0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x78,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x01,
  0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0x78, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x7F,
  0xF0, 0x1F, 0x9F, 0xFE, 0x07, 0xF3, 0xFF, 0xE0, 0xFE, 0xFF, 0xFE, 0x1F,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xDF, 0xC1,
  0xFF, 0xF3, 0xF0, 0x1F, 0xFE, 0x7E, 0x03, 0xFF, 0x8F, 0xC0, 0x1F, 0xE0,
  0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 44, 16, 3, -43 },
  { 56, 17, 16, 19, 1, -45 },
  { 90, 27, 43, 31, 2, -43 },
  { 236, 25, 57, 31, 3, -50 },
  { 415, 33, 45, 38, 3, -44 },
  { 601, 32, 45, 35, 2, -44 },
  { 781, 6, 17, 10, 2, -45 },
  { 794, 15, 60, 19, 3, -47 },
  { 907, 15, 60, 19, 2, -47 },
  { 1020, 26, 26, 28, 1, -43 },
  { 1105, 24, 31, 28, 2, -35 },
  { 1198, 11, 18, 15, 1, -7 },
  { 1223, 15, 7, 23, 4, -22 },
  { 1237, 10, 10, 18, 4, -9 },
  { 1250, 18, 47, 19, 0, -43 },
  { 1356, 25, 45, 31, 3, -44 },
  { 1497, 17, 43, 31, 5, -43 },
  { 1589, 26, 44, 31, 2, -44 },
  { 1732, 26, 45, 31, 2, -44 },
  { 1879, 26, 43, 31, 2, -43 },
  { 2019, 26, 44, 31, 2, -43 },
  { 2162, 26, 44, 31, 3, -43 },
  { 2305, 26, 43, 31, 2, -43 },
  { 2445, 25, 45, 31, 3, -44 },
  { 2586, 25, 44, 31, 3, -44 },
  { 2724, 10, 34, 17, 4, -33 },
  { 2767, 11, 44, 16, 2, -33 },
  { 2828, 21, 28, 27, 2, -32 },
  { 2902, 23, 20, 31, 4, -29 },
  { 2960, 22, 28, 27, 3, -32 },
  { 3037, 24, 45, 27, 1, -44 },
  { 3172, 42, 54, 46, 2, -41 },
  { 3456, 36, 43, 36, 0, -43 },
  { 3650, 28, 43, 34, 3, -43 },
  { 3801, 31, 45, 34, 2, -44 },
  { 3976, 28, 43, 34, 3, -43 },
  { 4127, 25, 43, 29, 3, -43 },
  { 4262, 24, 43, 29, 3, -43 },
  { 4391, 30, 45, 35, 3, -44 },
  { 4560, 31, 43, 37, 3, -43 },
  { 4727, 9, 43, 17, 4, -43 },
  { 4776, 25, 44, 30, 1, -43 },
  { 4914, 31, 43, 33, 3, -43 },
  { 5081, 24, 43, 29, 3, -43 },
  { 5210, 39, 43, 46, 3, -43 },
  { 5420, 30, 43, 37, 3, -43 },
  { 5582, 32, 45, 36, 2, -44 },
  { 5762, 29, 43, 34, 3, -43 },
  { 5918, 32, 52, 36, 2, -44 },
  { 6126, 29, 43, 34, 3, -43 },
  { 6282, 28, 45, 33, 2, -44 },
  { 6440, 30, 43, 33, 1, -43 },
  { 6602, 28, 44, 34, 3, -43 },
  { 6756, 34, 43, 35, 0, -43 },
  { 6939, 43, 43, 45, 1, -43 },
  { 7171, 32, 43, 34, 1, -43 },
  { 7343, 32, 43, 33, 0, -43 },
  { 7515, 28, 43, 32, 2, -43 },
  { 7666, 12, 60, 16, 3, -50 },
  { 7756, 24, 47, 23, 0, -43 },
  { 7897, 12, 60, 16, 1, -50 },
  { 7987, 22, 21, 24, 1, -43 },
  { 8045, 22, 7, 24, 1, 0 },
  { 8065, 15, 9, 20, 2, -45 },
  { 8082, 25, 34, 28, 2, -33 },
  { 8189, 25, 46, 30, 3, -45 },
  { 8333, 24, 34, 28, 2, -33 },
  { 8435, 25, 46, 30, 2, -45 },
  { 8579, 25, 34, 29, 2, -33 },
  { 8686, 18, 46, 20, 1, -46 },
  { 8790, 25, 45, 30, 2, -33 },
  { 8931, 24, 45, 30, 3, -45 },
  { 9066, 10, 45, 15, 3, -45 },
  { 9123, 14, 57, 15, -2, -45 },
  { 9223, 26, 45, 29, 3, -45 },
  { 9370, 9, 45, 15, 3, -45 },
  { 9421, 38, 33, 44, 3, -33 },
  { 9578, 24, 33, 30, 3, -33 },
  { 9677, 26, 34, 30, 2, -33 },
  { 9788, 25, 45, 30, 3, -33 },
  { 9929, 25, 45, 30, 2, -33 },
  { 10070, 16, 33, 20, 3, -33 },
  { 10136, 24, 34, 27, 1, -33 },
  { 10238, 16, 41, 19, 1, -40 },
  { 10320, 24, 33, 30, 3, -32 },
  { 10419, 26, 32, 27, 1, -32 },
  { 10523, 36, 32, 38, 1, -32 },
  { 10667, 26, 32, 27, 1, -32 },
  { 10771, 27, 44, 27, 0, -32 },
  { 10920, 23, 32, 27, 2, -32 },
  { 11012, 14, 58, 18, 2, -47 },
  { 11114, 5, 51, 15, 5, -43 },
  { 11146, 14, 58, 18, 2, -47 },
  { 11248, 27, 14, 33, 3, -25 },
};

const GFXfont RobotoCondensed_ExtraBold60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_EXTRABOLD60PT7B_H_
