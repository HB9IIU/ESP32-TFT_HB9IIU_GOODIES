#ifndef _ROBOTOCONDENSED_EXTRABOLD41PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x1C, 0x7D, 0xFF,
  0xFB, 0xE3, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xDE, 0x3B, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0,
  0x1C, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F,
  0x1F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xC7, 0xF7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8,
  0x07, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x60, 0xF1, 0xE1,
  0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x38, 0x3C, 0x79, 0xE0, 0xF1, 0xE7, 0x03,
  0xC7, 0xBC, 0x0F, 0xFE, 0xE0, 0x1F, 0xF7, 0x80, 0x3F, 0xBC, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xF8, 0x03, 0xBF,
  0xF0, 0x1E, 0xFF, 0xC0, 0x73, 0xCF, 0x03, 0xDE, 0x3C, 0x0E, 0x78, 0x70,
  0x79, 0xE1, 0xC3, 0xC7, 0x8F, 0x0F, 0x0F, 0x3C, 0x18, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7C, 0x7C, 0x03,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x0F,
  0x87, 0xFE, 0x7E, 0x3F, 0xF9, 0xF9, 0xFF, 0xF7, 0xC7, 0xEF, 0xFF, 0x3F,
  0x1F, 0xFC, 0xFC, 0x7F, 0xF3, 0xF0, 0xFF, 0x8F, 0xE1, 0xFE, 0x1F, 0xC7,
  0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBC, 0x00, 0x80,
  0x70, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x00, 0x80, 0x40, 0x18, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x01, 0x80, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x70, 0x6F, 0xDC, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07,
  0xDF, 0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x1C, 0x1C, 0x02, 0x02, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0xBF, 0x7C, 0xFB, 0xE7, 0x83, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7,
  0xFF, 0xF3, 0xF1, 0xFB, 0xF8, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFC, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x1F, 0x07, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF,
  0x9F, 0xCF, 0xE7, 0xE1, 0xF9, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xFB, 0xF8,
  0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF8,
  0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x7B, 0xF0, 0x3E, 0xFC, 0x0F, 0x3F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xF8,
  0xFC, 0x3E, 0x3F, 0x1F, 0x0F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xFF, 0xFC, 0x30, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xCF, 0x83, 0xF7, 0xF8,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0xFE, 0xFC, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xBF, 0x07, 0xE7, 0xE1,
  0xF9, 0xF8, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF8, 0xFD,
  0xFC, 0x7E, 0xFC, 0x3F, 0x7F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0xBF,
  0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x03,
  0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3, 0xFB,
  0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F,
  0xFF, 0xC7, 0xF7, 0xC1, 0xF7, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0x7E, 0x7E, 0xFE, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C, 0x3E,
  0x7F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0x30, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xF0, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0x7F, 0xF0, 0xFF, 0x01, 0xF8, 0x03,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xF3, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0,
  0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E,
  0x03, 0xE0, 0xF1, 0xF0, 0x7F, 0x87, 0x8F, 0x07, 0xFE, 0x1C, 0x78, 0x7F,
  0xF0, 0xE7, 0x83, 0xC7, 0x87, 0xBC, 0x3E, 0x3C, 0x3D, 0xE1, 0xE1, 0xE1,
  0xEF, 0x1F, 0x0F, 0x0F, 0x78, 0xF8, 0x78, 0x7B, 0xC7, 0x83, 0xC3, 0xFE,
  0x3C, 0x1E, 0x1F, 0xE1, 0xE0, 0xF0, 0xFF, 0x0F, 0x0F, 0x87, 0x78, 0x78,
  0x78, 0x39, 0xE3, 0xE3, 0xC3, 0xCF, 0x1F, 0x3F, 0x1C, 0x78, 0xFF, 0xF9,
  0xE3, 0xC3, 0xFF, 0xFE, 0x1E, 0x0F, 0xCF, 0xE0, 0xF8, 0x3C, 0x3E, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x10, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xF7, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xE3, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xEF, 0xE7, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0x87,
  0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE,
  0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFC, 0x7F,
  0xBF, 0x83, 0xF7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xF7, 0xF1, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xF8, 0xFE, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF8, 0x7F, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xBF, 0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F,
  0xBF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0x1F, 0x7F,
  0xFB, 0xE3, 0xEF, 0xFF, 0x7C, 0x7D, 0xFF, 0xEF, 0x8F, 0xBF, 0xFC, 0xFB,
  0xE7, 0xFF, 0x9F, 0x7C, 0xFF, 0xF3, 0xEF, 0x9F, 0xFE, 0x3D, 0xE3, 0xFF,
  0xC7, 0xFC, 0x7F, 0xF8, 0xFF, 0x8F, 0xFF, 0x1F, 0xF1, 0xFF, 0xE1, 0xFC,
  0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE,
  0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7E, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFB,
  0xE3, 0xFF, 0xDF, 0x1F, 0xFE, 0x7C, 0xFF, 0xF3, 0xE7, 0xFF, 0x9F, 0x3F,
  0xFC, 0x7D, 0xFF, 0xE3, 0xEF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0xC7, 0xF9, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF,
  0xF1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xF8, 0x1F, 0xDF,
  0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xF1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE7,
  0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xF8, 0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xE7,
  0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFF, 0x07, 0xE0, 0xFD, 0xFC, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x3F,
  0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0xFF, 0x0F, 0xCF, 0xC7, 0xF8, 0xFE, 0x7E,
  0x3F, 0xE7, 0xE3, 0xF9, 0xFF, 0x3F, 0x0F, 0xCF, 0xF9, 0xF8, 0x7E, 0xFF,
  0xCF, 0xC3, 0xF7, 0xFE, 0x7E, 0x1F, 0xBF, 0xF3, 0xE0, 0xFD, 0xFF, 0xFF,
  0x07, 0xEF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07,
  0xFE, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x03, 0xF1, 0xF8,
  0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xFB,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xBC, 0x3C, 0xF0, 0xF3,
  0xE7, 0xC7, 0x9F, 0x1E, 0x78, 0x7F, 0xE1, 0xFF, 0x83, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xFB, 0xF3, 0xF1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x7E, 0xFE, 0x3F, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFD, 0xF8, 0x7C, 0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xF3, 0xE0, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x83, 0xCF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0x7C, 0x1E, 0x3E, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x08, 0x7F, 0x07, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x1F,
  0xF3, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xCF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xEF, 0xC1, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x18, 0x1F,
  0x87, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xF8, 0xFD, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x0F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83,
  0xC0, 0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xBF, 0xEF,
  0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x0F, 0xEF, 0xC7, 0xFB, 0xF1, 0xFC, 0xFC, 0xFE, 0x3F, 0x3F,
  0x0F, 0xDF, 0xC3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFB, 0xF0, 0xFC,
  0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0xBF, 0x0F,
  0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0xF8, 0x3E, 0x3F, 0x7F, 0x3F, 0xCF, 0xFF, 0xEF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0xF8, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC7,
  0xE7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF8, 0x7F, 0x7F,
  0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xE7, 0xC3,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3E, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xFC, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7F, 0x7F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F,
  0x1F, 0x7E, 0x0F, 0xDF, 0x87, 0xF7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xEF, 0xC1,
  0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x3C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFE, 0x7E, 0x7C, 0xFE, 0x7E,
  0x7C, 0xFF, 0x7E, 0x7E, 0xFF, 0x7C, 0x3E, 0xFF, 0x7C, 0x3F, 0xFF, 0x7C,
  0x3F, 0xEF, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xF8,
  0x1F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x3F, 0xFF,
  0x1F, 0x9F, 0x8F, 0xCF, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0x7E, 0x1F, 0xBF, 0x1F,
  0x9F, 0xCF, 0xC7, 0xEF, 0xE3, 0xFF, 0xE0, 0xFC, 0xFE, 0x0F, 0xDF, 0x83,
  0xF7, 0xE1, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80,
  0xE0, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0x8F, 0xC3, 0xE0, 0xFC,
  0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xE0, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x1C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x0F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE3,
  0xF0, 0xF8, 0x1C, 0x06, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x7D, 0xFF, 0x0F,
  0xBF, 0xF3, 0xEF, 0xFF, 0xFD, 0xF3, 0xFF, 0xBE, 0x3F, 0xE7, 0x83, 0xF8,
  0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 11, 11, 13, 1, -31 },
  { 43, 19, 29, 21, 1, -29 },
  { 112, 17, 37, 21, 2, -33 },
  { 191, 22, 29, 26, 2, -29 },
  { 271, 22, 29, 24, 1, -29 },
  { 351, 5, 11, 6, 1, -31 },
  { 358, 10, 41, 13, 2, -32 },
  { 410, 10, 41, 13, 1, -32 },
  { 462, 18, 18, 19, 1, -29 },
  { 503, 17, 22, 19, 1, -25 },
  { 550, 7, 13, 11, 1, -5 },
  { 562, 10, 5, 16, 3, -15 },
  { 569, 7, 6, 12, 2, -6 },
  { 575, 13, 32, 13, 0, -29 },
  { 627, 17, 29, 21, 2, -29 },
  { 689, 12, 29, 21, 3, -29 },
  { 733, 18, 29, 21, 1, -29 },
  { 799, 18, 29, 21, 1, -29 },
  { 865, 18, 29, 21, 1, -29 },
  { 931, 17, 29, 21, 2, -29 },
  { 993, 18, 29, 21, 2, -29 },
  { 1059, 18, 29, 21, 1, -29 },
  { 1125, 17, 29, 21, 2, -29 },
  { 1187, 17, 29, 21, 2, -29 },
  { 1249, 8, 22, 12, 2, -22 },
  { 1271, 8, 30, 11, 1, -22 },
  { 1301, 15, 19, 18, 1, -22 },
  { 1337, 15, 14, 21, 3, -20 },
  { 1364, 15, 19, 19, 2, -22 },
  { 1400, 16, 29, 19, 1, -29 },
  { 1458, 29, 37, 31, 1, -28 },
  { 1593, 24, 29, 25, 0, -29 },
  { 1680, 19, 29, 23, 2, -29 },
  { 1749, 20, 29, 23, 2, -29 },
  { 1822, 19, 29, 23, 2, -29 },
  { 1891, 17, 29, 20, 2, -29 },
  { 1953, 17, 29, 20, 2, -29 },
  { 2015, 20, 29, 24, 2, -29 },
  { 2088, 21, 29, 25, 2, -29 },
  { 2165, 7, 29, 11, 2, -29 },
  { 2191, 17, 29, 20, 1, -29 },
  { 2253, 21, 29, 23, 2, -29 },
  { 2330, 17, 29, 20, 2, -29 },
  { 2392, 27, 29, 31, 2, -29 },
  { 2490, 21, 29, 25, 2, -29 },
  { 2567, 21, 29, 25, 2, -29 },
  { 2644, 20, 29, 23, 2, -29 },
  { 2717, 21, 34, 25, 2, -29 },
  { 2807, 20, 29, 23, 2, -29 },
  { 2880, 20, 29, 22, 1, -29 },
  { 2953, 20, 29, 23, 1, -29 },
  { 3026, 20, 29, 24, 2, -29 },
  { 3099, 24, 29, 24, 0, -29 },
  { 3186, 29, 29, 31, 1, -29 },
  { 3292, 23, 29, 23, 0, -29 },
  { 3376, 22, 29, 22, 0, -29 },
  { 3456, 20, 29, 22, 1, -29 },
  { 3529, 8, 41, 11, 2, -34 },
  { 3570, 17, 32, 16, 0, -29 },
  { 3638, 8, 41, 11, 1, -34 },
  { 3679, 14, 15, 16, 1, -29 },
  { 3706, 16, 5, 16, 0, 0 },
  { 3716, 11, 6, 14, 1, -31 },
  { 3725, 17, 22, 19, 1, -22 },
  { 3772, 17, 31, 20, 2, -31 },
  { 3838, 17, 22, 19, 1, -22 },
  { 3885, 17, 31, 20, 1, -31 },
  { 3951, 18, 22, 20, 1, -22 },
  { 4001, 12, 31, 14, 1, -31 },
  { 4048, 18, 30, 21, 1, -22 },
  { 4116, 16, 31, 20, 2, -31 },
  { 4178, 7, 30, 11, 2, -30 },
  { 4205, 10, 38, 10, -1, -30 },
  { 4253, 18, 31, 20, 2, -31 },
  { 4323, 6, 31, 11, 2, -31 },
  { 4347, 26, 22, 30, 2, -22 },
  { 4419, 16, 22, 20, 2, -22 },
  { 4463, 18, 22, 20, 1, -22 },
  { 4513, 17, 30, 20, 2, -22 },
  { 4577, 17, 30, 20, 1, -22 },
  { 4641, 11, 22, 14, 2, -22 },
  { 4672, 16, 22, 19, 1, -22 },
  { 4716, 12, 27, 13, 0, -27 },
  { 4757, 16, 22, 20, 2, -22 },
  { 4801, 18, 22, 19, 0, -22 },
  { 4851, 24, 22, 26, 1, -22 },
  { 4917, 17, 22, 19, 1, -22 },
  { 4964, 18, 30, 19, 0, -22 },
  { 5032, 15, 22, 19, 2, -22 },
  { 5074, 10, 39, 12, 1, -32 },
  { 5123, 4, 34, 10, 3, -29 },
  { 5140, 10, 39, 12, 1, -32 },
  { 5189, 19, 9, 23, 2, -16 },
};

const GFXfont RobotoCondensed_ExtraBold41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_EXTRABOLD41PT7B_H_
