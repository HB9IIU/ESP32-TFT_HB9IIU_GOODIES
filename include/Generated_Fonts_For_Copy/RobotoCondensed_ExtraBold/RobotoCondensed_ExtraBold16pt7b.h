#ifndef _ROBOTOCONDENSED_EXTRABOLD16PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3F, 0xDE, 0xF7, 0xA0, 0x16, 0x16, 0x14, 0x14, 0x7F,
  0x34, 0x34, 0xFE, 0x2C, 0x2C, 0x28, 0x68, 0x10, 0x47, 0xBF, 0xEF, 0x3E,
  0x1C, 0x3C, 0x3C, 0xF3, 0xFD, 0xE1, 0x04, 0xE0, 0x78, 0x25, 0x9E, 0x8E,
  0xC0, 0x40, 0x60, 0x2E, 0x3D, 0x16, 0xDB, 0x40, 0xE0, 0x78, 0x78, 0xCC,
  0xCC, 0x78, 0x70, 0xF6, 0xFE, 0xDE, 0xCE, 0xFE, 0x7F, 0xFF, 0x13, 0x66,
  0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0x10, 0x44, 0x63, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x64, 0x40, 0x18, 0x23, 0xDB, 0xF3, 0x8D, 0x89, 0x00, 0x18,
  0x30, 0x67, 0xFF, 0xE3, 0x06, 0x0C, 0x6D, 0xB4, 0xFF, 0x5F, 0x00, 0x18,
  0xC4, 0x63, 0x18, 0x8C, 0x63, 0x11, 0x8C, 0x00, 0x7B, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xDE, 0x1B, 0xFF, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x70, 0x7B, 0xFC, 0xF3, 0x0C, 0x71, 0x8C, 0x73, 0x8F, 0xFF, 0x3C, 0xFD,
  0x98, 0x30, 0x63, 0x87, 0x83, 0x06, 0xCD, 0xF9, 0xE0, 0x1C, 0x38, 0xF1,
  0xE7, 0xCB, 0xB7, 0x7F, 0xFE, 0x38, 0x70, 0xE0, 0xFF, 0xFC, 0x30, 0xFB,
  0xF0, 0xC3, 0x0F, 0x3F, 0xDE, 0x18, 0xF1, 0x87, 0x0F, 0x9F, 0xB3, 0x67,
  0xCF, 0x99, 0xF1, 0xC0, 0xFF, 0xFC, 0x18, 0x70, 0xC1, 0x87, 0x0C, 0x18,
  0x70, 0xC1, 0x80, 0x7B, 0xFC, 0xF3, 0xCD, 0xE7, 0xF3, 0xCF, 0x3F, 0xDE,
  0x7B, 0xFC, 0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x77, 0x9C, 0x5F, 0x00, 0x17,
  0xC0, 0x5F, 0x00, 0x06, 0xDB, 0x40, 0x04, 0x77, 0xFC, 0xF1, 0xF1, 0xC1,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x83, 0x8F, 0x8F, 0x3F, 0xEE, 0x20, 0x38,
  0xFB, 0xB8, 0x70, 0xC3, 0x86, 0x18, 0x00, 0x20, 0xE1, 0x80, 0x1F, 0x06,
  0x31, 0x83, 0x27, 0x2D, 0xB5, 0x36, 0xE4, 0xDD, 0x93, 0xB2, 0x53, 0xFA,
  0x7E, 0x60, 0x04, 0x00, 0xE4, 0x07, 0x80, 0x0C, 0x07, 0x01, 0xE0, 0x78,
  0x3E, 0x0D, 0xC3, 0x31, 0xCC, 0x7F, 0x1F, 0xE6, 0x3B, 0x86, 0xFD, 0xFF,
  0x3E, 0x3C, 0x7F, 0xBF, 0xE3, 0xC7, 0x8F, 0xFF, 0xE0, 0x3C, 0x7E, 0xE6,
  0xC7, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xE6, 0x7E, 0x3C, 0xF9, 0xFB, 0x3E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0xF7, 0xC0, 0xFF, 0xFC, 0x30, 0xC3,
  0xFF, 0xF0, 0xC3, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3,
  0x0C, 0x30, 0x3C, 0x7E, 0xE6, 0xC7, 0xC0, 0xCF, 0xCF, 0xC7, 0xC7, 0xE7,
  0x7F, 0x3C, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0xE6, 0xDD, 0xF1, 0xC0, 0xC7, 0xCE, 0xCC, 0xDC, 0xD8, 0xF8, 0xF8, 0xFC,
  0xCC, 0xCE, 0xCE, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F,
  0xFF, 0xE1, 0xF8, 0x7F, 0x1F, 0xCF, 0xF3, 0xFC, 0xFD, 0xAF, 0x7B, 0xDE,
  0xF3, 0xBC, 0xCF, 0x33, 0xC7, 0xE7, 0xE7, 0xF7, 0xF7, 0xDF, 0xDF, 0xCF,
  0xCF, 0xCF, 0xC7, 0xC7, 0x3C, 0x7E, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xE7, 0x7E, 0x3C, 0xFC, 0xFE, 0xC6, 0xC7, 0xC7, 0xC6, 0xFE, 0xFC,
  0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xE7, 0x7E, 0x3E, 0x07, 0x02, 0xFC, 0xFE, 0xCE, 0xC6, 0xC6, 0xCE,
  0xFE, 0xFC, 0xCC, 0xCE, 0xCE, 0xC6, 0x79, 0xFB, 0x3E, 0x3E, 0x0F, 0x0F,
  0x07, 0xC7, 0x8F, 0xFB, 0xE0, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xCF, 0xFB, 0xE0, 0xE3, 0xB1, 0xD8, 0xEE, 0x67, 0x31, 0xB8, 0xD8,
  0x6C, 0x3E, 0x0F, 0x07, 0x03, 0x80, 0xE6, 0x76, 0x66, 0x6E, 0x66, 0xF6,
  0x6F, 0x67, 0xFE, 0x7F, 0xE3, 0xFC, 0x3B, 0xC3, 0x9C, 0x39, 0xC3, 0x9C,
  0xE3, 0xBB, 0x9D, 0xC6, 0xC3, 0xE0, 0xE0, 0x70, 0x7C, 0x36, 0x3B, 0x9D,
  0xDC, 0x70, 0xE3, 0x31, 0x9D, 0xCE, 0xC3, 0x61, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61,
  0xC3, 0xFF, 0xF0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xBF, 0xE3, 0x86, 0x1C,
  0x70, 0xC3, 0x0E, 0x18, 0x61, 0xC3, 0x0C, 0xFD, 0xB6, 0xDB, 0x6D, 0xB6,
  0xFF, 0x30, 0xE3, 0x9A, 0x6D, 0x30, 0xFF, 0xF0, 0x61, 0x80, 0x3C, 0xFD,
  0xB8, 0x73, 0xED, 0xDB, 0xBF, 0x76, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3,
  0xCF, 0x3F, 0xFE, 0x3C, 0xFD, 0x9B, 0x0E, 0x0C, 0x19, 0xBF, 0x3C, 0x06,
  0x0C, 0x19, 0xB7, 0xEC, 0xF9, 0xF3, 0xE6, 0xCD, 0xF9, 0xB0, 0x7B, 0xFC,
  0xFF, 0xFF, 0x0C, 0x3F, 0x78, 0x39, 0xDD, 0xFF, 0xB9, 0xCE, 0x73, 0x9C,
  0xE0, 0x3E, 0xFD, 0x9B, 0x3E, 0x6C, 0xD9, 0xBF, 0x3E, 0x0D, 0xF9, 0xE0,
  0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xF3, 0xFF, 0xFF,
  0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x6D,
  0xDF, 0x3C, 0x7C, 0xF9, 0xBB, 0x76, 0x70, 0xFF, 0xFF, 0xFF, 0xDB, 0xBF,
  0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xC0, 0xFB, 0xFC,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0x3C, 0xFD, 0x9B, 0x3E, 0x6C, 0xD9, 0xBF,
  0x3C, 0xFB, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0xFB, 0x0C, 0x30, 0x3E, 0xFD,
  0x9F, 0x3E, 0x7C, 0xD9, 0xBF, 0x36, 0x0C, 0x18, 0x30, 0xFF, 0xEC, 0xCC,
  0xCC, 0xC0, 0x3C, 0xF9, 0xBB, 0x87, 0xC3, 0xFB, 0xBE, 0x3C, 0x63, 0x3F,
  0xF6, 0x31, 0x8C, 0x73, 0xCE, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x6C,
  0xE6, 0xDD, 0xB3, 0x66, 0xC7, 0x8E, 0x1C, 0x38, 0xED, 0xDB, 0x76, 0xD9,
  0xFE, 0x7F, 0x9F, 0xE7, 0x38, 0xCC, 0x33, 0x00, 0x6E, 0xD9, 0xF1, 0xC3,
  0x87, 0x9F, 0x36, 0xEE, 0xE6, 0xDD, 0xB3, 0x67, 0xC7, 0x8E, 0x1C, 0x38,
  0x61, 0xC3, 0x00, 0xFF, 0xF1, 0x8C, 0x71, 0x8E, 0x3F, 0xFC, 0x13, 0x37,
  0x76, 0xEE, 0x67, 0x77, 0x33, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x46, 0x66,
  0x66, 0x33, 0x76, 0x66, 0x66, 0x40, 0x67, 0xEF, 0x7C, 0x60,
};

const GFXglyph RobotoCondensed_ExtraBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 5, 0, -12 },
  { 7, 8, 12, 8, 0, -12 },
  { 19, 6, 16, 8, 1, -14 },
  { 31, 9, 12, 10, 1, -12 },
  { 45, 8, 12, 9, 1, -12 },
  { 57, 2, 4, 3, 0, -12 },
  { 58, 4, 17, 5, 1, -13 },
  { 67, 4, 17, 5, 0, -13 },
  { 76, 7, 7, 7, 0, -12 },
  { 83, 7, 8, 8, 0, -9 },
  { 90, 3, 5, 4, 0, -2 },
  { 92, 4, 2, 6, 1, -6 },
  { 93, 3, 3, 5, 1, -3 },
  { 95, 5, 13, 5, 0, -12 },
  { 104, 6, 12, 8, 1, -12 },
  { 113, 5, 12, 8, 1, -12 },
  { 121, 6, 12, 8, 1, -12 },
  { 130, 7, 12, 8, 0, -12 },
  { 141, 7, 12, 8, 1, -12 },
  { 152, 6, 12, 8, 1, -12 },
  { 161, 7, 12, 8, 1, -12 },
  { 172, 7, 12, 8, 0, -12 },
  { 183, 6, 12, 8, 1, -12 },
  { 192, 6, 12, 8, 1, -12 },
  { 201, 3, 9, 5, 1, -9 },
  { 205, 3, 12, 4, 1, -9 },
  { 210, 6, 8, 7, 0, -9 },
  { 216, 6, 6, 8, 1, -8 },
  { 221, 6, 8, 7, 1, -9 },
  { 227, 7, 12, 7, 0, -12 },
  { 238, 11, 15, 12, 1, -11 },
  { 259, 10, 12, 10, 0, -12 },
  { 274, 7, 12, 9, 1, -12 },
  { 285, 8, 12, 9, 1, -12 },
  { 297, 7, 12, 9, 1, -12 },
  { 308, 6, 12, 8, 1, -12 },
  { 317, 6, 12, 8, 1, -12 },
  { 326, 8, 12, 9, 1, -12 },
  { 338, 8, 12, 10, 1, -12 },
  { 350, 2, 12, 4, 1, -12 },
  { 353, 7, 12, 8, 0, -12 },
  { 364, 8, 12, 9, 1, -12 },
  { 376, 6, 12, 8, 1, -12 },
  { 385, 10, 12, 12, 1, -12 },
  { 400, 8, 12, 10, 1, -12 },
  { 412, 8, 12, 10, 1, -12 },
  { 424, 8, 12, 9, 1, -12 },
  { 436, 8, 14, 10, 1, -12 },
  { 450, 8, 12, 9, 1, -12 },
  { 462, 7, 12, 9, 1, -12 },
  { 473, 8, 12, 9, 0, -12 },
  { 485, 7, 12, 9, 1, -12 },
  { 496, 9, 12, 9, 0, -12 },
  { 510, 12, 12, 12, 0, -12 },
  { 528, 9, 12, 9, 0, -12 },
  { 542, 9, 12, 9, 0, -12 },
  { 556, 7, 12, 9, 1, -12 },
  { 567, 3, 16, 4, 1, -13 },
  { 573, 6, 13, 6, 0, -12 },
  { 583, 3, 16, 4, 0, -13 },
  { 589, 6, 6, 6, 0, -12 },
  { 594, 6, 2, 6, 0, 0 },
  { 596, 5, 2, 5, 0, -12 },
  { 598, 7, 9, 8, 0, -9 },
  { 606, 6, 12, 8, 1, -12 },
  { 615, 7, 9, 7, 0, -9 },
  { 623, 7, 12, 8, 0, -12 },
  { 634, 6, 9, 8, 1, -9 },
  { 641, 5, 12, 5, 0, -12 },
  { 649, 7, 12, 8, 0, -9 },
  { 660, 6, 12, 8, 1, -12 },
  { 669, 2, 12, 4, 1, -12 },
  { 672, 4, 15, 4, -1, -12 },
  { 680, 7, 12, 8, 1, -12 },
  { 691, 2, 12, 4, 1, -12 },
  { 694, 10, 9, 12, 1, -9 },
  { 706, 6, 9, 8, 1, -9 },
  { 713, 7, 9, 8, 0, -9 },
  { 721, 6, 12, 8, 1, -9 },
  { 730, 7, 12, 8, 0, -9 },
  { 741, 4, 9, 5, 1, -9 },
  { 746, 7, 9, 7, 0, -9 },
  { 754, 5, 11, 5, 0, -11 },
  { 761, 6, 9, 8, 1, -9 },
  { 768, 7, 9, 7, 0, -9 },
  { 776, 10, 9, 10, 0, -9 },
  { 788, 7, 9, 7, 0, -9 },
  { 796, 7, 12, 7, 0, -9 },
  { 807, 6, 9, 7, 1, -9 },
  { 814, 4, 15, 5, 0, -12 },
  { 822, 2, 14, 4, 1, -12 },
  { 826, 4, 15, 5, 0, -12 },
  { 834, 7, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBold16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_EXTRABOLD16PT7B_H_
