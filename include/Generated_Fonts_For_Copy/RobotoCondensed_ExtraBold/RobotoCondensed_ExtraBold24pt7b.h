#ifndef _ROBOTOCONDENSED_EXTRABOLD24PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x70, 0x07, 0xFF, 0x70, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xC0, 0x1D, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0xB9, 0xFF,
  0xFF, 0xF9, 0xD8, 0x33, 0x06, 0x63, 0xFF, 0x7F, 0xE3, 0x60, 0x6C, 0x1D,
  0x83, 0x30, 0x66, 0x00, 0x04, 0x01, 0x01, 0xF0, 0xFE, 0x7F, 0x9C, 0xF7,
  0x3D, 0xC7, 0x78, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xFC, 0xFF, 0x1F, 0xCF,
  0x7F, 0xCF, 0xE1, 0xF0, 0x30, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x3B, 0x19,
  0x9D, 0xCC, 0xEC, 0x76, 0xC1, 0xF6, 0x07, 0x60, 0x03, 0x00, 0x37, 0x81,
  0xFE, 0x1B, 0x31, 0xD9, 0x8C, 0xCC, 0xE6, 0x60, 0x3F, 0x00, 0xF0, 0x1E,
  0x01, 0xF8, 0x1F, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xFC, 0x07, 0xC0,
  0x3C, 0x73, 0xF3, 0xBF, 0xFD, 0xCF, 0xCE, 0x7E, 0x79, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3E, 0xF0, 0xFF, 0xFC, 0x04, 0x31, 0xCE, 0x31, 0xC7, 0x1C, 0x63,
  0x8E, 0x38, 0xE3, 0x86, 0x18, 0x71, 0xC7, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x0E, 0x1C, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x3C, 0xF3, 0x8E, 0x38,
  0xE3, 0x9C, 0x73, 0x8C, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x3B, 0x7F, 0xFE,
  0x1E, 0x07, 0xC1, 0xDC, 0x31, 0x82, 0x20, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0x39, 0xCE, 0x77, 0x39, 0x80, 0xFF, 0xFF, 0xC0, 0x73, 0xBC, 0xE0, 0x06,
  0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x87, 0x0E, 0x18,
  0x30, 0xE1, 0xC0, 0x1E, 0x0F, 0xE7, 0xF9, 0xCF, 0xF3, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xDC, 0xF7, 0xF8, 0xFE, 0x1E,
  0x00, 0x06, 0x7F, 0xFF, 0xFD, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xF3, 0xF8, 0xF0,
  0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x1F, 0xEF, 0xFB, 0xCF, 0xE3, 0xC0, 0xF0, 0x3C, 0x7E,
  0x1F, 0x07, 0xE0, 0x3C, 0x07, 0xE1, 0xFC, 0xFF, 0xFD, 0xFE, 0x3E, 0x00,
  0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE3, 0xF9, 0xDE, 0x77, 0xB9,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0x7F, 0xDF,
  0xF7, 0xFD, 0xC0, 0x70, 0x1C, 0x0F, 0xF3, 0xFE, 0xFF, 0xC0, 0xF0, 0x1C,
  0x07, 0xF3, 0xFC, 0xF7, 0xF9, 0xFE, 0x1E, 0x00, 0x07, 0x07, 0xC3, 0xF1,
  0xF0, 0x78, 0x1C, 0x0F, 0x73, 0xFE, 0xFF, 0xFC, 0xFF, 0x1F, 0xC7, 0xF1,
  0xDC, 0xF7, 0xFC, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xF3, 0xFC, 0xF7,
  0x39, 0xFE, 0x3F, 0x1F, 0xEF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF7, 0xFD, 0xFE,
  0x1F, 0x00, 0x1E, 0x0F, 0xC7, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0x7F, 0xDF, 0xF3, 0xFC, 0x0F, 0x03, 0x81, 0xE3, 0xF0, 0xF8, 0x38, 0x00,
  0x73, 0xBE, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0xF7, 0x00, 0x7F, 0xF7, 0x00,
  0x00, 0x00, 0x77, 0x77, 0x7E, 0x40, 0x01, 0x07, 0x1F, 0x3F, 0xFC, 0xF0,
  0xF0, 0xFC, 0x7F, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x70, 0x3E, 0x1F, 0xC3, 0xF8, 0x3C,
  0x3E, 0x7F, 0xFE, 0x7C, 0x38, 0x10, 0x00, 0x3E, 0x3F, 0xBF, 0xFC, 0xFE,
  0x78, 0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x07, 0x03, 0x80, 0x00, 0xC0, 0xF0,
  0x78, 0x18, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0x07, 0x07, 0x01, 0xC3,
  0x00, 0x63, 0x8F, 0x19, 0x8F, 0xCD, 0xCE, 0x66, 0xE6, 0x73, 0x63, 0x39,
  0xB3, 0x9C, 0xD9, 0xCE, 0x6C, 0xE7, 0x36, 0x73, 0x9B, 0x3B, 0xDD, 0xCF,
  0xFC, 0xE3, 0xBC, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x84, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x81, 0xEE, 0x07, 0xB8, 0x1C, 0xF0, 0x73, 0xC3, 0xC7, 0x0F, 0xFE, 0x3F,
  0xF9, 0xFF, 0xE7, 0x83, 0x9E, 0x0F, 0xF0, 0x3C, 0xFF, 0x9F, 0xFB, 0xFF,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xFE, 0xFF, 0x9F, 0xFF, 0xC7, 0xF8,
  0x7F, 0x0F, 0xE3, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0x83, 0xFC, 0x7F,
  0xE7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x0F,
  0xF8, 0xFF, 0xCF, 0x1E, 0xF1, 0xEF, 0x0E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF,
  0xEF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xE3, 0xBD, 0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF,
  0x3C, 0xF3, 0xCF, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0xBC, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x1F, 0xF0, 0xF0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xF7, 0x6F, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC,
  0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0xF7, 0x7F, 0x77, 0xF3, 0xFF, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7,
  0x8F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xF7, 0x8F, 0x7F, 0xE3, 0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0xFC,
  0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x81, 0xFE, 0x1F, 0xF8, 0xF1, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xDE, 0x0E,
  0xF0, 0x77, 0x83, 0xBC, 0x1D, 0xE0, 0xEF, 0x0F, 0x3C, 0x79, 0xFF, 0x87,
  0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x40, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0x1E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF,
  0x8F, 0x3C, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF0, 0xF0, 0x1F, 0x0F,
  0xF9, 0xFF, 0xF8, 0xFF, 0x1F, 0xE0, 0x1E, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x0F, 0xF8, 0xFF, 0x1F, 0xE3, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0xF0, 0x3D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x78, 0xE3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x71, 0xE3, 0xB8, 0xF1,
  0xDE, 0x79, 0xEF, 0x3C, 0xF7, 0x9E, 0x7B, 0xDF, 0xBC, 0xEF, 0xDC, 0x77,
  0xEE, 0x3B, 0xF7, 0x1F, 0xFF, 0x8F, 0xDF, 0xC7, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x1E, 0x00, 0x78, 0x7B, 0xC7,
  0x8F, 0x3C, 0x79, 0xC1, 0xDE, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x07, 0xF0, 0x3F, 0xC3, 0xDE, 0x1E, 0x79, 0xF3, 0xCF, 0x1E, 0x78,
  0x78, 0xF0, 0x7B, 0xC7, 0x9E, 0x3C, 0x71, 0xE3, 0xCE, 0x1E, 0xF0, 0x77,
  0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7F, 0xFF, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xFF, 0x38, 0x3C,
  0x3C, 0x7C, 0x6E, 0x6E, 0xE6, 0xE7, 0xC7, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1,
  0xC3, 0x8F, 0x3E, 0x1F, 0xCF, 0xFB, 0xCE, 0x03, 0x8F, 0xE7, 0xFB, 0xCE,
  0xE3, 0xB8, 0xEF, 0xFB, 0xFE, 0x7B, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3F, 0xCF, 0xFB, 0xFF, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x3F, 0xFF, 0xFF, 0xBB, 0xC0, 0x3E, 0x3F, 0xBF, 0xFE, 0x7E, 0x3F,
  0x03, 0x81, 0xC0, 0xE3, 0xF9, 0xFF, 0xEF, 0xE3, 0xE0, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xCE, 0xF7, 0xFF, 0xFF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFF, 0x3F, 0xFF, 0x7F, 0xCE, 0xF0, 0x1E, 0x1F, 0xE7, 0xFB,
  0xCF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x27, 0xF9, 0xFE, 0x1F,
  0x00, 0x0F, 0x1F, 0x3F, 0x3C, 0x38, 0xFE, 0xFE, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0xDF, 0xFF, 0xFF, 0xCF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3F, 0xC0,
  0xF0, 0x3D, 0xFE, 0x7F, 0x8F, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3D, 0xCF, 0xFB, 0xFE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xF0, 0x6F, 0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0xF3, 0xC6, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xEF, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE7, 0xBD, 0xE7, 0xBC, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xF1, 0xEE, 0x3D, 0xE7, 0x9C, 0xF3, 0xDE, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x3C, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF3, 0xCE, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xE7, 0x3F, 0xEF, 0xFB,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xC0, 0x1E, 0x1F, 0xEF, 0xFB, 0xCF, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE3,
  0xFC, 0xFF, 0xF9, 0xFE, 0x1E, 0x00, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x3D, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3B, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x00, 0x3E, 0x3F, 0xBF, 0xFC, 0xFF, 0x07, 0xE1, 0xFC,
  0x3F, 0x07, 0xF1, 0xFF, 0xEF, 0xE3, 0xE0, 0x38, 0x70, 0xE7, 0xFF, 0xFF,
  0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xCF, 0x8F, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF,
  0x3B, 0xC0, 0xF1, 0xEE, 0x39, 0xCF, 0x3D, 0xE7, 0xB8, 0x77, 0x0E, 0xE1,
  0xFC, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xE0, 0xF3, 0x9E, 0xE7, 0x39,
  0xCE, 0x73, 0x9E, 0xE7, 0x7D, 0xCF, 0xFB, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E,
  0xF8, 0x7D, 0xF0, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x00, 0x71, 0xCF, 0x78,
  0xEE, 0x1F, 0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x87, 0x71, 0xEF,
  0x3D, 0xE7, 0x1C, 0xF1, 0xEE, 0x39, 0xCF, 0x3D, 0xE7, 0xB8, 0x77, 0x0F,
  0xE1, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x78, 0x38, 0x3F, 0xFF, 0xFF, 0xF8, 0x09, 0xCE, 0xE7, 0x39, 0xCE,
  0x73, 0xBD, 0xCE, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x9C, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0x8E, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xCF,
  0x3D, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8C, 0x00, 0x38, 0xEF, 0x9F,
  0xFF, 0xF3, 0xEE, 0x38,
};

const GFXglyph RobotoCondensed_ExtraBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 6, 7, 8, 1, -18 },
  { 16, 11, 17, 13, 1, -17 },
  { 40, 10, 21, 12, 1, -19 },
  { 67, 13, 17, 15, 1, -17 },
  { 95, 13, 17, 14, 1, -17 },
  { 123, 2, 7, 4, 1, -18 },
  { 125, 6, 24, 8, 1, -19 },
  { 143, 6, 24, 8, 1, -19 },
  { 161, 11, 10, 11, 0, -17 },
  { 175, 10, 13, 11, 1, -14 },
  { 192, 5, 7, 6, 0, -3 },
  { 197, 6, 3, 9, 2, -9 },
  { 200, 5, 4, 7, 1, -4 },
  { 203, 7, 18, 8, 0, -17 },
  { 219, 10, 17, 12, 1, -17 },
  { 241, 7, 17, 12, 2, -17 },
  { 256, 10, 17, 12, 1, -17 },
  { 278, 10, 17, 12, 1, -17 },
  { 300, 10, 17, 12, 1, -17 },
  { 322, 10, 17, 12, 1, -17 },
  { 344, 10, 17, 12, 1, -17 },
  { 366, 10, 17, 12, 1, -17 },
  { 388, 10, 17, 12, 1, -17 },
  { 410, 10, 17, 12, 1, -17 },
  { 432, 5, 13, 7, 1, -13 },
  { 441, 4, 17, 6, 1, -13 },
  { 450, 8, 12, 11, 1, -13 },
  { 462, 9, 9, 12, 2, -12 },
  { 473, 9, 12, 11, 1, -13 },
  { 487, 9, 17, 11, 1, -17 },
  { 507, 17, 22, 18, 1, -17 },
  { 554, 14, 17, 14, 0, -17 },
  { 584, 11, 17, 14, 1, -17 },
  { 608, 12, 17, 14, 1, -17 },
  { 634, 12, 17, 14, 1, -17 },
  { 660, 10, 17, 12, 1, -17 },
  { 682, 10, 17, 11, 1, -17 },
  { 704, 12, 17, 14, 1, -17 },
  { 730, 12, 17, 15, 1, -17 },
  { 756, 4, 17, 7, 1, -17 },
  { 765, 10, 17, 12, 1, -17 },
  { 787, 12, 17, 13, 1, -17 },
  { 813, 10, 17, 11, 1, -17 },
  { 835, 16, 17, 18, 1, -17 },
  { 869, 12, 17, 15, 1, -17 },
  { 895, 12, 17, 14, 1, -17 },
  { 921, 12, 17, 14, 1, -17 },
  { 947, 13, 20, 14, 1, -17 },
  { 980, 12, 17, 13, 1, -17 },
  { 1006, 11, 17, 13, 1, -17 },
  { 1030, 12, 17, 13, 1, -17 },
  { 1056, 12, 17, 14, 1, -17 },
  { 1082, 14, 17, 14, 0, -17 },
  { 1112, 17, 17, 18, 0, -17 },
  { 1149, 13, 17, 13, 0, -17 },
  { 1177, 13, 17, 13, 0, -17 },
  { 1205, 11, 17, 13, 1, -17 },
  { 1229, 5, 24, 6, 1, -20 },
  { 1244, 10, 18, 9, 0, -17 },
  { 1267, 5, 24, 6, 0, -20 },
  { 1282, 8, 9, 10, 1, -17 },
  { 1291, 9, 3, 10, 0, 0 },
  { 1295, 6, 4, 8, 1, -18 },
  { 1298, 10, 13, 11, 1, -13 },
  { 1315, 10, 18, 12, 1, -18 },
  { 1338, 9, 13, 11, 1, -13 },
  { 1353, 10, 18, 12, 1, -18 },
  { 1376, 10, 13, 12, 1, -13 },
  { 1393, 8, 18, 8, 0, -18 },
  { 1411, 10, 18, 12, 1, -13 },
  { 1434, 10, 18, 12, 1, -18 },
  { 1457, 4, 18, 6, 1, -18 },
  { 1466, 6, 23, 6, -1, -18 },
  { 1484, 11, 18, 12, 1, -18 },
  { 1509, 4, 18, 6, 1, -18 },
  { 1518, 16, 13, 18, 1, -13 },
  { 1544, 10, 13, 12, 1, -13 },
  { 1561, 10, 13, 12, 1, -13 },
  { 1578, 10, 18, 12, 1, -13 },
  { 1601, 10, 18, 12, 1, -13 },
  { 1624, 7, 13, 8, 1, -13 },
  { 1636, 9, 13, 11, 1, -13 },
  { 1651, 7, 16, 7, 0, -16 },
  { 1665, 10, 13, 12, 1, -13 },
  { 1682, 11, 13, 11, 0, -13 },
  { 1700, 15, 13, 15, 0, -13 },
  { 1725, 11, 13, 11, 0, -13 },
  { 1743, 11, 18, 11, 0, -13 },
  { 1768, 9, 13, 11, 1, -13 },
  { 1783, 5, 23, 7, 1, -19 },
  { 1798, 2, 20, 6, 2, -17 },
  { 1803, 6, 23, 7, 1, -19 },
  { 1821, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBold24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_EXTRABOLD24PT7B_H_
