#ifndef _ROBOTOCONDENSED_EXTRABOLD63PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold63pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x03, 0xF8, 0xFF, 0x9F, 0xF7, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0x3F, 0xE3, 0xF8, 0x08, 0x00, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7E, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x1F,
  0xF7, 0xFE, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x7F, 0xDF, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0x00, 0x3F, 0x8F, 0xE0, 0x78, 0x07, 0xE0, 0xFC, 0x0F,
  0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x1F, 0x80, 0x7E, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF8, 0xFC, 0x01, 0xF8,
  0x3F, 0x1F, 0x00, 0x3F, 0x0F, 0xE7, 0xE0, 0x07, 0xF1, 0xF8, 0xF8, 0x00,
  0x7F, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xE7, 0xC0, 0x00, 0xFF, 0xF9, 0xF8,
  0x00, 0x0F, 0xFE, 0x3E, 0x00, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0x01, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xF0,
  0x00, 0x07, 0xE7, 0xFF, 0x80, 0x00, 0xFD, 0xFF, 0xF8, 0x00, 0x3F, 0x3F,
  0xFF, 0x00, 0x07, 0xCF, 0xFF, 0xF0, 0x01, 0xF9, 0xFC, 0x7E, 0x00, 0x3E,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x1F, 0x80,
  0x7E, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE0, 0x3F,
  0x8F, 0xC0, 0x1C, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF,
  0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07,
  0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF,
  0xFF, 0xC7, 0xF8, 0x7F, 0xDF, 0xF9, 0xFE, 0x1F, 0xF7, 0xFF, 0x7F, 0x8F,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFB, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFC, 0x00, 0x08, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x04, 0x40, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0x01, 0xF8, 0x04, 0x7C, 0x1F, 0x03, 0xC7, 0xF9,
  0xF0, 0xFE, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x07, 0xC0, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE7,
  0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xF8, 0x7F, 0xE3, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF,
  0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF,
  0xCF, 0xFC, 0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xDF, 0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFD,
  0xFF, 0x00, 0x1F, 0xDF, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0x9F, 0xF0,
  0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFC,
  0x3F, 0xF8, 0x3C, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F,
  0xF8, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x7F,
  0xDF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFD,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x0F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFC, 0x0F,
  0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC,
  0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF8, 0x7F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF,
  0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0x7F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x03,
  0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F,
  0xFD, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0,
  0x1F, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF,
  0xBF, 0xF3, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x1F, 0xC3, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x3F, 0xF3, 0xFE, 0x1F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x03, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0xBF, 0xF0, 0xFF,
  0xDF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0xC1, 0xF8, 0x03, 0xFF, 0xE0, 0x7E,
  0x1F, 0x80, 0x7F, 0xFF, 0x07, 0xE3, 0xF0, 0x0F, 0xFF, 0xF0, 0x7E, 0x3F,
  0x01, 0xFF, 0xFF, 0x03, 0xE3, 0xF0, 0x1F, 0xC3, 0xF0, 0x3E, 0x7F, 0x03,
  0xF8, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xF7, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xE0, 0x7F,
  0x03, 0xF7, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xFF, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xFF,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xEF, 0xC1,
  0xFC, 0x07, 0xE0, 0x3E, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xEF, 0xC1, 0xFE,
  0x07, 0xE0, 0x7E, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x7E, 0x0F, 0xE1, 0xFE, 0x0F, 0xC7, 0xE0, 0xFF, 0x1F, 0xE1,
  0xF8, 0x7E, 0x0F, 0xFF, 0xFF, 0x3F, 0x87, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0x03, 0xFF, 0xBF, 0xFE, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F,
  0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F,
  0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xCF, 0xFC,
  0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xBF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF,
  0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF,
  0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF,
  0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFB,
  0xFF, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0x00, 0xFF, 0xCF,
  0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F,
  0xFC, 0xFF, 0xF7, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF7, 0xF8, 0x1F, 0xDF, 0xFF, 0xFB, 0xFC, 0x0F, 0xEF, 0xFF, 0xFC,
  0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0x87, 0xF3, 0xFF, 0xFF, 0xBF, 0xC3,
  0xF9, 0xFF, 0xFF, 0xCF, 0xE1, 0xFC, 0xFF, 0xFF, 0xE7, 0xF1, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFC, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x7F, 0x1F, 0xFF, 0xFC,
  0x7F, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xBF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0,
  0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xDF, 0xC1, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0xDF,
  0xE1, 0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xF9, 0xFF, 0xFF, 0xC7, 0xF9, 0xFF, 0xFF, 0xC3, 0xF9, 0xFF, 0xFF, 0xC3,
  0xFD, 0xFF, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x3F,
  0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC,
  0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xFB,
  0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F,
  0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF,
  0xF3, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xDF, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xCF,
  0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0xF9, 0xFF,
  0x00, 0xFF, 0x9F, 0xFF, 0xCF, 0xF8, 0x07, 0xFD, 0xFE, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF7, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xBF, 0xDF, 0xF0, 0x0F,
  0xFF, 0xFD, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7F,
  0x7F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xE7, 0xFE, 0x7F, 0xE1, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF,
  0xFC, 0x1F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x7F,
  0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFB, 0xFE, 0x1F, 0xFE, 0xFF, 0x81,
  0xFE, 0x3F, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x40, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0xBF, 0xE0,
  0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF,
  0xBF, 0xE0, 0x7F, 0xDF, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x3F, 0xFD, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFD, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xCF, 0xF0, 0x3F, 0xC3, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF1, 0xFF, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x02, 0x0F, 0xFC, 0x00, 0xC1,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x1F, 0xFE, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0x3F, 0xCF, 0xFC, 0x00, 0x41, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x08, 0x00, 0xFF, 0xC1, 0xC0, 0x3F,
  0xF0, 0x7E, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xC1, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x0E, 0x0F, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x07, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x1F, 0xFC, 0xFF, 0x83, 0xFF, 0x8F, 0xF8,
  0x3F, 0xF8, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC,
  0x0F, 0xF9, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x0F, 0xFB, 0xFF, 0x00, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0x3F, 0xE7, 0xFF, 0x0F, 0xFE, 0x1F, 0xF7,
  0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xBF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x00, 0x80, 0x7F, 0xC7, 0xFC, 0x3F, 0xE7, 0xFF, 0x1F,
  0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xC0,
  0x7F, 0xEF, 0xFC, 0x0F, 0xF9, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x3F, 0xE3, 0xFC, 0x0F, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFC, 0x3F,
  0xE3, 0xFC, 0x0F, 0xF8, 0x10, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0xF3, 0xFC, 0x7F, 0xFE, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFE, 0x1F,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x02, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xE7, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x02, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFD, 0xFF, 0x07, 0xF8, 0xFF, 0x80, 0x40, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F,
  0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFC,
  0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFC, 0x07, 0xFB, 0xFE, 0x07, 0xF0, 0x3F,
  0xEF, 0xF8, 0x1F, 0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0x83, 0xFE, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0xC3, 0xFC, 0x3F, 0xC3, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F,
  0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xF1, 0xFF, 0x0F, 0xF9, 0xFF, 0xE7, 0xF8,
  0x3F, 0xE7, 0xFF, 0x9F, 0xE0, 0x7F, 0xBF, 0xFE, 0x7F, 0x81, 0xFE, 0xFF,
  0xF9, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0xF8, 0x1F, 0xEF, 0xDF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xF3,
  0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF9, 0xFF,
  0x83, 0xFF, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xF8, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x3F,
  0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF7,
  0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xE0,
  0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x07, 0xF9, 0xFF,
  0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x60, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0x83,
  0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xC7, 0xFF, 0x80, 0xFE, 0x7F, 0xFE, 0x07, 0xF3, 0xFF, 0xF0, 0x7F,
  0x3F, 0xFF, 0xC3, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x1F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFF, 0x3F, 0x81, 0xFF, 0xF1, 0xFC, 0x07,
  0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 46, 17, 3, -45 },
  { 65, 17, 17, 20, 1, -47 },
  { 102, 29, 45, 33, 2, -45 },
  { 266, 26, 59, 32, 3, -52 },
  { 458, 35, 47, 40, 3, -46 },
  { 664, 34, 47, 37, 2, -46 },
  { 864, 7, 17, 10, 2, -47 },
  { 879, 15, 64, 20, 4, -50 },
  { 999, 15, 64, 20, 2, -50 },
  { 1119, 28, 27, 29, 1, -45 },
  { 1214, 26, 32, 30, 2, -37 },
  { 1318, 11, 19, 16, 1, -8 },
  { 1345, 16, 8, 25, 4, -23 },
  { 1361, 10, 10, 19, 4, -9 },
  { 1374, 19, 49, 20, 0, -45 },
  { 1491, 26, 47, 32, 3, -46 },
  { 1644, 18, 45, 32, 5, -45 },
  { 1746, 27, 46, 32, 2, -46 },
  { 1902, 27, 47, 32, 2, -46 },
  { 2061, 28, 45, 32, 2, -45 },
  { 2219, 26, 46, 32, 3, -45 },
  { 2369, 27, 46, 32, 3, -45 },
  { 2525, 27, 45, 32, 2, -45 },
  { 2677, 26, 47, 32, 3, -46 },
  { 2830, 26, 46, 32, 3, -46 },
  { 2980, 11, 35, 18, 4, -34 },
  { 3029, 12, 45, 17, 2, -34 },
  { 3097, 22, 30, 28, 2, -34 },
  { 3180, 24, 22, 32, 4, -31 },
  { 3246, 22, 30, 29, 4, -34 },
  { 3329, 25, 47, 29, 1, -46 },
  { 3476, 44, 57, 48, 2, -43 },
  { 3790, 37, 45, 38, 0, -45 },
  { 3999, 30, 45, 36, 3, -45 },
  { 4168, 31, 47, 36, 3, -46 },
  { 4351, 30, 45, 36, 3, -45 },
  { 4520, 26, 45, 31, 3, -45 },
  { 4667, 25, 45, 30, 3, -45 },
  { 4808, 31, 47, 37, 3, -46 },
  { 4991, 32, 45, 39, 3, -45 },
  { 5171, 10, 45, 17, 4, -45 },
  { 5228, 27, 46, 31, 1, -45 },
  { 5384, 32, 45, 35, 3, -45 },
  { 5564, 26, 45, 30, 3, -45 },
  { 5711, 41, 45, 48, 3, -45 },
  { 5942, 32, 45, 38, 3, -45 },
  { 6122, 32, 47, 38, 3, -46 },
  { 6310, 31, 45, 36, 3, -45 },
  { 6485, 32, 54, 38, 3, -46 },
  { 6701, 31, 45, 35, 3, -45 },
  { 6876, 30, 47, 34, 2, -46 },
  { 7053, 31, 45, 35, 2, -45 },
  { 7228, 30, 46, 36, 3, -45 },
  { 7401, 36, 45, 37, 0, -45 },
  { 7604, 45, 45, 47, 1, -45 },
  { 7858, 34, 45, 35, 1, -45 },
  { 8050, 34, 45, 34, 0, -45 },
  { 8242, 30, 45, 34, 2, -45 },
  { 8411, 13, 63, 17, 3, -52 },
  { 8514, 25, 49, 24, 0, -45 },
  { 8668, 12, 63, 17, 1, -52 },
  { 8763, 23, 22, 25, 1, -45 },
  { 8827, 23, 7, 25, 1, 0 },
  { 8848, 16, 10, 21, 2, -48 },
  { 8868, 26, 35, 30, 2, -34 },
  { 8982, 26, 48, 31, 3, -47 },
  { 9138, 25, 35, 29, 2, -34 },
  { 9248, 26, 48, 31, 2, -47 },
  { 9404, 27, 35, 30, 2, -34 },
  { 9523, 19, 48, 21, 1, -48 },
  { 9637, 27, 47, 32, 2, -34 },
  { 9796, 25, 47, 31, 3, -47 },
  { 9943, 10, 47, 16, 3, -47 },
  { 10002, 15, 60, 16, -2, -47 },
  { 10115, 28, 47, 31, 3, -47 },
  { 10280, 10, 47, 16, 3, -47 },
  { 10339, 41, 34, 47, 3, -34 },
  { 10514, 25, 34, 31, 3, -34 },
  { 10621, 27, 35, 31, 2, -34 },
  { 10740, 26, 47, 31, 3, -34 },
  { 10893, 26, 47, 31, 2, -34 },
  { 11046, 17, 34, 21, 3, -34 },
  { 11119, 24, 35, 29, 2, -34 },
  { 11224, 17, 43, 20, 1, -42 },
  { 11316, 25, 34, 31, 3, -33 },
  { 11423, 27, 33, 29, 1, -33 },
  { 11535, 38, 33, 40, 1, -33 },
  { 11692, 27, 33, 29, 1, -33 },
  { 11804, 28, 46, 29, 0, -33 },
  { 11965, 24, 33, 29, 2, -33 },
  { 12064, 15, 60, 19, 2, -49 },
  { 12177, 6, 53, 16, 5, -45 },
  { 12217, 15, 60, 19, 2, -49 },
  { 12330, 29, 14, 35, 3, -25 },
};

const GFXfont RobotoCondensed_ExtraBold63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_EXTRABOLD63PT7B_H_
