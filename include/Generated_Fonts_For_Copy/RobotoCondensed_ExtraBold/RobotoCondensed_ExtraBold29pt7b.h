#ifndef _ROBOTOCONDENSED_EXTRABOLD29PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xEF, 0xFF, 0xE0,
  0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0x0E, 0x60, 0x73, 0x03, 0xB8,
  0x1D, 0xC0, 0xCE, 0x06, 0x71, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0x9C, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x3B, 0x81, 0xDC,
  0x0E, 0xE0, 0x67, 0x03, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F,
  0x01, 0xFE, 0x1F, 0xF1, 0xFF, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF7, 0xC7, 0xBE,
  0x3C, 0xF1, 0xE7, 0xDF, 0x3F, 0xF8, 0xFF, 0x81, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x10, 0xE7, 0x18, 0xE7, 0x38,
  0xE7, 0x30, 0xE7, 0x70, 0x7F, 0x60, 0x7E, 0xE0, 0x3C, 0xC0, 0x01, 0xC0,
  0x01, 0xBC, 0x03, 0xFE, 0x07, 0x7F, 0x07, 0xE7, 0x0E, 0xE3, 0x0E, 0xE3,
  0x1C, 0x67, 0x08, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x0F, 0x80, 0x3F, 0x80,
  0xFF, 0x81, 0xFF, 0x07, 0x8E, 0x0F, 0x1C, 0x1E, 0x78, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0xFC, 0x73, 0xFC, 0xE7, 0xFB, 0xDE, 0xFF, 0xBC, 0xFF,
  0x78, 0xFC, 0xF9, 0xF9, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xE1, 0xF3, 0xE0,
  0xFF, 0xFF, 0xFF, 0x04, 0x18, 0x71, 0xE3, 0x8F, 0x1C, 0x38, 0xF1, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0x60, 0x40, 0x81, 0xC3, 0x83, 0x87, 0x87, 0x0F, 0x1E,
  0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC7,
  0x8F, 0x1C, 0x78, 0xE3, 0x87, 0x08, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x86, 0x07, 0x33, 0xBF, 0xFC, 0xFF, 0xC0, 0xF0, 0x0F, 0x80, 0xEE, 0x0F,
  0x38, 0x71, 0xC0, 0x04, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x7B, 0xDE, 0xF7, 0xBB, 0xDC, 0x40, 0xFF, 0xFF,
  0xFF, 0xF0, 0x67, 0xBF, 0xF7, 0x00, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x0F, 0x81, 0xFC, 0x3F,
  0xE7, 0xFF, 0x78, 0xF7, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF7, 0x8F, 0x78, 0xF7, 0xFF, 0x3F,
  0xE1, 0xFC, 0x0F, 0x80, 0x01, 0x0F, 0x3F, 0xFF, 0xFF, 0xEF, 0x8F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F, 0x78, 0x7B, 0xC3,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x83, 0xFC, 0x7F, 0xEF, 0xFF, 0xF8, 0xFF, 0x0F, 0x00, 0xF0, 0x0F,
  0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xFF, 0x0F,
  0xF8, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x01, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xCF,
  0x1E, 0x78, 0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8, 0x7F, 0xE7, 0xFE, 0x79, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x8F, 0xF8, 0xF7, 0xFF, 0x7F, 0xE3,
  0xFC, 0x0F, 0x80, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x83, 0xE0, 0x3E,
  0x01, 0xE0, 0x0F, 0x78, 0xFF, 0xE7, 0xFF, 0xBF, 0x7D, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xEF, 0x1F, 0x78, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0xC0,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x00, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF, 0x79, 0xF7, 0x8F, 0x78, 0xF7,
  0x9F, 0x7F, 0xE3, 0xFE, 0x1F, 0xC3, 0xFE, 0x79, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xF7, 0xFF, 0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0x0F, 0x03, 0xFC,
  0x3F, 0xE7, 0xFE, 0x78, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0x7D, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x00, 0xF0, 0x1E, 0x03, 0xE1, 0xFC,
  0x1F, 0x81, 0xF0, 0x1C, 0x00, 0x27, 0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x4F, 0x7F, 0xEE, 0x31, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x38, 0x60, 0x00, 0x40, 0x70, 0x7C, 0x7F,
  0x7F, 0xFF, 0x8F, 0x83, 0xE0, 0xFE, 0x1F, 0xF1, 0xFC, 0x1F, 0x01, 0xC0,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x87, 0xF0, 0x7C,
  0x1F, 0x1F, 0xFF, 0xEF, 0xE3, 0xE0, 0xE0, 0x20, 0x00, 0x1F, 0x0F, 0xFB,
  0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x04, 0x03, 0xC0, 0x7C, 0x0F,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0x9F, 0x81, 0xE0, 0x3C,
  0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x78, 0x67, 0x0F, 0xE7, 0x71, 0xFE,
  0x7E, 0x3C, 0xE7, 0xE3, 0x8E, 0x7E, 0x38, 0xC7, 0xE7, 0x8C, 0x7E, 0x71,
  0xC7, 0xE7, 0x1C, 0x7E, 0x71, 0xC7, 0xE7, 0x9C, 0x6E, 0x3F, 0xEE, 0x63,
  0xFF, 0xC7, 0x1C, 0x78, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x3E, 0x07, 0x9F, 0x03, 0xCF,
  0x01, 0xFF, 0x80, 0xF8, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0xEF,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xCF, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3,
  0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0xBC, 0x1F, 0x7C, 0x3C, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9,
  0xFF, 0xEF, 0x0F, 0x78, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF7, 0xFF,
  0xBF, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x07, 0xFE, 0x0F, 0xBC,
  0x1F, 0x7C, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0x7E, 0x00, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x1F, 0xF1,
  0xEF, 0xFE, 0xFF, 0xE7, 0xFC, 0x1F, 0x00, 0xF0, 0xFF, 0xC3, 0xEF, 0x1F,
  0xBC, 0x7C, 0xF3, 0xE3, 0xCF, 0x8F, 0x7C, 0x3D, 0xF0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xEF, 0x8F, 0xBE, 0x3C, 0x7C, 0xF1,
  0xF3, 0xC7, 0xEF, 0x0F, 0xBC, 0x3F, 0xF0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xBF, 0xDC, 0xEF, 0xF7, 0x7B, 0xFD, 0xFE, 0xFF, 0x3F, 0x3F, 0xCF,
  0xCF, 0xF3, 0xF3, 0xFC, 0xFC, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3,
  0xC0, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xDC, 0xFF, 0x7B, 0xFC, 0xEF, 0xF3, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3C, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3, 0xEF,
  0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x1F, 0x7C, 0x3E, 0xFF, 0xF8,
  0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xC3, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x1F, 0x7C,
  0x3E, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0E, 0x00, 0x08, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0,
  0xFB, 0xC3, 0xEF, 0x07, 0xBC, 0x3E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F,
  0xF8, 0xFF, 0xC3, 0xCF, 0x8F, 0x3E, 0x3C, 0x7C, 0xF1, 0xF3, 0xC7, 0xCF,
  0x0F, 0xBC, 0x3E, 0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE,
  0x78, 0x7B, 0xE1, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x78,
  0x7D, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xBC, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xEF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x1F, 0xF1, 0xF1,
  0xFF, 0x9F, 0x1F, 0xF9, 0xF9, 0xEF, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x9F,
  0x9E, 0x7B, 0xFB, 0xE7, 0xBF, 0xBC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xBF, 0xC3, 0xFB, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xF8, 0x3F, 0x9F, 0x81,
  0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0x7C, 0x1F,
  0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C,
  0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xFF, 0xFC, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0xFF, 0xFF, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x83, 0xE0, 0xFC, 0x3F,
  0x1D, 0xC7, 0x39, 0xCE, 0xE3, 0xB8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0xF8, 0xF0, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xBE, 0xF9, 0xE0,
  0x1E, 0x1F, 0xE7, 0xFE, 0x7D, 0xEF, 0x9E, 0xF1, 0xEF, 0x1E, 0xFB, 0xEF,
  0xFE, 0x7F, 0xE3, 0xDF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xEF, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF, 0xBE, 0x3D, 0xF1, 0xEF,
  0x8F, 0x7C, 0x7F, 0xE3, 0xFF, 0x1E, 0xF8, 0xF7, 0xC7, 0xBF, 0xFD, 0xFF,
  0xEF, 0x7E, 0x79, 0xE0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE, 0xF1, 0xEF,
  0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xFF, 0x1E, 0xFF, 0xE7,
  0xFE, 0x3F, 0xC1, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x7F, 0xF1,
  0xEF, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0xE7, 0xFF, 0x3F, 0xE0,
  0xFC, 0x07, 0x87, 0xC7, 0xE7, 0xF3, 0xE1, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x1E, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0x3F,
  0xF1, 0xEF, 0x00, 0xF2, 0x0F, 0x3B, 0xF7, 0xFE, 0x7F, 0xC1, 0xF8, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFB, 0xCF, 0xFE, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x7F, 0xFE, 0xE0, 0x01,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x1E, 0x7C,
  0xF8, 0xE0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0xFF, 0xFB, 0xF7, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE7, 0xDF, 0x3E,
  0xFB, 0xE7, 0xDE, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF8, 0xFB, 0xC7, 0xDF, 0x3E, 0x79, 0xF3, 0xEF, 0x8F, 0x7C, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7,
  0x9F, 0xFD, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x1F, 0xF1, 0xE3,
  0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7,
  0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F,
  0xF3, 0xCF, 0x7E, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8,
  0xF3, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBC,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x1E, 0xF7, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0x7F, 0xF1, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x1F, 0x0F,
  0xF9, 0xFF, 0xFC, 0xFF, 0x1F, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC,
  0x0F, 0xF8, 0xFF, 0x1F, 0xFF, 0xDF, 0xF0, 0xF8, 0x3C, 0x3C, 0x3C, 0xFF,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F,
  0x3F, 0x1F, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF,
  0x7F, 0xF1, 0xEF, 0xF8, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0xDF, 0x1E,
  0xF0, 0xF7, 0x87, 0xBC, 0x1D, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x79, 0xE3, 0xDE, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xF7, 0x8E, 0xFD, 0xE3, 0xBF, 0x78, 0xFF, 0xDC, 0x3F,
  0xFF, 0x0F, 0xEF, 0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0xFB, 0xE7, 0x8F, 0x7C, 0x7B, 0xC1,
  0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0xC3, 0xDE, 0x3E, 0xF9, 0xF3, 0xCF, 0x1F, 0xF8, 0xFB, 0xC7, 0xDE, 0x3C,
  0xF1, 0xE7, 0xDF, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x1F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x38, 0x79, 0xE3, 0xC7, 0x8E, 0x1C,
  0x38, 0x70, 0xE3, 0xC7, 0x9E, 0x38, 0x78, 0x78, 0xF0, 0xE1, 0xC3, 0x87,
  0x0E, 0x1E, 0x3C, 0x3C, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xC3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC3, 0xC7, 0xC7, 0x9F, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x79, 0xE3, 0x86, 0x00, 0x1C, 0x3C, 0xF8, 0xF7, 0xF3, 0x9F, 0xFE,
  0xF3, 0xFB, 0xC7, 0xC0, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 7, 8, 9, 1, -22 },
  { 19, 13, 21, 15, 1, -21 },
  { 54, 13, 27, 15, 1, -24 },
  { 98, 16, 21, 19, 1, -21 },
  { 140, 15, 21, 17, 1, -21 },
  { 180, 3, 8, 5, 1, -22 },
  { 183, 7, 29, 9, 2, -23 },
  { 209, 7, 29, 9, 1, -23 },
  { 235, 13, 13, 13, 0, -21 },
  { 257, 12, 15, 14, 1, -17 },
  { 280, 5, 9, 7, 1, -4 },
  { 286, 7, 4, 11, 2, -11 },
  { 290, 5, 5, 9, 2, -5 },
  { 294, 9, 23, 9, 0, -21 },
  { 320, 12, 21, 15, 1, -21 },
  { 352, 8, 21, 15, 2, -21 },
  { 373, 13, 21, 15, 1, -21 },
  { 408, 12, 21, 15, 1, -21 },
  { 440, 13, 21, 15, 1, -21 },
  { 475, 12, 21, 15, 1, -21 },
  { 507, 13, 21, 15, 1, -21 },
  { 542, 13, 21, 15, 1, -21 },
  { 577, 12, 21, 15, 1, -21 },
  { 609, 12, 21, 15, 1, -21 },
  { 641, 5, 16, 8, 2, -16 },
  { 651, 6, 21, 8, 1, -16 },
  { 667, 10, 14, 13, 1, -16 },
  { 685, 11, 10, 15, 2, -14 },
  { 699, 10, 14, 13, 2, -16 },
  { 717, 11, 21, 13, 1, -21 },
  { 746, 20, 26, 22, 1, -20 },
  { 811, 17, 21, 17, 0, -21 },
  { 856, 13, 21, 16, 2, -21 },
  { 891, 15, 21, 17, 1, -21 },
  { 931, 13, 21, 16, 2, -21 },
  { 966, 12, 21, 14, 2, -21 },
  { 998, 11, 21, 14, 2, -21 },
  { 1027, 15, 21, 17, 1, -21 },
  { 1067, 14, 21, 18, 2, -21 },
  { 1104, 4, 21, 8, 2, -21 },
  { 1115, 12, 21, 14, 1, -21 },
  { 1147, 14, 21, 16, 2, -21 },
  { 1184, 11, 21, 14, 2, -21 },
  { 1213, 18, 21, 22, 2, -21 },
  { 1261, 14, 21, 18, 2, -21 },
  { 1298, 15, 21, 18, 1, -21 },
  { 1338, 13, 21, 17, 2, -21 },
  { 1373, 15, 25, 18, 1, -21 },
  { 1420, 14, 21, 16, 2, -21 },
  { 1457, 14, 21, 16, 1, -21 },
  { 1494, 14, 21, 16, 1, -21 },
  { 1531, 14, 21, 17, 1, -21 },
  { 1568, 17, 21, 17, 0, -21 },
  { 1613, 20, 21, 22, 1, -21 },
  { 1666, 16, 21, 16, 0, -21 },
  { 1708, 16, 21, 16, 0, -21 },
  { 1750, 14, 21, 15, 1, -21 },
  { 1787, 6, 29, 8, 1, -24 },
  { 1809, 12, 23, 11, 0, -21 },
  { 1844, 6, 29, 8, 0, -24 },
  { 1866, 10, 10, 11, 1, -21 },
  { 1879, 11, 3, 12, 0, 0 },
  { 1884, 7, 4, 10, 1, -21 },
  { 1888, 12, 16, 14, 1, -16 },
  { 1912, 13, 22, 14, 1, -22 },
  { 1948, 12, 16, 13, 1, -16 },
  { 1972, 12, 22, 14, 1, -22 },
  { 2005, 12, 16, 14, 1, -16 },
  { 2029, 9, 22, 10, 0, -22 },
  { 2054, 12, 22, 15, 1, -16 },
  { 2087, 12, 22, 14, 1, -22 },
  { 2120, 5, 22, 7, 1, -22 },
  { 2134, 7, 28, 7, -1, -22 },
  { 2159, 13, 22, 14, 1, -22 },
  { 2195, 4, 22, 7, 2, -22 },
  { 2206, 19, 16, 21, 1, -16 },
  { 2244, 12, 16, 14, 1, -16 },
  { 2268, 12, 16, 14, 1, -16 },
  { 2292, 12, 22, 14, 1, -16 },
  { 2325, 12, 22, 14, 1, -16 },
  { 2358, 8, 16, 10, 1, -16 },
  { 2374, 11, 16, 13, 1, -16 },
  { 2396, 8, 19, 9, 0, -19 },
  { 2415, 12, 16, 14, 1, -16 },
  { 2439, 13, 16, 13, 0, -16 },
  { 2465, 18, 16, 18, 0, -16 },
  { 2501, 13, 16, 13, 0, -16 },
  { 2527, 13, 22, 13, 0, -16 },
  { 2563, 11, 16, 13, 1, -16 },
  { 2585, 7, 28, 9, 1, -23 },
  { 2610, 3, 25, 7, 2, -21 },
  { 2620, 7, 28, 9, 1, -23 },
  { 2645, 14, 7, 16, 1, -12 },
};

const GFXfont RobotoCondensed_ExtraBold29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_EXTRABOLD29PT7B_H_
