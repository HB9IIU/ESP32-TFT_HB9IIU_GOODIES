#ifndef _ROBOTOCONDENSED_EXTRABOLD42PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x1E, 0x7D, 0xFF,
  0xFF, 0xF7, 0xC7, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x38,
  0xF0, 0x07, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1E,
  0x01, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x83, 0xCF, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xF7, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0x7E, 0x7E,
  0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x04, 0x0F, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0xF0, 0x78, 0xF1, 0xC0, 0xF1, 0xE7, 0x81,
  0xE3, 0xCE, 0x03, 0xFF, 0xBC, 0x03, 0xFE, 0x70, 0x03, 0xFD, 0xE0, 0x03,
  0xE7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x01,
  0xEF, 0xF0, 0x03, 0xDF, 0xF0, 0x0F, 0x7F, 0xF0, 0x1C, 0xF1, 0xE0, 0x79,
  0xE3, 0xC0, 0xE3, 0xC7, 0x83, 0xC7, 0x8F, 0x07, 0x0F, 0x1E, 0x1E, 0x1E,
  0x3C, 0x18, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x7C, 0x3F,
  0xF8, 0xF8, 0x7F, 0xF9, 0xF1, 0xFB, 0xFB, 0xE3, 0xF7, 0xFF, 0xCF, 0xE7,
  0xFF, 0x9F, 0xC7, 0xFE, 0x3F, 0x87, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0x1F,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF,
  0xC0, 0x7E, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xE0,
  0x00, 0xC0, 0x70, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x01, 0xC0, 0x30, 0x40, 0x0E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC0,
  0x70, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x38, 0x78, 0x6F, 0xDE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0xCF, 0x03, 0xE3,
  0xE0, 0xF0, 0x7C, 0x1C, 0x0E, 0x00, 0x02, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x18, 0x7E, 0x7E, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7,
  0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7E, 0xFC, 0x3F, 0x7F, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x30, 0x0F, 0x07, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0x7E, 0xFE,
  0x0F, 0xDF, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE1, 0xFD, 0xF8, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x7F, 0x1F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFE, 0x03, 0xDF, 0xC0, 0xFB, 0xF8, 0x1E, 0x7F, 0x07, 0xCF, 0xE0,
  0xF9, 0xFC, 0x3E, 0x3F, 0x87, 0xC7, 0xF1, 0xF0, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xDF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0xF0, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0x7E, 0xFE, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xEF, 0x83, 0xF7, 0xF8, 0xFF,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0xFE, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD,
  0xF8, 0x7E, 0x7F, 0x3F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xF3, 0xF9, 0xFD, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF,
  0x0F, 0xDF, 0x8F, 0xEF, 0xE7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0xBF, 0x87, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0xFF, 0xDF,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF9, 0xFB, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xF3, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x31, 0xFB, 0xF7, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x63, 0xF7, 0xFF, 0xFF, 0xFF, 0x3C, 0x0C, 0x3F, 0x7F,
  0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0x78, 0x10, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC1, 0xFC, 0x03,
  0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x0F,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x0F, 0x81, 0xE3, 0xC0, 0xFF, 0x87, 0x8F, 0x07, 0xFF, 0x1E,
  0x3C, 0x3F, 0xFC, 0x79, 0xE0, 0xF9, 0xF0, 0xE7, 0x87, 0xC7, 0xC3, 0x9E,
  0x1E, 0x1F, 0x0F, 0x78, 0x78, 0x78, 0x3D, 0xE3, 0xE1, 0xE0, 0xF7, 0x8F,
  0x87, 0x83, 0x9E, 0x3E, 0x1E, 0x0E, 0xF8, 0xF8, 0x78, 0x3B, 0xE3, 0xE1,
  0xE1, 0xE7, 0x8F, 0x87, 0x87, 0x9E, 0x3E, 0x3E, 0x1C, 0x78, 0xF8, 0xF8,
  0xF1, 0xE1, 0xFF, 0xF7, 0xC7, 0x87, 0xFF, 0xFE, 0x1F, 0x0F, 0xEF, 0xF0,
  0x3C, 0x1E, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x60, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFC,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0,
  0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7F, 0x9F, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xE7,
  0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x3F,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x3F, 0xE7, 0xF9, 0xFC, 0x0F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0xC7, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xC7,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF,
  0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF,
  0xC0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0xFE,
  0x07, 0xFB, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xBF, 0xFD, 0xF0, 0xFB, 0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF0,
  0xF7, 0xFF, 0xDF, 0x9F, 0x7F, 0xFC, 0xF9, 0xF7, 0xFF, 0xCF, 0x9F, 0x7F,
  0xFC, 0xFB, 0xE7, 0xFF, 0xE7, 0xFE, 0x7F, 0xFE, 0x7F, 0xE7, 0xFF, 0xE7,
  0xFE, 0x7F, 0xFE, 0x7F, 0xC7, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F, 0xC7,
  0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE,
  0x1F, 0x87, 0xFF, 0xE1, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0x7C, 0xFF, 0xFB, 0xE7, 0xFF, 0xDF, 0xBF,
  0xFE, 0x7D, 0xFF, 0xF3, 0xEF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0xC7, 0xF0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE,
  0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFE, 0x01, 0xFB, 0xF8,
  0x07, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0xC7, 0xF0, 0x7F, 0xBF, 0x80,
  0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFE, 0x01,
  0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0xCF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF,
  0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xF8, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x7F,
  0x8F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x9F, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x0F, 0x81, 0xFB, 0xF0, 0x3F,
  0x07, 0xEF, 0xE1, 0xFC, 0x1F, 0xBF, 0x87, 0xF0, 0x7E, 0x7E, 0x1F, 0xC3,
  0xF9, 0xF8, 0x7F, 0x0F, 0xE7, 0xE1, 0xFE, 0x3F, 0x1F, 0x87, 0xF8, 0xFC,
  0x7F, 0x3F, 0xE3, 0xF1, 0xFC, 0xFF, 0x8F, 0xC3, 0xF3, 0xFE, 0x3F, 0x0F,
  0xCF, 0xFD, 0xFC, 0x3F, 0x3F, 0xF7, 0xE0, 0xFD, 0xFF, 0xDF, 0x83, 0xF7,
  0xFF, 0x7E, 0x0F, 0xFF, 0x7D, 0xF8, 0x1F, 0xFD, 0xF7, 0xE0, 0x7F, 0xF7,
  0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F,
  0x01, 0xFE, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7E, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x07, 0xEF,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xE0,
  0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xF8,
  0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xE3,
  0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF8,
  0x79, 0xF1, 0xF1, 0xE3, 0xE3, 0xE7, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x8F, 0xE7, 0xE3, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0x8F, 0xEF, 0xE3, 0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xDF, 0x83, 0xE7, 0xF0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xCF, 0x83, 0xF7, 0xF8,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0xFE, 0xFC, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xE3, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xDF, 0xE3, 0xF3, 0xE0, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xFD, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x7E, 0xFC, 0x3F, 0x7F, 0x1F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0xFC, 0x7F, 0xBF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x1F, 0x3F, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE0, 0xFD,
  0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x04, 0x7F, 0x07, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x7F, 0x0F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x07, 0xC7,
  0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xF7,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x1F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xF3, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC7, 0x07, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x3E, 0x1F, 0xBF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0x7D, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x87, 0xE1, 0xFC,
  0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF3, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE3, 0xF0, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFF,
  0x7E, 0x1F, 0xCF, 0xC7, 0xF1, 0xF9, 0xFE, 0x3F, 0x3F, 0x87, 0xEF, 0xE0,
  0xFD, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0x9F, 0xC3,
  0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF9, 0xF8, 0x7F, 0x3F, 0x07, 0xF7,
  0xE0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x1F, 0x1F, 0xBF, 0xCF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0x9F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3F, 0x87,
  0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0xC3,
  0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x3F,
  0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F,
  0xC3, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0xF8, 0x7E,
  0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x1F, 0xDF, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0xF8,
  0x3F, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x8F, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFE, 0x3F,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFD, 0xFE, 0x3F, 0x3E, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xCF, 0xC7, 0xFB,
  0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x1F, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xEF, 0xC1, 0xF3, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF7, 0xF3,
  0xF1, 0xFD, 0xF8, 0xFE, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFC,
  0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFF, 0x3F, 0xE3, 0xFC,
  0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFD, 0xF8,
  0xFC, 0xFC, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x8F, 0xE3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x3C, 0x1F, 0xFE, 0x1F,
  0x0F, 0xBF, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7, 0xE7, 0xC7, 0xE3, 0xF3, 0xE3,
  0xF9, 0xF9, 0xF9, 0xFC, 0xF8, 0xFD, 0xFE, 0x7C, 0x7E, 0xFF, 0x3E, 0x1F,
  0x7F, 0xFF, 0x0F, 0xBF, 0xFF, 0x87, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xC1,
  0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0xFE, 0x1F, 0x9F, 0x8F, 0xE7, 0xE3, 0xF1, 0xFC,
  0xFC, 0x3F, 0x7E, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF3, 0xF1, 0xF8,
  0xFE, 0xFE, 0x1F, 0xBF, 0x07, 0xE0, 0xFE, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xFD,
  0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x80, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x3F,
  0x8F, 0xE3, 0xE0, 0xFC, 0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3C, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x1C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x07, 0xF0, 0xFC, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x7C,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE1, 0xF8, 0xFC, 0x1E, 0x07, 0x01, 0x80, 0x0F, 0x00, 0x07, 0xF8,
  0x3D, 0xFF, 0x8F, 0xBF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xBE, 0x3F,
  0xF7, 0xC3, 0xFC, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 30, 11, 2, -30 },
  { 28, 11, 11, 13, 1, -32 },
  { 44, 19, 30, 22, 1, -30 },
  { 116, 18, 38, 21, 2, -34 },
  { 202, 23, 30, 27, 2, -30 },
  { 289, 23, 30, 25, 1, -30 },
  { 376, 5, 12, 7, 1, -32 },
  { 384, 10, 42, 14, 2, -33 },
  { 437, 11, 42, 14, 1, -33 },
  { 495, 18, 18, 19, 1, -30 },
  { 536, 17, 22, 20, 1, -25 },
  { 583, 7, 13, 11, 1, -5 },
  { 595, 10, 5, 16, 3, -15 },
  { 602, 8, 7, 12, 2, -7 },
  { 609, 13, 33, 13, 0, -30 },
  { 663, 17, 30, 21, 2, -30 },
  { 727, 12, 30, 21, 3, -30 },
  { 772, 19, 30, 21, 1, -30 },
  { 844, 18, 30, 21, 1, -30 },
  { 912, 19, 30, 21, 1, -30 },
  { 984, 18, 30, 21, 2, -30 },
  { 1052, 18, 30, 21, 2, -30 },
  { 1120, 19, 30, 21, 1, -30 },
  { 1192, 17, 30, 21, 2, -30 },
  { 1256, 17, 30, 21, 2, -30 },
  { 1320, 7, 24, 12, 3, -24 },
  { 1341, 8, 32, 11, 1, -24 },
  { 1373, 15, 20, 19, 1, -23 },
  { 1411, 16, 14, 21, 3, -20 },
  { 1439, 16, 20, 19, 2, -23 },
  { 1479, 16, 30, 19, 1, -30 },
  { 1539, 30, 38, 32, 1, -29 },
  { 1682, 25, 30, 25, 0, -30 },
  { 1776, 20, 30, 24, 2, -30 },
  { 1851, 21, 30, 24, 2, -30 },
  { 1930, 20, 30, 24, 2, -30 },
  { 2005, 18, 30, 21, 2, -30 },
  { 2073, 17, 30, 20, 2, -30 },
  { 2137, 21, 30, 25, 2, -30 },
  { 2216, 21, 30, 26, 2, -30 },
  { 2295, 6, 30, 12, 3, -30 },
  { 2318, 17, 30, 21, 1, -30 },
  { 2382, 22, 30, 23, 2, -30 },
  { 2465, 17, 30, 20, 2, -30 },
  { 2529, 28, 30, 32, 2, -30 },
  { 2634, 21, 30, 26, 2, -30 },
  { 2713, 22, 30, 25, 2, -30 },
  { 2796, 20, 30, 24, 2, -30 },
  { 2871, 22, 35, 25, 2, -30 },
  { 2968, 21, 30, 24, 2, -30 },
  { 3047, 20, 30, 23, 1, -30 },
  { 3122, 21, 30, 23, 1, -30 },
  { 3201, 20, 30, 24, 2, -30 },
  { 3276, 24, 30, 24, 0, -30 },
  { 3366, 30, 30, 31, 1, -30 },
  { 3479, 23, 30, 24, 0, -30 },
  { 3566, 23, 30, 23, 0, -30 },
  { 3653, 20, 30, 22, 1, -30 },
  { 3728, 8, 42, 11, 2, -35 },
  { 3770, 17, 33, 16, 0, -30 },
  { 3841, 8, 42, 11, 1, -35 },
  { 3883, 15, 15, 17, 1, -30 },
  { 3912, 16, 5, 17, 0, 0 },
  { 3922, 11, 6, 14, 1, -31 },
  { 3931, 18, 22, 20, 1, -22 },
  { 3981, 18, 32, 21, 2, -32 },
  { 4053, 17, 22, 19, 1, -22 },
  { 4100, 18, 32, 21, 1, -32 },
  { 4172, 18, 22, 20, 1, -22 },
  { 4222, 12, 32, 14, 1, -32 },
  { 4270, 18, 31, 21, 1, -22 },
  { 4340, 17, 32, 21, 2, -32 },
  { 4408, 7, 31, 11, 2, -31 },
  { 4436, 10, 40, 11, -1, -31 },
  { 4486, 19, 32, 20, 2, -32 },
  { 4562, 7, 32, 11, 2, -32 },
  { 4590, 27, 22, 31, 2, -22 },
  { 4665, 17, 22, 21, 2, -22 },
  { 4712, 18, 22, 21, 1, -22 },
  { 4762, 18, 31, 21, 2, -22 },
  { 4832, 18, 31, 21, 1, -22 },
  { 4902, 11, 22, 14, 2, -22 },
  { 4933, 17, 22, 19, 1, -22 },
  { 4980, 11, 28, 13, 1, -28 },
  { 5019, 17, 22, 21, 2, -22 },
  { 5066, 19, 22, 19, 0, -22 },
  { 5119, 25, 22, 26, 1, -22 },
  { 5188, 18, 22, 19, 1, -22 },
  { 5238, 19, 31, 19, 0, -22 },
  { 5312, 15, 22, 19, 2, -22 },
  { 5354, 10, 40, 12, 1, -33 },
  { 5404, 3, 36, 11, 4, -30 },
  { 5418, 10, 40, 12, 1, -33 },
  { 5468, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_ExtraBold42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBold42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBold42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_EXTRABOLD42PT7B_H_
