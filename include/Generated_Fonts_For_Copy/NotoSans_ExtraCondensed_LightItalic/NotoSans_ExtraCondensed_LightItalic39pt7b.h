#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x30, 0x38, 0x0C, 0x00, 0x71, 0xB0, 0xD8,
  0xCC, 0x66, 0x32, 0x1B, 0x09, 0x8C, 0xC6, 0x43, 0x00, 0x00, 0x43, 0x00,
  0xC3, 0x00, 0xC2, 0x00, 0x86, 0x01, 0x86, 0x01, 0x84, 0x01, 0x8C, 0x03,
  0x0C, 0x1F, 0xFF, 0x1F, 0xFF, 0x02, 0x18, 0x06, 0x10, 0x06, 0x30, 0x04,
  0x30, 0x0C, 0x30, 0x0C, 0x60, 0x08, 0x60, 0xFF, 0xF8, 0xFF, 0xF8, 0x10,
  0xC0, 0x30, 0xC0, 0x30, 0x80, 0x31, 0x80, 0x61, 0x80, 0x61, 0x00, 0x63,
  0x00, 0x43, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x3F, 0xC0, 0xFB, 0xC3, 0x10, 0x86, 0x20, 0x18, 0x40, 0x31, 0x80,
  0x62, 0x00, 0xC4, 0x00, 0xC8, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x0D, 0x80, 0x11, 0x80, 0x23, 0x00, 0x46, 0x00, 0x8C,
  0x03, 0x18, 0x04, 0x61, 0x08, 0xC3, 0xFF, 0x07, 0xFC, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x0F, 0x01, 0x83, 0x70, 0x20, 0xC6, 0x0C,
  0x18, 0xC1, 0x06, 0x18, 0x60, 0xC3, 0x08, 0x18, 0x63, 0x02, 0x0C, 0x40,
  0xC1, 0x18, 0x18, 0x62, 0x03, 0x0C, 0xC0, 0x61, 0x91, 0xCC, 0x66, 0x7D,
  0x8C, 0x98, 0xB3, 0x32, 0x1F, 0xE4, 0xC3, 0x79, 0x98, 0x60, 0x22, 0x08,
  0x0C, 0xC3, 0x01, 0x18, 0x60, 0x63, 0x0C, 0x08, 0x41, 0x83, 0x08, 0x20,
  0x41, 0x0C, 0x18, 0x21, 0x86, 0x06, 0x60, 0xC0, 0xD8, 0x30, 0x1F, 0x00,
  0x01, 0xF0, 0x0E, 0xC0, 0x31, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x63,
  0x01, 0x8C, 0x06, 0x30, 0x19, 0x80, 0x6C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x06, 0xC0, 0x31, 0x8D, 0x86, 0x66, 0x19, 0xB0, 0x36, 0xC0,
  0xF3, 0x03, 0xCC, 0x0E, 0x30, 0x38, 0xC0, 0xE3, 0x07, 0x8F, 0xF3, 0x1F,
  0x8C, 0x37, 0x66, 0x66, 0x4C, 0xCC, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x23, 0x0F, 0x62, 0x7F,
  0xC3, 0xE0, 0xF0, 0x32, 0x0E, 0x61, 0x86, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x71, 0x86, 0x30, 0xC2, 0x18, 0xC0,
  0xFF, 0xFF, 0x5F, 0x60, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x81, 0x86, 0x18, 0x30, 0xC1,
  0x8C, 0x0C, 0x60, 0x67, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0xC0, 0x36,
  0x01, 0xB0, 0x1D, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x03, 0xB0, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x63, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x1F, 0xC0,
  0xF8, 0x00, 0x03, 0x07, 0x0F, 0x1B, 0x76, 0xE6, 0x46, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x01, 0xF8, 0x0F, 0xF8, 0x08, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x01,
  0xF8, 0x0F, 0xF8, 0x18, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x61, 0x01, 0xC3,
  0xDF, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x16,
  0x00, 0x36, 0x00, 0x2C, 0x00, 0x6C, 0x00, 0xCC, 0x00, 0x8C, 0x01, 0x8C,
  0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x04, 0x18, 0x0C, 0x30, 0x18, 0x30,
  0x18, 0x30, 0x30, 0x30, 0x20, 0x30, 0x60, 0x60, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xFF, 0x03, 0xFE, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xC0,
  0x1F, 0xE0, 0x08, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x80, 0xE0, 0xF7, 0xC0, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x19, 0xF0, 0x6F, 0xE1, 0xE1, 0xC7, 0x03, 0x38, 0x0C,
  0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x8C, 0x06,
  0x30, 0x38, 0xC0, 0xC1, 0x87, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xFE, 0x3F,
  0xFC, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x18, 0x30, 0x60, 0x70, 0xC0, 0x61,
  0x80, 0xC7, 0x01, 0x8E, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0xE0, 0x33,
  0x80, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x0E, 0x70, 0x30, 0x60, 0xC0, 0xE3,
  0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x61, 0xC1, 0xC1, 0xEF, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x61,
  0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0,
  0x33, 0x00, 0xCC, 0x07, 0x30, 0x1C, 0xC0, 0xE1, 0x87, 0x87, 0xF6, 0x0F,
  0x98, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x0D, 0xF0, 0x3F, 0x00, 0x04, 0x1C, 0x38, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x83,
  0x87, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x0F, 0x87, 0xF8, 0x43, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xC0, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x3E, 0x33, 0x06, 0x63, 0x30, 0xC6, 0x32, 0x18, 0x43,
  0x61, 0x8C, 0x36, 0x30, 0xC2, 0x63, 0x0C, 0x64, 0x20, 0x86, 0xC2, 0x18,
  0x6C, 0x61, 0x84, 0xC6, 0x18, 0xCC, 0x63, 0x08, 0xC6, 0x31, 0x8C, 0x65,
  0x90, 0xC3, 0xDF, 0x0C, 0x10, 0x40, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x86, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x19, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18,
  0x60, 0x70, 0xC0, 0xC1, 0x81, 0x83, 0x07, 0xFE, 0x0F, 0xFC, 0x38, 0x18,
  0x60, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x9C, 0x03, 0x30, 0x06, 0xE0,
  0x0D, 0x80, 0x1F, 0x00, 0x30, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0x0E, 0x06,
  0x07, 0x06, 0x03, 0x06, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x0C,
  0x06, 0x0C, 0x0E, 0x0C, 0x1C, 0x1F, 0xF8, 0x1F, 0xE0, 0x18, 0x70, 0x18,
  0x18, 0x38, 0x18, 0x30, 0x1C, 0x30, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x70,
  0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x70, 0x60, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0x82, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x03,
  0xFC, 0x07, 0x0E, 0x06, 0x07, 0x06, 0x03, 0x06, 0x03, 0x06, 0x03, 0x0C,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x07, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30,
  0x0C, 0x30, 0x0C, 0x70, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x60, 0x61,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xFF, 0x03, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x3C, 0x0C, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x03,
  0xF1, 0x80, 0xF8, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18,
  0xE0, 0x0C, 0x38, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x70, 0x1C, 0x0E,
  0x06, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0x00, 0x60, 0x60, 0x18, 0x1C,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0E, 0x06, 0x01, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x38, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x60, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0F, 0x01, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x03, 0x01, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x18, 0x06, 0x0E,
  0x01, 0x87, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00,
  0xCC, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x76,
  0x00, 0x39, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x1C, 0x38, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x1C, 0x0C,
  0x03, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0F, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xD8, 0x1E, 0x00,
  0x78, 0x1B, 0x00, 0x6C, 0x0D, 0x80, 0x36, 0x06, 0xC0, 0x33, 0x03, 0x60,
  0x1B, 0x81, 0x90, 0x19, 0x81, 0x88, 0x0C, 0xC0, 0xC4, 0x0C, 0x60, 0x63,
  0x06, 0x30, 0x31, 0x86, 0x38, 0x30, 0xC3, 0x18, 0x18, 0x63, 0x8C, 0x0C,
  0x31, 0x86, 0x06, 0x18, 0xC3, 0x03, 0x0C, 0xC3, 0x03, 0x06, 0x61, 0x81,
  0x83, 0x60, 0xC0, 0xC1, 0xB0, 0x60, 0x60, 0xF0, 0x30, 0x30, 0x78, 0x30,
  0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x38, 0x06,
  0x07, 0x80, 0x60, 0x78, 0x06, 0x07, 0x80, 0x60, 0x78, 0x06, 0x06, 0xC0,
  0xC0, 0xCC, 0x0C, 0x0C, 0xC0, 0xC0, 0xCC, 0x0C, 0x0C, 0xC1, 0xC0, 0xC4,
  0x18, 0x18, 0x61, 0x81, 0x86, 0x18, 0x18, 0x61, 0x81, 0x86, 0x30, 0x38,
  0x63, 0x03, 0x03, 0x30, 0x30, 0x33, 0x03, 0x03, 0x30, 0x30, 0x36, 0x06,
  0x03, 0x60, 0x60, 0x36, 0x06, 0x01, 0xE0, 0x60, 0x1E, 0x06, 0x01, 0xC0,
  0xC0, 0x1C, 0x0C, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xE1, 0xC0,
  0xC0, 0x60, 0xE0, 0x30, 0x60, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0x38, 0x03,
  0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x03, 0x38, 0x01, 0x9C, 0x01, 0xCE,
  0x00, 0xC7, 0x00, 0x63, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x30, 0x38, 0x30,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1C, 0x70, 0x30,
  0x70, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x87, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x30, 0x38, 0x60, 0x61, 0x81, 0xC3, 0x07, 0x06, 0x3C, 0x0F, 0xF0, 0x3E,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0x60, 0x1C, 0x60,
  0x0E, 0x30, 0x07, 0x38, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x67,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x03,
  0x38, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x60, 0xC0,
  0x70, 0x60, 0x30, 0x38, 0x30, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1C, 0x70, 0x30, 0x70, 0x60, 0x60, 0xC0,
  0xC1, 0x81, 0x87, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x38, 0x60, 0x61,
  0x81, 0xC3, 0x07, 0x07, 0xFC, 0x0F, 0xE0, 0x38, 0xC0, 0x61, 0x80, 0xC3,
  0x01, 0x86, 0x03, 0x0C, 0x0E, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0xC3, 0x01, 0xC6, 0x03, 0x80, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0x02,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x80, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0x83, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x70, 0x0C, 0x30,
  0x06, 0x18, 0x07, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x0E, 0x18, 0x06,
  0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xE0,
  0x60, 0x30, 0x70, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xC0, 0x0F, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0,
  0x61, 0x80, 0xC3, 0x03, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0xE0,
  0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x70, 0x0C, 0xC0, 0x19,
  0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x06, 0xC0, 0x38,
  0x06, 0xC0, 0x28, 0x0E, 0xC0, 0x78, 0x0C, 0xC0, 0x78, 0x0C, 0xC0, 0x58,
  0x18, 0xC0, 0xD8, 0x18, 0xC0, 0xD8, 0x38, 0xC1, 0x98, 0x30, 0xC1, 0x98,
  0x30, 0xC1, 0x18, 0x60, 0xC3, 0x18, 0x60, 0xC3, 0x18, 0xE0, 0xC6, 0x18,
  0xC0, 0xC6, 0x18, 0xC0, 0xC4, 0x19, 0x80, 0xCC, 0x19, 0x80, 0xCC, 0x19,
  0x80, 0xD8, 0x1B, 0x00, 0xD8, 0x1B, 0x00, 0xD8, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x16, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x18,
  0x00, 0x03, 0x80, 0xC0, 0x60, 0x60, 0x18, 0x38, 0x06, 0x0C, 0x01, 0x87,
  0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x36, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x60,
  0x07, 0x18, 0x01, 0x87, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x00, 0xC0, 0xC0, 0x3E, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0E,
  0x30, 0x61, 0x87, 0x0C, 0x30, 0x63, 0x83, 0x18, 0x19, 0xC0, 0xCC, 0x06,
  0xC0, 0x16, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x61, 0x86, 0x08, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x61, 0x86, 0x18, 0x60, 0x83, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0x60, 0x19, 0x80, 0xC6, 0x06,
  0x0C, 0x18, 0x30, 0xC0, 0xE3, 0x01, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x30,
  0xFF, 0xFF, 0xFC, 0xCC, 0x66, 0x23, 0x03, 0xC4, 0x1F, 0xB0, 0xE3, 0xC7,
  0x07, 0x18, 0x1C, 0xC0, 0x63, 0x01, 0x9C, 0x06, 0x60, 0x19, 0x80, 0xC6,
  0x03, 0x38, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE3,
  0x03, 0x8E, 0x16, 0x1D, 0xD0, 0x3E, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x33,
  0xE0, 0xDF, 0xC3, 0xC3, 0x0E, 0x0C, 0x30, 0x31, 0xC0, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x01, 0x9C,
  0x06, 0x70, 0x39, 0xC0, 0xC7, 0x07, 0x14, 0x38, 0xDD, 0xC3, 0x3E, 0x00,
  0x03, 0xF0, 0x7E, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x03, 0xCC, 0x07, 0xEC, 0x0C, 0x3C, 0x1C, 0x1C, 0x18, 0x1C,
  0x30, 0x18, 0x30, 0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30,
  0xE0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xE0,
  0xC0, 0xE0, 0xE1, 0x60, 0x77, 0x40, 0x3E, 0xC0, 0x03, 0xE0, 0x7F, 0x0C,
  0x31, 0x83, 0x38, 0x33, 0x03, 0x30, 0x36, 0x06, 0x60, 0xC6, 0x78, 0xFF,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x47, 0xB8, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x2E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0x01, 0xFB,
  0x03, 0x0F, 0x07, 0x07, 0x06, 0x07, 0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x06,
  0x18, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x30, 0x18, 0x30, 0x18, 0x30, 0x38, 0x30, 0x38, 0x38, 0x58, 0x1D, 0xF0,
  0x0F, 0xB0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x81, 0xC0, 0xF7, 0x80, 0x7F, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x33, 0xE0, 0xDF, 0x83, 0xC7, 0x0E, 0x0C, 0x30, 0x31, 0xC0, 0xC6, 0x06,
  0x18, 0x18, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x30, 0xC0, 0xC3, 0x03,
  0x0C, 0x0C, 0x60, 0x31, 0x81, 0x86, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x03,
  0x80, 0x03, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0x60, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x30,
  0xC1, 0xC3, 0x06, 0x0C, 0x30, 0x31, 0x81, 0x8E, 0x06, 0x30, 0x19, 0x80,
  0x6C, 0x01, 0xF0, 0x0D, 0x60, 0x39, 0x80, 0xE6, 0x03, 0x18, 0x18, 0x60,
  0x61, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC0, 0xC3, 0x03, 0x00, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0x60, 0xC0, 0xC0, 0x0C, 0xF0, 0xF0, 0x6F, 0xDF, 0xC3, 0xC7,
  0x86, 0x1C, 0x18, 0x30, 0xC0, 0xC1, 0x8E, 0x0E, 0x0C, 0x60, 0x60, 0x63,
  0x03, 0x03, 0x18, 0x18, 0x18, 0xC0, 0xC1, 0x8C, 0x0C, 0x0C, 0x60, 0x60,
  0x63, 0x03, 0x03, 0x18, 0x18, 0x19, 0xC1, 0xC1, 0x8C, 0x0C, 0x0C, 0x60,
  0x60, 0x63, 0x03, 0x03, 0x18, 0x18, 0x19, 0x81, 0x81, 0x8C, 0x0C, 0x0C,
  0x00, 0x0C, 0xF8, 0x37, 0xE0, 0xF1, 0xC3, 0x83, 0x0C, 0x0C, 0x70, 0x31,
  0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x0C, 0x30, 0x30,
  0xC0, 0xC7, 0x03, 0x18, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30, 0x18,
  0xC0, 0xE0, 0x03, 0xE0, 0x3F, 0x83, 0x0C, 0x30, 0x33, 0x81, 0x98, 0x0C,
  0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x1B, 0x01, 0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x38, 0x70, 0xEF, 0x03, 0xE0,
  0x00, 0x03, 0x3E, 0x01, 0xBF, 0x80, 0xF0, 0xC0, 0x70, 0x60, 0x30, 0x30,
  0x38, 0x1C, 0x1C, 0x0E, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x30, 0x30, 0x18, 0x38, 0x1C, 0x1C,
  0x0C, 0x0E, 0x0E, 0x07, 0x0E, 0x06, 0xFE, 0x03, 0x3E, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC4, 0x1F, 0xB0, 0xC3, 0xC6, 0x07,
  0x18, 0x1C, 0xC0, 0x63, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0xC6, 0x03,
  0x38, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03,
  0x8E, 0x16, 0x1D, 0xF0, 0x3E, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0xF0,
  0xDE, 0x0F, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0x04, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x20,
  0x71, 0xEF, 0x07, 0xF0, 0x00, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x1F, 0x7F,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE8, 0xF8, 0x18, 0x0C, 0x60, 0x61, 0x81,
  0x86, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x03, 0x0C, 0x0C, 0x30, 0x31, 0xC0,
  0xC6, 0x03, 0x18, 0x18, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x38, 0xC0,
  0xC3, 0x07, 0x0C, 0x3C, 0x3F, 0xB0, 0x7C, 0x80, 0xC0, 0x3C, 0x06, 0xC0,
  0x6C, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x18, 0xC3, 0x0C, 0x30, 0xC6,
  0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xCC, 0x0D, 0x80, 0xD8, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x60, 0x78, 0x1C, 0x0F, 0x03, 0x83, 0xE0,
  0x70, 0x6C, 0x1E, 0x0D, 0x83, 0xC3, 0x30, 0xD8, 0x66, 0x1B, 0x0C, 0xC2,
  0x63, 0x18, 0xCC, 0x63, 0x19, 0x98, 0x66, 0x33, 0x0C, 0xC6, 0x61, 0x90,
  0xD8, 0x36, 0x1B, 0x06, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x06, 0x00, 0x06, 0x07, 0x06, 0x06, 0x06, 0x0C,
  0x03, 0x0C, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x60, 0x60, 0xE0, 0x60,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x06, 0x06, 0x01, 0x83, 0x80,
  0x60, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xBC, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0xF8, 0x03, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x1F, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x78, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x05,
  0xFC, 0x1C, 0x3F, 0xE0, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 28, 9, 0, -28 },
  { 33, 9, 10, 12, 4, -28 },
  { 45, 16, 28, 15, 0, -28 },
  { 101, 15, 32, 14, 0, -30 },
  { 161, 19, 28, 22, 2, -28 },
  { 228, 14, 28, 15, 0, -28 },
  { 277, 4, 10, 6, 4, -28 },
  { 282, 11, 34, 10, 1, -28 },
  { 329, 11, 34, 10, -3, -28 },
  { 376, 11, 12, 13, 4, -30 },
  { 393, 14, 18, 16, 1, -23 },
  { 425, 6, 9, 7, -2, -4 },
  { 432, 8, 2, 10, 1, -12 },
  { 434, 3, 4, 7, 1, -4 },
  { 436, 17, 28, 12, -2, -28 },
  { 496, 13, 28, 14, 1, -28 },
  { 542, 8, 28, 14, 4, -28 },
  { 570, 15, 28, 14, -1, -28 },
  { 623, 15, 28, 14, -1, -28 },
  { 676, 16, 28, 14, -1, -28 },
  { 732, 16, 28, 14, -1, -28 },
  { 788, 14, 28, 14, 1, -28 },
  { 837, 15, 28, 14, 1, -28 },
  { 890, 15, 28, 14, 0, -28 },
  { 943, 14, 28, 14, 0, -28 },
  { 992, 7, 21, 7, 0, -21 },
  { 1011, 9, 26, 7, -2, -21 },
  { 1041, 14, 17, 16, 1, -22 },
  { 1071, 14, 10, 16, 1, -19 },
  { 1089, 14, 17, 16, 1, -22 },
  { 1119, 11, 28, 10, 1, -28 },
  { 1158, 20, 31, 21, 1, -28 },
  { 1236, 15, 28, 14, -3, -28 },
  { 1289, 16, 28, 16, 0, -28 },
  { 1345, 16, 28, 14, 1, -28 },
  { 1401, 16, 28, 17, 0, -28 },
  { 1457, 15, 28, 14, 0, -28 },
  { 1510, 15, 28, 13, 0, -28 },
  { 1563, 18, 28, 18, 1, -28 },
  { 1626, 19, 28, 18, 0, -28 },
  { 1693, 13, 28, 8, -2, -28 },
  { 1739, 14, 35, 7, -6, -28 },
  { 1801, 18, 28, 15, 0, -28 },
  { 1864, 10, 28, 12, 0, -28 },
  { 1899, 25, 28, 24, 0, -28 },
  { 1987, 20, 28, 19, 0, -28 },
  { 2057, 17, 28, 18, 1, -28 },
  { 2117, 15, 28, 15, 0, -28 },
  { 2170, 17, 35, 18, 1, -28 },
  { 2245, 15, 28, 15, 0, -28 },
  { 2298, 16, 28, 14, -1, -28 },
  { 2354, 12, 28, 12, 3, -28 },
  { 2396, 17, 28, 17, 1, -28 },
  { 2456, 15, 28, 15, 3, -28 },
  { 2509, 24, 28, 24, 3, -28 },
  { 2593, 18, 28, 13, -2, -28 },
  { 2656, 13, 28, 13, 3, -28 },
  { 2702, 17, 28, 12, -2, -28 },
  { 2762, 14, 34, 11, -1, -28 },
  { 2822, 6, 28, 13, 4, -28 },
  { 2843, 14, 34, 11, -2, -28 },
  { 2903, 14, 14, 15, 1, -28 },
  { 2928, 11, 2, 11, -3, 3 },
  { 2931, 4, 6, 9, 6, -30 },
  { 2934, 14, 21, 16, 1, -21 },
  { 2971, 14, 30, 15, 0, -30 },
  { 3024, 12, 21, 11, 1, -21 },
  { 3056, 16, 30, 16, 1, -30 },
  { 3116, 12, 21, 14, 1, -21 },
  { 3148, 18, 39, 8, -5, -30 },
  { 3236, 16, 30, 16, -1, -21 },
  { 3296, 14, 30, 15, 0, -30 },
  { 3349, 8, 28, 7, 0, -28 },
  { 3377, 13, 37, 7, -5, -28 },
  { 3438, 14, 30, 13, 0, -30 },
  { 3491, 8, 30, 7, 0, -30 },
  { 3521, 21, 21, 23, 0, -21 },
  { 3577, 14, 21, 15, 0, -21 },
  { 3614, 13, 21, 15, 1, -21 },
  { 3649, 17, 30, 15, -2, -21 },
  { 3713, 14, 30, 16, 1, -21 },
  { 3766, 12, 21, 10, 0, -21 },
  { 3798, 13, 21, 12, -1, -21 },
  { 3833, 8, 26, 8, 1, -26 },
  { 3859, 14, 21, 15, 1, -21 },
  { 3896, 12, 21, 12, 2, -21 },
  { 3928, 19, 21, 20, 2, -21 },
  { 3978, 16, 21, 12, -2, -21 },
  { 4020, 18, 30, 12, -4, -21 },
  { 4088, 12, 21, 10, -1, -21 },
  { 4120, 14, 34, 12, 1, -28 },
  { 4180, 2, 39, 14, 6, -30 },
  { 4190, 13, 34, 12, -2, -28 },
  { 4246, 14, 4, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC39PT7B_H_
