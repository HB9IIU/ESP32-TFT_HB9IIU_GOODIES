#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x44, 0x40, 0x8C, 0x9A, 0xAA, 0x1A, 0x24, 0x53,
  0xF2, 0x45, 0x0A, 0x7E, 0x50, 0xA2, 0x45, 0x00, 0x08, 0x30, 0xBA, 0x45,
  0x06, 0x0C, 0x0C, 0x28, 0x50, 0xA7, 0x82, 0x08, 0x00, 0x72, 0x92, 0x94,
  0x94, 0xAA, 0xAD, 0xD5, 0x19, 0x29, 0x29, 0x4A, 0xCE, 0x18, 0x92, 0x8A,
  0x30, 0x85, 0x25, 0x96, 0x29, 0xBA, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x08,
  0x84, 0x21, 0x04, 0x21, 0x00, 0x10, 0x82, 0x10, 0x84, 0x22, 0x10, 0x88,
  0x44, 0x22, 0x00, 0x25, 0x1E, 0xC9, 0x00, 0x20, 0x82, 0x08, 0xFC, 0x82,
  0x08, 0x29, 0x40, 0xF0, 0x60, 0x03, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x92, 0x51, 0x45, 0x14, 0x61, 0x8A,
  0x29, 0x1C, 0x2E, 0x94, 0x92, 0x52, 0x40, 0x1E, 0x04, 0x08, 0x10, 0x20,
  0x82, 0x04, 0x10, 0x41, 0x07, 0xE0, 0x3C, 0x10, 0x41, 0x08, 0xC0, 0x82,
  0x08, 0x21, 0xBC, 0x04, 0x31, 0x45, 0x28, 0xA4, 0xA2, 0xFC, 0x41, 0x04,
  0x3C, 0x82, 0x10, 0x41, 0xE0, 0x82, 0x08, 0x21, 0xBC, 0x1E, 0x40, 0x82,
  0x05, 0x0D, 0x11, 0x42, 0x85, 0x12, 0x23, 0x80, 0x7C, 0x20, 0x82, 0x10,
  0x42, 0x08, 0x41, 0x08, 0x20, 0x3C, 0x94, 0x49, 0x28, 0x47, 0xA2, 0x8A,
  0x28, 0x9C, 0x3C, 0x94, 0x51, 0x45, 0x17, 0xC2, 0x08, 0x21, 0x38, 0x24,
  0x00, 0x04, 0x80, 0x11, 0x00, 0x00, 0x02, 0x44, 0x80, 0x04, 0x66, 0x20,
  0xC0, 0xC0, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0x03, 0x03, 0x18, 0x8C, 0x20,
  0x78, 0x42, 0x11, 0x10, 0x88, 0x40, 0x11, 0x00, 0x0F, 0x08, 0x48, 0x24,
  0xD4, 0xAA, 0x95, 0x53, 0x29, 0x95, 0x4F, 0x20, 0x08, 0x07, 0xC0, 0x04,
  0x30, 0xC5, 0x14, 0x52, 0x4F, 0x45, 0x18, 0x61, 0x3C, 0x44, 0x89, 0x12,
  0x4F, 0x11, 0x22, 0x44, 0x8A, 0x27, 0x80, 0x1C, 0x84, 0x10, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x1C, 0x3C, 0x44, 0x89, 0x12, 0x28, 0x50, 0xA1, 0x44,
  0x8A, 0x27, 0x80, 0x3E, 0x40, 0x81, 0x02, 0x0F, 0x10, 0x20, 0x41, 0x02,
  0x07, 0x80, 0x3E, 0x40, 0x81, 0x02, 0x08, 0x1E, 0x20, 0x41, 0x02, 0x04,
  0x00, 0x1E, 0x41, 0x04, 0x08, 0x10, 0x23, 0x42, 0x85, 0x0A, 0x23, 0xC0,
  0x31, 0x21, 0x21, 0x22, 0x22, 0x7E, 0x42, 0x42, 0x44, 0x84, 0x84, 0x84,
  0x1C, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x38, 0x0C, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x8C, 0x00, 0x33, 0x22, 0x24,
  0x28, 0x30, 0x50, 0x70, 0x50, 0x48, 0x88, 0x88, 0x88, 0x32, 0x22, 0x24,
  0x44, 0x48, 0x8F, 0x30, 0x66, 0x08, 0xC3, 0x18, 0x63, 0x14, 0xA2, 0x94,
  0xA2, 0x94, 0x54, 0x92, 0x92, 0x22, 0x44, 0x80, 0x30, 0x98, 0x8C, 0x46,
  0x22, 0x92, 0x51, 0x28, 0x94, 0x4A, 0x45, 0x21, 0x10, 0x80, 0x3C, 0x45,
  0x0C, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12, 0x27, 0x80, 0x3C, 0x44, 0x89,
  0x12, 0x48, 0x9E, 0x20, 0x40, 0x82, 0x04, 0x00, 0x3C, 0x45, 0x0C, 0x18,
  0x30, 0x61, 0x42, 0x85, 0x12, 0x27, 0x82, 0x02, 0x04, 0x00, 0x3C, 0x44,
  0x89, 0x12, 0x49, 0x9C, 0x28, 0x48, 0x92, 0x24, 0x40, 0x3E, 0x41, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x08, 0x10, 0x27, 0x80, 0xFC, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x42, 0x85, 0x12, 0x28, 0x50, 0xA1, 0x44,
  0x89, 0x12, 0x47, 0x80, 0x87, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x48, 0xA1,
  0x43, 0x06, 0x00, 0x84, 0x30, 0x8A, 0x31, 0x46, 0x49, 0x49, 0x29, 0x25,
  0x45, 0x28, 0xA5, 0x18, 0xC3, 0x18, 0x62, 0x00, 0x11, 0x12, 0x12, 0x14,
  0x18, 0x08, 0x18, 0x18, 0x28, 0x48, 0x48, 0x88, 0x85, 0x24, 0x94, 0x51,
  0x84, 0x10, 0x41, 0x08, 0x20, 0x1E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x81, 0x07, 0xC0, 0x1C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x0E, 0x00, 0xAA, 0xA5, 0x55, 0x1C, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x20, 0x8E, 0x00, 0x18, 0x30, 0xA1, 0x24, 0x58,
  0x40, 0xF0, 0xD4, 0x3A, 0x49, 0x12, 0x24, 0x50, 0xA2, 0x44, 0x78, 0x10,
  0x82, 0x08, 0x3C, 0x94, 0x51, 0x45, 0x14, 0x72, 0xF0, 0x19, 0x10, 0x84,
  0x42, 0x08, 0x70, 0x03, 0x02, 0x02, 0x02, 0x3A, 0x24, 0x44, 0x44, 0x44,
  0x84, 0x88, 0x88, 0x78, 0x3C, 0x94, 0x52, 0x72, 0x08, 0x10, 0x70, 0x07,
  0x04, 0x08, 0x08, 0x1C, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x40, 0xC0, 0x3A, 0x49, 0x12, 0x24, 0x50, 0xA2, 0x44, 0x78,
  0x10, 0x40, 0x8E, 0x00, 0x10, 0x82, 0x08, 0x3C, 0x94, 0x51, 0x45, 0x24,
  0xA2, 0x88, 0x30, 0x02, 0x24, 0x44, 0x44, 0x88, 0x0C, 0x00, 0x02, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x30, 0x10, 0x82, 0x08, 0x24,
  0xA5, 0x14, 0x71, 0x45, 0x24, 0x98, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48,
  0x80, 0x3F, 0x92, 0x51, 0x28, 0x94, 0x8A, 0x45, 0x25, 0x12, 0x89, 0x00,
  0x3C, 0x94, 0x51, 0x45, 0x24, 0xA2, 0x88, 0x3C, 0x94, 0x51, 0x46, 0x18,
  0xA2, 0x70, 0x1E, 0x24, 0x89, 0x12, 0x24, 0x48, 0xB2, 0x78, 0x81, 0x04,
  0x08, 0x00, 0x3A, 0x49, 0x12, 0x24, 0x50, 0xA2, 0x44, 0x78, 0x10, 0x20,
  0x81, 0x00, 0x39, 0x10, 0x84, 0x21, 0x10, 0x80, 0x3A, 0x10, 0x82, 0x08,
  0x42, 0xE0, 0x22, 0x72, 0x44, 0x44, 0x88, 0xC0, 0x24, 0x94, 0x51, 0x45,
  0x28, 0xA2, 0x78, 0x8C, 0xA5, 0x2A, 0x53, 0x18, 0x80, 0x89, 0x99, 0x9A,
  0xAA, 0xAA, 0xCC, 0xCC, 0xC8, 0x88, 0x22, 0x28, 0x60, 0xC1, 0x06, 0x0A,
  0x24, 0xC8, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x20, 0xC0, 0x3C, 0x20, 0x84, 0x10, 0x82, 0x10, 0xF0, 0x0C, 0x41,
  0x04, 0x10, 0x42, 0x30, 0x20, 0x84, 0x10, 0x41, 0x02, 0x00, 0xFF, 0xFF,
  0x80, 0x18, 0x20, 0x82, 0x08, 0x20, 0x83, 0x10, 0x42, 0x08, 0x20, 0x8C,
  0x00, 0xE6, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 4, 4, 5, 2, -12 },
  { 9, 7, 12, 7, 0, -12 },
  { 20, 7, 14, 6, 0, -13 },
  { 33, 8, 12, 10, 1, -12 },
  { 45, 6, 12, 6, 0, -12 },
  { 54, 1, 4, 3, 2, -12 },
  { 55, 5, 15, 4, 0, -12 },
  { 65, 5, 15, 4, -1, -12 },
  { 75, 5, 5, 6, 2, -13 },
  { 79, 6, 8, 7, 1, -10 },
  { 85, 3, 4, 3, -1, -2 },
  { 87, 4, 1, 4, 0, -5 },
  { 88, 2, 2, 3, 0, -2 },
  { 89, 8, 12, 5, -1, -12 },
  { 101, 6, 12, 6, 0, -12 },
  { 110, 3, 12, 6, 2, -12 },
  { 115, 7, 12, 6, -1, -12 },
  { 126, 6, 12, 6, 0, -12 },
  { 135, 6, 12, 6, 0, -12 },
  { 144, 6, 12, 6, 0, -12 },
  { 153, 7, 12, 6, 0, -12 },
  { 164, 6, 12, 6, 1, -12 },
  { 173, 6, 12, 6, 0, -12 },
  { 182, 6, 12, 6, 0, -12 },
  { 191, 3, 9, 3, 0, -9 },
  { 195, 4, 11, 3, -1, -9 },
  { 201, 6, 8, 7, 1, -10 },
  { 207, 6, 4, 7, 1, -8 },
  { 210, 6, 8, 7, 1, -10 },
  { 216, 5, 12, 5, 0, -12 },
  { 224, 9, 13, 9, 0, -12 },
  { 239, 6, 12, 6, -1, -12 },
  { 248, 7, 12, 7, 0, -12 },
  { 259, 6, 12, 6, 1, -12 },
  { 268, 7, 12, 7, 0, -12 },
  { 279, 7, 12, 6, 0, -12 },
  { 290, 7, 12, 6, 0, -12 },
  { 301, 7, 12, 8, 1, -12 },
  { 312, 8, 12, 8, 0, -12 },
  { 324, 6, 12, 4, -1, -12 },
  { 333, 6, 15, 3, -2, -12 },
  { 345, 8, 12, 6, 0, -12 },
  { 357, 4, 12, 5, 0, -12 },
  { 363, 11, 12, 10, 0, -12 },
  { 380, 9, 12, 8, 0, -12 },
  { 394, 7, 12, 8, 1, -12 },
  { 405, 7, 12, 6, 0, -12 },
  { 416, 7, 15, 8, 1, -12 },
  { 430, 7, 12, 7, 0, -12 },
  { 441, 7, 12, 6, 0, -12 },
  { 452, 6, 12, 5, 1, -12 },
  { 461, 7, 12, 8, 1, -12 },
  { 472, 7, 12, 6, 1, -12 },
  { 483, 11, 12, 11, 1, -12 },
  { 500, 8, 12, 6, -1, -12 },
  { 512, 6, 12, 5, 1, -12 },
  { 521, 7, 12, 5, -1, -12 },
  { 532, 6, 15, 5, 0, -12 },
  { 544, 2, 12, 6, 2, -12 },
  { 547, 6, 15, 5, -1, -12 },
  { 559, 7, 6, 7, 0, -12 },
  { 565, 4, 1, 5, -1, 1 },
  { 566, 2, 3, 4, 2, -13 },
  { 567, 7, 9, 7, 0, -9 },
  { 575, 6, 13, 7, 0, -13 },
  { 585, 5, 9, 5, 0, -9 },
  { 591, 8, 13, 7, 0, -13 },
  { 604, 6, 9, 6, 0, -9 },
  { 611, 8, 17, 4, -2, -13 },
  { 628, 7, 13, 7, 0, -9 },
  { 640, 6, 13, 7, 0, -13 },
  { 650, 4, 12, 3, 0, -12 },
  { 656, 6, 16, 3, -2, -12 },
  { 668, 6, 13, 6, 0, -13 },
  { 678, 4, 13, 3, 0, -13 },
  { 685, 9, 9, 10, 0, -9 },
  { 696, 6, 9, 7, 0, -9 },
  { 703, 6, 9, 7, 0, -9 },
  { 710, 7, 13, 7, -1, -9 },
  { 722, 7, 13, 7, 0, -9 },
  { 734, 5, 9, 4, 0, -9 },
  { 740, 5, 9, 5, 0, -9 },
  { 746, 4, 11, 4, 0, -11 },
  { 752, 6, 9, 7, 0, -9 },
  { 759, 5, 9, 5, 1, -9 },
  { 765, 8, 9, 9, 1, -9 },
  { 774, 7, 9, 5, -1, -9 },
  { 782, 8, 13, 5, -2, -9 },
  { 795, 6, 9, 4, -1, -9 },
  { 802, 6, 15, 5, 0, -12 },
  { 814, 1, 17, 6, 2, -13 },
  { 817, 6, 15, 5, -1, -12 },
  { 829, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC17PT7B_H_
