#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x0E,
  0x3C, 0x3C, 0x70, 0x78, 0xE0, 0xF3, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C,
  0x1E, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x0E, 0x0E,
  0x18, 0x1C, 0x70, 0x38, 0xE0, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0x80, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x18, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF8,
  0xC3, 0x80, 0x70, 0x60, 0x40, 0x78, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x1E, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03,
  0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x3C, 0x60, 0x00,
  0x0F, 0x60, 0x00, 0x07, 0xB0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xDE, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x18, 0x78, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x07, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0xC1, 0xE0, 0x40, 0x61, 0xE0, 0x38, 0x31, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x70, 0x07, 0xF8, 0x00, 0xE0,
  0x1E, 0x70, 0x03, 0x80, 0x38, 0x70, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x07, 0x00, 0x70, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x38, 0x03, 0x80,
  0x60, 0x70, 0x07, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x83, 0x80, 0x1C, 0x07,
  0x0E, 0x00, 0x30, 0x0E, 0x1C, 0x00, 0xE0, 0x18, 0x70, 0x01, 0xC0, 0x70,
  0xE0, 0x03, 0x80, 0xE3, 0x83, 0xC7, 0x01, 0xC7, 0x1F, 0xCE, 0x07, 0x1C,
  0x7F, 0xDC, 0x0E, 0x38, 0xE3, 0xB8, 0x38, 0xE3, 0x83, 0xF0, 0x71, 0xC7,
  0x07, 0xE1, 0xC7, 0x1C, 0x0E, 0xFF, 0x0E, 0x38, 0x1D, 0xFE, 0x38, 0xE0,
  0x39, 0xF0, 0x71, 0xC0, 0x70, 0x01, 0xC3, 0x80, 0xE0, 0x03, 0x8E, 0x01,
  0x80, 0x0E, 0x1C, 0x07, 0x00, 0x1C, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x1C,
  0x00, 0xE0, 0xC0, 0x38, 0x03, 0x83, 0x80, 0x60, 0x07, 0x07, 0x01, 0xC0,
  0x1C, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x01,
  0xC0, 0x70, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x03, 0x87, 0x00, 0x70, 0x07, 0x9E, 0x01, 0xC0, 0x07, 0xF8, 0x07, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38,
  0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70,
  0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x73,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x0F, 0x1E, 0x0F, 0x0E, 0x1C, 0x07,
  0x0E, 0x3C, 0x07, 0x1E, 0x38, 0x07, 0x9C, 0x78, 0x07, 0xBC, 0x70, 0x03,
  0xB8, 0x70, 0x03, 0xB8, 0x70, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0x70, 0x07, 0xE0, 0x78, 0x0F,
  0xF0, 0x78, 0x1E, 0xF0, 0x3F, 0xFC, 0x70, 0x3F, 0xF8, 0x78, 0x1F, 0xF0,
  0x78, 0x03, 0x00, 0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x10, 0x38, 0x0F, 0x0C,
  0x03, 0xF3, 0x02, 0x3F, 0xDF, 0x81, 0xFF, 0xE0, 0x1F, 0xC4, 0x0F, 0x00,
  0x07, 0x60, 0x03, 0x9C, 0x03, 0xC7, 0x01, 0xE0, 0xE0, 0x70, 0x38, 0x08,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x33, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0x70,
  0x1E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x78,
  0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xC7,
  0x00, 0x0F, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x07, 0x83, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x07, 0xF0,
  0x7F, 0x07, 0xB8, 0x79, 0xC7, 0x8E, 0xF8, 0xF7, 0x87, 0x10, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x30, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1E, 0x03, 0xE0, 0x0C, 0x00, 0xF0, 0x02, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x40, 0x03,
  0xC0, 0x30, 0x07, 0xE0, 0x1F, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x63, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xF0, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x01,
  0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3E,
  0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x40, 0x03, 0xC0, 0x30, 0x07, 0xE0, 0x1F, 0xBF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE1, 0xFC, 0x01, 0xCF, 0xFC, 0x07, 0xBF, 0xFC, 0x0E, 0xE0, 0x78, 0x1D,
  0x80, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x00, 0xE1, 0xF0, 0x01, 0xC3, 0xC0,
  0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0,
  0x70, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0xF8, 0x03,
  0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x81, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x00,
  0x3C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0E,
  0x00, 0x38, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0x78, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x01, 0xE1, 0xE0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x0F,
  0x01, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xF3, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xC1, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC1, 0xC0, 0x0F,
  0x83, 0x80, 0x1F, 0x07, 0x80, 0x7E, 0x0F, 0x81, 0xFC, 0x0F, 0xDF, 0x70,
  0x0F, 0xFC, 0xE0, 0x0F, 0xE3, 0xC0, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x07, 0xBF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x81,
  0xE0, 0x40, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x7F,
  0x07, 0x0E, 0x01, 0xFF, 0x07, 0x0E, 0x03, 0xC7, 0x07, 0x1C, 0x07, 0x07,
  0x07, 0x1C, 0x0E, 0x07, 0x07, 0x18, 0x0E, 0x0E, 0x07, 0x38, 0x1C, 0x0E,
  0x07, 0x38, 0x1C, 0x0E, 0x07, 0x30, 0x38, 0x0C, 0x06, 0x70, 0x38, 0x1C,
  0x06, 0x70, 0x30, 0x1C, 0x0E, 0x70, 0x70, 0x1C, 0x0E, 0x70, 0x70, 0x18,
  0x0E, 0x60, 0x70, 0x38, 0x0C, 0xE0, 0x60, 0x38, 0x1C, 0xE0, 0xE0, 0x38,
  0x1C, 0xE0, 0xE0, 0x78, 0x18, 0xE0, 0xE0, 0x70, 0x38, 0xE0, 0xE0, 0x70,
  0x38, 0xE0, 0xE0, 0xF0, 0x30, 0xC0, 0xE0, 0xF0, 0x70, 0xC0, 0xE1, 0xB0,
  0xE0, 0xC0, 0xF3, 0xB1, 0xC0, 0xC0, 0x7F, 0x3F, 0xC0, 0xC0, 0x7E, 0x1F,
  0x00, 0xC0, 0x18, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x40, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x01,
  0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xF0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80,
  0x03, 0x9E, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xE0, 0xFC, 0x00,
  0x70, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x01, 0xE0,
  0x0E, 0x01, 0xF0, 0x03, 0x87, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01,
  0xE0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x1C,
  0x00, 0xF8, 0x07, 0x00, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFC, 0x06, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3C, 0x7F, 0x80, 0x07, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C,
  0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x3C,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0E, 0x01, 0xF8, 0x01, 0xC1,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0x10, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x04, 0x1E, 0x00, 0x3F, 0xE0, 0x70, 0x00, 0xFF, 0x81, 0xC0,
  0x03, 0xFE, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x07,
  0x80, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xF0, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x0E, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1D, 0xF8,
  0x00, 0x00, 0xEF, 0xC0, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x7E, 0x70, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xDC, 0x00,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x00, 0xFF,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x00, 0x3D, 0xE0, 0x07, 0x38, 0x00,
  0x1C, 0xF0, 0x03, 0x9C, 0x00, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x71,
  0xC0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x01,
  0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0,
  0x07, 0x07, 0x00, 0xF0, 0xE0, 0x07, 0x83, 0x80, 0x70, 0x70, 0x03, 0x81,
  0xC0, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x38, 0x3C, 0x00, 0xE0, 0x70, 0x3C,
  0x1E, 0x00, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x78, 0x1C, 0x1E, 0x07, 0x00,
  0x38, 0x0E, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x0F, 0x03, 0xC0, 0x0E, 0x03,
  0x87, 0x01, 0xE0, 0x0F, 0x01, 0xC7, 0x80, 0xE0, 0x07, 0x80, 0xE3, 0x80,
  0x70, 0x03, 0x80, 0x71, 0xC0, 0x38, 0x01, 0xC0, 0x39, 0xC0, 0x3C, 0x00,
  0xE0, 0x1C, 0xE0, 0x1E, 0x00, 0xF0, 0x0E, 0xE0, 0x0E, 0x00, 0x78, 0x07,
  0x70, 0x07, 0x00, 0x38, 0x03, 0xF8, 0x03, 0x80, 0x1C, 0x01, 0xF8, 0x03,
  0xC0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0xEE, 0x00,
  0x1E, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0xEF, 0x00, 0x1C, 0x00, 0xE7, 0x00,
  0x1C, 0x01, 0xE7, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x3C, 0x01, 0xC7, 0x00,
  0x3C, 0x01, 0xC7, 0x00, 0x38, 0x01, 0xC7, 0x80, 0x38, 0x03, 0xC3, 0x80,
  0x38, 0x03, 0x83, 0x80, 0x78, 0x03, 0x83, 0x80, 0x78, 0x03, 0x83, 0x80,
  0x70, 0x07, 0x83, 0x80, 0x70, 0x07, 0x83, 0xC0, 0xF0, 0x07, 0x01, 0xC0,
  0xF0, 0x07, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0xE0, 0x0F, 0x01, 0xC0,
  0xE0, 0x0F, 0x01, 0xC1, 0xE0, 0x0E, 0x01, 0xE1, 0xE0, 0x0E, 0x00, 0xE1,
  0xC0, 0x0E, 0x00, 0xE1, 0xC0, 0x1E, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0xE3,
  0xC0, 0x1C, 0x00, 0xF3, 0xC0, 0x1C, 0x00, 0x73, 0x80, 0x3C, 0x00, 0x73,
  0x80, 0x3C, 0x00, 0x73, 0x80, 0x38, 0x00, 0x77, 0x80, 0x38, 0x00, 0x77,
  0x00, 0x38, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x1F,
  0xC0, 0x07, 0x01, 0xF0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x3C,
  0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0,
  0x70, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1C, 0x01, 0xE0,
  0x0E, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0x03, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x70,
  0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03,
  0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x1F,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0x1F, 0xC0, 0x07, 0x01, 0xF0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x3C, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03,
  0x80, 0x70, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x03,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xF0,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x04, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x10, 0x00, 0x7C, 0x01, 0xC0,
  0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x3C,
  0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x78, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x80,
  0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x71,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0x77, 0x80, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0xF0, 0x00, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0xFC, 0x00, 0x38, 0xF0, 0x00, 0xFC, 0x00, 0x78,
  0xF0, 0x01, 0xDC, 0x00, 0x78, 0xF0, 0x01, 0xDC, 0x00, 0x70, 0xF0, 0x01,
  0xDC, 0x00, 0xF0, 0xF0, 0x03, 0x98, 0x00, 0xE0, 0xF0, 0x03, 0x98, 0x01,
  0xE0, 0xF0, 0x07, 0xB8, 0x01, 0xE0, 0xF0, 0x07, 0x38, 0x01, 0xC0, 0xF0,
  0x07, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x38,
  0x03, 0x80, 0xE0, 0x1E, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x38, 0x0E, 0x00, 0xE0, 0x38,
  0x38, 0x0E, 0x00, 0xE0, 0x38, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x38, 0x1C,
  0x00, 0xE0, 0x70, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x37, 0x80, 0x00, 0xFC,
  0x00, 0x37, 0x00, 0x00, 0xFC, 0x00, 0x37, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00,
  0x70, 0x3C, 0x03, 0xC0, 0xF0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1C,
  0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xF0,
  0x03, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x78, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1E,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x06, 0x07,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0x1C, 0x03, 0xFF, 0x38, 0x0F, 0xDE, 0x70,
  0x3C, 0x0E, 0xE0, 0xF0, 0x0F, 0x81, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x0E,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1,
  0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x78, 0x1E,
  0x01, 0xF0, 0x3C, 0x07, 0xE0, 0x3C, 0x1D, 0xC0, 0x7E, 0xF3, 0x80, 0x7F,
  0xC6, 0x00, 0x7F, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0xC0, 0x01, 0xE3, 0xF8, 0x01, 0xCF, 0xFC, 0x01,
  0xDE, 0x7E, 0x01, 0xD8, 0x1E, 0x03, 0xF0, 0x0E, 0x03, 0xE0, 0x0E, 0x03,
  0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x7C, 0x01, 0xE0, 0x7E, 0x03, 0xC0, 0x76,
  0x07, 0xC0, 0x77, 0x9F, 0x80, 0xE3, 0xFF, 0x00, 0xE1, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0xE0,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x40, 0x7E, 0x78, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0xE0, 0x01, 0xFE, 0x38, 0x00, 0xFF, 0xCE, 0x00,
  0x7E, 0xF7, 0x80, 0x3C, 0x0F, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xF0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x1B, 0x80, 0x1C, 0x0E, 0xE0, 0x07, 0xCF, 0x38,
  0x00, 0xFF, 0x8C, 0x00, 0x1F, 0xC7, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0x1E, 0x03, 0xC0, 0xE0,
  0x78, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xC0, 0x0E,
  0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x0F,
  0x87, 0x01, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x40, 0x7E, 0x3C, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFC, 0x70, 0x01, 0xFF, 0x9C, 0x00, 0xFD, 0xE7, 0x00, 0x78,
  0x1D, 0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x01,
  0xC0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x3C,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x3C, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0,
  0x70, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x03, 0xE0, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0,
  0x3F, 0x00, 0x3C, 0x1D, 0xC0, 0x0F, 0xDE, 0xF0, 0x01, 0xFF, 0x38, 0x00,
  0x3F, 0x8E, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x20,
  0x03, 0xC0, 0x0C, 0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0xF3, 0xFC, 0x01, 0xCF, 0xFC, 0x03, 0xBF, 0xF8, 0x07, 0xE0, 0x78, 0x1F,
  0x80, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0,
  0x0E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01,
  0xE0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x3C,
  0x0E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81,
  0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0xF0, 0x03,
  0x80, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0xC0,
  0x78, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xF0, 0x03, 0x81, 0xE0, 0x03, 0x83,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0E, 0xFC,
  0x00, 0x0E, 0xFC, 0x00, 0x0F, 0xDC, 0x00, 0x1F, 0x9C, 0x00, 0x1F, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x07,
  0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x38, 0xFF, 0x0F, 0xF0, 0x07, 0x3F, 0xE3, 0xFF, 0x00, 0xEF,
  0x7E, 0xFB, 0xF0, 0x1F, 0x83, 0xD8, 0x1E, 0x07, 0xC0, 0x3E, 0x01, 0xC0,
  0xF8, 0x07, 0xC0, 0x38, 0x1E, 0x00, 0xF0, 0x07, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x07, 0x83, 0xC0, 0x1E,
  0x00, 0xF0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xC0,
  0x0E, 0x00, 0x70, 0x78, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x03, 0x81,
  0xC0, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x01,
  0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x0E, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0x07,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70,
  0x03, 0x83, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x8F,
  0xF0, 0x07, 0x3F, 0xF0, 0x0E, 0xFF, 0xE0, 0x1F, 0x81, 0xE0, 0x76, 0x03,
  0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x81,
  0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38,
  0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x3C, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x38, 0x01, 0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE7, 0xC0, 0x3C,
  0x0F, 0x03, 0xC0, 0x38, 0x3C, 0x01, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x78,
  0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00,
  0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0xBC,
  0x00, 0x1D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0,
  0x07, 0x0E, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x38, 0x0F, 0x03, 0xC0,
  0x7E, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x07, 0x0F, 0xE0, 0x00, 0xE7, 0xFE, 0x00, 0x1D, 0xE7,
  0xE0, 0x03, 0xB0, 0x3C, 0x00, 0xFC, 0x03, 0x80, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x38,
  0x00, 0x78, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xF0, 0x1E, 0x00, 0x76, 0x07, 0xC0, 0x0E,
  0xF3, 0xF0, 0x01, 0xCF, 0xFC, 0x00, 0x78, 0xFE, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0x1C, 0x03, 0xFF, 0x38, 0x0F, 0xDE, 0x70,
  0x3C, 0x0E, 0xE0, 0xF0, 0x0F, 0x81, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0E,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1,
  0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x78, 0x1C,
  0x01, 0xF0, 0x3C, 0x07, 0xE0, 0x7C, 0x1D, 0xC0, 0x7E, 0xF7, 0x80, 0x7F,
  0xCE, 0x00, 0x7F, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x38, 0xFC, 0x07, 0x3F, 0x80, 0xEF, 0xE0, 0x1B, 0x80,
  0x07, 0x60, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xE1, 0xE0, 0x3C,
  0x02, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x18, 0x07, 0xC0,
  0xF8, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x81, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x40, 0x7F, 0x01, 0xFC,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1,
  0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80,
  0x1E, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03,
  0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x1E, 0x0E, 0x00, 0xF8, 0x38, 0x03, 0xC0, 0xE0, 0x1F, 0x03, 0x80,
  0x7C, 0x0F, 0x03, 0x70, 0x3F, 0x79, 0xC0, 0x7F, 0xC6, 0x00, 0xFE, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70,
  0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87,
  0x80, 0x70, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x77, 0x00, 0x3C, 0x01, 0xEE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xB0, 0x07,
  0x38, 0x07, 0x60, 0x1E, 0x70, 0x0E, 0xC0, 0x38, 0xE0, 0x19, 0x80, 0xF1,
  0xC0, 0x73, 0x01, 0xC3, 0x80, 0xEE, 0x03, 0x87, 0x03, 0x9C, 0x0F, 0x0E,
  0x07, 0x38, 0x1C, 0x1C, 0x0C, 0x70, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0x70,
  0x71, 0xC1, 0xC0, 0xE1, 0xC3, 0x87, 0x81, 0xC3, 0x87, 0x0E, 0x03, 0x86,
  0x0E, 0x1C, 0x07, 0x1C, 0x1C, 0x70, 0x0E, 0x38, 0x38, 0xE0, 0x1C, 0xE0,
  0x73, 0xC0, 0x39, 0xC0, 0xE7, 0x00, 0x73, 0x01, 0xCE, 0x00, 0xEE, 0x03,
  0xB8, 0x01, 0xDC, 0x07, 0x70, 0x03, 0xF0, 0x0E, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0E,
  0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9C,
  0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0,
  0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0xC0,
  0x05, 0xFF, 0xE0, 0x1F, 0x83, 0xF9, 0xFC, 0x01, 0xFF, 0xD0, 0x00, 0xFF,
  0x20, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 46, 14, 1, -46 },
  { 82, 15, 17, 19, 6, -46 },
  { 114, 27, 46, 25, 0, -46 },
  { 270, 25, 53, 23, 0, -49 },
  { 436, 31, 47, 36, 3, -46 },
  { 619, 24, 47, 24, -1, -46 },
  { 760, 7, 17, 11, 6, -46 },
  { 775, 19, 56, 16, 1, -46 },
  { 908, 19, 56, 16, -5, -46 },
  { 1041, 18, 20, 22, 7, -49 },
  { 1086, 23, 30, 27, 2, -38 },
  { 1173, 10, 15, 11, -3, -7 },
  { 1192, 14, 3, 17, 1, -19 },
  { 1198, 5, 6, 11, 1, -6 },
  { 1202, 28, 46, 20, -3, -46 },
  { 1363, 22, 47, 23, 1, -46 },
  { 1493, 13, 46, 23, 7, -46 },
  { 1568, 26, 46, 23, -2, -46 },
  { 1718, 25, 47, 23, -1, -46 },
  { 1865, 25, 46, 23, -1, -46 },
  { 2009, 25, 47, 23, -1, -46 },
  { 2156, 23, 47, 23, 2, -46 },
  { 2292, 24, 46, 23, 2, -46 },
  { 2430, 25, 47, 23, -1, -46 },
  { 2577, 23, 47, 23, 0, -46 },
  { 2713, 11, 34, 11, 0, -34 },
  { 2760, 14, 42, 12, -3, -34 },
  { 2834, 23, 27, 27, 2, -36 },
  { 2912, 23, 17, 27, 2, -31 },
  { 2961, 23, 27, 27, 2, -36 },
  { 3039, 19, 46, 17, 1, -46 },
  { 3149, 32, 52, 35, 2, -46 },
  { 3357, 23, 46, 23, -4, -46 },
  { 3490, 26, 46, 26, 0, -46 },
  { 3640, 26, 47, 23, 2, -46 },
  { 3793, 27, 46, 28, 0, -46 },
  { 3949, 25, 46, 23, 0, -46 },
  { 4093, 25, 46, 21, 0, -46 },
  { 4237, 30, 47, 30, 2, -46 },
  { 4414, 31, 46, 30, 0, -46 },
  { 4593, 21, 46, 14, -3, -46 },
  { 4714, 22, 58, 11, -9, -46 },
  { 4874, 29, 46, 24, 0, -46 },
  { 5041, 16, 46, 20, 0, -46 },
  { 5133, 41, 46, 39, 0, -46 },
  { 5369, 32, 46, 31, 0, -46 },
  { 5553, 27, 47, 30, 2, -46 },
  { 5712, 25, 46, 24, 0, -46 },
  { 5856, 27, 57, 30, 2, -46 },
  { 6049, 25, 46, 25, 0, -46 },
  { 6193, 27, 47, 23, -2, -46 },
  { 6352, 21, 46, 20, 4, -46 },
  { 6473, 28, 47, 29, 2, -46 },
  { 6638, 24, 46, 24, 5, -46 },
  { 6776, 40, 46, 40, 5, -46 },
  { 7006, 30, 46, 22, -4, -46 },
  { 7179, 22, 46, 21, 4, -46 },
  { 7306, 27, 46, 20, -3, -46 },
  { 7462, 23, 56, 18, -1, -46 },
  { 7623, 9, 46, 21, 7, -46 },
  { 7675, 23, 56, 18, -4, -46 },
  { 7836, 24, 23, 25, 1, -46 },
  { 7905, 18, 2, 18, -5, 6 },
  { 7910, 8, 10, 15, 9, -49 },
  { 7920, 23, 36, 26, 2, -35 },
  { 8024, 24, 50, 25, 0, -49 },
  { 8174, 19, 36, 19, 2, -35 },
  { 8260, 26, 50, 26, 2, -49 },
  { 8423, 20, 36, 23, 2, -35 },
  { 8513, 29, 64, 13, -8, -49 },
  { 8745, 26, 50, 26, -1, -35 },
  { 8908, 23, 49, 25, 0, -49 },
  { 9049, 13, 46, 11, 0, -46 },
  { 9124, 22, 61, 11, -8, -46 },
  { 9292, 24, 49, 21, 0, -49 },
  { 9439, 14, 49, 11, 0, -49 },
  { 9525, 35, 35, 37, 0, -35 },
  { 9679, 23, 35, 25, 0, -35 },
  { 9780, 21, 36, 25, 2, -35 },
  { 9875, 27, 50, 25, -3, -35 },
  { 10044, 23, 50, 26, 2, -35 },
  { 10188, 19, 35, 16, 0, -35 },
  { 10272, 21, 36, 19, -1, -35 },
  { 10367, 14, 43, 13, 1, -42 },
  { 10443, 22, 35, 25, 2, -34 },
  { 10540, 19, 34, 19, 4, -34 },
  { 10621, 31, 34, 32, 4, -34 },
  { 10753, 25, 34, 20, -3, -34 },
  { 10860, 31, 49, 20, -7, -34 },
  { 11050, 20, 34, 16, -2, -34 },
  { 11135, 22, 56, 20, 2, -46 },
  { 11289, 3, 64, 23, 10, -49 },
  { 11313, 22, 56, 20, -4, -46 },
  { 11467, 23, 7, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC64PT7B_H_
