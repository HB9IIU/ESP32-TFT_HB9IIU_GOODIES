#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x38,
  0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x9C, 0x78, 0x03,
  0xC3, 0x01, 0x00, 0xF0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x81, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C, 0x30, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x6F,
  0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x61, 0xE0, 0x00,
  0x0C, 0x1C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0C, 0x0F,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x30, 0x38, 0x08, 0x06, 0x0F, 0x01, 0x80, 0xC3, 0xC0,
  0x3F, 0x1F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x1F,
  0xE0, 0x01, 0xE0, 0x0F, 0x3C, 0x00, 0x70, 0x07, 0x87, 0x00, 0x3C, 0x01,
  0xC1, 0xC0, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x80, 0x38, 0x1E, 0x01, 0xC0,
  0x1C, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x1E,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x03, 0xC0, 0x0E, 0x01, 0xC0,
  0xE0, 0x07, 0x80, 0x70, 0x78, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0x70, 0x0E,
  0x0E, 0x00, 0x1C, 0x03, 0x83, 0x80, 0x07, 0x00, 0xE1, 0xC0, 0x01, 0xC0,
  0x38, 0x70, 0x00, 0x70, 0x1C, 0x38, 0x08, 0x38, 0x07, 0x0E, 0x0F, 0xCE,
  0x01, 0xC7, 0x0F, 0xFB, 0x80, 0xE1, 0xC7, 0xDE, 0xE0, 0x38, 0xE1, 0xC3,
  0xF8, 0x1E, 0x38, 0xE0, 0x7F, 0x07, 0x1C, 0x38, 0x1D, 0xC3, 0x87, 0x1C,
  0x07, 0x79, 0xE3, 0x87, 0x01, 0xDF, 0xF0, 0xE3, 0xC0, 0x73, 0xF8, 0x70,
  0xE0, 0x1C, 0x30, 0x1C, 0x38, 0x07, 0x00, 0x0E, 0x1E, 0x03, 0xC0, 0x03,
  0x87, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0x70, 0x70, 0x0E, 0x00,
  0x38, 0x3C, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x03,
  0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x00,
  0xE0, 0xE0, 0x0E, 0x00, 0x3C, 0xF0, 0x03, 0x80, 0x07, 0xF8, 0x01, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F,
  0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE1, 0xC0, 0xF0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x0E, 0x1E, 0x03, 0x83, 0x87, 0x00, 0xF1, 0xE3, 0xC0, 0x3C,
  0x70, 0xE0, 0x0F, 0x3C, 0x78, 0x01, 0xCF, 0x1E, 0x00, 0x7B, 0x87, 0x00,
  0x1F, 0xE1, 0xC0, 0x03, 0xF0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x1E, 0x00, 0xFE,
  0x07, 0x80, 0x7B, 0xC1, 0xF0, 0x3C, 0xF0, 0x3F, 0xFE, 0x3C, 0x07, 0xFF,
  0x07, 0x00, 0xFF, 0x81, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xE3,
  0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x81, 0xC0, 0x3C, 0x38, 0x07, 0xE7,
  0x03, 0x3F, 0xE7, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x1E, 0xE0, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x78, 0x1C, 0x1E, 0x03,
  0x80, 0x80, 0x78, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xE1, 0xF0,
  0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xF0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC3,
  0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x07, 0xF8,
  0x3E, 0xE1, 0xF7, 0x8F, 0x9E, 0x7C, 0x73, 0xC1, 0xCE, 0x0F, 0x10, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0x80, 0x1E, 0x00, 0x10, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x00,
  0xE0, 0x07, 0x80, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x01, 0xF8, 0x06, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x1C,
  0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0xC0,
  0x38, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1C, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x01, 0x00, 0x07, 0xC0, 0x38, 0x03, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC1, 0xF8, 0x01, 0xE3, 0xFE, 0x00, 0xF7, 0xFF, 0x80,
  0x77, 0xC7, 0xE0, 0x7B, 0x80, 0xF0, 0x3F, 0x80, 0x7C, 0x1F, 0x80, 0x1E,
  0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x00,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80,
  0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38,
  0x00, 0x78, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x70,
  0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x83, 0xE0, 0x1F, 0xC0, 0xF0,
  0x1D, 0xE0, 0x7F, 0x3E, 0xE0, 0x1F, 0xFE, 0xF0, 0x07, 0xFC, 0x78, 0x01,
  0xF8, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x01, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0x01, 0xF0, 0x20, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x0F, 0xF0, 0x38, 0x38,
  0x03, 0xFF, 0x07, 0x0E, 0x00, 0xFB, 0xC0, 0xE1, 0xC0, 0x38, 0x38, 0x1C,
  0x38, 0x0E, 0x07, 0x03, 0x8E, 0x03, 0xC0, 0xE0, 0x71, 0xC0, 0x70, 0x38,
  0x0E, 0x38, 0x1C, 0x07, 0x01, 0xCE, 0x03, 0x80, 0xE0, 0x39, 0xC0, 0xF0,
  0x1C, 0x07, 0x38, 0x1C, 0x07, 0x01, 0xCE, 0x03, 0x80, 0xE0, 0x39, 0xC0,
  0xE0, 0x1C, 0x07, 0x38, 0x1C, 0x03, 0x80, 0xE7, 0x03, 0x80, 0xE0, 0x38,
  0xE0, 0x70, 0x1C, 0x07, 0x3C, 0x1E, 0x03, 0x80, 0xE7, 0x03, 0x80, 0xF0,
  0x18, 0xE0, 0x70, 0x1E, 0x07, 0x1C, 0x0E, 0x03, 0x80, 0xE3, 0x81, 0xC0,
  0xF0, 0x38, 0x70, 0x38, 0x1E, 0x07, 0x0E, 0x07, 0x06, 0xC1, 0xC1, 0xC0,
  0xE0, 0xD8, 0x38, 0x38, 0x1E, 0x33, 0x8E, 0x07, 0x01, 0xFE, 0x7F, 0x80,
  0xE0, 0x3F, 0x87, 0xE0, 0x1C, 0x03, 0xE0, 0x78, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0,
  0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x78, 0x3F, 0xC0, 0x03, 0x80, 0x3E, 0x00,
  0x1C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x1F,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3C, 0x1F, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x78, 0xFF, 0x80,
  0x03, 0xC0, 0x7E, 0x00, 0x1C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1F, 0x00, 0x70, 0x01, 0xF0,
  0x07, 0x80, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x01, 0xE3, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00,
  0x0C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x7F,
  0xE0, 0xF0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xC7, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x03, 0x9F, 0x00, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x07, 0xF7, 0x00,
  0x00, 0x07, 0xF7, 0x80, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x77, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x00, 0x3D,
  0xC0, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x0E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0x80, 0x1E,
  0x78, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x00, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x1C, 0x78, 0x00,
  0x38, 0x70, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x38, 0x00, 0x70,
  0xF0, 0x03, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0, 0x07,
  0x83, 0x80, 0x3C, 0x1E, 0x00, 0x70, 0x38, 0x03, 0xC1, 0xE0, 0x07, 0x03,
  0x80, 0x78, 0x1C, 0x00, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x0F, 0x03, 0x80,
  0x70, 0x3C, 0x00, 0xF0, 0x38, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0xE0,
  0x3C, 0x00, 0xE0, 0x38, 0x1E, 0x03, 0x80, 0x1E, 0x03, 0xC1, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0x01,
  0xC0, 0x3C, 0x78, 0x07, 0x00, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0x03, 0xC0,
  0x3C, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x03, 0x80, 0x3D,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xDE, 0x00, 0xE0, 0x07, 0x80, 0x1D, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x07,
  0x80, 0x1F, 0x80, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x7E, 0x00,
  0x03, 0x80, 0x1F, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x77,
  0x80, 0x03, 0xC0, 0x0E, 0xF0, 0x00, 0x70, 0x03, 0xCE, 0x00, 0x1E, 0x00,
  0x79, 0xC0, 0x03, 0xC0, 0x0F, 0x38, 0x00, 0x78, 0x01, 0xC7, 0x80, 0x0F,
  0x00, 0x38, 0xF0, 0x01, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x01, 0xE1, 0xC0,
  0x0F, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0xF0, 0x07, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x00,
  0xF0, 0x38, 0x07, 0x80, 0x1C, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x1C,
  0x00, 0xF0, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0x38,
  0x1E, 0x00, 0x70, 0x07, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0xC0,
  0x1E, 0x1E, 0x00, 0x78, 0x03, 0xC3, 0xC0, 0x0E, 0x00, 0x78, 0x78, 0x01,
  0xC0, 0x07, 0x0E, 0x00, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x00, 0x1C, 0x78,
  0x01, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0x00, 0x79, 0xC0, 0x0F, 0x00, 0x0F,
  0x38, 0x01, 0xE0, 0x00, 0xEF, 0x00, 0x3C, 0x00, 0x1D, 0xE0, 0x07, 0x80,
  0x03, 0xBC, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x07,
  0x80, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x03, 0xF0,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xC3, 0xFC, 0x00, 0x38, 0x07, 0xC0, 0x03,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0,
  0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x80, 0x38, 0x01, 0xF0, 0x03, 0x80, 0x3E, 0x00, 0x78, 0x0F, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x7C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xC7, 0xFC, 0x00,
  0x38, 0x07, 0xC0, 0x03, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0x80, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0x00, 0x1F,
  0x00, 0x08, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x03, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x70, 0x00,
  0x3F, 0x00, 0x07, 0x87, 0x00, 0x07, 0x70, 0x00, 0xF0, 0x70, 0x00, 0x77,
  0x00, 0x0F, 0x07, 0x00, 0x0F, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE7, 0x00,
  0x1E, 0x07, 0x00, 0x0E, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE7, 0x00, 0x3C,
  0x07, 0x00, 0x1C, 0x70, 0x03, 0xC0, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x07,
  0x00, 0x38, 0x70, 0x07, 0x80, 0x70, 0x03, 0x87, 0x00, 0x78, 0x07, 0x00,
  0x78, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0,
  0xF0, 0x0F, 0x00, 0x70, 0x0E, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0xF0,
  0x1E, 0x00, 0x70, 0x1E, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x00, 0xF0, 0x3C, 0x0E, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x00,
  0xF0, 0x38, 0x0E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x00, 0xF0,
  0x70, 0x0E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xF0,
  0x0E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x0E,
  0x1C, 0x00, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x0E, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0x80, 0x0E, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x78,
  0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xF8, 0xF0, 0x07, 0xFF, 0x38, 0x03, 0xFF, 0xCE, 0x01, 0xF0, 0x3B,
  0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3E,
  0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x06, 0xE0, 0x1E, 0x03, 0xF8, 0x07, 0xC1,
  0xDE, 0x01, 0xFF, 0xE7, 0x00, 0x3F, 0xF1, 0xC0, 0x07, 0xF8, 0x70, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xE1, 0xFE, 0x00, 0x39,
  0xFF, 0xC0, 0x1E, 0xF9, 0xF8, 0x07, 0xB8, 0x1E, 0x01, 0xF8, 0x07, 0x80,
  0x7E, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0x81,
  0xF8, 0x03, 0xC0, 0x76, 0x01, 0xF0, 0x1D, 0xC0, 0xF8, 0x07, 0x3F, 0xFC,
  0x01, 0xCF, 0xFE, 0x00, 0xE1, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF9, 0xE0, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x3F, 0xE3, 0x80, 0x03, 0xFF, 0x9C, 0x00,
  0x3F, 0xFD, 0xE0, 0x03, 0xE0, 0x7F, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xDC, 0x00,
  0x78, 0x0F, 0xE0, 0x03, 0xC0, 0xEE, 0x00, 0x1F, 0xFE, 0x70, 0x00, 0x7F,
  0xE3, 0x80, 0x01, 0xFE, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0x3E, 0x01, 0xE0, 0x78,
  0x0F, 0x00, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x38,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03,
  0xC3, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x0F, 0xC1, 0xE3, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x30, 0x0F, 0xEF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xE3, 0xC0, 0x03, 0xFF, 0x9C, 0x00, 0x3F, 0xFC, 0xE0, 0x03, 0xE0, 0x77,
  0x00, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0xDC, 0x00, 0x78, 0x0F, 0xE0, 0x03, 0xC0, 0xEF,
  0x00, 0x1F, 0xFE, 0x70, 0x00, 0x7F, 0xE3, 0x80, 0x01, 0xFE, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x04, 0x00, 0x3C, 0x00, 0x30, 0x07, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0xF3, 0xFE, 0x00, 0x73, 0xFF, 0x80, 0x3B,
  0xEF, 0xC0, 0x3F, 0x81, 0xF0, 0x1D, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x07,
  0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x80,
  0xF0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0,
  0x03, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x38, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x00,
  0x1C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x38, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x07, 0x7E, 0x00, 0x03,
  0xDF, 0x80, 0x00, 0xFE, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07,
  0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x07,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xC7, 0xFC, 0x1F, 0xF0, 0x03, 0x9F, 0xF8, 0xFF, 0xE0,
  0x0F, 0x7D, 0xFB, 0xE7, 0xE0, 0x1D, 0xC0, 0xF7, 0x03, 0xC0, 0x3B, 0x01,
  0xFC, 0x03, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x0F,
  0x03, 0xE0, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x03, 0x80, 0xF0,
  0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0xF0, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x71, 0xFF, 0x00, 0x39, 0xFF,
  0xC0, 0x3D, 0xF7, 0xE0, 0x1D, 0xC0, 0xF8, 0x0E, 0xC0, 0x3C, 0x07, 0xC0,
  0x1E, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0,
  0x01, 0xC0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1C,
  0x07, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xE7, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xE7,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xE1, 0xFE, 0x00, 0x07, 0x3F, 0xF8, 0x00, 0x39, 0xE7, 0xE0, 0x03, 0xDC,
  0x0F, 0x00, 0x1D, 0xC0, 0x78, 0x00, 0xEC, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x7E, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF8,
  0x1F, 0x00, 0x1C, 0xFF, 0xF0, 0x00, 0xE7, 0xFF, 0x00, 0x0F, 0x1F, 0xF0,
  0x00, 0x78, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xF8, 0xF0, 0x07, 0xFF, 0x38, 0x03, 0xF7, 0xCE,
  0x01, 0xF0, 0x3B, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x7C,
  0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x06, 0xE0, 0x3E, 0x03,
  0xF8, 0x07, 0x81, 0xDE, 0x01, 0xFF, 0xE7, 0x00, 0x3F, 0xF3, 0xC0, 0x07,
  0xF8, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0x1F, 0xC0, 0x39, 0xFC, 0x03, 0xDF, 0xE0, 0x1D, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7E,
  0x1F, 0x03, 0xE0, 0x18, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x82, 0x00, 0x3C, 0x0E,
  0x01, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF0, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x03, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x1F, 0xC0, 0xF8, 0x3B,
  0x80, 0xFF, 0xF3, 0x80, 0x7F, 0xE3, 0x80, 0x3F, 0xC3, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x38, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7,
  0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x3B, 0xC0, 0x0F, 0xC0, 0x1E, 0xF0, 0x03, 0xE0, 0x07,
  0xBC, 0x01, 0xD8, 0x01, 0xCF, 0x00, 0x7E, 0x00, 0xF3, 0xC0, 0x1F, 0x80,
  0x38, 0xF0, 0x0E, 0xE0, 0x1E, 0x3C, 0x03, 0xB8, 0x07, 0x8F, 0x01, 0xEE,
  0x01, 0xC3, 0xC0, 0x73, 0x80, 0xF0, 0xF0, 0x1C, 0xE0, 0x38, 0x3C, 0x0E,
  0x38, 0x1E, 0x0F, 0x03, 0x8E, 0x07, 0x83, 0xC1, 0xE3, 0x81, 0xC0, 0xF0,
  0x70, 0xE0, 0xF0, 0x3C, 0x1C, 0x38, 0x38, 0x0F, 0x0E, 0x0E, 0x0E, 0x03,
  0xC3, 0x83, 0x87, 0x80, 0xF1, 0xE0, 0xE1, 0xC0, 0x3C, 0x70, 0x38, 0xF0,
  0x0F, 0x1C, 0x0E, 0x38, 0x03, 0x8E, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0xE7,
  0x80, 0x39, 0xE0, 0x39, 0xC0, 0x0E, 0x70, 0x0E, 0xF0, 0x03, 0x9C, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03,
  0x80, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x37, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x9F, 0xFC, 0x00, 0x5F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xF2, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 50, 15, 1, -50 },
  { 95, 16, 18, 21, 7, -50 },
  { 131, 29, 50, 28, 0, -50 },
  { 313, 27, 57, 26, 0, -53 },
  { 506, 34, 52, 39, 3, -51 },
  { 727, 26, 52, 26, -1, -51 },
  { 896, 7, 18, 12, 7, -50 },
  { 912, 20, 61, 17, 2, -50 },
  { 1065, 20, 61, 18, -5, -50 },
  { 1218, 19, 21, 24, 8, -53 },
  { 1268, 25, 33, 29, 2, -41 },
  { 1372, 10, 16, 13, -3, -7 },
  { 1392, 16, 4, 18, 1, -21 },
  { 1400, 5, 6, 12, 1, -6 },
  { 1404, 30, 50, 22, -3, -50 },
  { 1592, 25, 52, 26, 1, -51 },
  { 1755, 14, 50, 26, 8, -50 },
  { 1843, 28, 51, 26, -2, -51 },
  { 2022, 27, 52, 26, -1, -51 },
  { 2198, 27, 51, 26, -1, -51 },
  { 2371, 27, 51, 26, -1, -50 },
  { 2544, 25, 52, 26, 2, -51 },
  { 2707, 26, 50, 26, 2, -50 },
  { 2870, 27, 52, 26, -1, -51 },
  { 3046, 25, 52, 26, 0, -51 },
  { 3209, 12, 37, 13, 0, -37 },
  { 3265, 15, 46, 13, -3, -37 },
  { 3352, 25, 30, 29, 2, -40 },
  { 3446, 25, 18, 29, 2, -34 },
  { 3503, 25, 30, 29, 2, -40 },
  { 3597, 20, 51, 19, 1, -51 },
  { 3725, 35, 56, 38, 2, -50 },
  { 3970, 26, 50, 26, -5, -50 },
  { 4133, 29, 50, 28, 0, -50 },
  { 4315, 28, 52, 25, 3, -51 },
  { 4497, 29, 50, 31, 0, -50 },
  { 4679, 28, 50, 25, 0, -50 },
  { 4854, 28, 50, 23, 0, -50 },
  { 5029, 32, 52, 33, 3, -51 },
  { 5237, 34, 50, 32, 0, -50 },
  { 5450, 24, 50, 15, -4, -50 },
  { 5600, 24, 63, 12, -10, -50 },
  { 5789, 32, 50, 26, 0, -50 },
  { 5989, 17, 50, 22, 0, -50 },
  { 6096, 44, 50, 43, 0, -50 },
  { 6371, 35, 50, 34, 0, -50 },
  { 6590, 30, 52, 33, 2, -51 },
  { 6785, 28, 50, 26, 0, -50 },
  { 6960, 30, 63, 33, 2, -51 },
  { 7197, 28, 50, 27, 0, -50 },
  { 7372, 29, 52, 25, -2, -51 },
  { 7561, 23, 50, 22, 5, -50 },
  { 7705, 31, 51, 31, 2, -50 },
  { 7903, 26, 50, 26, 6, -50 },
  { 8066, 44, 50, 44, 5, -50 },
  { 8341, 33, 50, 24, -4, -50 },
  { 8548, 24, 50, 23, 5, -50 },
  { 8698, 30, 50, 22, -3, -50 },
  { 8886, 26, 61, 19, -2, -50 },
  { 9085, 10, 50, 23, 7, -50 },
  { 9148, 25, 61, 19, -4, -50 },
  { 9339, 26, 25, 28, 1, -50 },
  { 9421, 20, 3, 20, -6, 6 },
  { 9429, 8, 11, 16, 10, -53 },
  { 9440, 26, 39, 28, 2, -38 },
  { 9567, 26, 54, 28, 0, -53 },
  { 9743, 21, 39, 21, 2, -38 },
  { 9846, 29, 54, 28, 2, -53 },
  { 10042, 22, 39, 25, 2, -38 },
  { 10150, 32, 71, 14, -9, -54 },
  { 10434, 29, 55, 28, -1, -38 },
  { 10634, 25, 53, 27, 0, -53 },
  { 10800, 15, 51, 12, 0, -51 },
  { 10896, 24, 68, 12, -9, -51 },
  { 11100, 26, 53, 23, 0, -53 },
  { 11273, 15, 53, 12, 0, -53 },
  { 11373, 39, 38, 41, 0, -38 },
  { 11559, 25, 38, 27, 0, -38 },
  { 11678, 23, 39, 27, 2, -38 },
  { 11791, 29, 54, 28, -3, -38 },
  { 11987, 26, 55, 28, 2, -38 },
  { 12166, 21, 38, 18, 0, -38 },
  { 12266, 22, 39, 21, -1, -38 },
  { 12374, 15, 47, 15, 1, -46 },
  { 12463, 24, 38, 27, 2, -37 },
  { 12577, 21, 37, 21, 4, -37 },
  { 12675, 34, 37, 35, 4, -37 },
  { 12833, 28, 37, 22, -3, -37 },
  { 12963, 33, 54, 22, -7, -37 },
  { 13186, 22, 37, 18, -2, -37 },
  { 13288, 25, 61, 22, 2, -50 },
  { 13479, 3, 70, 25, 11, -53 },
  { 13506, 24, 61, 22, -4, -50 },
  { 13689, 25, 7, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC70PT7B_H_
