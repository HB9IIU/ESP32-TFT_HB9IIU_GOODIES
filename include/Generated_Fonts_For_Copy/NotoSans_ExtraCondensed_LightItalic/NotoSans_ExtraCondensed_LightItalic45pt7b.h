#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0x38, 0xE7, 0x1C, 0xC3, 0x18, 0x63, 0x0C, 0xE3, 0x98, 0x63, 0x0C,
  0x61, 0x8C, 0x33, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x83,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x18,
  0x01, 0x83, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x30, 0x60, 0x06, 0x18, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x1C, 0x00, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x1C, 0xC6,
  0x1C, 0x60, 0x0C, 0x20, 0x06, 0x10, 0x03, 0x08, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0x72, 0x00, 0x19, 0x00, 0x0E, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x1B, 0x80, 0x0C, 0xC0, 0x04, 0x70, 0x02, 0x18,
  0x01, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x43, 0x08, 0x23, 0x86, 0x13,
  0x83, 0xFF, 0x80, 0x7F, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0xCC, 0x06,
  0x06, 0x30, 0x18, 0x18, 0x60, 0xC0, 0xC1, 0x83, 0x03, 0x0E, 0x18, 0x18,
  0x30, 0x60, 0x60, 0xC3, 0x01, 0x83, 0x0C, 0x06, 0x0C, 0x60, 0x38, 0x31,
  0x80, 0xC1, 0xCC, 0x03, 0x06, 0x30, 0x8C, 0x19, 0x8F, 0xB0, 0xE6, 0x66,
  0xC3, 0x33, 0x0F, 0x1C, 0xCC, 0x36, 0xE6, 0x60, 0xDF, 0x19, 0x83, 0x10,
  0xC6, 0x0C, 0x03, 0x30, 0x60, 0x18, 0xC1, 0x80, 0x63, 0x06, 0x03, 0x0C,
  0x18, 0x0C, 0x30, 0x60, 0x61, 0x83, 0x01, 0x86, 0x0C, 0x0C, 0x18, 0x30,
  0x70, 0x61, 0x81, 0x80, 0xC6, 0x0E, 0x03, 0x70, 0x30, 0x0F, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x01, 0xDC, 0x03, 0x8E, 0x03, 0x0E,
  0x03, 0x0E, 0x03, 0x0E, 0x07, 0x0C, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x03, 0x30, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x1D, 0xC0, 0x38, 0xC3, 0x30, 0xC7, 0x70, 0xE6, 0x60, 0xE6,
  0xE0, 0x6E, 0xC0, 0x6C, 0xC0, 0x7C, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x78,
  0xC0, 0xF8, 0xE1, 0xD8, 0x7F, 0x9C, 0x7F, 0x1C, 0x39, 0xCC, 0x63, 0x19,
  0x8C, 0x63, 0x30, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x03, 0x0C, 0x20, 0xF6, 0x03, 0xEF, 0x0F, 0xF0, 0xE0, 0x1B,
  0x03, 0x30, 0xF1, 0x86, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x01, 0xF8,
  0x07, 0xF8, 0x1C, 0x70, 0x70, 0x60, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x1C,
  0x06, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xDC, 0x03,
  0xB8, 0x07, 0x60, 0x0E, 0xC0, 0x19, 0x80, 0x37, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xC6, 0x03,
  0x0C, 0x0E, 0x1C, 0x18, 0x18, 0x60, 0x3F, 0xC0, 0x3E, 0x00, 0x03, 0x83,
  0xC3, 0xE3, 0xF3, 0xB7, 0x1B, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0x00, 0x0C,
  0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0xC0, 0xE0, 0x10, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x0C, 0x0E, 0x02, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x08, 0x0F, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x06, 0xE0, 0x01, 0xB0,
  0x00, 0xCC, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x0C, 0x60, 0x07, 0x18, 0x01,
  0x86, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x18, 0x30, 0x0E, 0x0C, 0x03, 0x03,
  0x01, 0x81, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x06, 0x06, 0x01, 0x83,
  0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x20, 0x3C, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x8F, 0x00, 0xDF, 0xC0, 0xFC, 0x70, 0x68, 0x1C, 0x38, 0x0E, 0x1C, 0x07,
  0x0C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x0E, 0x1C, 0x06, 0x0E, 0x07, 0x03, 0x03, 0x01,
  0xC3, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x38, 0x70, 0x0C,
  0x38, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x86, 0x01, 0xC3, 0x80, 0xC1, 0xC0,
  0xE0, 0x60, 0xE0, 0x38, 0xE0, 0x0E, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x07, 0x9C, 0x07, 0x07, 0x07, 0x01, 0x83, 0x00, 0xE3, 0x80, 0x71,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01,
  0x87, 0x01, 0xC1, 0xC1, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x10,
  0x01, 0xFC, 0x03, 0xFE, 0x07, 0x07, 0x06, 0x07, 0x0E, 0x03, 0x0C, 0x03,
  0x1C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x18, 0x0E, 0x1C, 0x1E, 0x1E, 0x76,
  0x0F, 0xEE, 0x07, 0x8E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0xC0,
  0xFF, 0x80, 0xFE, 0x00, 0x07, 0x07, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0xF0, 0xE0, 0xE0, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0x40, 0x30, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x20, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7D, 0xE0, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x3F,
  0x8C, 0x60, 0xF6, 0x18, 0xC3, 0x8C, 0x33, 0x06, 0x18, 0x66, 0x18, 0x30,
  0xCC, 0x30, 0xC1, 0xB0, 0xC1, 0x86, 0x61, 0x83, 0x0C, 0xC3, 0x0E, 0x19,
  0x86, 0x18, 0x33, 0x18, 0x30, 0xCC, 0x30, 0x61, 0x98, 0x61, 0xC3, 0x30,
  0xC3, 0x0C, 0x61, 0x8E, 0x18, 0xC3, 0x96, 0x61, 0x83, 0xEF, 0x83, 0x03,
  0x8E, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x30, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x33, 0x00, 0x33, 0x00, 0x73,
  0x00, 0x63, 0x00, 0xE3, 0x00, 0xC3, 0x00, 0xC3, 0x01, 0xC3, 0x01, 0x83,
  0x03, 0x83, 0x03, 0x03, 0x03, 0xFF, 0x07, 0xFF, 0x06, 0x03, 0x0E, 0x03,
  0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03,
  0x70, 0x03, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x03, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x70, 0x0C,
  0x1C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x70, 0x60, 0x18, 0x38, 0x0E, 0x0E,
  0x07, 0x03, 0x03, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1C, 0x3C, 0x07, 0x03,
  0x81, 0x80, 0x60, 0x60, 0x1C, 0x18, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xC0, 0x1C, 0x30, 0x06, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x70, 0x60,
  0x3C, 0x18, 0x3E, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0x02, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x02, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x0E, 0x1E, 0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x06,
  0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x18,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x60,
  0x06, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE1, 0x80,
  0x18, 0x70, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x07, 0x0E, 0x01,
  0xC1, 0xC0, 0x70, 0x30, 0x1E, 0x06, 0x07, 0x80, 0xC3, 0xE0, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1C,
  0x02, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xF8,
  0xC0, 0x3F, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0E, 0x00,
  0x60, 0xE0, 0x06, 0x07, 0x00, 0xE0, 0x78, 0x0C, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80, 0xE0,
  0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C,
  0x06, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x03, 0x80, 0x18, 0x0E,
  0x00, 0x60, 0x30, 0x03, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1C, 0x00,
  0xC0, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80,
  0xE0, 0x06, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x01, 0xC0,
  0x0C, 0x07, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x18,
  0x0E, 0x00, 0x60, 0x38, 0x03, 0x80, 0x03, 0xFE, 0x03, 0xF0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x11, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x38, 0x1C, 0x03, 0x03, 0x80, 0x30, 0x30,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x38,
  0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0xCE, 0x00, 0x0D, 0xC0, 0x00, 0xDC,
  0x00, 0x1F, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x38,
  0x60, 0x03, 0x87, 0x00, 0x30, 0x70, 0x03, 0x03, 0x00, 0x30, 0x30, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x06, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x80, 0x0D, 0x80, 0xFC, 0x00, 0xEC, 0x06, 0xE0, 0x06, 0xE0, 0x33, 0x00,
  0x77, 0x01, 0x98, 0x03, 0x30, 0x1C, 0xC0, 0x19, 0x80, 0xE6, 0x01, 0x8C,
  0x06, 0x30, 0x0C, 0xE0, 0x31, 0x80, 0xC6, 0x01, 0x8C, 0x06, 0x30, 0x1C,
  0x60, 0x71, 0x80, 0xC3, 0x03, 0x1C, 0x06, 0x18, 0x38, 0xE0, 0x30, 0xC1,
  0x86, 0x03, 0x86, 0x1C, 0x30, 0x1C, 0x30, 0xC1, 0x80, 0xC1, 0x8E, 0x1C,
  0x06, 0x0C, 0x60, 0xE0, 0x30, 0x67, 0x06, 0x03, 0x83, 0x30, 0x30, 0x1C,
  0x19, 0x81, 0x80, 0xC0, 0xF8, 0x1C, 0x06, 0x07, 0xC0, 0xC0, 0x30, 0x3C,
  0x06, 0x03, 0x81, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x18, 0x0F, 0x00, 0x30, 0x1E, 0x00, 0x60, 0x3E, 0x01, 0xC0,
  0x6C, 0x03, 0x81, 0xD8, 0x06, 0x03, 0xB0, 0x0C, 0x06, 0x60, 0x18, 0x0C,
  0xC0, 0x70, 0x19, 0xC0, 0xE0, 0x71, 0x81, 0x80, 0xE3, 0x03, 0x01, 0x86,
  0x0E, 0x03, 0x0C, 0x1C, 0x06, 0x18, 0x30, 0x1C, 0x38, 0x60, 0x30, 0x30,
  0xC0, 0x60, 0x63, 0x80, 0xC0, 0xC7, 0x03, 0x81, 0x8C, 0x07, 0x03, 0x98,
  0x0C, 0x07, 0x30, 0x18, 0x06, 0xE0, 0x30, 0x0D, 0xC0, 0xE0, 0x1B, 0x01,
  0xC0, 0x36, 0x03, 0x00, 0x7C, 0x06, 0x00, 0x78, 0x0C, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x0E, 0x0E, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x0C, 0x70, 0x03, 0x18,
  0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x70, 0x00, 0xDC, 0x00,
  0x36, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0,
  0x06, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x70, 0xE0, 0x18, 0x38, 0x0E,
  0x07, 0x07, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x38, 0x78, 0x0E, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x70, 0x1C,
  0x1C, 0x07, 0x06, 0x01, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x38, 0x06, 0x0E,
  0x03, 0x83, 0x00, 0xC0, 0xC0, 0x70, 0x30, 0x38, 0x1C, 0x7C, 0x07, 0xFE,
  0x01, 0xFC, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0E, 0x0E, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x0C,
  0x70, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x70,
  0x00, 0xDC, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x33,
  0x00, 0x1C, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x70, 0xE0,
  0x18, 0x38, 0x0E, 0x07, 0x07, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x38, 0x78,
  0x0E, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x06,
  0x01, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x01,
  0xC0, 0xC0, 0xE0, 0x30, 0x78, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x0E, 0x1C, 0x03, 0x07, 0x00, 0xC0, 0xC0, 0x30,
  0x30, 0x1C, 0x0C, 0x07, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x38, 0x18, 0x06,
  0x0E, 0x01, 0x83, 0x80, 0x70, 0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xE0, 0x60, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x30, 0x1C, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x7F, 0xFE, 0xFF, 0xFC, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00,
  0x60, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x70, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0x38,
  0x07, 0x07, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18,
  0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xE0,
  0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC3, 0x80, 0xC3, 0x80, 0xC3, 0x00,
  0xC7, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0xDC, 0x00,
  0xD8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x07, 0x00, 0x3B, 0x00, 0x38, 0x03, 0x98, 0x01, 0xC0, 0x1C, 0xC0,
  0x1E, 0x00, 0xC6, 0x00, 0xF0, 0x0E, 0x30, 0x0D, 0x80, 0x61, 0x80, 0x6C,
  0x07, 0x0C, 0x03, 0x60, 0x38, 0x60, 0x33, 0x01, 0x83, 0x01, 0xB8, 0x1C,
  0x18, 0x1D, 0xC0, 0xC0, 0xC0, 0xCC, 0x0E, 0x06, 0x06, 0x60, 0x70, 0x30,
  0x63, 0x03, 0x01, 0x83, 0x18, 0x38, 0x0C, 0x38, 0xC1, 0x80, 0x61, 0x86,
  0x1C, 0x03, 0x0C, 0x30, 0xE0, 0x38, 0xC1, 0x86, 0x01, 0xC6, 0x0C, 0x70,
  0x0E, 0x70, 0x63, 0x00, 0x73, 0x03, 0x38, 0x03, 0x98, 0x19, 0xC0, 0x1D,
  0xC0, 0xCC, 0x00, 0xEC, 0x06, 0xE0, 0x07, 0x60, 0x36, 0x00, 0x3E, 0x01,
  0xB0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x03, 0xC0,
  0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x18, 0x07,
  0x01, 0x80, 0x38, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x98, 0x00, 0x1D,
  0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0,
  0x00, 0x19, 0x80, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00, 0xE3, 0x80, 0x06,
  0x1C, 0x00, 0x70, 0x60, 0x07, 0x03, 0x00, 0x30, 0x18, 0x03, 0x80, 0xC0,
  0x18, 0x06, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0x60, 0x0E, 0xC0, 0x1D,
  0x80, 0x73, 0x00, 0xC7, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x18, 0x30, 0x30,
  0xE0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x60, 0x0D, 0xC0,
  0x1B, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC3, 0x0C, 0x30, 0xC3, 0x8E, 0x18,
  0x61, 0x86, 0x18, 0x61, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0x61, 0x86,
  0x18, 0x61, 0x87, 0x1C, 0x30, 0xC3, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x36, 0x00, 0x3B, 0x00, 0x19, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x1C,
  0x06, 0x06, 0x06, 0x03, 0x87, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x39, 0x80,
  0x0D, 0xC0, 0x07, 0x7F, 0xFF, 0xFF, 0xC0, 0xC7, 0x18, 0xE3, 0x18, 0x60,
  0x01, 0xF1, 0x81, 0xFD, 0xC1, 0xC3, 0xC1, 0xC1, 0xE1, 0xC0, 0x70, 0xC0,
  0x38, 0xE0, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18,
  0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x03, 0x85, 0x81, 0xFE,
  0xC0, 0x7E, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x9F, 0x80, 0xDF, 0xE0, 0x78, 0x70, 0x78, 0x18, 0x3C, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x0C, 0x70, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0xF0, 0xE0, 0xCF,
  0xE0, 0x63, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC1, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x07, 0xCE,
  0x01, 0xFD, 0x80, 0x70, 0xF0, 0x1C, 0x1E, 0x07, 0x01, 0xC0, 0xC0, 0x38,
  0x38, 0x06, 0x07, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0,
  0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x03,
  0x80, 0x60, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x03,
  0x85, 0x80, 0x7F, 0xB0, 0x07, 0xE6, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x71,
  0xC3, 0x83, 0x1C, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x07, 0x70, 0x39, 0xC1,
  0xC6, 0x1E, 0x1F, 0xF0, 0x7E, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x83, 0xFE, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x27, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x60, 0x1F, 0xDC, 0x07, 0x0F, 0x01, 0xC1, 0xE0, 0x70, 0x1C,
  0x0C, 0x03, 0x83, 0x80, 0x60, 0x70, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x70,
  0x70, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x38, 0x06, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03,
  0x81, 0xC0, 0x38, 0x78, 0x07, 0xFB, 0x00, 0x7E, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x04, 0x07, 0x00, 0xE3, 0xC0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x7E, 0x06, 0xFF,
  0x07, 0x87, 0x07, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x07, 0x0C, 0x07,
  0x1C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x38, 0x0C,
  0x38, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x30, 0x18, 0x70, 0x18, 0x60, 0x18,
  0x60, 0x38, 0x60, 0x38, 0xE0, 0x30, 0xE0, 0x30, 0x00, 0x80, 0xC0, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x9C, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0xE0, 0xC0, 0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x38, 0x60, 0x18, 0x70,
  0x0C, 0x70, 0x06, 0x70, 0x07, 0x30, 0x03, 0xB8, 0x01, 0xBC, 0x00, 0xFE,
  0x00, 0x7B, 0x00, 0x79, 0x80, 0x38, 0xC0, 0x18, 0x70, 0x0C, 0x38, 0x06,
  0x1C, 0x07, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x06, 0x7C,
  0x3E, 0x03, 0x7F, 0x3F, 0x81, 0xE1, 0xF0, 0xE1, 0xE0, 0xF0, 0x70, 0xE0,
  0x70, 0x38, 0x70, 0x38, 0x1C, 0x30, 0x1C, 0x0C, 0x18, 0x0C, 0x06, 0x1C,
  0x06, 0x03, 0x0E, 0x07, 0x01, 0x86, 0x03, 0x81, 0xC3, 0x01, 0x80, 0xC1,
  0x80, 0xC0, 0x61, 0xC0, 0x60, 0x30, 0xE0, 0x70, 0x38, 0x60, 0x38, 0x1C,
  0x30, 0x18, 0x0C, 0x38, 0x0C, 0x06, 0x1C, 0x06, 0x03, 0x0C, 0x07, 0x03,
  0x86, 0x03, 0x01, 0xC3, 0x01, 0x80, 0xC3, 0x80, 0xC0, 0x61, 0xC0, 0xE0,
  0x70, 0x06, 0x7E, 0x06, 0xFE, 0x07, 0x87, 0x0F, 0x03, 0x0E, 0x03, 0x0E,
  0x07, 0x0C, 0x07, 0x0C, 0x06, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x18,
  0x0E, 0x18, 0x0C, 0x38, 0x0C, 0x38, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x70,
  0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x38, 0xE0, 0x30, 0xE0,
  0x30, 0x01, 0xF8, 0x0F, 0xF8, 0x18, 0x30, 0x70, 0x71, 0xC0, 0xE3, 0x00,
  0xCE, 0x01, 0x98, 0x03, 0x30, 0x06, 0xE0, 0x1D, 0x80, 0x3B, 0x00, 0x76,
  0x00, 0xCC, 0x01, 0xB8, 0x03, 0x70, 0x0E, 0xE0, 0x19, 0xC0, 0x33, 0x80,
  0xE7, 0x01, 0x86, 0x07, 0x0E, 0x1C, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0x9F,
  0x80, 0x37, 0xF8, 0x06, 0x87, 0x01, 0xE0, 0x60, 0x3C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x18, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x60, 0x0C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x0C,
  0x0C, 0x03, 0x81, 0x80, 0x70, 0x70, 0x0C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x3C, 0x38, 0x0E, 0xFF, 0x01, 0xCF, 0x80, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF1, 0x81, 0xFD, 0xC1,
  0xC3, 0xC1, 0xC1, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0x63, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x38, 0x0E, 0x1C,
  0x0F, 0x0E, 0x07, 0x03, 0x85, 0x81, 0xFE, 0xC0, 0x7E, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x06, 0x7C,
  0x1B, 0xE0, 0x7C, 0x03, 0x40, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x38, 0x10, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x10, 0x1C, 0x3F, 0xF0, 0x3F,
  0xC0, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0x83, 0xFC, 0xFE, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xF8, 0x1E, 0x00, 0x0C, 0x03, 0x0C, 0x07, 0x0C, 0x07, 0x1C, 0x06, 0x1C,
  0x06, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x1C, 0x30, 0x1C, 0x70, 0x18, 0x70, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60,
  0x38, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xE1, 0xF0, 0x7F,
  0x60, 0x7E, 0x60, 0xC0, 0x3E, 0x01, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0x60,
  0x73, 0x03, 0x18, 0x38, 0xC1, 0x86, 0x1C, 0x30, 0xC1, 0x86, 0x0C, 0x70,
  0x63, 0x03, 0x38, 0x19, 0x80, 0xDC, 0x06, 0xC0, 0x36, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0x6C,
  0x07, 0x03, 0xB0, 0x3C, 0x0C, 0xC0, 0xF0, 0x33, 0x06, 0xC1, 0xCC, 0x1B,
  0x06, 0x30, 0x6C, 0x38, 0xC3, 0x30, 0xC3, 0x0C, 0xC3, 0x0C, 0x73, 0x1C,
  0x31, 0x8C, 0x60, 0xC6, 0x31, 0x83, 0x30, 0xCC, 0x0C, 0xC3, 0x30, 0x37,
  0x0D, 0xC0, 0xD8, 0x36, 0x03, 0x60, 0xD8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x30, 0x0C, 0x00,
  0x03, 0x01, 0xC0, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x03, 0x86, 0x00,
  0x63, 0x00, 0x19, 0xC0, 0x06, 0x60, 0x01, 0xB8, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80,
  0x06, 0x60, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C,
  0x0C, 0x06, 0x03, 0x83, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0E, 0x03, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00,
  0x1B, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x8E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x04,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x83, 0xC3, 0xFE, 0x80, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 32, 10, 1, -32 },
  { 37, 11, 11, 13, 4, -32 },
  { 53, 19, 32, 18, 0, -32 },
  { 129, 17, 37, 16, 0, -34 },
  { 208, 22, 34, 25, 2, -33 },
  { 302, 16, 33, 17, 0, -33 },
  { 368, 5, 11, 7, 4, -32 },
  { 375, 13, 39, 11, 1, -32 },
  { 439, 13, 39, 11, -3, -32 },
  { 503, 12, 13, 15, 5, -34 },
  { 523, 16, 21, 19, 2, -26 },
  { 565, 7, 11, 8, -2, -5 },
  { 575, 10, 2, 12, 1, -13 },
  { 578, 3, 4, 8, 1, -4 },
  { 580, 19, 32, 14, -2, -32 },
  { 656, 15, 33, 17, 1, -33 },
  { 718, 9, 32, 17, 5, -32 },
  { 754, 19, 33, 17, -2, -33 },
  { 833, 18, 33, 17, -1, -33 },
  { 908, 18, 32, 17, -1, -32 },
  { 980, 18, 32, 17, -1, -32 },
  { 1052, 17, 33, 17, 1, -33 },
  { 1123, 16, 32, 17, 2, -32 },
  { 1187, 17, 33, 17, 0, -33 },
  { 1258, 16, 33, 17, 0, -33 },
  { 1324, 8, 24, 8, 0, -24 },
  { 1348, 10, 30, 8, -2, -24 },
  { 1386, 16, 20, 19, 2, -26 },
  { 1426, 16, 12, 19, 2, -22 },
  { 1450, 16, 20, 19, 2, -26 },
  { 1490, 13, 33, 12, 1, -33 },
  { 1544, 23, 36, 25, 1, -32 },
  { 1648, 16, 32, 16, -3, -32 },
  { 1712, 18, 32, 18, 0, -32 },
  { 1784, 18, 33, 16, 2, -33 },
  { 1859, 19, 32, 20, 0, -32 },
  { 1935, 18, 32, 16, 0, -32 },
  { 2007, 18, 32, 15, 0, -32 },
  { 2079, 20, 33, 21, 2, -33 },
  { 2162, 22, 32, 21, 0, -32 },
  { 2250, 15, 32, 10, -2, -32 },
  { 2310, 15, 40, 8, -6, -32 },
  { 2385, 20, 32, 17, 0, -32 },
  { 2465, 11, 32, 14, 0, -32 },
  { 2509, 29, 32, 28, 0, -32 },
  { 2625, 23, 32, 22, 0, -32 },
  { 2717, 18, 33, 21, 2, -33 },
  { 2792, 18, 32, 17, 0, -32 },
  { 2864, 18, 41, 21, 2, -33 },
  { 2957, 18, 32, 17, 0, -32 },
  { 3029, 19, 33, 16, -1, -33 },
  { 3108, 15, 32, 14, 3, -32 },
  { 3168, 20, 32, 20, 1, -32 },
  { 3248, 16, 32, 17, 4, -32 },
  { 3312, 29, 32, 28, 3, -32 },
  { 3428, 21, 32, 15, -3, -32 },
  { 3512, 15, 32, 15, 3, -32 },
  { 3572, 19, 32, 14, -2, -32 },
  { 3648, 16, 39, 13, -1, -32 },
  { 3726, 6, 32, 15, 5, -32 },
  { 3750, 17, 39, 13, -3, -32 },
  { 3833, 17, 16, 18, 1, -32 },
  { 3867, 13, 2, 13, -4, 4 },
  { 3871, 5, 7, 10, 7, -34 },
  { 3876, 17, 24, 18, 1, -24 },
  { 3927, 17, 34, 18, 0, -34 },
  { 4000, 14, 24, 13, 1, -24 },
  { 4042, 19, 34, 18, 1, -34 },
  { 4123, 14, 24, 16, 1, -24 },
  { 4165, 21, 45, 9, -6, -34 },
  { 4284, 19, 35, 18, -1, -24 },
  { 4368, 16, 34, 17, 0, -34 },
  { 4436, 9, 33, 8, 0, -33 },
  { 4474, 16, 44, 8, -6, -33 },
  { 4562, 17, 34, 15, 0, -34 },
  { 4635, 10, 34, 8, 0, -34 },
  { 4678, 25, 24, 26, 0, -24 },
  { 4753, 16, 24, 17, 0, -24 },
  { 4801, 15, 24, 17, 1, -24 },
  { 4846, 19, 34, 18, -2, -24 },
  { 4927, 17, 35, 18, 1, -24 },
  { 5002, 14, 24, 11, 0, -24 },
  { 5044, 15, 24, 13, -1, -24 },
  { 5089, 10, 30, 9, 1, -30 },
  { 5127, 16, 24, 17, 1, -24 },
  { 5175, 13, 24, 14, 3, -24 },
  { 5214, 22, 24, 23, 3, -24 },
  { 5280, 18, 24, 14, -2, -24 },
  { 5334, 22, 35, 14, -5, -24 },
  { 5431, 15, 24, 12, -2, -24 },
  { 5476, 16, 39, 14, 1, -32 },
  { 5554, 2, 45, 16, 7, -34 },
  { 5566, 16, 39, 14, -3, -32 },
  { 5644, 16, 4, 19, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC45PT7B_H_
