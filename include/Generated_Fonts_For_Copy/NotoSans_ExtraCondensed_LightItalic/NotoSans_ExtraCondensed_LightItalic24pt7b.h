#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x31, 0x08, 0x46, 0x21, 0x08, 0x46, 0x00, 0x18, 0xC0,
  0x6D, 0x34, 0x92, 0x4A, 0x20, 0x04, 0x41, 0x20, 0x48, 0x22, 0x09, 0x0F,
  0xF1, 0x10, 0x48, 0x12, 0x08, 0x82, 0x63, 0xFC, 0x44, 0x11, 0x04, 0x81,
  0x20, 0x98, 0x00, 0x02, 0x01, 0x03, 0xE2, 0x92, 0x41, 0x20, 0x90, 0x68,
  0x18, 0x06, 0x03, 0x81, 0x41, 0x20, 0x90, 0x49, 0x2C, 0xF8, 0x10, 0x08,
  0x00, 0x38, 0x62, 0x44, 0x44, 0x84, 0x48, 0x49, 0x08, 0x90, 0x8A, 0x08,
  0xAE, 0x95, 0x9F, 0x51, 0x09, 0x30, 0xB2, 0x12, 0x21, 0x22, 0x22, 0x62,
  0x24, 0x43, 0x80, 0x0E, 0x0C, 0x84, 0x42, 0x61, 0x20, 0x90, 0x50, 0x30,
  0x38, 0x34, 0xD3, 0x58, 0xA8, 0x74, 0x32, 0x19, 0x14, 0x73, 0x00, 0x69,
  0x25, 0x00, 0x04, 0x21, 0x04, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x30, 0x40, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x83, 0x04, 0x18, 0x20, 0x82, 0x0C,
  0x00, 0x12, 0x4E, 0x4E, 0x53, 0x40, 0x80, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x32, 0x44, 0x80, 0xFC, 0x70, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x04, 0xC4,
  0x66, 0x12, 0x19, 0x0D, 0x86, 0xC2, 0x41, 0x20, 0x90, 0xC8, 0x4C, 0x26,
  0x31, 0x10, 0x98, 0x78, 0x00, 0x1B, 0xB5, 0x23, 0x10, 0x84, 0x23, 0x10,
  0x84, 0x63, 0x10, 0x80, 0x0F, 0x82, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0xFE, 0x00, 0x1F, 0x08, 0xC0, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x1C, 0x1C,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x19, 0x18, 0xF8, 0x00, 0x01, 0x81,
  0xC0, 0xC0, 0xA0, 0xD0, 0x58, 0x4C, 0x24, 0x22, 0x31, 0x11, 0x90, 0x8F,
  0xF0, 0x20, 0x10, 0x18, 0x08, 0x00, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0xF8, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x20, 0x10, 0x19, 0x18,
  0xF8, 0x00, 0x0F, 0x18, 0x30, 0x20, 0x40, 0x40, 0x48, 0xFC, 0xC6, 0x82,
  0x82, 0x82, 0x86, 0x84, 0x84, 0x88, 0x78, 0x7F, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x80, 0x00, 0x0F, 0x08, 0xCC, 0x24, 0x12, 0x09, 0x88, 0x4C, 0x38,
  0x1C, 0x33, 0x10, 0x90, 0x48, 0x34, 0x12, 0x09, 0x8C, 0x7C, 0x00, 0x0F,
  0x08, 0x8C, 0x64, 0x32, 0x1B, 0x0D, 0x86, 0xC2, 0x63, 0x1E, 0x84, 0xC0,
  0x40, 0x20, 0x30, 0x10, 0x10, 0xF0, 0x00, 0x13, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46, 0x21, 0x10,
  0x01, 0x03, 0x0E, 0x38, 0x60, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x06, 0x18, 0x70, 0xC0, 0x80, 0x3E, 0x44, 0x08, 0x10, 0x20, 0x83, 0x04,
  0x10, 0x40, 0x83, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x07, 0xC0, 0x82, 0x10,
  0x22, 0x01, 0x20, 0x14, 0x79, 0x49, 0x9C, 0x91, 0x91, 0x29, 0x12, 0x93,
  0x29, 0x26, 0x92, 0x49, 0xD8, 0x80, 0x08, 0x00, 0x80, 0x04, 0x20, 0x3C,
  0x00, 0x01, 0x80, 0xC0, 0xE0, 0x50, 0x28, 0x24, 0x12, 0x19, 0x08, 0x8C,
  0x47, 0xE2, 0x13, 0x09, 0x05, 0x82, 0x81, 0xC0, 0x80, 0x0F, 0x86, 0x21,
  0x0C, 0x43, 0x10, 0xCC, 0x23, 0x18, 0xFC, 0x3E, 0x08, 0x46, 0x11, 0x84,
  0x41, 0x10, 0x44, 0x33, 0x18, 0xFC, 0x00, 0x0F, 0xC6, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x7C, 0x00, 0x0F, 0x06, 0x21, 0x0C, 0x41, 0x10, 0x4C,
  0x13, 0x04, 0x81, 0x20, 0xC8, 0x36, 0x09, 0x82, 0x41, 0x90, 0xC4, 0x23,
  0x30, 0xF8, 0x00, 0x0F, 0x8C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x7E,
  0x3E, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0xFC, 0x00, 0x0F,
  0xC6, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x3E, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x00, 0x07, 0xE3, 0x04,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x83, 0x90, 0x12, 0x02,
  0x40, 0xC8, 0x11, 0x02, 0x30, 0x42, 0x08, 0x3F, 0x00, 0x08, 0x31, 0x82,
  0x10, 0x21, 0x06, 0x10, 0x63, 0x04, 0x30, 0x43, 0xFC, 0x3F, 0xC2, 0x08,
  0x60, 0x84, 0x08, 0x40, 0x84, 0x18, 0x41, 0x0C, 0x10, 0x81, 0x00, 0x1F,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x20, 0xF0, 0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30,
  0xE0, 0x08, 0x63, 0x18, 0x42, 0x08, 0x81, 0x30, 0x6C, 0x0D, 0x01, 0x40,
  0x3C, 0x05, 0x81, 0x90, 0x22, 0x04, 0x40, 0x8C, 0x10, 0x86, 0x10, 0x82,
  0x00, 0x08, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04,
  0x30, 0xFC, 0x0C, 0x06, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x61, 0x41, 0x46,
  0x82, 0x89, 0x09, 0x12, 0x16, 0x24, 0x68, 0x48, 0x91, 0x93, 0x22, 0x24,
  0xC4, 0x59, 0x88, 0xA2, 0x11, 0xC4, 0x63, 0x08, 0x86, 0x30, 0x08, 0x11,
  0x81, 0x1C, 0x31, 0x42, 0x14, 0x23, 0x42, 0x34, 0x62, 0x66, 0x22, 0x42,
  0x24, 0x62, 0x44, 0x2C, 0x42, 0x84, 0x38, 0x41, 0x8C, 0x18, 0x81, 0x80,
  0x0F, 0x86, 0x23, 0x0C, 0x81, 0x60, 0x50, 0x34, 0x0F, 0x03, 0xC0, 0xA0,
  0x28, 0x0A, 0x06, 0x81, 0x20, 0xC8, 0x23, 0x18, 0x78, 0x00, 0x0F, 0x0C,
  0xC4, 0x22, 0x11, 0x09, 0x84, 0xC2, 0x42, 0x23, 0x1E, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x00, 0x0F, 0x86, 0x23, 0x0C, 0x81, 0x60,
  0x50, 0x34, 0x0F, 0x03, 0xC0, 0xA0, 0x28, 0x0A, 0x06, 0x81, 0x20, 0xC8,
  0x23, 0x18, 0x78, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x0F, 0x0C, 0xC4,
  0x22, 0x11, 0x09, 0x84, 0xC6, 0x42, 0x3E, 0x1E, 0x19, 0x08, 0x84, 0x42,
  0x31, 0x19, 0x84, 0x82, 0x00, 0x07, 0xC2, 0x11, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x32,
  0x18, 0xFC, 0x00, 0xFF, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x30, 0x4C, 0x12, 0x0C,
  0x83, 0x20, 0x98, 0x24, 0x09, 0x06, 0x41, 0x10, 0x4C, 0x12, 0x0C, 0x83,
  0x20, 0x88, 0x23, 0x10, 0x78, 0x00, 0x81, 0xC0, 0xA0, 0xD0, 0x48, 0x24,
  0x32, 0x11, 0x18, 0x88, 0x4C, 0x24, 0x12, 0x0B, 0x05, 0x03, 0x81, 0x80,
  0xC0, 0x00, 0x81, 0x07, 0x06, 0x0A, 0x0C, 0x34, 0x38, 0x48, 0x50, 0x90,
  0xA3, 0x22, 0x44, 0x44, 0x98, 0x99, 0x21, 0x22, 0x42, 0x45, 0x85, 0x0A,
  0x0A, 0x14, 0x14, 0x70, 0x30, 0xE0, 0x61, 0xC0, 0xC3, 0x00, 0x08, 0x61,
  0x08, 0x22, 0x04, 0x40, 0xD0, 0x1E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x78, 0x0B, 0x02, 0x60, 0x44, 0x10, 0x86, 0x10, 0x82, 0x00, 0x83, 0x82,
  0xC4, 0xC4, 0xC8, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x80, 0x0F, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0xFE,
  0x00, 0x07, 0x82, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0F,
  0x80, 0xC4, 0x44, 0x44, 0x66, 0x22, 0x22, 0x22, 0x31, 0x10, 0x07, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x04, 0x07,
  0x02, 0x82, 0x61, 0x11, 0x08, 0x86, 0x81, 0xC0, 0x80, 0xFE, 0xCC, 0x80,
  0x1D, 0x33, 0x63, 0x43, 0x43, 0xC2, 0x82, 0x82, 0x86, 0x86, 0x84, 0x8C,
  0xF4, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0xB8, 0xE6, 0x61, 0x30, 0x90,
  0x48, 0x6C, 0x34, 0x12, 0x09, 0x0C, 0x84, 0xA6, 0x5E, 0x00, 0x1E, 0x61,
  0x82, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x87, 0x43, 0x31, 0x8C, 0x43, 0x30, 0xCC, 0x22,
  0x08, 0x82, 0x21, 0x88, 0x62, 0x10, 0x8C, 0x3D, 0x00, 0x1C, 0x65, 0x8A,
  0x1C, 0x71, 0xBC, 0x40, 0x81, 0x02, 0x04, 0x27, 0x80, 0x01, 0xE0, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x1F, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x38, 0x06, 0x00, 0x0E, 0x8C, 0xCC, 0x64, 0x32, 0x1B,
  0x09, 0x04, 0x82, 0x43, 0x21, 0x91, 0x88, 0xC7, 0xA0, 0x30, 0x10, 0x08,
  0x0C, 0x4C, 0x3C, 0x00, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0xB8, 0x64,
  0x63, 0x31, 0x10, 0x88, 0x4C, 0x26, 0x32, 0x11, 0x08, 0x84, 0xC6, 0x43,
  0x00, 0x18, 0x80, 0x01, 0x08, 0xC4, 0x21, 0x18, 0x84, 0x21, 0x18, 0x80,
  0x03, 0x01, 0x00, 0x00, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0xE0, 0xC0, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x8C, 0x44, 0x64, 0x24, 0x16, 0x0A, 0x0F,
  0x06, 0x82, 0x61, 0x10, 0x88, 0xC4, 0x42, 0x00, 0x08, 0x46, 0x21, 0x08,
  0x46, 0x21, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x00, 0x17, 0x71, 0xCE, 0x4C,
  0x62, 0x42, 0x12, 0x10, 0x90, 0x8D, 0x8C, 0x4C, 0x42, 0x42, 0x12, 0x10,
  0x90, 0x8D, 0x8C, 0x48, 0x42, 0x00, 0x17, 0x1C, 0x8C, 0x66, 0x22, 0x11,
  0x09, 0x84, 0x86, 0x42, 0x21, 0x10, 0x98, 0xC8, 0x60, 0x1C, 0x32, 0x62,
  0x43, 0xC3, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x0B, 0x87,
  0x31, 0x84, 0x61, 0x10, 0x44, 0x33, 0x0C, 0x82, 0x20, 0x88, 0x62, 0x11,
  0xCC, 0x5E, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x1D, 0x33,
  0x63, 0x43, 0x43, 0xC2, 0x82, 0x82, 0x86, 0x86, 0x84, 0x8C, 0xF4, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x16, 0x70, 0xC1, 0x82, 0x04, 0x18, 0x20,
  0x40, 0x81, 0x06, 0x08, 0x00, 0x1E, 0x45, 0x83, 0x06, 0x04, 0x04, 0x04,
  0x0C, 0x18, 0x34, 0x4F, 0x00, 0x08, 0x41, 0x1F, 0x30, 0x82, 0x08, 0x21,
  0x84, 0x10, 0x41, 0x0C, 0x18, 0x21, 0x61, 0x63, 0x42, 0x42, 0x42, 0xC6,
  0x86, 0x84, 0x84, 0x8C, 0x94, 0xFC, 0xC3, 0xC2, 0xC6, 0xC4, 0xCC, 0xC8,
  0xC8, 0xD0, 0xD0, 0xE0, 0x60, 0x60, 0x40, 0xC2, 0x1C, 0x63, 0xC6, 0x2C,
  0xE2, 0xCA, 0x4C, 0xA4, 0xD2, 0xCD, 0x28, 0xF2, 0x8E, 0x38, 0xA3, 0x0C,
  0x30, 0xC2, 0x00, 0x10, 0x88, 0xC6, 0x43, 0x40, 0xA0, 0x60, 0x30, 0x38,
  0x14, 0x12, 0x19, 0x08, 0xCC, 0x60, 0x04, 0x30, 0x42, 0x04, 0x20, 0x44,
  0x04, 0x40, 0x4C, 0x04, 0x80, 0x58, 0x05, 0x00, 0x50, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x0B, 0x00, 0xE0, 0x00, 0x1F,
  0x03, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x44, 0xF8,
  0x07, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x60, 0xC0, 0x60,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x60, 0x30, 0xFF, 0xFF, 0xFF,
  0x06, 0x01, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xE0, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x06, 0x0E, 0x00,
  0x61, 0xDD, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 17, 5, 0, -17 },
  { 12, 6, 6, 7, 2, -17 },
  { 17, 10, 17, 9, 0, -17 },
  { 39, 9, 19, 9, 0, -18 },
  { 61, 12, 17, 14, 1, -17 },
  { 87, 9, 17, 9, 0, -17 },
  { 107, 3, 6, 4, 2, -17 },
  { 110, 6, 21, 6, 1, -17 },
  { 126, 7, 21, 6, -2, -17 },
  { 145, 6, 7, 8, 3, -18 },
  { 151, 8, 11, 10, 1, -14 },
  { 162, 4, 5, 4, -1, -2 },
  { 165, 6, 1, 6, 0, -7 },
  { 166, 2, 2, 4, 0, -2 },
  { 167, 10, 17, 8, -1, -17 },
  { 189, 9, 17, 9, 0, -17 },
  { 209, 5, 17, 9, 3, -17 },
  { 220, 10, 17, 9, -1, -17 },
  { 242, 9, 17, 9, 0, -17 },
  { 262, 9, 17, 9, 0, -17 },
  { 282, 9, 17, 9, 0, -17 },
  { 302, 8, 17, 9, 1, -17 },
  { 319, 9, 17, 9, 1, -17 },
  { 339, 9, 17, 9, 0, -17 },
  { 359, 9, 17, 9, 0, -17 },
  { 379, 4, 13, 4, 0, -13 },
  { 386, 5, 16, 4, -1, -13 },
  { 396, 8, 11, 10, 1, -14 },
  { 407, 8, 7, 10, 1, -12 },
  { 414, 8, 11, 10, 1, -14 },
  { 425, 7, 17, 6, 0, -17 },
  { 440, 12, 19, 13, 1, -17 },
  { 469, 9, 17, 9, -2, -17 },
  { 489, 10, 17, 10, 0, -17 },
  { 511, 10, 17, 9, 1, -17 },
  { 533, 10, 17, 11, 0, -17 },
  { 555, 9, 17, 8, 0, -17 },
  { 575, 10, 17, 8, 0, -17 },
  { 597, 11, 17, 11, 1, -17 },
  { 621, 12, 17, 11, 0, -17 },
  { 647, 8, 17, 5, -1, -17 },
  { 664, 8, 21, 4, -3, -17 },
  { 685, 11, 17, 9, 0, -17 },
  { 709, 6, 17, 8, 0, -17 },
  { 722, 15, 17, 15, 0, -17 },
  { 754, 12, 17, 12, 0, -17 },
  { 780, 10, 17, 11, 1, -17 },
  { 802, 9, 17, 9, 0, -17 },
  { 822, 10, 21, 11, 1, -17 },
  { 849, 9, 17, 9, 0, -17 },
  { 869, 10, 17, 9, -1, -17 },
  { 891, 8, 17, 8, 2, -17 },
  { 908, 10, 17, 11, 1, -17 },
  { 930, 9, 17, 9, 2, -17 },
  { 950, 15, 17, 15, 2, -17 },
  { 982, 11, 17, 8, -1, -17 },
  { 1006, 8, 17, 8, 2, -17 },
  { 1023, 10, 17, 8, -1, -17 },
  { 1045, 9, 21, 7, -1, -17 },
  { 1069, 4, 17, 8, 2, -17 },
  { 1078, 9, 21, 7, -2, -17 },
  { 1102, 9, 9, 9, 0, -17 },
  { 1113, 7, 1, 7, -2, 2 },
  { 1114, 3, 3, 5, 3, -18 },
  { 1116, 8, 13, 10, 1, -13 },
  { 1129, 9, 18, 9, 0, -18 },
  { 1150, 7, 13, 7, 1, -13 },
  { 1162, 10, 18, 10, 1, -18 },
  { 1185, 7, 13, 9, 1, -13 },
  { 1197, 11, 24, 5, -3, -18 },
  { 1230, 9, 19, 10, 0, -13 },
  { 1252, 9, 18, 9, 0, -18 },
  { 1273, 5, 17, 4, 0, -17 },
  { 1284, 8, 23, 4, -3, -17 },
  { 1307, 9, 18, 8, 0, -18 },
  { 1328, 5, 18, 4, 0, -18 },
  { 1340, 13, 13, 14, 0, -13 },
  { 1362, 9, 13, 9, 0, -13 },
  { 1377, 8, 13, 9, 1, -13 },
  { 1390, 10, 19, 9, -1, -13 },
  { 1414, 8, 19, 10, 1, -13 },
  { 1433, 7, 13, 6, 0, -13 },
  { 1445, 7, 13, 7, 0, -13 },
  { 1457, 6, 16, 5, 0, -16 },
  { 1469, 8, 13, 9, 1, -13 },
  { 1482, 8, 13, 7, 1, -13 },
  { 1495, 12, 13, 12, 1, -13 },
  { 1515, 9, 13, 8, -1, -13 },
  { 1530, 12, 19, 8, -3, -13 },
  { 1559, 8, 13, 6, -1, -13 },
  { 1572, 8, 21, 8, 1, -17 },
  { 1593, 1, 24, 9, 4, -18 },
  { 1596, 9, 21, 8, -2, -17 },
  { 1620, 8, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC24PT7B_H_
