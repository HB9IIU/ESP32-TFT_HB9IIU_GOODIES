#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x22, 0x10, 0x84, 0x22, 0x00, 0x04, 0x60, 0x5A, 0xA5,
  0x29, 0x00, 0x09, 0x09, 0x0A, 0x12, 0x7F, 0x14, 0x24, 0x24, 0x24, 0xDA,
  0x48, 0x48, 0x90, 0x90, 0x04, 0x0C, 0x37, 0x28, 0x28, 0x28, 0x28, 0x10,
  0x18, 0x14, 0x14, 0x14, 0xA4, 0xF8, 0x20, 0x20, 0x31, 0x92, 0x44, 0xA2,
  0x48, 0x94, 0x25, 0x69, 0xA6, 0xA9, 0x54, 0x45, 0x22, 0x48, 0x92, 0x45,
  0x11, 0xC0, 0x1C, 0x2C, 0x91, 0x22, 0x43, 0x0C, 0x38, 0x4B, 0x16, 0x34,
  0x68, 0xDE, 0x80, 0x5A, 0x80, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x41,
  0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x18, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x44, 0x21, 0x10, 0x88, 0x80, 0x12, 0x47, 0xCC, 0xD0, 0x20, 0x10, 0x20,
  0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x2D, 0x28, 0xF8, 0x70, 0x01,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x00, 0x1E, 0x24, 0x89, 0x16, 0x28, 0x50, 0xA1, 0x47, 0x8A,
  0x14, 0x44, 0x8E, 0x00, 0x37, 0x91, 0x22, 0x22, 0x64, 0x44, 0x48, 0x1F,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40,
  0xFC, 0x3E, 0x04, 0x08, 0x10, 0x20, 0x8E, 0x06, 0x04, 0x08, 0x10, 0x20,
  0x9E, 0x00, 0x02, 0x0C, 0x28, 0x51, 0x44, 0x89, 0x22, 0x45, 0x13, 0xF8,
  0x40, 0x83, 0x00, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x70, 0x4C, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0xF0, 0x0F, 0x10, 0x20, 0x20, 0x20, 0x5C, 0x64,
  0x42, 0x42, 0x46, 0xC4, 0x44, 0x4C, 0x78, 0x7E, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x00, 0x1E, 0x23, 0x21, 0x22,
  0x22, 0x34, 0x18, 0x28, 0x44, 0x84, 0x84, 0x84, 0x84, 0x78, 0x1E, 0x44,
  0x8A, 0x14, 0x28, 0x51, 0xB5, 0x14, 0x08, 0x10, 0x41, 0x9E, 0x00, 0x24,
  0x00, 0x00, 0x1A, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x10, 0x84,
  0x40, 0x06, 0x31, 0x84, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0xC2, 0x18, 0x40, 0x3C, 0x10, 0x41,
  0x08, 0x61, 0x08, 0x41, 0x00, 0x00, 0x43, 0x00, 0x07, 0xC1, 0x08, 0x40,
  0x90, 0x12, 0x72, 0x92, 0x52, 0x4A, 0x92, 0x52, 0x4A, 0x4A, 0x5A, 0x44,
  0x84, 0x00, 0x80, 0x18, 0x80, 0xE0, 0x06, 0x0C, 0x28, 0x50, 0xA2, 0x44,
  0x91, 0x3E, 0x45, 0x0A, 0x18, 0x30, 0x40, 0x1E, 0x11, 0x31, 0x21, 0x21,
  0x22, 0x3C, 0x46, 0x42, 0x42, 0x42, 0x46, 0x84, 0xF8, 0x04, 0x1F, 0x30,
  0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78,
  0x1E, 0x11, 0x31, 0x21, 0x21, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x44,
  0x8C, 0xF0, 0x1F, 0x10, 0x30, 0x20, 0x20, 0x20, 0x3C, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0xF8, 0x1F, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x7C,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x02, 0x0F, 0xCC, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x8F, 0x41, 0x20, 0x90, 0x48, 0x26, 0x21, 0xF0, 0x10,
  0xC4, 0x23, 0x08, 0x82, 0x20, 0x88, 0x43, 0xF1, 0x04, 0x41, 0x10, 0xC4,
  0x21, 0x08, 0x82, 0x21, 0x80, 0x1E, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x1E, 0x00, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xA1, 0x80, 0x11, 0x88,
  0x8C, 0x84, 0x82, 0xC1, 0x40, 0xE0, 0xD0, 0x48, 0x24, 0x12, 0x08, 0x88,
  0x44, 0x20, 0x10, 0x8C, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x7C, 0x18,
  0x18, 0xC1, 0x8A, 0x0C, 0x50, 0xA2, 0x85, 0x14, 0x50, 0xA2, 0x89, 0x24,
  0x49, 0x22, 0x49, 0x12, 0x90, 0x94, 0x88, 0xC4, 0x46, 0x20, 0x10, 0x46,
  0x12, 0x8C, 0xA2, 0x28, 0x8A, 0x22, 0x49, 0x14, 0x45, 0x11, 0x44, 0x51,
  0x14, 0x82, 0x20, 0x80, 0x1E, 0x21, 0x61, 0x41, 0x41, 0x81, 0x81, 0x83,
  0x82, 0x82, 0x82, 0x84, 0x8C, 0x78, 0x1E, 0x13, 0x31, 0x21, 0x21, 0x22,
  0x26, 0x7C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x21, 0x61, 0x41,
  0x41, 0x81, 0x81, 0x83, 0x82, 0x82, 0x82, 0x84, 0x8C, 0x78, 0x10, 0x10,
  0x18, 0x1E, 0x13, 0x31, 0x21, 0x21, 0x22, 0x26, 0x78, 0x48, 0x48, 0x48,
  0x4C, 0x84, 0x84, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x48, 0x47, 0xC0, 0x7E, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x00, 0x21, 0x21, 0x41, 0x41,
  0x42, 0x42, 0x42, 0x82, 0x86, 0x84, 0x84, 0x84, 0x88, 0xF0, 0x83, 0x0A,
  0x14, 0x48, 0x91, 0x24, 0x48, 0xA1, 0x43, 0x86, 0x0C, 0x10, 0x00, 0x42,
  0x0A, 0x10, 0x91, 0x84, 0x8C, 0x64, 0xA2, 0x25, 0x11, 0x29, 0x0A, 0x48,
  0x52, 0xC2, 0x94, 0x18, 0xA1, 0x46, 0x0C, 0x30, 0x61, 0x80, 0x10, 0x8C,
  0x82, 0x41, 0x40, 0xE0, 0x60, 0x20, 0x10, 0x14, 0x12, 0x09, 0x08, 0x84,
  0x44, 0x20, 0x42, 0x89, 0x12, 0x44, 0x8A, 0x14, 0x30, 0x20, 0x81, 0x02,
  0x04, 0x18, 0x00, 0x1F, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x08, 0x04, 0x07, 0xE0, 0x1E, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xE0, 0x92, 0x24,
  0x92, 0x49, 0x12, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xE0, 0x08, 0x14, 0x14, 0x22, 0x22,
  0x42, 0xC1, 0xFC, 0x94, 0x1A, 0xCD, 0x16, 0x28, 0x50, 0xA1, 0x44, 0x89,
  0x33, 0xA0, 0x10, 0x20, 0x41, 0x82, 0xC6, 0x48, 0x91, 0x42, 0x85, 0x0A,
  0x14, 0x58, 0xAE, 0x00, 0x1B, 0x11, 0x08, 0x42, 0x10, 0x84, 0x3C, 0x01,
  0x02, 0x02, 0x02, 0x1A, 0x66, 0x44, 0xC4, 0x84, 0x84, 0x84, 0x88, 0x88,
  0x98, 0xE8, 0x19, 0x94, 0x63, 0x8B, 0xC8, 0x20, 0x82, 0x0F, 0x00, 0x01,
  0x81, 0x00, 0x80, 0x40, 0xF0, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x18, 0x00, 0x0D, 0x33,
  0x22, 0x62, 0x42, 0x42, 0x42, 0x44, 0x44, 0x4C, 0x74, 0x04, 0x08, 0x08,
  0x90, 0xE0, 0x10, 0x20, 0x40, 0x82, 0xC6, 0x48, 0x91, 0x42, 0x8D, 0x12,
  0x24, 0x50, 0xA2, 0x00, 0x11, 0x00, 0x22, 0x22, 0x44, 0x44, 0x48, 0x80,
  0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x86, 0x00, 0x10, 0x20, 0x40, 0x82, 0x24, 0xC9,
  0x14, 0x50, 0xE1, 0x22, 0x44, 0x91, 0x22, 0x00, 0x11, 0x11, 0x22, 0x22,
  0x44, 0x44, 0x48, 0x80, 0x2C, 0xC6, 0x64, 0x88, 0x91, 0x14, 0x22, 0x88,
  0x91, 0x12, 0x22, 0x44, 0x51, 0x8A, 0x22, 0x00, 0x2C, 0x64, 0x89, 0x14,
  0x28, 0xD1, 0x22, 0x45, 0x0A, 0x20, 0x19, 0x94, 0x61, 0x86, 0x18, 0x62,
  0x8A, 0x6F, 0x00, 0x16, 0x19, 0x11, 0x11, 0x31, 0x21, 0x21, 0x21, 0x22,
  0x62, 0x5C, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1A, 0xCD, 0x16, 0x28, 0x50,
  0xA1, 0x44, 0x89, 0x33, 0xA0, 0x41, 0x02, 0x04, 0x08, 0x2C, 0xC2, 0x08,
  0x61, 0x04, 0x10, 0x42, 0x08, 0x00, 0x1D, 0x94, 0x10, 0x60, 0xC1, 0x02,
  0x08, 0x4F, 0x00, 0x11, 0x1E, 0x42, 0x11, 0x08, 0x42, 0x11, 0x06, 0x00,
  0x46, 0x89, 0x12, 0x28, 0x51, 0x22, 0x44, 0x89, 0x33, 0xC0, 0x86, 0x18,
  0xA2, 0x92, 0x4A, 0x28, 0xA3, 0x0C, 0x00, 0x84, 0x63, 0x38, 0xCA, 0x52,
  0x95, 0x25, 0x4A, 0x52, 0x98, 0xC6, 0x31, 0x08, 0x40, 0x11, 0x12, 0x12,
  0x14, 0x18, 0x08, 0x18, 0x28, 0x28, 0x44, 0xC4, 0x10, 0x88, 0x44, 0x42,
  0x20, 0x90, 0x50, 0x28, 0x18, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80,
  0x81, 0x80, 0x1E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x60, 0x83, 0xE0,
  0x0E, 0x20, 0x40, 0x83, 0x04, 0x08, 0x30, 0x80, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x60, 0xFF, 0xFF, 0xF0, 0x1C, 0x08, 0x10, 0x20, 0xC1, 0x02,
  0x04, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0xC0, 0xE3, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 4, 0, -14 },
  { 10, 5, 5, 6, 2, -14 },
  { 14, 8, 14, 8, 0, -14 },
  { 28, 8, 16, 7, 0, -15 },
  { 44, 10, 14, 11, 1, -14 },
  { 62, 7, 14, 8, 0, -14 },
  { 75, 2, 5, 3, 2, -14 },
  { 77, 6, 17, 5, 0, -14 },
  { 90, 5, 17, 5, -1, -14 },
  { 101, 6, 6, 7, 2, -15 },
  { 106, 7, 10, 8, 1, -12 },
  { 115, 3, 5, 4, -1, -2 },
  { 117, 5, 1, 5, 0, -6 },
  { 118, 2, 2, 4, 0, -2 },
  { 119, 9, 14, 6, -1, -14 },
  { 135, 7, 14, 7, 0, -14 },
  { 148, 4, 14, 7, 2, -14 },
  { 155, 8, 14, 7, -1, -14 },
  { 169, 7, 14, 7, 0, -14 },
  { 182, 7, 14, 7, 0, -14 },
  { 195, 8, 14, 7, 0, -14 },
  { 209, 8, 14, 7, 0, -14 },
  { 223, 7, 14, 7, 1, -14 },
  { 236, 8, 14, 7, 0, -14 },
  { 250, 7, 14, 7, 0, -14 },
  { 263, 3, 11, 4, 0, -11 },
  { 268, 5, 14, 4, -1, -11 },
  { 277, 7, 8, 8, 1, -11 },
  { 284, 7, 6, 8, 1, -10 },
  { 290, 7, 8, 8, 1, -11 },
  { 297, 6, 14, 5, 0, -14 },
  { 308, 11, 16, 11, 0, -14 },
  { 330, 7, 14, 7, -1, -14 },
  { 343, 8, 14, 8, 0, -14 },
  { 357, 8, 15, 7, 1, -15 },
  { 372, 8, 14, 9, 0, -14 },
  { 386, 8, 14, 7, 0, -14 },
  { 400, 8, 14, 7, 0, -14 },
  { 414, 9, 15, 9, 1, -15 },
  { 431, 10, 14, 9, 0, -14 },
  { 449, 7, 14, 4, -1, -14 },
  { 462, 7, 18, 4, -3, -14 },
  { 478, 9, 14, 8, 0, -14 },
  { 494, 5, 14, 6, 0, -14 },
  { 503, 13, 14, 12, 0, -14 },
  { 526, 10, 14, 10, 0, -14 },
  { 544, 8, 14, 9, 1, -14 },
  { 558, 8, 14, 8, 0, -14 },
  { 572, 8, 17, 9, 1, -14 },
  { 589, 8, 14, 8, 0, -14 },
  { 603, 9, 14, 7, -1, -14 },
  { 619, 7, 14, 6, 1, -14 },
  { 632, 8, 14, 9, 1, -14 },
  { 646, 7, 14, 7, 2, -14 },
  { 659, 13, 14, 13, 1, -14 },
  { 682, 9, 14, 7, -1, -14 },
  { 698, 7, 14, 6, 1, -14 },
  { 711, 9, 14, 6, -1, -14 },
  { 727, 7, 17, 6, 0, -14 },
  { 742, 3, 14, 7, 2, -14 },
  { 748, 7, 17, 6, -1, -14 },
  { 763, 8, 7, 8, 0, -14 },
  { 770, 6, 1, 6, -2, 2 },
  { 771, 2, 3, 5, 3, -15 },
  { 772, 7, 11, 8, 1, -11 },
  { 782, 7, 15, 8, 0, -15 },
  { 796, 5, 11, 6, 1, -11 },
  { 803, 8, 15, 8, 1, -15 },
  { 818, 6, 11, 7, 1, -11 },
  { 827, 9, 20, 4, -3, -15 },
  { 850, 8, 16, 8, 0, -11 },
  { 866, 7, 15, 8, 0, -15 },
  { 880, 4, 15, 3, 0, -15 },
  { 888, 7, 20, 4, -3, -15 },
  { 906, 7, 15, 7, 0, -15 },
  { 920, 4, 15, 3, 0, -15 },
  { 928, 11, 11, 12, 0, -11 },
  { 944, 7, 11, 8, 0, -11 },
  { 954, 6, 11, 8, 1, -11 },
  { 963, 8, 16, 8, -1, -11 },
  { 979, 7, 16, 8, 1, -11 },
  { 993, 6, 11, 5, 0, -11 },
  { 1002, 6, 11, 6, 0, -11 },
  { 1011, 5, 13, 4, 0, -13 },
  { 1020, 7, 11, 8, 1, -11 },
  { 1030, 6, 11, 6, 1, -11 },
  { 1039, 10, 11, 10, 1, -11 },
  { 1053, 8, 11, 6, -1, -11 },
  { 1064, 9, 16, 6, -2, -11 },
  { 1082, 7, 11, 5, -1, -11 },
  { 1092, 7, 17, 6, 1, -14 },
  { 1107, 1, 20, 7, 3, -15 },
  { 1110, 7, 17, 6, -1, -14 },
  { 1125, 7, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC20PT7B_H_
