#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0x55, 0x5A, 0x14, 0x51, 0x5F, 0x28,
  0xA5, 0x3E, 0x52, 0x8A, 0x00, 0x10, 0xF5, 0x14, 0x50, 0x83, 0x0A, 0x2A,
  0xC4, 0x10, 0x65, 0x4A, 0xA5, 0x4B, 0x57, 0x7A, 0x95, 0x52, 0xAA, 0x30,
  0x19, 0x4A, 0x53, 0x11, 0xB3, 0x9C, 0xBA, 0x56, 0x08, 0x88, 0x44, 0x21,
  0x10, 0x84, 0x21, 0x04, 0x00, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80,
  0x4F, 0x4A, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x29, 0x40, 0xF0, 0x80, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x00, 0x19, 0x52, 0x94,
  0xA6, 0x31, 0x94, 0x98, 0x2F, 0x24, 0x94, 0x92, 0x00, 0x1C, 0x48, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x20, 0x83, 0xE0, 0x39, 0x10, 0x42, 0x08, 0xC1,
  0x02, 0x08, 0x4E, 0x00, 0x0C, 0x21, 0x8A, 0x29, 0x25, 0x24, 0xF8, 0x41,
  0x00, 0x3C, 0x84, 0x10, 0x60, 0x40, 0x82, 0x08, 0x4E, 0x00, 0x1C, 0x82,
  0x10, 0x71, 0x28, 0xA2, 0x8A, 0x47, 0x00, 0xF8, 0x44, 0x22, 0x10, 0x88,
  0x44, 0x20, 0x38, 0x94, 0x52, 0x28, 0xC5, 0x22, 0x8A, 0x2F, 0x00, 0x39,
  0x52, 0x94, 0xA5, 0xE1, 0x10, 0xB8, 0x60, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x24, 0x48, 0x08, 0x99, 0x04, 0x18, 0x20, 0xF8, 0x01, 0xF0, 0x86, 0x0C,
  0x13, 0x22, 0x00, 0x70, 0x42, 0x21, 0x11, 0x08, 0x00, 0x20, 0x0E, 0x11,
  0x21, 0x4D, 0x55, 0x55, 0xA5, 0xAA, 0xAE, 0x90, 0x80, 0x78, 0x08, 0x46,
  0x31, 0x94, 0xE9, 0x4A, 0x62, 0x38, 0x92, 0x49, 0x49, 0xC4, 0x92, 0x8A,
  0x2F, 0x00, 0x1D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0E, 0x00, 0x38,
  0x92, 0x49, 0x45, 0x14, 0x51, 0x8A, 0x6E, 0x00, 0x3C, 0x82, 0x08, 0x41,
  0xE4, 0x10, 0x82, 0x0F, 0x00, 0x3C, 0x82, 0x08, 0x41, 0xE4, 0x10, 0x82,
  0x08, 0x00, 0x1C, 0x84, 0x20, 0x82, 0x48, 0xA2, 0x8A, 0x2F, 0x00, 0x22,
  0x44, 0x89, 0x14, 0x4F, 0x91, 0x22, 0x85, 0x12, 0x20, 0x38, 0x84, 0x22,
  0x10, 0x84, 0x22, 0x38, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x44,
  0x60, 0x22, 0x48, 0xA1, 0x45, 0x0C, 0x14, 0x28, 0x91, 0x22, 0x20, 0x22,
  0x22, 0x44, 0x44, 0x88, 0xF0, 0x20, 0xC8, 0x23, 0x19, 0x46, 0x52, 0x94,
  0xA5, 0x51, 0x54, 0x99, 0x26, 0x49, 0x20, 0x21, 0x22, 0x32, 0x52, 0x52,
  0x52, 0x54, 0x4C, 0x8C, 0x8C, 0x88, 0x39, 0x14, 0x61, 0x86, 0x18, 0xA2,
  0x8A, 0x4E, 0x00, 0x38, 0x92, 0x49, 0x45, 0x27, 0x10, 0x82, 0x08, 0x00,
  0x39, 0x14, 0x61, 0x86, 0x18, 0xA2, 0x8A, 0x4E, 0x08, 0x20, 0x80, 0x38,
  0x92, 0x49, 0x45, 0xA5, 0x14, 0x92, 0x48, 0x80, 0x3D, 0x04, 0x10, 0x40,
  0x81, 0x04, 0x08, 0x4E, 0x00, 0xF9, 0x08, 0x84, 0x21, 0x08, 0x84, 0x20,
  0x22, 0x44, 0x8A, 0x24, 0x48, 0x91, 0x22, 0x89, 0x11, 0xC0, 0x86, 0x28,
  0xA2, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x00, 0x88, 0x62, 0x28, 0x8A, 0x64,
  0x99, 0x2A, 0x4A, 0xA2, 0xA8, 0xCC, 0x33, 0x08, 0x80, 0x12, 0x24, 0x50,
  0xC1, 0x82, 0x04, 0x14, 0x48, 0x92, 0x20, 0x8C, 0x65, 0x26, 0x21, 0x08,
  0x84, 0x20, 0x1E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x83, 0xE0,
  0x39, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x0C, 0x00, 0xAA, 0xAA, 0x54,
  0x1C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0xE0, 0x10, 0xC2,
  0x92, 0x46, 0x10, 0xF0, 0x90, 0x3D, 0x14, 0x92, 0x8A, 0x29, 0x9A, 0x20,
  0x82, 0x16, 0x65, 0x14, 0x52, 0x8A, 0x2F, 0x00, 0x3A, 0x10, 0x88, 0x42,
  0x0C, 0x02, 0x08, 0x11, 0xE4, 0x49, 0x12, 0x44, 0x89, 0x31, 0xA0, 0x3A,
  0x52, 0xE8, 0x42, 0x0E, 0x0E, 0x10, 0x20, 0xE1, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x08, 0x20, 0x00, 0x3D, 0x14, 0x92, 0x8A, 0x29, 0x9C,
  0x10, 0x4A, 0x10, 0x21, 0x08, 0x74, 0xA5, 0x29, 0x8C, 0xA4, 0x20, 0x14,
  0x92, 0x92, 0x00, 0x08, 0x00, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x22,
  0x00, 0x20, 0x82, 0x0B, 0x49, 0x46, 0x18, 0x92, 0x49, 0x00, 0x24, 0x94,
  0x92, 0x92, 0x00, 0x5F, 0x69, 0x49, 0x49, 0x49, 0x89, 0x92, 0x92, 0x5B,
  0x52, 0x94, 0xC6, 0x52, 0x3A, 0x52, 0x98, 0xC6, 0x4E, 0x2C, 0x64, 0x89,
  0x12, 0x48, 0x91, 0x3C, 0x40, 0x82, 0x00, 0x3D, 0x14, 0x92, 0x8A, 0x29,
  0x9C, 0x10, 0x41, 0x04, 0x5B, 0x10, 0x84, 0x42, 0x10, 0x7A, 0x10, 0x82,
  0x08, 0x5C, 0x22, 0x74, 0x44, 0x48, 0x8C, 0x45, 0x24, 0x92, 0x4A, 0x29,
  0x1C, 0x99, 0xAA, 0xCC, 0x88, 0x93, 0x26, 0xD5, 0xAD, 0x5B, 0x26, 0x48,
  0x24, 0xA1, 0x84, 0x10, 0xC5, 0x32, 0x13, 0x12, 0x12, 0x14, 0x14, 0x18,
  0x18, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x38, 0x44, 0x22, 0x11, 0x1E, 0x0C,
  0x41, 0x04, 0x20, 0x8C, 0x10, 0x21, 0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10,
  0x42, 0x11, 0x08, 0x22, 0x21, 0x08, 0x4C, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 6, 11, 6, 0, -11 },
  { 17, 6, 12, 5, 0, -11 },
  { 26, 7, 11, 8, 1, -11 },
  { 36, 5, 11, 6, 0, -11 },
  { 43, 2, 4, 2, 1, -11 },
  { 44, 5, 13, 4, 0, -11 },
  { 53, 4, 13, 4, -1, -11 },
  { 60, 4, 4, 5, 2, -11 },
  { 62, 5, 7, 6, 1, -9 },
  { 67, 3, 4, 3, -1, -2 },
  { 69, 4, 1, 4, 0, -5 },
  { 70, 1, 1, 3, 0, -1 },
  { 71, 7, 11, 5, -1, -11 },
  { 81, 5, 11, 6, 0, -11 },
  { 88, 3, 11, 6, 2, -11 },
  { 93, 7, 11, 6, -1, -11 },
  { 103, 6, 11, 6, 0, -11 },
  { 112, 6, 11, 6, 0, -11 },
  { 121, 6, 11, 6, 0, -11 },
  { 130, 6, 11, 6, 0, -11 },
  { 139, 5, 11, 6, 1, -11 },
  { 146, 6, 11, 6, 0, -11 },
  { 155, 5, 11, 6, 0, -11 },
  { 162, 3, 8, 3, 0, -8 },
  { 165, 4, 10, 3, -1, -8 },
  { 170, 5, 7, 6, 1, -9 },
  { 175, 5, 4, 6, 1, -7 },
  { 178, 5, 7, 6, 1, -9 },
  { 183, 5, 11, 4, 0, -11 },
  { 190, 8, 12, 8, 0, -11 },
  { 202, 5, 11, 5, -1, -11 },
  { 209, 6, 11, 6, 0, -11 },
  { 218, 6, 11, 5, 1, -11 },
  { 227, 6, 11, 7, 0, -11 },
  { 236, 6, 11, 5, 0, -11 },
  { 245, 6, 11, 5, 0, -11 },
  { 254, 6, 11, 7, 1, -11 },
  { 263, 7, 11, 7, 0, -11 },
  { 273, 5, 11, 3, -1, -11 },
  { 280, 5, 14, 3, -2, -11 },
  { 289, 7, 11, 6, 0, -11 },
  { 299, 4, 11, 5, 0, -11 },
  { 305, 10, 11, 9, 0, -11 },
  { 319, 8, 11, 7, 0, -11 },
  { 330, 6, 11, 7, 1, -11 },
  { 339, 6, 11, 6, 0, -11 },
  { 348, 6, 14, 7, 1, -11 },
  { 359, 6, 11, 6, 0, -11 },
  { 368, 6, 11, 5, 0, -11 },
  { 377, 5, 11, 5, 1, -11 },
  { 384, 7, 11, 7, 0, -11 },
  { 394, 6, 11, 6, 1, -11 },
  { 403, 10, 11, 9, 1, -11 },
  { 417, 7, 11, 5, -1, -11 },
  { 427, 5, 11, 5, 1, -11 },
  { 434, 7, 11, 5, -1, -11 },
  { 444, 5, 13, 4, 0, -11 },
  { 453, 2, 11, 5, 2, -11 },
  { 456, 6, 13, 4, -1, -11 },
  { 466, 6, 6, 6, 0, -11 },
  { 471, 4, 1, 4, -1, 1 },
  { 472, 2, 2, 3, 2, -11 },
  { 473, 6, 8, 6, 0, -8 },
  { 479, 6, 11, 6, 0, -11 },
  { 488, 5, 8, 4, 0, -8 },
  { 493, 7, 11, 6, 0, -11 },
  { 503, 5, 8, 5, 0, -8 },
  { 508, 7, 15, 3, -2, -11 },
  { 522, 6, 12, 6, 0, -8 },
  { 531, 5, 11, 6, 0, -11 },
  { 538, 3, 11, 3, 0, -11 },
  { 543, 5, 15, 3, -2, -11 },
  { 553, 6, 11, 5, 0, -11 },
  { 562, 3, 11, 3, 0, -11 },
  { 567, 8, 8, 9, 0, -8 },
  { 575, 5, 8, 6, 0, -8 },
  { 580, 5, 8, 6, 0, -8 },
  { 585, 7, 11, 6, -1, -8 },
  { 595, 6, 12, 6, 0, -8 },
  { 604, 5, 8, 4, 0, -8 },
  { 609, 5, 8, 4, 0, -8 },
  { 614, 4, 10, 3, 0, -10 },
  { 619, 6, 8, 6, 0, -8 },
  { 625, 4, 8, 5, 1, -8 },
  { 629, 7, 8, 8, 1, -8 },
  { 636, 6, 8, 5, -1, -8 },
  { 642, 8, 12, 5, -2, -8 },
  { 654, 5, 8, 4, -1, -8 },
  { 659, 6, 13, 5, 0, -11 },
  { 669, 1, 15, 5, 2, -11 },
  { 671, 5, 13, 5, -1, -11 },
  { 680, 5, 1, 6, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC15PT7B_H_
