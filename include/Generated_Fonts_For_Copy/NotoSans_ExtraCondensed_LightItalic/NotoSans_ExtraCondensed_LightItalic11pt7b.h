#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x25, 0x04, 0xB7, 0x00, 0x29, 0x9E, 0xA6, 0x7A, 0x98, 0x36,
  0x64, 0x25, 0x6C, 0x40, 0xD6, 0xB9, 0xFE, 0xB6, 0xB6, 0x25, 0x66, 0x5B,
  0xAE, 0xE0, 0x25, 0x29, 0x24, 0x88, 0x24, 0x92, 0x49, 0x50, 0xCE, 0x80,
  0x22, 0xF2, 0x20, 0xC0, 0xE0, 0x80, 0x08, 0x44, 0x22, 0x11, 0x18, 0x35,
  0x59, 0x99, 0xAE, 0x79, 0x24, 0xA4, 0x71, 0x11, 0x24, 0x8E, 0x71, 0x16,
  0x21, 0x2E, 0x11, 0x35, 0xAF, 0x22, 0x34, 0x46, 0x11, 0x2E, 0x34, 0x4E,
  0x99, 0x9E, 0x71, 0x12, 0x24, 0x48, 0x35, 0x56, 0x69, 0x9E, 0x35, 0x99,
  0x71, 0x2C, 0x40, 0x20, 0x20, 0x00, 0xB0, 0x34, 0xC3, 0xF0, 0xF0, 0xC3,
  0x3C, 0x64, 0x95, 0x04, 0x39, 0x15, 0xEB, 0xB7, 0x5A, 0xA0, 0x60, 0x11,
  0x33, 0x35, 0x59, 0x35, 0x57, 0x59, 0x9E, 0x3A, 0x11, 0x08, 0x42, 0x0C,
  0x32, 0x52, 0x94, 0xCA, 0x5C, 0x34, 0x46, 0x48, 0x8E, 0x34, 0x44, 0x68,
  0x88, 0x3A, 0x11, 0x09, 0xC6, 0x4E, 0x4A, 0x52, 0xF4, 0xCA, 0x52, 0x32,
  0x22, 0x24, 0x4E, 0x11, 0x11, 0x12, 0x22, 0x2C, 0x4A, 0x98, 0xC6, 0x52,
  0x94, 0x49, 0x25, 0x27, 0x22, 0xCD, 0x93, 0x66, 0xD6, 0xAD, 0x52, 0x25,
  0xA6, 0x9A, 0x6A, 0x49, 0x24, 0x3A, 0x53, 0x18, 0xC6, 0x4C, 0x35, 0x55,
  0x68, 0x88, 0x3A, 0x53, 0x18, 0xC6, 0x4C, 0x21, 0x00, 0x35, 0x55, 0x6A,
  0xAA, 0x34, 0x44, 0x22, 0x2E, 0xE9, 0x49, 0x24, 0x4A, 0x52, 0x99, 0x4A,
  0x4C, 0x99, 0xAA, 0xCC, 0x88, 0x93, 0x2A, 0xD5, 0xAD, 0x93, 0x24, 0x48,
  0x29, 0x4C, 0x22, 0x19, 0x52, 0xB7, 0x69, 0x24, 0x71, 0x22, 0x44, 0x8E,
  0x34, 0x44, 0x48, 0x88, 0x8C, 0xAA, 0x95, 0x31, 0x11, 0x12, 0x22, 0x2C,
  0x25, 0x59, 0xE0, 0x80, 0x35, 0x99, 0x9E, 0x44, 0x75, 0x59, 0x9E, 0x34,
  0x88, 0x8E, 0x08, 0x4C, 0xA9, 0x4A, 0x5C, 0x35, 0xAC, 0x8E, 0x19, 0x0C,
  0x42, 0x21, 0x08, 0x42, 0x20, 0x35, 0x99, 0x9E, 0x22, 0xC0, 0x44, 0x75,
  0x59, 0xAA, 0x45, 0x6A, 0x20, 0x92, 0x92, 0x52, 0x00, 0x44, 0x56, 0x4A,
  0xAA, 0x55, 0x6A, 0x7D, 0x55, 0x65, 0xA6, 0xA0, 0x75, 0x59, 0xAA, 0x35,
  0x99, 0x9E, 0x75, 0x59, 0x9E, 0x88, 0x80, 0x35, 0x99, 0x9E, 0x22, 0x20,
  0x69, 0x49, 0x00, 0x71, 0x23, 0x80, 0x4D, 0x29, 0x30, 0x55, 0x59, 0xAE,
  0xB7, 0x49, 0x00, 0xAD, 0x7D, 0x6A, 0x50, 0x56, 0x44, 0xAA, 0x29, 0x4C,
  0x62, 0x11, 0x08, 0x80, 0x65, 0x29, 0x80, 0x12, 0x22, 0xC4, 0x44, 0x44,
  0xFF, 0xE0, 0x21, 0x11, 0x12, 0x22, 0x4C, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 2, 0, -8 },
  { 4, 3, 3, 3, 1, -8 },
  { 6, 5, 8, 4, 0, -8 },
  { 11, 4, 9, 4, 0, -8 },
  { 16, 5, 8, 6, 1, -8 },
  { 21, 4, 8, 4, 0, -8 },
  { 25, 1, 3, 2, 1, -8 },
  { 26, 3, 10, 3, 0, -8 },
  { 30, 3, 10, 3, -1, -8 },
  { 34, 3, 3, 4, 1, -8 },
  { 36, 4, 5, 5, 0, -6 },
  { 39, 1, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 0, -1 },
  { 42, 5, 8, 3, -1, -8 },
  { 47, 4, 8, 4, 0, -8 },
  { 51, 3, 8, 4, 1, -8 },
  { 54, 4, 8, 4, 0, -8 },
  { 58, 4, 8, 4, 0, -8 },
  { 62, 4, 8, 4, 0, -8 },
  { 66, 4, 8, 4, 0, -8 },
  { 70, 4, 8, 4, 0, -8 },
  { 74, 4, 8, 4, 0, -8 },
  { 78, 4, 8, 4, 0, -8 },
  { 82, 4, 8, 4, 0, -8 },
  { 86, 2, 6, 2, 0, -6 },
  { 88, 3, 7, 2, -1, -6 },
  { 91, 4, 4, 5, 0, -6 },
  { 93, 4, 3, 5, 0, -5 },
  { 95, 4, 4, 5, 0, -6 },
  { 97, 3, 8, 3, 0, -8 },
  { 100, 6, 9, 6, 0, -8 },
  { 107, 4, 8, 4, -1, -8 },
  { 111, 4, 8, 4, 0, -8 },
  { 115, 5, 8, 4, 0, -8 },
  { 120, 5, 8, 5, 0, -8 },
  { 125, 4, 8, 4, 0, -8 },
  { 129, 4, 8, 4, 0, -8 },
  { 133, 5, 8, 5, 0, -8 },
  { 138, 5, 8, 5, 0, -8 },
  { 143, 4, 8, 2, -1, -8 },
  { 147, 4, 10, 2, -2, -8 },
  { 152, 5, 8, 4, 0, -8 },
  { 157, 3, 8, 4, 0, -8 },
  { 160, 7, 8, 7, 0, -8 },
  { 167, 6, 8, 5, 0, -8 },
  { 173, 5, 8, 5, 0, -8 },
  { 178, 4, 8, 4, 0, -8 },
  { 182, 5, 10, 5, 0, -8 },
  { 189, 4, 8, 4, 0, -8 },
  { 193, 4, 8, 4, 0, -8 },
  { 197, 3, 8, 4, 1, -8 },
  { 200, 5, 8, 5, 0, -8 },
  { 205, 4, 8, 4, 1, -8 },
  { 209, 7, 8, 7, 1, -8 },
  { 216, 5, 8, 4, -1, -8 },
  { 221, 3, 8, 4, 1, -8 },
  { 224, 4, 8, 4, 0, -8 },
  { 228, 4, 10, 3, 0, -8 },
  { 233, 2, 8, 4, 1, -8 },
  { 235, 4, 10, 3, -1, -8 },
  { 240, 4, 4, 4, 0, -8 },
  { 242, 3, 1, 3, -1, 1 },
  { 243, 1, 1, 3, 2, -8 },
  { 244, 4, 6, 4, 0, -6 },
  { 247, 4, 8, 4, 0, -8 },
  { 251, 4, 6, 3, 0, -6 },
  { 254, 5, 8, 4, 0, -8 },
  { 259, 4, 6, 4, 0, -6 },
  { 262, 5, 11, 2, -1, -8 },
  { 269, 4, 9, 4, 0, -6 },
  { 274, 4, 8, 4, 0, -8 },
  { 278, 2, 8, 2, 0, -8 },
  { 280, 3, 11, 2, -1, -8 },
  { 285, 4, 8, 4, 0, -8 },
  { 289, 2, 8, 2, 0, -8 },
  { 291, 6, 6, 6, 0, -6 },
  { 296, 4, 6, 4, 0, -6 },
  { 299, 4, 6, 4, 0, -6 },
  { 302, 4, 9, 4, 0, -6 },
  { 307, 4, 9, 4, 0, -6 },
  { 312, 3, 6, 3, 0, -6 },
  { 315, 3, 6, 3, 0, -6 },
  { 318, 3, 7, 2, 0, -7 },
  { 321, 4, 6, 4, 0, -6 },
  { 324, 3, 6, 3, 1, -6 },
  { 327, 5, 6, 6, 1, -6 },
  { 331, 4, 6, 3, 0, -6 },
  { 334, 5, 9, 3, -1, -6 },
  { 340, 3, 6, 3, 0, -6 },
  { 343, 4, 10, 4, 0, -8 },
  { 348, 1, 11, 4, 1, -8 },
  { 350, 4, 10, 4, -1, -8 },
  { 355, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC11PT7B_H_
