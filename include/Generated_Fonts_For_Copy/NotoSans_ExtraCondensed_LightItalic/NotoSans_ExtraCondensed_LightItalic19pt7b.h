#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x44, 0x40, 0x4C, 0x55, 0x99, 0xA0, 0x09,
  0x09, 0x0A, 0x12, 0x7F, 0x14, 0x24, 0x24, 0x28, 0xFE, 0x48, 0x50, 0x90,
  0x90, 0x04, 0x3C, 0xA9, 0x42, 0x85, 0x0C, 0x0C, 0x1C, 0x28, 0x91, 0x6F,
  0x84, 0x08, 0x00, 0x31, 0x28, 0x94, 0x92, 0x49, 0x44, 0xA2, 0x6F, 0x55,
  0x54, 0x8A, 0x49, 0x24, 0xA4, 0x52, 0x30, 0x0C, 0x28, 0x91, 0x22, 0x45,
  0x04, 0x18, 0x53, 0x1A, 0x34, 0x48, 0x9E, 0x80, 0x5A, 0x80, 0x04, 0x21,
  0x04, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x10,
  0x82, 0x10, 0x84, 0x21, 0x08, 0x44, 0x21, 0x11, 0x08, 0x80, 0x37, 0x0E,
  0xA9, 0x00, 0x10, 0x41, 0x04, 0xFC, 0x41, 0x04, 0x10, 0x2D, 0x60, 0xF8,
  0x70, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x0C, 0x24, 0x89, 0x12, 0x28, 0x50, 0xA2, 0x45, 0x0A,
  0x14, 0x44, 0x8E, 0x00, 0x13, 0x5A, 0x22, 0x22, 0x44, 0x44, 0x88, 0x0E,
  0x13, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40,
  0xFC, 0x1C, 0x44, 0x08, 0x10, 0x20, 0x8E, 0x0C, 0x04, 0x08, 0x10, 0x40,
  0x9E, 0x00, 0x02, 0x0C, 0x28, 0x61, 0x42, 0x89, 0x22, 0x49, 0x13, 0xF0,
  0x41, 0x02, 0x00, 0x1E, 0x40, 0x81, 0x02, 0x08, 0x1E, 0x02, 0x04, 0x08,
  0x10, 0x60, 0x9E, 0x00, 0x06, 0x30, 0x41, 0x02, 0x08, 0x1F, 0x22, 0x44,
  0x8A, 0x14, 0x24, 0x8E, 0x00, 0x7E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x10, 0x00, 0x0C, 0x64, 0x89, 0x12, 0x24, 0x86,
  0x14, 0x49, 0x0A, 0x14, 0x28, 0x8F, 0x00, 0x0C, 0x6C, 0x8A, 0x14, 0x28,
  0x51, 0xA6, 0x34, 0x08, 0x10, 0x41, 0x1C, 0x00, 0x24, 0x00, 0x00, 0x90,
  0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x04, 0x33, 0x30, 0x81, 0x81, 0x81,
  0xFC, 0x00, 0x00, 0xFC, 0x83, 0x03, 0x03, 0x04, 0x66, 0x20, 0x38, 0xB0,
  0x41, 0x08, 0x21, 0x08, 0x41, 0x04, 0x00, 0x43, 0x00, 0x07, 0x02, 0x21,
  0x04, 0x81, 0x27, 0x52, 0x54, 0xA5, 0x49, 0x52, 0x64, 0xA9, 0x6A, 0x6C,
  0x80, 0x10, 0x04, 0x40, 0xE0, 0x06, 0x0C, 0x28, 0x50, 0xA2, 0x44, 0x91,
  0x3E, 0x45, 0x0A, 0x18, 0x30, 0x40, 0x1C, 0x12, 0x21, 0x21, 0x23, 0x22,
  0x3C, 0x44, 0x42, 0x42, 0x42, 0x44, 0x8C, 0xF8, 0x0E, 0x24, 0x82, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0E, 0x00, 0x18, 0x16, 0x21,
  0x21, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x44, 0x88, 0xF0, 0x1F,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0xF8, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x7C, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x0E, 0x11, 0x20, 0x40, 0x40, 0x80, 0x80, 0x8E, 0x82,
  0x82, 0x84, 0x84, 0x84, 0x7C, 0x10, 0x88, 0x48, 0x24, 0x22, 0x11, 0x08,
  0xFC, 0x82, 0x42, 0x21, 0x10, 0x88, 0x48, 0x24, 0x20, 0x1C, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x23, 0xC0, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xE0, 0x11,
  0x88, 0x88, 0x84, 0x82, 0x41, 0x40, 0xC0, 0xE0, 0x48, 0x24, 0x12, 0x09,
  0x08, 0xC4, 0x20, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x7C,
  0x10, 0x11, 0x03, 0x30, 0x32, 0x86, 0x28, 0x62, 0x8A, 0x28, 0xA4, 0x92,
  0x49, 0x44, 0xA4, 0x4A, 0x44, 0xC4, 0x8C, 0x88, 0x88, 0x10, 0x44, 0x22,
  0x88, 0xA2, 0x28, 0x8A, 0x22, 0x91, 0x24, 0x45, 0x11, 0x44, 0x61, 0x18,
  0x86, 0x21, 0x80, 0x0C, 0x32, 0x22, 0x41, 0x41, 0x83, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x88, 0x70, 0x18, 0x2C, 0x89, 0x12, 0x24, 0x49, 0xBE,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x00, 0x0C, 0x32, 0x22, 0x41, 0x41, 0x83,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x10, 0x10, 0x18, 0x18,
  0x2C, 0x89, 0x12, 0x24, 0x49, 0xBE, 0x48, 0x91, 0x22, 0x48, 0x90, 0x80,
  0x07, 0x19, 0x10, 0x30, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x06,
  0x04, 0xF8, 0x7E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x00, 0x21, 0x21, 0x43, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84,
  0x84, 0x84, 0x88, 0x88, 0xF0, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x48,
  0xA1, 0x43, 0x06, 0x0C, 0x10, 0x00, 0x42, 0x14, 0x21, 0x46, 0x24, 0x62,
  0x4A, 0x24, 0xA4, 0x8A, 0x49, 0x28, 0x92, 0x8A, 0x28, 0xA3, 0x0A, 0x30,
  0xC3, 0x0C, 0x20, 0x10, 0x88, 0x84, 0x41, 0x40, 0xA0, 0x60, 0x20, 0x10,
  0x18, 0x14, 0x09, 0x08, 0x84, 0x44, 0x20, 0x42, 0x89, 0x12, 0x44, 0x8A,
  0x14, 0x30, 0x60, 0x81, 0x02, 0x04, 0x10, 0x00, 0x1F, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x40, 0xFC, 0x1E, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0xE0, 0x92, 0x48, 0x92, 0x49, 0x22, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0xE0, 0x08, 0x10,
  0x51, 0x22, 0x48, 0x70, 0x80, 0xFC, 0xA4, 0x3E, 0x89, 0x14, 0x28, 0x51,
  0x22, 0x44, 0x99, 0xD0, 0x10, 0x20, 0x81, 0x03, 0xE4, 0x48, 0xA1, 0x42,
  0x85, 0x12, 0x2C, 0xD7, 0x00, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x87, 0x00,
  0x02, 0x04, 0x08, 0x13, 0xC8, 0xB1, 0x42, 0x85, 0x12, 0x24, 0x49, 0x9D,
  0x00, 0x1C, 0x94, 0x51, 0x79, 0x08, 0x20, 0x41, 0xE0, 0x01, 0x07, 0x04,
  0x04, 0x08, 0x1E, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x80, 0x1F, 0x22, 0x22, 0x42, 0x42, 0x44, 0x44,
  0x44, 0x4C, 0x78, 0x08, 0x08, 0x08, 0x90, 0x60, 0x10, 0x20, 0x81, 0x03,
  0xE4, 0x48, 0xA2, 0x44, 0x89, 0x12, 0x28, 0x91, 0x00, 0x11, 0x00, 0x22,
  0x24, 0x44, 0x44, 0x88, 0x04, 0x10, 0x00, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x21, 0x08, 0x00, 0x10, 0x20, 0x81, 0x02, 0x64,
  0x8A, 0x28, 0x70, 0xE1, 0x42, 0x48, 0x91, 0x00, 0x11, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x88, 0x3D, 0xC8, 0x92, 0x25, 0x11, 0x44, 0x51, 0x14, 0x45,
  0x22, 0x88, 0xA2, 0x20, 0x3E, 0x44, 0x8A, 0x24, 0x48, 0x91, 0x22, 0x89,
  0x10, 0x39, 0x18, 0x61, 0x86, 0x28, 0xA2, 0x93, 0x80, 0x1F, 0x11, 0x11,
  0x21, 0x21, 0x21, 0x22, 0x22, 0x66, 0x5C, 0x40, 0x40, 0x40, 0x80, 0x3E,
  0x89, 0x14, 0x28, 0x51, 0x22, 0x44, 0x99, 0xE0, 0x40, 0x81, 0x06, 0x00,
  0x3C, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x3D, 0x04, 0x10, 0x20,
  0x41, 0x04, 0x13, 0xC0, 0x32, 0x72, 0x24, 0x44, 0x44, 0x86, 0x22, 0x44,
  0x8A, 0x24, 0x48, 0x91, 0x26, 0xC8, 0xF0, 0x8E, 0x28, 0xA4, 0x92, 0x8A,
  0x30, 0xC3, 0x00, 0x88, 0xC4, 0x66, 0x53, 0x2A, 0x95, 0x52, 0xA9, 0x98,
  0xCC, 0x46, 0x00, 0x33, 0x12, 0x14, 0x18, 0x18, 0x18, 0x28, 0x28, 0x48,
  0xCC, 0x10, 0x88, 0x84, 0x42, 0x41, 0x20, 0x90, 0x50, 0x28, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x03, 0x00, 0x1C, 0x10, 0x82, 0x10, 0x42, 0x18,
  0x43, 0xE0, 0x04, 0x61, 0x04, 0x20, 0x82, 0x08, 0xC1, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x60, 0xFF, 0xFF, 0xF0, 0x10, 0x30, 0x41, 0x08, 0x20, 0x82,
  0x04, 0x21, 0x04, 0x10, 0x82, 0x08, 0xC0, 0x66, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 6, 2, -14 },
  { 11, 8, 14, 8, 0, -14 },
  { 25, 7, 15, 7, 0, -14 },
  { 39, 9, 14, 11, 1, -14 },
  { 55, 7, 14, 7, 0, -14 },
  { 68, 2, 5, 3, 2, -14 },
  { 70, 6, 17, 5, 0, -14 },
  { 83, 5, 17, 5, -1, -14 },
  { 94, 5, 5, 6, 2, -14 },
  { 98, 6, 9, 8, 1, -11 },
  { 105, 3, 4, 3, -1, -2 },
  { 107, 5, 1, 5, 0, -6 },
  { 108, 2, 2, 3, 0, -2 },
  { 109, 8, 14, 6, -1, -14 },
  { 123, 7, 14, 7, 0, -14 },
  { 136, 4, 14, 7, 2, -14 },
  { 143, 8, 14, 7, -1, -14 },
  { 157, 7, 14, 7, 0, -14 },
  { 170, 7, 14, 7, 0, -14 },
  { 183, 7, 14, 7, 0, -14 },
  { 196, 7, 14, 7, 0, -14 },
  { 209, 7, 14, 7, 1, -14 },
  { 222, 7, 14, 7, 0, -14 },
  { 235, 7, 14, 7, 0, -14 },
  { 248, 3, 10, 3, 0, -10 },
  { 252, 4, 12, 3, -1, -10 },
  { 258, 6, 8, 8, 1, -11 },
  { 264, 6, 5, 8, 1, -9 },
  { 268, 6, 8, 8, 1, -11 },
  { 274, 6, 14, 5, 0, -14 },
  { 285, 10, 16, 10, 0, -14 },
  { 305, 7, 14, 7, -1, -14 },
  { 318, 8, 14, 8, 0, -14 },
  { 332, 7, 14, 7, 1, -14 },
  { 345, 8, 14, 8, 0, -14 },
  { 359, 8, 14, 7, 0, -14 },
  { 373, 8, 14, 6, 0, -14 },
  { 387, 8, 14, 9, 1, -14 },
  { 401, 9, 14, 9, 0, -14 },
  { 417, 6, 14, 4, -1, -14 },
  { 428, 7, 17, 3, -3, -14 },
  { 443, 9, 14, 7, 0, -14 },
  { 459, 5, 14, 6, 0, -14 },
  { 468, 12, 14, 12, 0, -14 },
  { 489, 10, 14, 9, 0, -14 },
  { 507, 8, 14, 9, 1, -14 },
  { 521, 7, 14, 7, 0, -14 },
  { 534, 8, 17, 9, 1, -14 },
  { 551, 7, 14, 7, 0, -14 },
  { 564, 8, 14, 7, -1, -14 },
  { 578, 7, 14, 6, 1, -14 },
  { 591, 8, 14, 9, 1, -14 },
  { 605, 7, 14, 7, 2, -14 },
  { 618, 12, 14, 12, 1, -14 },
  { 639, 9, 14, 6, -1, -14 },
  { 655, 7, 14, 6, 1, -14 },
  { 668, 8, 14, 6, -1, -14 },
  { 682, 7, 17, 5, 0, -14 },
  { 697, 3, 14, 6, 2, -14 },
  { 703, 7, 17, 5, -1, -14 },
  { 718, 7, 7, 8, 0, -14 },
  { 725, 6, 1, 5, -2, 2 },
  { 726, 2, 3, 4, 3, -15 },
  { 727, 7, 10, 8, 1, -10 },
  { 736, 7, 14, 8, 0, -14 },
  { 749, 5, 10, 6, 1, -10 },
  { 756, 7, 14, 8, 1, -14 },
  { 769, 6, 10, 7, 0, -10 },
  { 777, 8, 20, 4, -2, -15 },
  { 797, 8, 15, 8, 0, -10 },
  { 812, 7, 14, 7, 0, -14 },
  { 825, 4, 14, 3, 0, -14 },
  { 832, 6, 19, 3, -2, -14 },
  { 847, 7, 14, 6, 0, -14 },
  { 860, 4, 14, 3, 0, -14 },
  { 867, 10, 10, 11, 0, -10 },
  { 880, 7, 10, 7, 0, -10 },
  { 889, 6, 10, 7, 1, -10 },
  { 897, 8, 14, 8, -1, -10 },
  { 911, 7, 14, 8, 1, -10 },
  { 924, 6, 10, 5, 0, -10 },
  { 932, 6, 10, 6, 0, -10 },
  { 940, 4, 12, 4, 0, -12 },
  { 946, 7, 10, 7, 0, -10 },
  { 955, 6, 10, 6, 1, -10 },
  { 963, 9, 10, 10, 1, -10 },
  { 975, 8, 10, 6, -1, -10 },
  { 985, 9, 15, 6, -2, -10 },
  { 1002, 6, 10, 5, -1, -10 },
  { 1010, 6, 17, 6, 1, -14 },
  { 1023, 1, 20, 7, 3, -15 },
  { 1026, 6, 17, 6, -1, -14 },
  { 1039, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC19PT7B_H_
