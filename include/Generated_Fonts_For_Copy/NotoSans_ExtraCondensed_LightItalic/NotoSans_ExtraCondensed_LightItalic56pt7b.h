#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3,
  0x87, 0x0C, 0x1C, 0x70, 0x71, 0xC1, 0x87, 0x06, 0x18, 0x38, 0x60, 0xE3,
  0x83, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC1, 0xC0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x38, 0x30, 0x00, 0x60, 0x60,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x06,
  0x06, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x60, 0x60, 0x00, 0xC0,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xC6, 0x18, 0x0E, 0x18,
  0x00, 0x70, 0x40, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x82, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x39,
  0x80, 0x00, 0xF4, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xBC, 0x00, 0x06, 0x70, 0x00,
  0x19, 0xE0, 0x00, 0x63, 0x80, 0x01, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x08, 0x38, 0x00, 0x61, 0xC0,
  0x81, 0x8F, 0x03, 0x86, 0x78, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x1F,
  0xC0, 0x1C, 0x07, 0x18, 0x03, 0x01, 0xC3, 0x00, 0xE0, 0x30, 0x70, 0x18,
  0x0E, 0x0E, 0x07, 0x01, 0x81, 0xC0, 0xC0, 0x70, 0x38, 0x38, 0x0E, 0x06,
  0x06, 0x01, 0x80, 0xC1, 0xC0, 0x30, 0x18, 0x30, 0x0E, 0x07, 0x0E, 0x01,
  0xC0, 0xE1, 0x80, 0x38, 0x1C, 0x70, 0x06, 0x03, 0x0C, 0x00, 0xC0, 0xE3,
  0x80, 0x18, 0x1C, 0x61, 0xF3, 0x03, 0x1C, 0x7F, 0x60, 0xE3, 0x1C, 0x6C,
  0x1C, 0xE7, 0x0D, 0x87, 0x18, 0xC1, 0xF8, 0xC7, 0x38, 0x3F, 0xF8, 0xC6,
  0x07, 0x7E, 0x39, 0xC0, 0xC2, 0x06, 0x38, 0x18, 0x01, 0xC6, 0x03, 0x00,
  0x70, 0xC0, 0x60, 0x0E, 0x38, 0x1C, 0x03, 0x87, 0x03, 0x80, 0x70, 0xE0,
  0x70, 0x1C, 0x18, 0x0C, 0x03, 0x83, 0x03, 0x80, 0xE0, 0x60, 0x70, 0x1C,
  0x0C, 0x0C, 0x07, 0x01, 0x83, 0x80, 0xE0, 0x30, 0x60, 0x38, 0x06, 0x1C,
  0x07, 0x00, 0xE3, 0x01, 0xC0, 0x1F, 0xE0, 0x38, 0x01, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x71,
  0xC0, 0x07, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x1E, 0xE0, 0x00, 0xE7, 0x07, 0x0E, 0x1C, 0x38, 0xE0, 0xE1, 0x8F, 0x07,
  0x1C, 0x70, 0x38, 0xE3, 0x80, 0xE6, 0x38, 0x07, 0x71, 0xC0, 0x3B, 0x8E,
  0x00, 0xF8, 0x70, 0x07, 0xC3, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xE0, 0x1F,
  0x07, 0x00, 0xF8, 0x38, 0x0F, 0xC1, 0xF1, 0xE7, 0x07, 0xFE, 0x38, 0x1F,
  0xE1, 0xE0, 0x30, 0x00, 0x00, 0x39, 0xCE, 0xE7, 0x39, 0xCC, 0x67, 0x39,
  0x8C, 0x60, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x04, 0x1C, 0x0C, 0x30, 0x3E, 0x60, 0x9F, 0xDF, 0x0F, 0xFE, 0x07,
  0x80, 0x1E, 0x00, 0x76, 0x01, 0xCE, 0x0F, 0x0C, 0x1C, 0x1C, 0x10, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x78, 0xF0, 0x1E, 0x0E, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x1C, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x0C, 0x38, 0x01, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1E, 0x07, 0x03,
  0x80, 0xE0, 0xE0, 0x1E, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x80,
  0x00, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0E, 0xE1, 0xCE, 0x78, 0xCF,
  0x1C, 0x61, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xC3,
  0xC0, 0x06, 0x03, 0xC0, 0x08, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7C, 0x3E, 0x01, 0xC0,
  0x38, 0x02, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x02, 0x00, 0x78, 0x0E, 0x07, 0xC0, 0x3F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0,
  0x00, 0x33, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0xC7, 0x00, 0x07, 0x18, 0x00, 0x38, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x1C, 0x00,
  0xE0, 0x70, 0x07, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x03, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x80, 0x1E, 0x03, 0x81, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7C,
  0x20, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x7C, 0x01, 0xCF,
  0xF0, 0x0E, 0xFF, 0xC0, 0x7E, 0x0F, 0x03, 0x60, 0x38, 0x3E, 0x01, 0xC1,
  0xE0, 0x0E, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0xC0, 0xE0, 0x1C,
  0x07, 0x01, 0xE0, 0x38, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3E,
  0x1E, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xE1,
  0xE0, 0x03, 0x8F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xF8, 0x00, 0x3C, 0xF0, 0x03, 0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x03,
  0x07, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0xE0, 0x1C, 0x03, 0xE1,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0x1E, 0x01, 0xC0, 0xE0, 0x38,
  0x07, 0x03, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x1E,
  0x1C, 0x01, 0xE0, 0xE0, 0x3E, 0x0F, 0x0E, 0xE0, 0x7F, 0xCE, 0x07, 0xF9,
  0xC0, 0x1E, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x83, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x1E,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x30, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x08, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x80, 0x06, 0x00, 0x30, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0,
  0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0C, 0x03, 0xF0, 0x70, 0xE0, 0x3F, 0xC3, 0x86, 0x03, 0x8E,
  0x1C, 0x30, 0x38, 0x60, 0xE3, 0x83, 0x83, 0x07, 0x18, 0x18, 0x38, 0x38,
  0xC1, 0xC1, 0xC1, 0x8E, 0x0C, 0x0C, 0x0C, 0x60, 0xE0, 0x60, 0x63, 0x07,
  0x07, 0x03, 0x18, 0x30, 0x38, 0x39, 0xC1, 0x81, 0x81, 0x8E, 0x1C, 0x0C,
  0x0C, 0x60, 0xE0, 0xE0, 0xE3, 0x07, 0x07, 0x06, 0x18, 0x30, 0x38, 0x30,
  0xC1, 0x83, 0x83, 0x86, 0x0C, 0x1C, 0x18, 0x70, 0x61, 0xE1, 0xC3, 0x83,
  0x8F, 0x0C, 0x1C, 0x1F, 0xCF, 0xC0, 0xE0, 0x7C, 0x7C, 0x07, 0x00, 0x80,
  0x80, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x67, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x78, 0x1C,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x81, 0xC0, 0x0E, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xE0, 0xFC, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81,
  0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38,
  0x01, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x3C, 0x07, 0x00,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0xE0, 0x0F, 0x00,
  0x80, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x87, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x7C, 0x00,
  0xE0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x0F, 0x03,
  0x80, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x70,
  0x3E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x01, 0x80, 0x7C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0x0F, 0x00, 0x3F, 0xC3, 0x80, 0x10, 0x70, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80,
  0x78, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xF0, 0x3C, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x01,
  0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xE0,
  0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x01,
  0xDE, 0x00, 0x01, 0xDF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xEC, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xDC, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x1B,
  0x80, 0x01, 0xDC, 0x03, 0x98, 0x00, 0x3B, 0x80, 0x39, 0x80, 0x03, 0xB8,
  0x03, 0x98, 0x00, 0x73, 0x80, 0x39, 0x80, 0x07, 0x38, 0x07, 0x18, 0x00,
  0xE3, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0,
  0x0E, 0x1C, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x70, 0xE0, 0x0E, 0x1C, 0x06,
  0x0E, 0x00, 0xC1, 0xC0, 0xE0, 0xE0, 0x1C, 0x1C, 0x0E, 0x1C, 0x01, 0xC1,
  0xC1, 0xC1, 0xC0, 0x1C, 0x1C, 0x1C, 0x1C, 0x01, 0xC1, 0xC3, 0x81, 0xC0,
  0x38, 0x1C, 0x38, 0x1C, 0x03, 0x81, 0xC7, 0x03, 0x80, 0x38, 0x1C, 0x70,
  0x38, 0x03, 0x81, 0xCE, 0x03, 0x80, 0x38, 0x0C, 0xE0, 0x38, 0x07, 0x00,
  0xDC, 0x03, 0x00, 0x70, 0x0D, 0xC0, 0x70, 0x07, 0x00, 0xF8, 0x07, 0x00,
  0x70, 0x0F, 0x80, 0x70, 0x06, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x00, 0xF8, 0x00, 0x70, 0x0F, 0x80, 0x07, 0x00, 0xF8, 0x00, 0xE0,
  0x1F, 0x80, 0x0E, 0x01, 0xD8, 0x00, 0xE0, 0x1D, 0x80, 0x0E, 0x01, 0xDC,
  0x00, 0xE0, 0x19, 0xC0, 0x1C, 0x03, 0x9C, 0x01, 0xC0, 0x39, 0xC0, 0x1C,
  0x03, 0x8C, 0x01, 0xC0, 0x38, 0xE0, 0x38, 0x07, 0x0E, 0x03, 0x80, 0x70,
  0xE0, 0x38, 0x07, 0x0E, 0x03, 0x80, 0x70, 0xE0, 0x38, 0x07, 0x06, 0x07,
  0x00, 0xE0, 0x70, 0x70, 0x0E, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x70, 0x0E,
  0x07, 0x07, 0x00, 0xC0, 0x70, 0xE0, 0x1C, 0x03, 0x0E, 0x01, 0xC0, 0x38,
  0xE0, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x38, 0xC0, 0x38, 0x03, 0x9C, 0x03,
  0x80, 0x19, 0xC0, 0x38, 0x01, 0x9C, 0x03, 0x80, 0x1D, 0xC0, 0x38, 0x01,
  0xD8, 0x07, 0x00, 0x1F, 0x80, 0x70, 0x01, 0xF8, 0x07, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xC3, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0xF0, 0x03, 0x81, 0xC0,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x70,
  0x0F, 0x01, 0xE0, 0x0F, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x38, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07,
  0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF8, 0x0E, 0x0F,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xC3, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0xF0,
  0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x03,
  0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x78,
  0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x0F, 0x80, 0x0F, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x02, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xF0, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x78,
  0x03, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0x81, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x03,
  0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xE1, 0xE0, 0x1E, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x10, 0x03, 0xE0, 0x3E,
  0x1F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x30,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0D,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xEE, 0x00, 0x1C, 0x00, 0x1D, 0xC0, 0x03, 0x80,
  0x07, 0x38, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x1E, 0x00, 0x38, 0xE0, 0x03,
  0xC0, 0x07, 0x1C, 0x00, 0xF8, 0x00, 0xE3, 0x80, 0x1B, 0x00, 0x38, 0x70,
  0x07, 0x60, 0x07, 0x0E, 0x00, 0xEC, 0x01, 0xC1, 0xC0, 0x19, 0x80, 0x38,
  0x30, 0x07, 0x30, 0x07, 0x06, 0x00, 0xCE, 0x01, 0xC0, 0xC0, 0x39, 0xC0,
  0x38, 0x18, 0x07, 0x38, 0x0E, 0x03, 0x00, 0xC7, 0x01, 0xC0, 0xE0, 0x38,
  0xE0, 0x38, 0x1C, 0x07, 0x1C, 0x0E, 0x03, 0x81, 0xC3, 0x81, 0xC0, 0x70,
  0x38, 0x70, 0x70, 0x0E, 0x06, 0x0E, 0x0E, 0x01, 0xC1, 0xC1, 0xC1, 0xC0,
  0x38, 0x38, 0x38, 0x70, 0x07, 0x0E, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0xE3,
  0xC0, 0x1C, 0x30, 0x1C, 0x70, 0x03, 0x8E, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x73, 0x80, 0x0E, 0x70, 0x0E, 0x70, 0x01, 0xCE, 0x01, 0x8E, 0x00, 0x39,
  0x80, 0x33, 0x80, 0x07, 0x70, 0x06, 0x70, 0x00, 0xEE, 0x00, 0xDC, 0x00,
  0x1D, 0x80, 0x1B, 0x80, 0x03, 0xF0, 0x03, 0x70, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x06, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0F,
  0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0x70,
  0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00,
  0x6E, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x08, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x73, 0x00, 0x03, 0x9C, 0x00, 0x38, 0xE0,
  0x01, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE1, 0xC3, 0xC3, 0x83, 0x07, 0x06, 0x0E, 0x00, 0xFC, 0x30, 0x1F,
  0xE7, 0x03, 0xEF, 0x70, 0x78, 0x36, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x1C,
  0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x03,
  0xE0, 0xE0, 0x6E, 0x0F, 0x0E, 0xC0, 0x7F, 0xCC, 0x03, 0xF8, 0xC0, 0x04,
  0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC7, 0xE0, 0x0E, 0x7F, 0x80, 0x77, 0x3E, 0x03, 0xE0, 0x70, 0x1E,
  0x03, 0x81, 0xF0, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xF0, 0x1C, 0x0D, 0x81, 0xE0, 0x6E,
  0x1E, 0x07, 0x3F, 0xE0, 0x38, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xE6, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x60, 0x7F, 0xE0, 0x3F, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x1F, 0x8E, 0x00, 0x7F, 0x9C, 0x01, 0xF7, 0xB8, 0x07, 0x83,
  0x60, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x1E,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0x00, 0x3C, 0x06, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x0F, 0x80, 0x70, 0x37, 0x00, 0xF0, 0xCC, 0x00, 0xFF, 0x98,
  0x00, 0xFC, 0x30, 0x00, 0x20, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1E, 0x38, 0x0E, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x70,
  0x07, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x3C, 0x38, 0x1E,
  0x1C, 0x3F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x40, 0xF0, 0x60, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x04, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x86, 0x00, 0x7F, 0x9C, 0x01, 0xF7, 0xB8, 0x07, 0x83, 0x60,
  0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x07,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x03, 0x00, 0x3C, 0x06, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x0F, 0x80, 0x70, 0x37, 0x00, 0xF0, 0xEC, 0x00, 0xFF, 0xB8, 0x00,
  0xFE, 0x70, 0x00, 0x20, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x40, 0x1E, 0x00, 0xE0, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0xFC, 0x03, 0xBF, 0xE0, 0x3B, 0x9F, 0x03, 0xE0, 0x70, 0x3C,
  0x07, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x06, 0x07,
  0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xC1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x18,
  0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x30, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x06, 0x06, 0x00,
  0xE0, 0xE0, 0x0E, 0x00, 0x00, 0x40, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x4F, 0x00, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x3C, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xC0,
  0x18, 0x1E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8F,
  0x00, 0x18, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x03,
  0xBC, 0x00, 0x3B, 0xE0, 0x01, 0xFB, 0x00, 0x0F, 0x9C, 0x00, 0x78, 0xE0,
  0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x38, 0x03, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x8F, 0xC1, 0xF8, 0x07, 0x7F, 0xCF, 0xF8, 0x0D, 0xE7, 0xBC,
  0xF0, 0x1B, 0x07, 0x60, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x01,
  0xC1, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x1C,
  0x1E, 0x01, 0xC0, 0x38, 0x38, 0x03, 0x80, 0x70, 0x70, 0x07, 0x00, 0xE0,
  0xE0, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x07, 0x07, 0x00, 0x70, 0x0E, 0x0E,
  0x00, 0xE0, 0x1C, 0x1C, 0x01, 0x80, 0x38, 0x38, 0x07, 0x00, 0x60, 0x70,
  0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x07, 0x07, 0x00,
  0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x18, 0x18, 0x03, 0x80, 0x70, 0x70, 0x07,
  0x00, 0xE0, 0xE0, 0x0C, 0x01, 0xC1, 0xC0, 0x38, 0x03, 0x83, 0x80, 0x70,
  0x0E, 0x0E, 0x00, 0xE0, 0x1C, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x8F,
  0xC0, 0x3B, 0xFE, 0x03, 0x79, 0xE0, 0x36, 0x0F, 0x03, 0xC0, 0x70, 0x78,
  0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x60, 0xF0, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0C, 0x1C, 0x01, 0xC1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x38,
  0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x00, 0x70, 0x70, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3C, 0x78, 0x1C, 0x0E, 0x0E, 0x03,
  0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xC0, 0x07,
  0x30, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x38, 0xE0, 0x1C, 0x38, 0x0F, 0x0E,
  0x07, 0x81, 0xE3, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x40, 0x00, 0x00,
  0xE3, 0xF0, 0x01, 0xCF, 0xF0, 0x03, 0xB8, 0xF0, 0x06, 0xC0, 0xE0, 0x0D,
  0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81,
  0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x3C,
  0x03, 0x80, 0x7C, 0x0F, 0x00, 0xFC, 0x3C, 0x01, 0x9F, 0xF0, 0x07, 0x1F,
  0xC0, 0x0E, 0x08, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x1F, 0xE7, 0x03, 0xEF, 0x70, 0x78,
  0x36, 0x0F, 0x01, 0x60, 0xE0, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x1E, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0xF0, 0xC0, 0x0E,
  0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x03, 0xE0, 0xE0, 0x6E, 0x0F, 0x0F,
  0xC0, 0x7F, 0xDC, 0x03, 0xF9, 0xC0, 0x04, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x8F, 0x81, 0xDF, 0x80, 0xCF, 0xC0, 0x6E, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x3C, 0x3C, 0x1E, 0x02, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x08, 0x03, 0x83, 0x83, 0xE0, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x00, 0xFF, 0x3F, 0xF3, 0xFF, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF1, 0x0F, 0xE0, 0x7E,
  0x00, 0x80, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01,
  0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0x80,
  0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x03, 0xE0, 0x70, 0x3E, 0x07, 0x8E, 0xC0,
  0x7F, 0xCC, 0x03, 0xF8, 0xC0, 0x04, 0x00, 0x00, 0xE0, 0x03, 0xF0, 0x03,
  0xB8, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x06, 0x07,
  0x07, 0x03, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0,
  0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x07, 0x00, 0x7E, 0x00, 0xF0, 0x0E, 0xE0, 0x0F, 0x00, 0xEE, 0x01,
  0xF0, 0x0C, 0xE0, 0x1F, 0x01, 0xCE, 0x01, 0xF0, 0x1C, 0xE0, 0x3F, 0x03,
  0x8E, 0x03, 0x70, 0x38, 0xE0, 0x77, 0x03, 0x0E, 0x07, 0x70, 0x70, 0xE0,
  0x67, 0x07, 0x0E, 0x0E, 0x70, 0xE0, 0xE0, 0xC7, 0x0E, 0x0E, 0x1C, 0x70,
  0xC0, 0xE1, 0xC7, 0x1C, 0x0E, 0x18, 0x71, 0xC0, 0xE3, 0x87, 0x18, 0x0E,
  0x30, 0x63, 0x80, 0xE7, 0x06, 0x30, 0x0E, 0x70, 0x67, 0x00, 0xE6, 0x06,
  0x70, 0x0E, 0xE0, 0x66, 0x00, 0xEC, 0x06, 0xE0, 0x0F, 0xC0, 0x6C, 0x00,
  0xFC, 0x06, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x07,
  0x07, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9C,
  0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xE6, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x8F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x17, 0xFC, 0x01, 0xFF,
  0xE0, 0x3E, 0x0F, 0xFF, 0x80, 0x3F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 40, 12, 1, -40 },
  { 61, 14, 14, 17, 5, -40 },
  { 86, 23, 40, 22, 0, -40 },
  { 201, 22, 46, 21, 0, -43 },
  { 328, 27, 42, 32, 3, -41 },
  { 470, 21, 42, 21, -1, -41 },
  { 581, 5, 14, 9, 6, -40 },
  { 590, 16, 49, 14, 1, -40 },
  { 688, 16, 49, 14, -4, -40 },
  { 786, 15, 17, 19, 6, -43 },
  { 818, 20, 26, 23, 2, -33 },
  { 883, 8, 13, 10, -2, -6 },
  { 896, 12, 3, 15, 1, -17 },
  { 901, 4, 5, 10, 1, -5 },
  { 904, 25, 40, 18, -3, -40 },
  { 1029, 19, 42, 21, 1, -41 },
  { 1129, 12, 40, 21, 6, -40 },
  { 1189, 23, 41, 21, -2, -41 },
  { 1307, 22, 42, 21, -1, -41 },
  { 1423, 22, 40, 21, -1, -40 },
  { 1533, 22, 41, 21, -1, -40 },
  { 1646, 21, 42, 21, 1, -41 },
  { 1757, 21, 40, 21, 2, -40 },
  { 1862, 22, 42, 21, -1, -41 },
  { 1978, 20, 42, 21, 0, -41 },
  { 2083, 10, 30, 10, 0, -30 },
  { 2121, 13, 37, 10, -3, -30 },
  { 2182, 20, 24, 23, 2, -32 },
  { 2242, 20, 15, 23, 2, -27 },
  { 2280, 20, 24, 23, 2, -32 },
  { 2340, 16, 41, 15, 1, -41 },
  { 2422, 29, 45, 31, 1, -40 },
  { 2586, 21, 40, 20, -4, -40 },
  { 2691, 23, 40, 23, 0, -40 },
  { 2806, 23, 42, 20, 2, -41 },
  { 2927, 24, 40, 25, 0, -40 },
  { 3047, 22, 40, 20, 0, -40 },
  { 3157, 22, 40, 18, 0, -40 },
  { 3267, 26, 42, 26, 2, -41 },
  { 3404, 27, 40, 26, 0, -40 },
  { 3539, 19, 40, 12, -3, -40 },
  { 3634, 20, 50, 10, -8, -40 },
  { 3759, 25, 40, 21, 0, -40 },
  { 3884, 14, 40, 18, 0, -40 },
  { 3954, 36, 40, 35, 0, -40 },
  { 4134, 28, 40, 27, 0, -40 },
  { 4274, 23, 42, 26, 2, -41 },
  { 4395, 22, 40, 21, 0, -40 },
  { 4505, 23, 51, 26, 2, -41 },
  { 4652, 22, 40, 22, 0, -40 },
  { 4762, 23, 42, 20, -1, -41 },
  { 4883, 18, 40, 18, 4, -40 },
  { 4973, 24, 41, 25, 2, -40 },
  { 5096, 20, 40, 21, 5, -40 },
  { 5196, 35, 40, 35, 4, -40 },
  { 5371, 26, 40, 19, -3, -40 },
  { 5501, 19, 40, 18, 4, -40 },
  { 5596, 23, 40, 18, -2, -40 },
  { 5711, 20, 49, 16, -1, -40 },
  { 5834, 8, 40, 18, 6, -40 },
  { 5874, 21, 49, 16, -4, -40 },
  { 6003, 21, 20, 22, 1, -40 },
  { 6056, 16, 2, 16, -5, 5 },
  { 6060, 7, 9, 13, 8, -43 },
  { 6068, 20, 31, 22, 2, -30 },
  { 6146, 21, 44, 22, 0, -43 },
  { 6262, 16, 31, 16, 2, -30 },
  { 6324, 23, 44, 22, 2, -43 },
  { 6451, 18, 31, 20, 1, -30 },
  { 6521, 25, 56, 12, -7, -43 },
  { 6696, 23, 43, 22, -1, -30 },
  { 6820, 20, 43, 22, 0, -43 },
  { 6928, 12, 41, 10, 0, -41 },
  { 6990, 19, 54, 10, -7, -41 },
  { 7119, 21, 43, 18, 0, -43 },
  { 7232, 12, 43, 9, 0, -43 },
  { 7297, 31, 30, 32, 0, -30 },
  { 7414, 20, 30, 22, 0, -30 },
  { 7489, 18, 31, 21, 2, -30 },
  { 7559, 23, 43, 22, -2, -30 },
  { 7683, 20, 43, 22, 2, -30 },
  { 7791, 17, 30, 14, 0, -30 },
  { 7855, 18, 31, 17, -1, -30 },
  { 7925, 12, 38, 12, 1, -37 },
  { 7982, 20, 31, 22, 1, -30 },
  { 8060, 17, 30, 17, 3, -30 },
  { 8124, 28, 30, 28, 3, -30 },
  { 8229, 22, 30, 18, -2, -30 },
  { 8312, 27, 44, 18, -6, -30 },
  { 8461, 18, 30, 14, -2, -30 },
  { 8529, 19, 49, 18, 2, -40 },
  { 8646, 3, 56, 20, 8, -43 },
  { 8667, 20, 49, 18, -4, -40 },
  { 8790, 20, 6, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC56PT7B_H_
