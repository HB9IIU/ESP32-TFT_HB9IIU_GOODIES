#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x80, 0x03, 0x18, 0x4A,
  0x52, 0x99, 0x48, 0x04, 0x82, 0x42, 0x41, 0x20, 0x91, 0xFC, 0x48, 0x24,
  0x24, 0x12, 0x3F, 0xC8, 0x84, 0x82, 0x42, 0x21, 0x20, 0x02, 0x04, 0x0F,
  0x15, 0x24, 0x24, 0x28, 0x38, 0x18, 0x0C, 0x14, 0x12, 0x12, 0x12, 0x94,
  0xF8, 0x20, 0x20, 0x38, 0x45, 0x11, 0x22, 0x24, 0x88, 0x91, 0x14, 0x24,
  0xB4, 0xAA, 0x95, 0x2D, 0x44, 0x29, 0x09, 0x21, 0x24, 0x44, 0x88, 0xA2,
  0x1C, 0x0E, 0x12, 0x12, 0x12, 0x12, 0x14, 0x1C, 0x18, 0x38, 0x49, 0xCA,
  0x8A, 0x86, 0x84, 0x8C, 0xF2, 0x55, 0xA0, 0x02, 0x08, 0x20, 0x81, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18, 0x10, 0x20, 0x40, 0x81, 0x80,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x43, 0x00, 0x10, 0x4D, 0x0F, 0x31, 0x20, 0x80, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x25, 0x28, 0x7F,
  0xC0, 0x70, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08,
  0x0C, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0E, 0x1B, 0x11, 0x21,
  0x21, 0x21, 0x61, 0x43, 0x42, 0x42, 0x42, 0x42, 0xC4, 0x44, 0x48, 0x70,
  0x09, 0xDF, 0xA1, 0x08, 0x44, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x0F, 0x0C,
  0xC0, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03,
  0x01, 0x01, 0x01, 0xFC, 0x1E, 0x33, 0x01, 0x01, 0x01, 0x03, 0x02, 0x1C,
  0x2C, 0x04, 0x06, 0x06, 0x04, 0x04, 0x8C, 0xF8, 0x01, 0x03, 0x05, 0x06,
  0x0A, 0x12, 0x12, 0x22, 0x24, 0x44, 0x84, 0xFE, 0x0C, 0x08, 0x08, 0x08,
  0x1F, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x7C, 0x06, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x8C, 0xF8, 0x0F, 0x18, 0x20, 0x20, 0x40, 0x40, 0xD8, 0xAC,
  0xC4, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0xF0, 0x7F, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x80,
  0x0E, 0x11, 0x21, 0x21, 0x21, 0x23, 0x16, 0x1C, 0x3C, 0x44, 0xC6, 0x82,
  0x82, 0x86, 0xC4, 0x78, 0x0E, 0x13, 0x21, 0x21, 0x61, 0x41, 0x43, 0x43,
  0x66, 0x3A, 0x02, 0x06, 0x04, 0x0C, 0x18, 0xF0, 0x13, 0x00, 0x00, 0x00,
  0x00, 0xCC, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC4, 0x22, 0x00,
  0x01, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x0C, 0x30,
  0xC0, 0x80, 0x1C, 0x4C, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x02,
  0x00, 0x00, 0x10, 0x60, 0x07, 0x81, 0x08, 0x41, 0x10, 0x14, 0x02, 0x8E,
  0x52, 0x4C, 0x91, 0x92, 0x52, 0x4A, 0x89, 0x53, 0x49, 0xB9, 0x20, 0x20,
  0x04, 0x00, 0xC4, 0x07, 0x00, 0x03, 0x03, 0x07, 0x07, 0x0B, 0x0B, 0x1B,
  0x13, 0x13, 0x3F, 0x23, 0x63, 0x43, 0x43, 0x83, 0x83, 0x1E, 0x08, 0x84,
  0x22, 0x13, 0x09, 0x0C, 0x84, 0x7C, 0x26, 0x31, 0x90, 0x48, 0x64, 0x22,
  0x13, 0x11, 0xF0, 0x07, 0x8C, 0x8C, 0x04, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0xF0, 0x1E, 0x09, 0x84,
  0x22, 0x13, 0x09, 0x04, 0x82, 0x41, 0x20, 0xB0, 0xD0, 0x48, 0x24, 0x22,
  0x33, 0x31, 0xF0, 0x1F, 0x88, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x7C,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0xF8, 0x1F, 0x88, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x3E, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x07, 0x86, 0x33, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02,
  0x02, 0x87, 0x20, 0x48, 0x12, 0x04, 0x83, 0x20, 0x8C, 0x21, 0xF8, 0x18,
  0x62, 0x08, 0x41, 0x08, 0x23, 0x0C, 0x41, 0x08, 0x21, 0xFC, 0x20, 0x8C,
  0x31, 0x04, 0x20, 0x84, 0x10, 0x82, 0x30, 0xC4, 0x10, 0x1E, 0x18, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x78, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x18, 0xC4, 0x21, 0x10, 0x4C,
  0x32, 0x09, 0x02, 0xC0, 0xE0, 0x38, 0x1A, 0x04, 0xC1, 0x10, 0x44, 0x11,
  0x0C, 0x62, 0x18, 0x18, 0x84, 0x23, 0x10, 0x84, 0x23, 0x10, 0x84, 0x22,
  0x1F, 0x18, 0x0C, 0x60, 0x31, 0x81, 0x86, 0x06, 0x38, 0x28, 0xA0, 0xA2,
  0x85, 0x8A, 0x14, 0x28, 0xD1, 0xA2, 0x44, 0x99, 0x13, 0x4C, 0x45, 0x21,
  0x18, 0x88, 0x62, 0x21, 0x18, 0x18, 0x23, 0x04, 0x60, 0x8C, 0x23, 0xC4,
  0x48, 0x89, 0x11, 0x26, 0x24, 0x8C, 0x91, 0x1A, 0x21, 0x44, 0x38, 0x86,
  0x20, 0xC4, 0x18, 0x0F, 0x0C, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x03,
  0x81, 0x40, 0xA0, 0x50, 0x68, 0x24, 0x33, 0x10, 0xF0, 0x1E, 0x09, 0x84,
  0x62, 0x33, 0x19, 0x08, 0x84, 0x46, 0x3E, 0x38, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x0F, 0x0C, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x03,
  0x81, 0xC0, 0xA0, 0x50, 0x68, 0x24, 0x33, 0x10, 0xF0, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x1E, 0x09, 0x84, 0x62, 0x33, 0x19, 0x08, 0x84, 0x46, 0x3C,
  0x34, 0x13, 0x08, 0x84, 0x42, 0x23, 0x11, 0x0C, 0x07, 0xC2, 0x21, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x88, 0x63, 0xF0, 0x7F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x20, 0x90, 0x48, 0x24,
  0x36, 0x12, 0x09, 0x04, 0x82, 0x43, 0x41, 0x20, 0x90, 0x48, 0x64, 0x22,
  0x30, 0xF0, 0x81, 0x83, 0x82, 0x86, 0x84, 0x84, 0x88, 0x88, 0x98, 0x90,
  0xB0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0x82, 0x0C, 0x10, 0x61, 0x87, 0x0C,
  0x28, 0xE1, 0x45, 0x12, 0x28, 0x92, 0x4C, 0x92, 0x44, 0x92, 0x28, 0xA1,
  0x45, 0x0C, 0x38, 0x61, 0x83, 0x0C, 0x10, 0x40, 0x18, 0x42, 0x20, 0x88,
  0x24, 0x09, 0x02, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x40, 0x90, 0x24,
  0x11, 0x04, 0x62, 0x18, 0x41, 0x42, 0x42, 0x44, 0x44, 0x48, 0x68, 0x30,
  0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x0F, 0x88, 0x40, 0x60,
  0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x01,
  0x01, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x90, 0xE0, 0x91, 0x24,
  0x92, 0x4C, 0x92, 0x49, 0x0F, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0xF0,
  0x04, 0x06, 0x03, 0x82, 0x43, 0x21, 0x19, 0x85, 0x83, 0xFE, 0xC9, 0x10,
  0x19, 0x26, 0x42, 0x42, 0xC2, 0x86, 0x84, 0x84, 0x84, 0x8C, 0x94, 0xF8,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x36, 0x29, 0x31, 0x21, 0x21, 0x61, 0x41,
  0x43, 0x42, 0x42, 0xC4, 0xB8, 0x1C, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x3C, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0xC8, 0x98, 0x84, 0x42,
  0x41, 0x21, 0x90, 0x88, 0x44, 0x22, 0x31, 0x28, 0xE8, 0x00, 0x1C, 0x94,
  0x51, 0x86, 0x6E, 0x20, 0x82, 0x08, 0x3E, 0x00, 0xC0, 0x40, 0x20, 0x08,
  0x02, 0x03, 0xC0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x38, 0x00, 0x0E,
  0x89, 0x88, 0x44, 0x24, 0x12, 0x19, 0x08, 0x84, 0x42, 0x23, 0x13, 0x8F,
  0x80, 0x40, 0x20, 0x30, 0x10, 0xF0, 0x00, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x1E, 0x33, 0x31, 0x21, 0x22, 0x62, 0x42, 0x42, 0x46, 0x44, 0xC4, 0x84,
  0x18, 0x80, 0x01, 0x10, 0x84, 0x23, 0x10, 0x84, 0x23, 0x10, 0x03, 0x02,
  0x00, 0x00, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x11, 0x22, 0x24, 0x2C, 0x28, 0x78, 0x68, 0x48, 0x48, 0x48, 0xCC, 0x84,
  0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x18, 0x84, 0x21, 0x18, 0x80, 0x2E,
  0x63, 0x39, 0x31, 0x12, 0x31, 0x22, 0x16, 0x23, 0x42, 0x24, 0x22, 0x44,
  0x24, 0x42, 0xC4, 0x48, 0x44, 0x2E, 0x33, 0x31, 0x21, 0x22, 0x62, 0x42,
  0x42, 0x46, 0x44, 0xC4, 0x84, 0x1C, 0x4D, 0x0A, 0x18, 0x30, 0x61, 0xC2,
  0x85, 0x1A, 0x27, 0x80, 0x1B, 0x0A, 0x46, 0x22, 0x11, 0x09, 0x84, 0x82,
  0x43, 0x21, 0x10, 0x98, 0x8B, 0x84, 0x02, 0x01, 0x01, 0x00, 0x80, 0x00,
  0x19, 0x26, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0x8C, 0xF8,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x2E, 0x50, 0xC1, 0x02, 0x0C, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x00, 0x1C, 0x45, 0x02, 0x06, 0x06, 0x04, 0x04, 0x08,
  0x12, 0x27, 0x80, 0x10, 0x9E, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x8C, 0x30,
  0x62, 0x85, 0x0A, 0x34, 0x58, 0xA1, 0x42, 0x8D, 0x12, 0x67, 0x40, 0x83,
  0x0A, 0x14, 0x48, 0x93, 0x24, 0x48, 0xA1, 0x43, 0x06, 0x00, 0x84, 0x30,
  0x8E, 0x31, 0x46, 0x29, 0x49, 0x29, 0x25, 0x25, 0x28, 0xA5, 0x14, 0xC3,
  0x18, 0x63, 0x00, 0x11, 0x88, 0x84, 0x82, 0x40, 0xC0, 0x40, 0x60, 0x30,
  0x24, 0x12, 0x11, 0x18, 0x80, 0x08, 0x42, 0x30, 0x88, 0x22, 0x09, 0x02,
  0x40, 0xA0, 0x28, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0xE0, 0x00, 0x1E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x18, 0x20, 0xC1,
  0x07, 0xC0, 0x02, 0x18, 0x20, 0x81, 0x02, 0x04, 0x18, 0x21, 0x81, 0x03,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x81, 0x80, 0xFF, 0xFF, 0xFC, 0x08, 0x28,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x0C, 0x30, 0x41, 0x02, 0x04, 0x08,
  0x30, 0x43, 0x80, 0xE1, 0x9E,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 5, 6, 7, 2, -16 },
  { 15, 9, 16, 9, 0, -16 },
  { 33, 8, 18, 8, 0, -17 },
  { 51, 11, 16, 12, 1, -16 },
  { 73, 8, 16, 8, 0, -16 },
  { 89, 2, 6, 4, 2, -16 },
  { 91, 7, 19, 5, 0, -16 },
  { 108, 7, 19, 6, -2, -16 },
  { 125, 6, 7, 7, 2, -17 },
  { 131, 8, 10, 9, 1, -13 },
  { 141, 3, 5, 4, -1, -2 },
  { 143, 5, 2, 6, 0, -7 },
  { 145, 2, 2, 4, 0, -2 },
  { 146, 9, 16, 7, -1, -16 },
  { 164, 8, 16, 8, 0, -16 },
  { 180, 5, 16, 8, 2, -16 },
  { 190, 9, 16, 8, -1, -16 },
  { 208, 8, 16, 8, 0, -16 },
  { 224, 8, 16, 8, 0, -16 },
  { 240, 8, 16, 8, 0, -16 },
  { 256, 8, 16, 8, 1, -16 },
  { 272, 8, 16, 8, 1, -16 },
  { 288, 8, 16, 8, 0, -16 },
  { 304, 8, 16, 8, 0, -16 },
  { 320, 4, 12, 4, 0, -12 },
  { 326, 5, 15, 4, -1, -12 },
  { 336, 8, 10, 9, 1, -13 },
  { 346, 8, 6, 9, 1, -11 },
  { 352, 8, 10, 9, 1, -13 },
  { 362, 7, 16, 6, 0, -16 },
  { 376, 11, 18, 12, 1, -16 },
  { 401, 8, 16, 8, -1, -16 },
  { 417, 9, 16, 9, 0, -16 },
  { 435, 9, 16, 8, 1, -16 },
  { 453, 9, 16, 10, 0, -16 },
  { 471, 9, 16, 8, 0, -16 },
  { 489, 9, 16, 7, 0, -16 },
  { 507, 10, 16, 10, 1, -16 },
  { 527, 11, 16, 10, 0, -16 },
  { 549, 7, 16, 5, -1, -16 },
  { 563, 8, 20, 4, -3, -16 },
  { 583, 10, 16, 8, 0, -16 },
  { 603, 5, 16, 7, 0, -16 },
  { 613, 14, 16, 14, 0, -16 },
  { 641, 11, 16, 11, 0, -16 },
  { 663, 9, 16, 10, 1, -16 },
  { 681, 9, 16, 8, 0, -16 },
  { 699, 9, 20, 10, 1, -16 },
  { 722, 9, 16, 9, 0, -16 },
  { 740, 10, 16, 8, -1, -16 },
  { 760, 8, 16, 7, 1, -16 },
  { 776, 9, 16, 10, 1, -16 },
  { 794, 8, 16, 8, 2, -16 },
  { 810, 13, 16, 14, 2, -16 },
  { 836, 10, 16, 7, -1, -16 },
  { 856, 8, 16, 7, 1, -16 },
  { 872, 9, 16, 7, -1, -16 },
  { 890, 8, 20, 6, 0, -16 },
  { 910, 3, 16, 7, 2, -16 },
  { 916, 8, 20, 6, -1, -16 },
  { 936, 9, 8, 9, 0, -16 },
  { 945, 7, 1, 6, -2, 2 },
  { 946, 3, 4, 5, 3, -17 },
  { 948, 8, 12, 9, 1, -12 },
  { 960, 8, 17, 9, 0, -17 },
  { 977, 6, 12, 6, 1, -12 },
  { 986, 9, 17, 9, 1, -17 },
  { 1006, 6, 12, 8, 1, -12 },
  { 1015, 10, 22, 5, -3, -17 },
  { 1043, 9, 17, 9, 0, -12 },
  { 1063, 8, 17, 8, 0, -17 },
  { 1080, 5, 16, 4, 0, -16 },
  { 1090, 8, 21, 4, -3, -16 },
  { 1111, 8, 17, 7, 0, -17 },
  { 1128, 5, 17, 4, 0, -17 },
  { 1139, 12, 12, 13, 0, -12 },
  { 1157, 8, 12, 8, 0, -12 },
  { 1169, 7, 12, 8, 1, -12 },
  { 1180, 9, 17, 9, -1, -12 },
  { 1200, 8, 17, 9, 1, -12 },
  { 1217, 7, 12, 6, 0, -12 },
  { 1228, 7, 12, 6, 0, -12 },
  { 1239, 5, 14, 5, 0, -14 },
  { 1248, 7, 12, 8, 1, -12 },
  { 1259, 7, 12, 7, 1, -12 },
  { 1270, 11, 12, 11, 1, -12 },
  { 1287, 9, 12, 7, -1, -12 },
  { 1301, 10, 17, 7, -2, -12 },
  { 1323, 7, 12, 6, -1, -12 },
  { 1334, 7, 19, 7, 1, -16 },
  { 1351, 1, 22, 8, 3, -17 },
  { 1354, 7, 19, 7, -1, -16 },
  { 1371, 8, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC22PT7B_H_
