#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x38, 0x73,
  0x86, 0x30, 0xE3, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x1C, 0x61, 0xCE,
  0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x80, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC3,
  0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x0E, 0x03, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0xE1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0xFE, 0xF8, 0x1C, 0x42,
  0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x08, 0x00, 0xE1, 0x00,
  0x1C, 0x60, 0x03, 0x8C, 0x00, 0x31, 0x00, 0x07, 0x20, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x37, 0x00,
  0x06, 0x70, 0x00, 0xCE, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0x43, 0x80, 0x18, 0x60, 0x83, 0x1C, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x07, 0xE0,
  0x0C, 0x0E, 0x70, 0x18, 0x1C, 0x30, 0x18, 0x18, 0x30, 0x30, 0x18, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x30, 0x30, 0x60, 0x30, 0x70, 0xC0, 0x70, 0x70,
  0xC0, 0x60, 0x61, 0x80, 0x60, 0x61, 0x80, 0x60, 0x63, 0x00, 0x60, 0xE3,
  0x00, 0xE0, 0xC6, 0x1C, 0xE0, 0xC6, 0x3F, 0xE1, 0xCC, 0x77, 0xE1, 0x8C,
  0xE3, 0x63, 0x98, 0xC3, 0x63, 0x19, 0x83, 0x7E, 0x31, 0x83, 0x3C, 0x33,
  0x83, 0x00, 0x63, 0x03, 0x00, 0xE3, 0x03, 0x00, 0xC3, 0x03, 0x01, 0xC7,
  0x07, 0x01, 0x86, 0x06, 0x03, 0x86, 0x06, 0x03, 0x06, 0x06, 0x07, 0x06,
  0x0E, 0x06, 0x06, 0x0C, 0x0E, 0x06, 0x0C, 0x0C, 0x06, 0x18, 0x1C, 0x06,
  0x38, 0x18, 0x07, 0xF0, 0x38, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x3E,
  0x00, 0x3F, 0xC0, 0x0E, 0x70, 0x07, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0,
  0x38, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x3B, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3B, 0x80, 0x1C, 0xE1, 0xCE, 0x18, 0x73,
  0x07, 0x19, 0xC1, 0xCE, 0x60, 0x73, 0xB8, 0x0C, 0xCE, 0x03, 0xF3, 0x00,
  0xF8, 0xC0, 0x1E, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x7E,
  0x3C, 0x3B, 0x87, 0xFC, 0xE0, 0xFE, 0x1C, 0x0C, 0x00, 0x00, 0x39, 0xCE,
  0x67, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x10, 0x60, 0x61, 0x83, 0xE4, 0x11, 0xF7, 0xC1,
  0xFF, 0x07, 0x80, 0x3E, 0x01, 0xCC, 0x0E, 0x30, 0x70, 0x60, 0x81, 0xC0,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x0E, 0x18, 0x70, 0xC3,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x4E, 0xFE, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x80, 0x79, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x0C, 0x18, 0x06, 0x1C,
  0x03, 0x0E, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x71, 0x80, 0x39,
  0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x03, 0x38, 0x01, 0x9C, 0x01,
  0xCE, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x33, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xC1, 0xC0, 0xE0, 0x60, 0xE0, 0x38, 0xE0, 0x1F, 0xE0, 0x07, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0xE1, 0xFC, 0x7B, 0x9E,
  0x77, 0x0C, 0x41, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x01, 0xF1,
  0xE0, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xE1, 0xE0, 0x18, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x80, 0x3C, 0x0C, 0x07, 0x80,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00,
  0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x19, 0xC0, 0x01, 0x9C, 0x00, 0x31, 0x80,
  0x07, 0x18, 0x00, 0x63, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x30,
  0x03, 0x83, 0x00, 0x30, 0x70, 0x06, 0x07, 0x00, 0xE0, 0x70, 0x0C, 0x06,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xE0, 0x70, 0x0C, 0x06, 0x00,
  0xC4, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x40, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x80, 0x3C,
  0x0C, 0x07, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xE1, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x7E, 0x01, 0x9F,
  0xE0, 0x37, 0x1E, 0x0F, 0x81, 0xC1, 0xE0, 0x18, 0x3C, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x38, 0x07,
  0x03, 0x01, 0xC0, 0x70, 0x38, 0x0F, 0x1E, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x20, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xE1, 0xE0, 0x1C, 0x0E, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x01,
  0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0x79, 0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x70, 0x03, 0x07, 0x00, 0x38, 0x60, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x30, 0x60, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x03, 0xC1,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x1E, 0x78, 0x0E, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0xE0,
  0x1C, 0x38, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x18, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x0F, 0x18, 0x03, 0x87,
  0x01, 0xE1, 0xC0, 0xF8, 0x38, 0x7E, 0x0F, 0xFB, 0x81, 0xF8, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x20,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x01, 0x03, 0xC1,
  0xE0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xE0,
  0xF0, 0x78, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0xE3, 0xC2,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xC0, 0x3E, 0x0C, 0x30, 0x3F, 0xC3,
  0x1C, 0x1C, 0x61, 0xC6, 0x0E, 0x18, 0x71, 0x83, 0x0E, 0x1C, 0xC1, 0x83,
  0x06, 0x30, 0x60, 0xC1, 0x8C, 0x38, 0x30, 0x67, 0x0C, 0x1C, 0x19, 0x83,
  0x06, 0x0E, 0x60, 0xC1, 0x83, 0x18, 0x70, 0x60, 0xC6, 0x18, 0x38, 0x31,
  0x86, 0x0E, 0x18, 0xE1, 0x83, 0x06, 0x38, 0x61, 0xC3, 0x8C, 0x18, 0x70,
  0xC3, 0x07, 0x34, 0x60, 0xC1, 0xF9, 0xF8, 0x30, 0x3C, 0x7C, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x01, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xDC, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x06, 0x70, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x70, 0x70,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1C,
  0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1C, 0x0F, 0x01, 0x80, 0x70, 0x18, 0x07, 0x03, 0x80, 0x30, 0x38, 0x03,
  0x03, 0x80, 0x30, 0x30, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x06, 0x01, 0xC0, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0C, 0x3F, 0x00, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C,
  0x01, 0x81, 0x80, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x18, 0x38, 0x01, 0x83,
  0x80, 0x38, 0x30, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0xF0,
  0x60, 0x1E, 0x06, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0x00, 0xF8, 0x60, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC1, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0x83, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x18, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x00,
  0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x00, 0x38, 0x38,
  0x03, 0x81, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x60, 0x3C, 0x03, 0x1F, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x10, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8,
  0x03, 0xF0, 0xF8, 0x0F, 0x00, 0x60, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x23, 0x80, 0x3F,
  0x87, 0x00, 0x7F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x78, 0x03, 0x00, 0x78, 0x0E, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x0E, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C,
  0x00, 0x60, 0x18, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x03, 0x80, 0x60, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x33, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xC0,
  0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x18, 0x07,
  0x00, 0x30, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x06, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00,
  0xC7, 0x00, 0x01, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x37, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x86,
  0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0x60, 0x01, 0xC0, 0xE0, 0x03, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x6C, 0x03, 0xF0, 0x00, 0xEC, 0x03, 0x70, 0x00, 0xFC,
  0x03, 0x70, 0x01, 0xDC, 0x07, 0x70, 0x01, 0xDC, 0x07, 0x30, 0x03, 0x98,
  0x07, 0x30, 0x03, 0x98, 0x06, 0x30, 0x03, 0x38, 0x06, 0x30, 0x07, 0x38,
  0x0E, 0x30, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70,
  0x0C, 0x30, 0x1C, 0x70, 0x0C, 0x30, 0x18, 0x70, 0x1C, 0x30, 0x38, 0x60,
  0x1C, 0x30, 0x30, 0x60, 0x18, 0x30, 0x70, 0xE0, 0x18, 0x30, 0x60, 0xE0,
  0x38, 0x38, 0xE0, 0xE0, 0x38, 0x38, 0xE0, 0xC0, 0x38, 0x39, 0xC0, 0xC0,
  0x30, 0x39, 0xC1, 0xC0, 0x30, 0x39, 0x81, 0xC0, 0x70, 0x3B, 0x81, 0xC0,
  0x70, 0x3B, 0x01, 0x80, 0x70, 0x3F, 0x03, 0x80, 0x60, 0x3E, 0x03, 0x80,
  0x60, 0x3E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x3C, 0x00,
  0x70, 0x1F, 0x00, 0x30, 0x0F, 0x80, 0x18, 0x0F, 0xC0, 0x1C, 0x07, 0x60,
  0x0E, 0x03, 0x30, 0x07, 0x01, 0x98, 0x03, 0x01, 0xCE, 0x03, 0x80, 0xE7,
  0x01, 0xC0, 0x71, 0x80, 0xE0, 0x30, 0xC0, 0x70, 0x18, 0x60, 0x30, 0x1C,
  0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x07, 0x0E, 0x0E, 0x03, 0x03, 0x06, 0x01,
  0x81, 0x83, 0x01, 0xC0, 0xC3, 0x80, 0xE0, 0x71, 0xC0, 0x70, 0x38, 0xE0,
  0x30, 0x1C, 0x60, 0x38, 0x06, 0x30, 0x1C, 0x03, 0x38, 0x0E, 0x01, 0x9C,
  0x06, 0x00, 0xEE, 0x03, 0x00, 0x76, 0x03, 0x80, 0x3B, 0x01, 0xC0, 0x0F,
  0x80, 0xE0, 0x07, 0xC0, 0x60, 0x03, 0xC0, 0x30, 0x01, 0xE0, 0x38, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3C,
  0x78, 0x03, 0x81, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x18, 0x00, 0xC1,
  0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x98, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83,
  0x80, 0x18, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xC3, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1C, 0x1E, 0x01, 0x80, 0xE0, 0x18, 0x0E, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x30, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x06, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0xC0, 0xE0, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x0C, 0x1F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3C, 0x78, 0x03, 0x81, 0xE0,
  0x38, 0x07, 0x03, 0x80, 0x38, 0x18, 0x00, 0xC1, 0xC0, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x98,
  0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x61,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0xC3, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1C, 0x1E, 0x01, 0x80,
  0xE0, 0x18, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x30,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06,
  0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xC3, 0x00, 0x1C, 0x38, 0x01, 0x83, 0x80,
  0x18, 0x38, 0x03, 0x83, 0x80, 0x38, 0x18, 0x03, 0x81, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x0C, 0x06, 0x00,
  0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0,
  0x7E, 0x7C, 0x03, 0x80, 0x40, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x80, 0x1C, 0x07, 0x03, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x81, 0x80, 0x0E,
  0x06, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x1C, 0x0C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x18, 0x00,
  0xE0, 0x60, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x01, 0xC0,
  0xC0, 0x07, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x81, 0xC0,
  0x0E, 0x06, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x0C,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x1C,
  0x0C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x60, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x77, 0x00, 0x3C, 0x00,
  0xEE, 0x00, 0x78, 0x01, 0x9C, 0x01, 0xF0, 0x07, 0x38, 0x03, 0x60, 0x0E,
  0x70, 0x06, 0xC0, 0x38, 0xE0, 0x1F, 0x80, 0x71, 0xC0, 0x37, 0x00, 0xC3,
  0x80, 0xEE, 0x03, 0x87, 0x01, 0x9C, 0x07, 0x0E, 0x03, 0x38, 0x1C, 0x1C,
  0x0E, 0x70, 0x38, 0x38, 0x18, 0xE0, 0x60, 0x70, 0x71, 0x81, 0xC0, 0xE0,
  0xE3, 0x03, 0x81, 0xC1, 0x86, 0x0E, 0x03, 0x87, 0x0C, 0x1C, 0x07, 0x0C,
  0x18, 0x30, 0x0C, 0x18, 0x30, 0xE0, 0x18, 0x70, 0x61, 0xC0, 0x30, 0xC0,
  0xC7, 0x00, 0x63, 0x81, 0x8E, 0x00, 0xC6, 0x03, 0x18, 0x01, 0x8C, 0x06,
  0x70, 0x03, 0x38, 0x0C, 0xE0, 0x06, 0x60, 0x19, 0x80, 0x0D, 0xC0, 0x37,
  0x00, 0x1B, 0x00, 0x6C, 0x00, 0x36, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC7,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x00, 0x00,
  0xE7, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38,
  0x00, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0xE1,
  0x80, 0x70, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x67, 0x00, 0x33, 0x00, 0x1B,
  0x80, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xE1, 0xC3, 0x83, 0x06,
  0x0C, 0x18, 0x38, 0x70, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x70,
  0x60, 0xC1, 0x83, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x87,
  0x0E, 0x0C, 0x18, 0x30, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0xB8, 0x00, 0x63, 0x00,
  0x1C, 0x70, 0x07, 0x0E, 0x00, 0xC0, 0xC0, 0x38, 0x1C, 0x06, 0x03, 0x81,
  0xC0, 0x30, 0x30, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0xDC,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC7, 0x0C, 0x38,
  0x60, 0xC3, 0x00, 0xF8, 0x60, 0x3F, 0x9C, 0x0F, 0x3B, 0x03, 0x81, 0x60,
  0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x18, 0x0F, 0x03, 0x83, 0xE0, 0x70,
  0xDC, 0x07, 0xFB, 0x00, 0x7C, 0x60, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x8F, 0x80, 0x33, 0xF8, 0x0E, 0xC7, 0x81, 0xF0, 0x70, 0x3C, 0x06, 0x07,
  0x00, 0xC1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x18,
  0x01, 0x87, 0x00, 0x30, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x60,
  0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1, 0xC0,
  0x38, 0x78, 0x06, 0x0F, 0x01, 0xC1, 0xE0, 0x70, 0x36, 0x1C, 0x0E, 0xFF,
  0x81, 0x8F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0x10,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x78, 0x20, 0x7F, 0x80, 0x7F, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x01, 0xF1, 0xC0, 0x1F, 0xCE, 0x01, 0xE7, 0x60,
  0x1C, 0x0B, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0C, 0x0E,
  0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0C,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x03, 0x01, 0xE0, 0x1C, 0x1F, 0x00, 0xE1, 0xB8, 0x03, 0xFD, 0x80,
  0x1F, 0x8C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xCE,
  0x07, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x06,
  0x38, 0x0E, 0x30, 0x1C, 0x70, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x78, 0x30, 0x3F, 0xF0, 0x1F, 0xE0,
  0x02, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x40, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x2F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x18, 0x03,
  0xF9, 0xC0, 0x3C, 0xEC, 0x03, 0x81, 0x60, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x00, 0x38, 0x18, 0x01, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x78, 0x1C, 0x03, 0x80, 0x60, 0x3C, 0x03, 0x83, 0xE0, 0x1C,
  0x37, 0x00, 0x7F, 0xB0, 0x03, 0xF9, 0x80, 0x02, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x01, 0x00, 0xE0, 0x0F, 0x3E, 0x00, 0x7F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x7C, 0x03, 0x7F, 0x81, 0xFC, 0xE0, 0x7C,
  0x1C, 0x1E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0xE0, 0x18, 0x38, 0x06,
  0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x1C, 0x03, 0x06,
  0x01, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x06, 0x0E, 0x01, 0x83, 0x00,
  0xE0, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0x80, 0x70,
  0x60, 0x1C, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x27, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x03, 0x03, 0x01, 0xC1, 0xC0, 0xE0, 0x70, 0x70,
  0x18, 0x18, 0x06, 0x0E, 0x01, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0C,
  0x70, 0x03, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1B, 0xE0, 0x07, 0x98,
  0x01, 0xC6, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x07, 0x00,
  0xC0, 0xC0, 0x70, 0x30, 0x1C, 0x0E, 0x06, 0x03, 0x81, 0x80, 0xE0, 0xE0,
  0x38, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x1F, 0x0F,
  0x80, 0x37, 0xF9, 0xFE, 0x07, 0xE7, 0xB9, 0xE0, 0x68, 0x3E, 0x06, 0x07,
  0x81, 0xE0, 0x70, 0x70, 0x1C, 0x06, 0x0E, 0x01, 0xC0, 0x60, 0xE0, 0x18,
  0x06, 0x0E, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x0E, 0x0C, 0x03, 0x80, 0xE1,
  0xC0, 0x30, 0x0C, 0x1C, 0x07, 0x00, 0xC1, 0xC0, 0x70, 0x1C, 0x18, 0x07,
  0x01, 0xC1, 0x80, 0x60, 0x1C, 0x38, 0x06, 0x01, 0x83, 0x80, 0xE0, 0x18,
  0x38, 0x0E, 0x03, 0x83, 0x00, 0xE0, 0x38, 0x30, 0x0C, 0x03, 0x07, 0x00,
  0xC0, 0x30, 0x70, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x70, 0x60, 0x1C, 0x07,
  0x0E, 0x01, 0x80, 0x60, 0xE0, 0x38, 0x0E, 0x00, 0x03, 0x1F, 0x00, 0xDF,
  0xE0, 0x7F, 0x38, 0x1B, 0x07, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0xF0, 0x1C,
  0x38, 0x06, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x07, 0x00, 0xC1, 0x80, 0x70, 0x60, 0x1C, 0x38, 0x07, 0x0E, 0x01,
  0x83, 0x80, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xC1,
  0xC0, 0x70, 0x60, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xF3, 0xC0, 0xE0, 0xE0, 0xE0, 0x30, 0x60, 0x1C, 0x70, 0x0E,
  0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x33, 0x80, 0x19, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x07, 0x70, 0x03, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE1, 0x80, 0xE0, 0xE0, 0x70,
  0x70, 0x70, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x00, 0xC7, 0xC0,
  0x06, 0x7F, 0x00, 0x76, 0x3C, 0x03, 0xE0, 0xE0, 0x1A, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x38, 0x18, 0x01,
  0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xE0,
  0x1B, 0x0F, 0x00, 0xDF, 0xF0, 0x0E, 0x7E, 0x00, 0x70, 0x80, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x60, 0x3F, 0x9C, 0x0F, 0x3B, 0x03,
  0x83, 0x60, 0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x18, 0x01, 0x87, 0x00, 0x30, 0xE0,
  0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x03, 0x83,
  0xE0, 0x70, 0xDC, 0x07, 0xFB, 0x00, 0xFC, 0x60, 0x02, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x1E, 0x06, 0xFC, 0x19, 0xF0, 0x36, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0x87, 0x07, 0x02,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0xC0, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x04, 0x00,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03, 0xF9, 0xFF, 0x3F,
  0xC1, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xE0, 0x7C, 0x02, 0x00, 0x06,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x18, 0x38, 0x06, 0x0C, 0x03, 0x83, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x1C, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x06, 0x0E, 0x01, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x70, 0x60, 0x1C, 0x38, 0x0E,
  0x0E, 0x03, 0x83, 0x81, 0xE0, 0xF0, 0xD8, 0x1F, 0xEE, 0x03, 0xF3, 0x00,
  0x20, 0x00, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x00, 0xCC, 0x03, 0x98,
  0x07, 0x30, 0x1C, 0x60, 0x38, 0xC0, 0x61, 0x81, 0xC3, 0x03, 0x06, 0x0E,
  0x0C, 0x18, 0x18, 0x70, 0x30, 0xE0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x03,
  0x38, 0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x06, 0xE0, 0x7C, 0x0E, 0xE0, 0x6C, 0x0C, 0xE0,
  0x6C, 0x1C, 0xE0, 0xDC, 0x1C, 0xE0, 0xDC, 0x18, 0xE1, 0xDC, 0x38, 0xC1,
  0x9C, 0x30, 0xC1, 0x9C, 0x30, 0xC3, 0x1C, 0x70, 0xC3, 0x1C, 0x60, 0xC7,
  0x1C, 0xE0, 0xC6, 0x1C, 0xC0, 0xC6, 0x18, 0xC0, 0xCE, 0x19, 0xC0, 0xCC,
  0x19, 0x80, 0xDC, 0x1B, 0x80, 0xD8, 0x1B, 0x00, 0xD8, 0x1B, 0x00, 0xF8,
  0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C,
  0x01, 0x83, 0x80, 0x18, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x0D, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB0, 0x00, 0x33, 0x00, 0x07,
  0x30, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x03,
  0x81, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x06, 0x01,
  0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70,
  0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0xCE, 0x00, 0x01, 0x98, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x09, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x02, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xF0, 0x3E, 0x3F, 0xFE, 0x03, 0xFE, 0x80, 0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 36, 11, 1, -36 },
  { 46, 12, 13, 15, 5, -36 },
  { 66, 21, 36, 20, 0, -36 },
  { 161, 19, 41, 18, 0, -38 },
  { 259, 24, 37, 28, 2, -36 },
  { 370, 18, 37, 19, 0, -36 },
  { 454, 5, 13, 8, 5, -36 },
  { 463, 14, 44, 12, 1, -36 },
  { 540, 15, 44, 13, -4, -36 },
  { 623, 14, 15, 17, 5, -38 },
  { 650, 17, 23, 21, 2, -29 },
  { 699, 7, 11, 9, -2, -5 },
  { 709, 11, 3, 13, 1, -15 },
  { 714, 4, 5, 9, 1, -5 },
  { 717, 21, 36, 16, -2, -36 },
  { 812, 17, 37, 18, 1, -36 },
  { 891, 11, 36, 18, 5, -36 },
  { 941, 20, 36, 18, -2, -36 },
  { 1031, 20, 37, 18, -1, -36 },
  { 1124, 20, 36, 18, -1, -36 },
  { 1214, 20, 37, 18, -1, -36 },
  { 1307, 19, 37, 18, 1, -36 },
  { 1395, 18, 36, 18, 2, -36 },
  { 1476, 20, 37, 18, -1, -36 },
  { 1569, 18, 37, 18, 0, -36 },
  { 1653, 9, 27, 9, 0, -27 },
  { 1684, 11, 33, 9, -2, -27 },
  { 1730, 18, 21, 21, 2, -28 },
  { 1778, 17, 13, 21, 2, -24 },
  { 1806, 18, 21, 21, 2, -28 },
  { 1854, 14, 36, 13, 1, -36 },
  { 1917, 26, 40, 27, 1, -36 },
  { 2047, 18, 36, 18, -3, -36 },
  { 2128, 20, 36, 20, 0, -36 },
  { 2218, 20, 37, 18, 2, -36 },
  { 2311, 21, 36, 22, 0, -36 },
  { 2406, 20, 36, 18, 0, -36 },
  { 2496, 20, 36, 16, 0, -36 },
  { 2586, 23, 37, 24, 2, -36 },
  { 2693, 24, 36, 23, 0, -36 },
  { 2801, 17, 36, 11, -3, -36 },
  { 2878, 17, 45, 9, -7, -36 },
  { 2974, 23, 36, 19, 0, -36 },
  { 3078, 12, 36, 16, 0, -36 },
  { 3132, 32, 36, 31, 0, -36 },
  { 3276, 25, 36, 24, 0, -36 },
  { 3389, 21, 37, 24, 2, -36 },
  { 3487, 20, 36, 19, 0, -36 },
  { 3577, 21, 45, 24, 2, -36 },
  { 3696, 20, 36, 19, 0, -36 },
  { 3786, 21, 37, 18, -1, -36 },
  { 3884, 17, 36, 16, 3, -36 },
  { 3961, 22, 37, 22, 2, -36 },
  { 4063, 19, 36, 19, 4, -36 },
  { 4149, 31, 36, 31, 4, -36 },
  { 4289, 23, 36, 17, -3, -36 },
  { 4393, 17, 36, 16, 3, -36 },
  { 4470, 21, 36, 16, -2, -36 },
  { 4565, 18, 44, 14, -1, -36 },
  { 4664, 7, 36, 17, 5, -36 },
  { 4696, 18, 44, 14, -3, -36 },
  { 4795, 19, 18, 20, 1, -36 },
  { 4838, 14, 3, 14, -4, 4 },
  { 4844, 6, 8, 11, 7, -38 },
  { 4850, 19, 28, 20, 1, -27 },
  { 4917, 19, 39, 20, 0, -38 },
  { 5010, 15, 28, 15, 1, -27 },
  { 5063, 21, 39, 20, 1, -38 },
  { 5166, 16, 28, 18, 1, -27 },
  { 5222, 22, 50, 10, -6, -38 },
  { 5360, 21, 39, 20, -1, -27 },
  { 5463, 18, 38, 19, 0, -38 },
  { 5549, 10, 36, 9, 0, -36 },
  { 5594, 18, 48, 9, -7, -36 },
  { 5702, 18, 38, 16, 0, -38 },
  { 5788, 11, 38, 8, 0, -38 },
  { 5841, 28, 27, 29, 0, -27 },
  { 5936, 18, 27, 19, 0, -27 },
  { 5997, 17, 28, 19, 1, -27 },
  { 6057, 21, 39, 20, -2, -27 },
  { 6160, 19, 39, 20, 1, -27 },
  { 6253, 15, 27, 13, 0, -27 },
  { 6304, 16, 28, 15, -1, -27 },
  { 6360, 11, 34, 11, 1, -33 },
  { 6407, 18, 28, 19, 1, -27 },
  { 6470, 15, 27, 15, 3, -27 },
  { 6521, 24, 27, 25, 3, -27 },
  { 6602, 20, 27, 16, -2, -27 },
  { 6670, 23, 39, 16, -5, -27 },
  { 6783, 16, 27, 13, -2, -27 },
  { 6837, 18, 44, 16, 1, -36 },
  { 6936, 2, 50, 18, 8, -38 },
  { 6949, 17, 44, 16, -3, -36 },
  { 7043, 18, 5, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC50PT7B_H_
