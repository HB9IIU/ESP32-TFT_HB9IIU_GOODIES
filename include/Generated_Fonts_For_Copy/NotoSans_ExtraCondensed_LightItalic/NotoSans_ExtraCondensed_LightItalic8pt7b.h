#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x6D, 0xDD, 0x80, 0x39, 0x25, 0x80, 0x5A, 0xBF,
  0x77, 0x4D, 0x3D, 0xC0, 0xC0, 0x5A, 0xA8, 0x24, 0x92, 0xB0, 0xB0, 0x4B,
  0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x6E, 0xDB, 0x80, 0x6A, 0xA0,
  0x64, 0xA9, 0x80, 0x64, 0xB3, 0x80, 0x25, 0x5E, 0x80, 0x6B, 0x13, 0x80,
  0x2B, 0x5B, 0x80, 0x64, 0xA5, 0x00, 0x75, 0xEB, 0x80, 0x76, 0xB3, 0x80,
  0x10, 0x18, 0x2B, 0x10, 0xFC, 0x89, 0xC0, 0x56, 0xA0, 0x35, 0xFF, 0xF8,
  0x40, 0x24, 0xB7, 0x40, 0x6E, 0xFB, 0x80, 0x34, 0x88, 0x8C, 0x6E, 0xDB,
  0x80, 0x6A, 0xE9, 0x80, 0x6A, 0x69, 0x00, 0x34, 0x8B, 0xAE, 0x55, 0x9E,
  0xAA, 0x56, 0xA0, 0x25, 0x24, 0xB0, 0x56, 0xCC, 0xCA, 0x5A, 0xB0, 0x4A,
  0x77, 0xAB, 0x58, 0x55, 0xDA, 0xAA, 0x25, 0x99, 0xAE, 0x6E, 0xA9, 0x00,
  0x25, 0x99, 0xAA, 0x40, 0x6E, 0xAD, 0x40, 0x71, 0x23, 0x80, 0xEA, 0xA0,
  0x55, 0x9A, 0xAE, 0xBB, 0x49, 0x00, 0xAE, 0xAD, 0x4A, 0x50, 0x6D, 0x2D,
  0x80, 0xFA, 0xA0, 0x65, 0x29, 0x80, 0x69, 0x49, 0x20, 0xFC, 0x24, 0x92,
  0x70, 0x4E, 0x80, 0xE0, 0x80, 0x76, 0xE0, 0x49, 0xDB, 0x80, 0x72, 0x60,
  0x12, 0x6A, 0xAC, 0xFA, 0x70, 0x36, 0x24, 0x44, 0x48, 0x76, 0xE5, 0x80,
  0x49, 0xDB, 0x40, 0x4A, 0xA0, 0x21, 0x24, 0x94, 0x4A, 0xAD, 0x80, 0x5A,
  0xA0, 0x7B, 0xBD, 0x76, 0xD0, 0xF6, 0xE0, 0x76, 0xE9, 0x00, 0x76, 0xE4,
  0x80, 0x6A, 0xE7, 0x6A, 0x80, 0xB6, 0xE0, 0xBB, 0x40, 0xBB, 0xEA, 0xA9,
  0x60, 0x56, 0x24, 0x48, 0x5B, 0x29, 0x65, 0x30, 0xFF, 0x24, 0x92, 0xB0,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 3, 6, 3, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 4, 6, 5, 0, -6 },
  { 13, 3, 6, 3, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 3, 7, 2, -1, -6 },
  { 22, 2, 2, 3, 1, -6 },
  { 23, 3, 4, 3, 0, -5 },
  { 25, 1, 2, 1, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 1, 0, -1 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 2, 6, 3, 1, -6 },
  { 36, 3, 6, 3, 0, -6 },
  { 39, 3, 6, 3, 0, -6 },
  { 42, 3, 6, 3, 0, -6 },
  { 45, 3, 6, 3, 0, -6 },
  { 48, 3, 6, 3, 0, -6 },
  { 51, 3, 6, 3, 0, -6 },
  { 54, 3, 6, 3, 0, -6 },
  { 57, 3, 6, 3, 0, -6 },
  { 60, 1, 4, 1, 0, -4 },
  { 61, 1, 5, 1, 0, -4 },
  { 62, 3, 4, 3, 0, -5 },
  { 64, 3, 2, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -5 },
  { 67, 2, 6, 2, 0, -6 },
  { 69, 4, 7, 4, 0, -6 },
  { 73, 3, 6, 3, -1, -6 },
  { 76, 3, 6, 3, 0, -6 },
  { 79, 4, 6, 3, 0, -6 },
  { 82, 3, 6, 4, 0, -6 },
  { 85, 3, 6, 3, 0, -6 },
  { 88, 3, 6, 3, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 6, 4, 0, -6 },
  { 97, 2, 6, 2, 0, -6 },
  { 99, 3, 7, 1, -1, -6 },
  { 102, 4, 6, 3, 0, -6 },
  { 105, 2, 6, 3, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 4, 6, 4, 0, -6 },
  { 114, 4, 6, 4, 0, -6 },
  { 117, 3, 6, 3, 0, -6 },
  { 120, 4, 7, 4, 0, -6 },
  { 124, 3, 6, 3, 0, -6 },
  { 127, 3, 6, 3, 0, -6 },
  { 130, 2, 6, 3, 1, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 3, 6, 3, 1, -6 },
  { 138, 5, 6, 5, 1, -6 },
  { 142, 3, 6, 3, 0, -6 },
  { 145, 2, 6, 3, 1, -6 },
  { 147, 3, 6, 3, 0, -6 },
  { 150, 3, 7, 2, 0, -6 },
  { 153, 1, 6, 3, 1, -6 },
  { 154, 3, 7, 2, -1, -6 },
  { 157, 3, 3, 3, 0, -6 },
  { 159, 3, 1, 2, -1, 0 },
  { 160, 1, 1, 2, 1, -6 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 3, 6, 3, 0, -6 },
  { 166, 3, 4, 2, 0, -4 },
  { 168, 4, 6, 3, 0, -6 },
  { 171, 3, 4, 3, 0, -4 },
  { 173, 4, 8, 2, -1, -6 },
  { 177, 3, 6, 3, 0, -4 },
  { 180, 3, 6, 3, 0, -6 },
  { 183, 2, 6, 1, 0, -6 },
  { 185, 3, 8, 1, -1, -6 },
  { 188, 3, 6, 3, 0, -6 },
  { 191, 2, 6, 1, 0, -6 },
  { 193, 4, 4, 5, 0, -4 },
  { 195, 3, 4, 3, 0, -4 },
  { 197, 3, 4, 3, 0, -4 },
  { 199, 3, 6, 3, 0, -4 },
  { 202, 3, 6, 3, 0, -4 },
  { 205, 2, 4, 2, 0, -4 },
  { 206, 2, 4, 2, 0, -4 },
  { 207, 2, 5, 2, 0, -5 },
  { 209, 3, 4, 3, 0, -4 },
  { 211, 3, 4, 2, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 4, 6, 3, -1, -4 },
  { 220, 2, 4, 2, 0, -4 },
  { 221, 3, 7, 3, 0, -6 },
  { 224, 1, 8, 3, 1, -6 },
  { 225, 3, 7, 3, -1, -6 },
  { 228, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC8PT7B_H_
