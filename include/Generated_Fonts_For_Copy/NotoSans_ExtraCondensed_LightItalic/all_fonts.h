#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_LightItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_LightItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_LightItalic72pt7b.h"
