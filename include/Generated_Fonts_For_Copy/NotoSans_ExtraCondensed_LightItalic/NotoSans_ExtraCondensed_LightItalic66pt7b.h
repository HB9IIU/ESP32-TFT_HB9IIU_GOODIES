#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x38, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x30, 0x60, 0x70, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x1C, 0x00,
  0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x01,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFE, 0xDF, 0x80, 0xF8, 0xC1, 0x80, 0x78, 0x60, 0x00,
  0x78, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x3C, 0x60, 0x00, 0x0F, 0x30, 0x00, 0x07, 0xD8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xDE, 0x00, 0x00,
  0x67, 0x80, 0x00, 0x31, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x18, 0x38, 0x00,
  0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x01, 0x81, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0xF0,
  0x20, 0x30, 0xF0, 0x1E, 0x19, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x03, 0xFE,
  0x00, 0x38, 0x07, 0x8E, 0x00, 0x70, 0x07, 0x0E, 0x00, 0x70, 0x0E, 0x0E,
  0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x1C, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x38, 0x0E,
  0x07, 0x00, 0x70, 0x0E, 0x06, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0E,
  0x1C, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x38, 0x00, 0x60, 0x1C,
  0x38, 0x00, 0xE0, 0x1C, 0x70, 0x00, 0xE0, 0x38, 0x70, 0x78, 0xE0, 0x38,
  0xE1, 0xFC, 0xE0, 0x38, 0xE3, 0xFE, 0xE0, 0x71, 0xC3, 0x8E, 0xE0, 0x71,
  0xC7, 0x07, 0xE0, 0xE3, 0x8F, 0x07, 0xE0, 0xE3, 0x8E, 0x07, 0x71, 0xC7,
  0x1C, 0x07, 0x7F, 0x87, 0x1C, 0x07, 0x3F, 0x0E, 0x1C, 0x07, 0x0C, 0x0E,
  0x38, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x1C, 0x38, 0x0E, 0x00, 0x38,
  0x38, 0x0E, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x70,
  0x70, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x1C, 0x01, 0xC0,
  0x70, 0x1C, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x80, 0x60, 0x38, 0x03, 0x80,
  0x60, 0x38, 0x07, 0x00, 0x60, 0x70, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x00,
  0x70, 0xE0, 0x0E, 0x00, 0x71, 0xE0, 0x1C, 0x00, 0x3F, 0xC0, 0x3C, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xF0, 0x00,
  0x3C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0,
  0x70, 0x70, 0x38, 0x38, 0x78, 0x1C, 0x3C, 0x78, 0x0F, 0x1C, 0x38, 0x07,
  0x8E, 0x1C, 0x01, 0xCF, 0x1E, 0x00, 0xE7, 0x0E, 0x00, 0x7F, 0x87, 0x00,
  0x1F, 0x83, 0x80, 0x0F, 0xC3, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0,
  0x01, 0xE0, 0x78, 0x01, 0xF8, 0x1C, 0x00, 0xFC, 0x0F, 0x00, 0xEE, 0x07,
  0x81, 0xE7, 0x81, 0xFF, 0xE3, 0xC0, 0xFF, 0xE0, 0xE0, 0x1F, 0xE0, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x9C, 0x71, 0xC7,
  0x38, 0xE3, 0x8E, 0x30, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x40, 0x60,
  0x18, 0x38, 0x0F, 0x8E, 0x01, 0xFB, 0x87, 0x1F, 0xDF, 0xC0, 0xFF, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x03, 0x8C, 0x01, 0xC3, 0x80, 0xF0,
  0xE0, 0x78, 0x1C, 0x0C, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x73,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0x83, 0xC0, 0x0E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0x01,
  0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC7, 0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C,
  0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E,
  0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0,
  0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0xE1, 0xE7, 0x8F, 0x1C, 0xF8,
  0x71, 0xC3, 0xC2, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x38, 0x07,
  0x80, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0x00, 0xF8,
  0x02, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x10, 0x00,
  0xF8, 0x0C, 0x00, 0xF8, 0x07, 0xE7, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x08, 0x00,
  0x7C, 0x03, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x86, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x7F, 0x00, 0x38, 0xFF, 0x80, 0x39, 0xFF, 0xC0,
  0x7B, 0x83, 0xE0, 0x7E, 0x01, 0xE0, 0x7E, 0x00, 0xE0, 0x7C, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80,
  0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1E, 0x00,
  0x78, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1E,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x78, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x0E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3E, 0x0E, 0x00,
  0x3E, 0x0F, 0x00, 0x7E, 0x0F, 0x00, 0x7E, 0x0F, 0x80, 0xFC, 0x07, 0xC3,
  0xDC, 0x07, 0xFF, 0xBC, 0x03, 0xFF, 0x3C, 0x00, 0xFC, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xE7, 0xE0, 0x60, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x03,
  0xFC, 0x1C, 0x38, 0x03, 0xFE, 0x0E, 0x1C, 0x03, 0xC7, 0x07, 0x0C, 0x03,
  0x83, 0x83, 0x8E, 0x03, 0x83, 0x81, 0xC7, 0x03, 0x81, 0xC0, 0xE7, 0x01,
  0xC0, 0xE0, 0x73, 0x81, 0xC0, 0x70, 0x39, 0xC0, 0xE0, 0x70, 0x1C, 0xC0,
  0xE0, 0x38, 0x0C, 0xE0, 0x70, 0x1C, 0x0E, 0x70, 0x38, 0x0E, 0x07, 0x38,
  0x18, 0x0E, 0x03, 0x9C, 0x1C, 0x07, 0x01, 0x8C, 0x0E, 0x03, 0x81, 0xCE,
  0x07, 0x03, 0xC0, 0xE7, 0x03, 0x81, 0xC0, 0x73, 0x81, 0x80, 0xE0, 0x71,
  0xC1, 0xC0, 0xF0, 0x38, 0xE0, 0xE0, 0x78, 0x18, 0x70, 0x70, 0x3C, 0x1C,
  0x38, 0x38, 0x3E, 0x0C, 0x1C, 0x0E, 0x3F, 0x0E, 0x0C, 0x07, 0x19, 0x8E,
  0x06, 0x03, 0xF8, 0xFE, 0x03, 0x00, 0xF8, 0x3E, 0x01, 0xC0, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x20, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEF, 0x00, 0x01,
  0xCF, 0x00, 0x01, 0xCF, 0x00, 0x03, 0xCF, 0x00, 0x03, 0x8F, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xC0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x1F, 0x00,
  0x38, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x03,
  0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78,
  0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x38, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF3, 0xE0, 0x01, 0xF0, 0x08,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x08, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x03, 0x80, 0x0F,
  0x80, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x0F, 0xC0, 0x07,
  0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x10, 0x78, 0x00, 0x7F, 0xC0, 0xF0, 0x01, 0xFF,
  0x81, 0xE0, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xF8,
  0x01, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x63, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0,
  0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE1, 0xC0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0x07,
  0xB8, 0x01, 0xEF, 0x00, 0x01, 0xCE, 0x00, 0x7B, 0xC0, 0x00, 0xF3, 0x80,
  0x1C, 0x70, 0x00, 0x39, 0xE0, 0x07, 0x1C, 0x00, 0x1E, 0x78, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x00,
  0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x3C,
  0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xC0,
  0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x03, 0x81,
  0xC0, 0x0E, 0x07, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x00,
  0xE0, 0x70, 0x3C, 0x0E, 0x00, 0x78, 0x1E, 0x0E, 0x03, 0x80, 0x1E, 0x07,
  0x87, 0x80, 0xE0, 0x07, 0x01, 0xE1, 0xC0, 0x78, 0x01, 0xC0, 0x78, 0xF0,
  0x1E, 0x00, 0xF0, 0x1E, 0x38, 0x07, 0x00, 0x3C, 0x03, 0x9E, 0x01, 0xC0,
  0x0E, 0x00, 0xE7, 0x00, 0xF0, 0x03, 0x80, 0x39, 0xC0, 0x3C, 0x00, 0xE0,
  0x0E, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0xB8, 0x03, 0x80, 0x1E, 0x00, 0xFE,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1F, 0x00,
  0x01, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0xF0, 0x07, 0xE0,
  0x00, 0x70, 0x03, 0xF0, 0x00, 0x38, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0xF7, 0x00, 0x0F, 0x00, 0x73, 0x80, 0x07, 0x00, 0x39,
  0xC0, 0x03, 0x80, 0x1C, 0xE0, 0x03, 0xC0, 0x1E, 0x78, 0x01, 0xE0, 0x0F,
  0x3C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03, 0x87, 0x00, 0x38, 0x01,
  0xC3, 0x80, 0x3C, 0x01, 0xE1, 0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0x0E, 0x00,
  0x70, 0x78, 0x07, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x3C, 0x0E, 0x03, 0xC0,
  0x1E, 0x07, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xE0, 0x70,
  0x03, 0x80, 0x70, 0x78, 0x03, 0xC0, 0x38, 0x3C, 0x01, 0xE0, 0x1C, 0x1E,
  0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x07, 0x87, 0x00, 0x38, 0x03, 0xC7,
  0x80, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x38,
  0xE0, 0x07, 0x00, 0x1C, 0x70, 0x07, 0x80, 0x0F, 0x78, 0x03, 0xC0, 0x07,
  0xBC, 0x01, 0xE0, 0x01, 0xDC, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x70, 0x00,
  0x77, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x1F, 0xC0, 0x1C, 0x00,
  0x0F, 0xC0, 0x0E, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x3E, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0xFC,
  0x00, 0x78, 0x0F, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0x70, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0xFC,
  0x00, 0x78, 0x0F, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0xE0, 0x07, 0xC0, 0x04, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x04, 0x00, 0x1E, 0x00, 0x70, 0x07, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03,
  0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x0F,
  0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x78,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xE0,
  0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xE3, 0x80,
  0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x00, 0x03, 0xDC,
  0x00, 0x0F, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xC0, 0x01, 0xE7, 0x00, 0x03,
  0xE0, 0x00, 0xE3, 0x80, 0x03, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0xE0, 0x01, 0xD8, 0x00, 0x38, 0xF0, 0x00, 0xEC, 0x00, 0x3C, 0x78,
  0x00, 0x7E, 0x00, 0x1C, 0x3C, 0x00, 0x77, 0x00, 0x1E, 0x1E, 0x00, 0x3B,
  0x80, 0x0F, 0x0F, 0x00, 0x3D, 0xC0, 0x07, 0x07, 0x80, 0x1C, 0xE0, 0x07,
  0x83, 0xC0, 0x0E, 0x70, 0x03, 0x81, 0xE0, 0x0E, 0x38, 0x03, 0xC0, 0xF0,
  0x07, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x8E, 0x00, 0xE0, 0x3C, 0x03, 0x87,
  0x00, 0xF0, 0x1E, 0x01, 0xC3, 0x80, 0x70, 0x0F, 0x01, 0xC1, 0xC0, 0x78,
  0x07, 0x80, 0xE0, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x70, 0x1C, 0x01, 0xE0,
  0x70, 0x38, 0x1E, 0x00, 0xF0, 0x38, 0x1C, 0x0E, 0x00, 0x78, 0x3C, 0x0E,
  0x0F, 0x00, 0x3C, 0x1C, 0x07, 0x07, 0x80, 0x1E, 0x0E, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x80, 0x71, 0xE0, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x00, 0xE1, 0xC0, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x00,
  0x1C, 0xF0, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x03, 0x9E, 0x00, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x78, 0xE0,
  0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00,
  0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80,
  0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00,
  0xF3, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0x78, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80,
  0x01, 0xC3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF1, 0xE1,
  0xC3, 0xC3, 0x87, 0x87, 0x0E, 0x0E, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0x87, 0x00, 0xFF, 0xC7, 0x01, 0xFD, 0xEF, 0x03, 0xE0, 0x6E, 0x03, 0xC0,
  0x7E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x78, 0x1B, 0x80, 0x7E, 0xFB,
  0x80, 0x3F, 0xF3, 0x80, 0x1F, 0xC3, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x01, 0xE3, 0xFC, 0x01, 0xE7,
  0xFE, 0x01, 0xCF, 0x3E, 0x01, 0xDC, 0x0F, 0x01, 0xF8, 0x0F, 0x03, 0xF0,
  0x07, 0x03, 0xE0, 0x07, 0x03, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0x76, 0x01, 0xE0, 0x77, 0x03, 0xC0, 0x77, 0xDF, 0x80, 0x63, 0xFF,
  0x00, 0xE1, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0xFC, 0x60, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x08, 0x0F, 0xEF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x03, 0xFC, 0x38, 0x00, 0xFF, 0xCF, 0x00, 0x3F, 0xBD, 0xE0,
  0x0F, 0x81, 0xB8, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78,
  0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00,
  0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00,
  0x70, 0x03, 0xE0, 0x0F, 0x00, 0xDC, 0x01, 0xE0, 0x1F, 0x80, 0x1E, 0x06,
  0xE0, 0x03, 0xF7, 0x9C, 0x00, 0x3F, 0xE3, 0x80, 0x03, 0xF8, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0x9F, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x07, 0x80, 0x70, 0xF0, 0x07,
  0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x01,
  0xE3, 0x80, 0x1C, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x70, 0x7F, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x02, 0x07, 0xF3, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xA0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x3C, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x1C, 0x00, 0x7F, 0xE3, 0x80,
  0x1F, 0xDE, 0x70, 0x07, 0xC0, 0xDC, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x01, 0xC0,
  0x01, 0xE0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x3C, 0x03, 0x80, 0x07, 0x80, 0x70, 0x01, 0xF0, 0x0E, 0x00, 0x3C, 0x01,
  0xC0, 0x07, 0x80, 0x38, 0x01, 0xF0, 0x07, 0x80, 0x7E, 0x00, 0xF0, 0x1F,
  0xC0, 0x0F, 0x07, 0x70, 0x01, 0xFB, 0xCE, 0x00, 0x1F, 0xF9, 0xC0, 0x01,
  0xFC, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x04, 0x00, 0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0xE7, 0xFC, 0x01, 0xEF, 0xFC,
  0x01, 0xDF, 0x7E, 0x01, 0xD8, 0x1E, 0x01, 0xF0, 0x0E, 0x01, 0xE0, 0x0F,
  0x03, 0xE0, 0x0E, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0xF0, 0x03, 0xC0, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x08, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xE0, 0x03, 0x81, 0xE0, 0x03, 0x83, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x87,
  0x00, 0x07, 0x8F, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x3C,
  0x00, 0x0F, 0x7C, 0x00, 0x0E, 0xFC, 0x00, 0x0F, 0xDE, 0x00, 0x0F, 0xDE,
  0x00, 0x1F, 0x9E, 0x00, 0x1F, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0xF0, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x7F,
  0x83, 0xFC, 0x01, 0xCF, 0xFC, 0x7F, 0xE0, 0x1D, 0xF7, 0xEF, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0x03, 0xE0, 0x0F, 0x00,
  0x70, 0x3E, 0x00, 0xF0, 0x07, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x3C, 0x01,
  0xE0, 0x07, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x0F, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x70, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0xF0, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x1C, 0x1E,
  0x00, 0x70, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x03,
  0x81, 0xC0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x0E,
  0x00, 0x78, 0x3C, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xE0, 0x07, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x0F,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x03, 0x8F, 0xF8, 0x07, 0x3F, 0xF0, 0x0E, 0xFB, 0xF0, 0x1D,
  0x81, 0xE0, 0x3E, 0x01, 0xC0, 0xF8, 0x03, 0x81, 0xF0, 0x07, 0x03, 0xC0,
  0x0E, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x7C, 0x03, 0xC0, 0xF8, 0x1E, 0x01, 0xE0,
  0x78, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xF1, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xE7, 0x80, 0x03,
  0x9E, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00,
  0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0xF0,
  0xE0, 0x03, 0xC3, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x78,
  0x1E, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x1C, 0x00, 0x01, 0x87, 0xF8, 0x00, 0x38, 0xFF, 0xC0,
  0x03, 0x9E, 0x7C, 0x00, 0x3B, 0x81, 0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x0F,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xEC, 0x07, 0xC0, 0x0E, 0xE0, 0xF8, 0x00, 0xEF, 0xBF, 0x00,
  0x0E, 0x7F, 0xE0, 0x01, 0xE3, 0xFC, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0x87, 0x00, 0xFF, 0xC7, 0x01, 0xFB, 0xEF,
  0x03, 0xE0, 0x6E, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0,
  0xE0, 0x03, 0xC0, 0xE0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0,
  0x78, 0x3B, 0x80, 0x7E, 0xFB, 0x80, 0x3F, 0xF3, 0x80, 0x1F, 0xC7, 0x80,
  0x07, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x7F, 0x01, 0xCF, 0xE0, 0x1D, 0xFE, 0x01, 0xDC,
  0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0xF1, 0xF0, 0x3C, 0x03, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x10, 0x01, 0xC0, 0xC0, 0x3E, 0x07, 0xEF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x0F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC0, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x03,
  0x00, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1,
  0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF8,
  0x1C, 0x01, 0xF0, 0x38, 0x07, 0xE0, 0x78, 0x1F, 0x80, 0xFF, 0xF7, 0x00,
  0xFF, 0xCE, 0x00, 0xFE, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38,
  0x01, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70,
  0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0,
  0x70, 0x1C, 0x1E, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xBC,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0xC0,
  0x1E, 0xE0, 0x07, 0xC0, 0x1C, 0xE0, 0x0F, 0xC0, 0x1C, 0xE0, 0x0F, 0xC0,
  0x3C, 0xE0, 0x1D, 0xC0, 0x38, 0xE0, 0x1D, 0xC0, 0x78, 0xE0, 0x1D, 0xC0,
  0x70, 0xE0, 0x39, 0xC0, 0x70, 0xE0, 0x39, 0xC0, 0xF0, 0xE0, 0x79, 0xC0,
  0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0xE0, 0x71, 0xC1, 0xC0, 0xE0, 0xE1, 0xC1,
  0xC0, 0xE0, 0xE1, 0xC3, 0xC0, 0xE1, 0xE1, 0xC3, 0x80, 0xE1, 0xC1, 0xC3,
  0x80, 0xE1, 0xC1, 0xC7, 0x00, 0xE3, 0x81, 0xC7, 0x00, 0xE3, 0x81, 0xCF,
  0x00, 0xE7, 0x81, 0xCE, 0x00, 0xE7, 0x01, 0xCE, 0x00, 0xE7, 0x01, 0xDC,
  0x00, 0xEE, 0x01, 0xDC, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0xEE, 0x01, 0xB8,
  0x00, 0xFC, 0x01, 0xB8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x23, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x3F, 0xE0, 0x01,
  0x7F, 0xF8, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x3F, 0xFE, 0xC0, 0x0F, 0xFC,
  0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 47, 14, 1, -47 },
  { 84, 16, 17, 20, 6, -47 },
  { 118, 27, 47, 26, 0, -47 },
  { 277, 25, 54, 24, 0, -50 },
  { 446, 32, 49, 37, 3, -48 },
  { 642, 25, 49, 25, -1, -48 },
  { 796, 6, 17, 11, 7, -47 },
  { 809, 19, 57, 16, 1, -47 },
  { 945, 19, 57, 17, -5, -47 },
  { 1081, 18, 20, 22, 7, -50 },
  { 1126, 24, 31, 27, 2, -39 },
  { 1219, 10, 16, 12, -3, -7 },
  { 1239, 15, 4, 17, 1, -20 },
  { 1247, 5, 6, 12, 1, -6 },
  { 1251, 28, 47, 21, -3, -47 },
  { 1416, 23, 49, 24, 1, -48 },
  { 1557, 14, 47, 24, 7, -47 },
  { 1640, 26, 48, 24, -2, -48 },
  { 1796, 25, 49, 24, -1, -48 },
  { 1950, 26, 48, 24, -1, -48 },
  { 2106, 26, 48, 24, -1, -47 },
  { 2262, 24, 49, 24, 2, -48 },
  { 2409, 25, 47, 24, 2, -47 },
  { 2556, 26, 49, 24, -1, -48 },
  { 2716, 24, 49, 24, 0, -48 },
  { 2863, 11, 35, 12, 0, -35 },
  { 2912, 15, 44, 12, -3, -35 },
  { 2995, 24, 28, 27, 2, -37 },
  { 3079, 24, 17, 27, 2, -32 },
  { 3130, 24, 28, 27, 2, -37 },
  { 3214, 19, 48, 17, 1, -48 },
  { 3328, 33, 53, 36, 2, -47 },
  { 3547, 24, 47, 24, -4, -47 },
  { 3688, 27, 47, 27, 0, -47 },
  { 3847, 27, 49, 24, 2, -48 },
  { 4013, 28, 47, 29, 0, -47 },
  { 4178, 26, 47, 23, 0, -47 },
  { 4331, 26, 47, 22, 0, -47 },
  { 4484, 31, 49, 31, 2, -48 },
  { 4674, 32, 47, 30, 0, -47 },
  { 4862, 23, 47, 14, -4, -47 },
  { 4998, 24, 59, 12, -10, -47 },
  { 5175, 30, 47, 25, 0, -47 },
  { 5352, 16, 47, 21, 0, -47 },
  { 5446, 42, 47, 41, 0, -47 },
  { 5693, 33, 47, 32, 0, -47 },
  { 5887, 28, 49, 31, 2, -48 },
  { 6059, 26, 47, 25, 0, -47 },
  { 6212, 28, 59, 31, 2, -48 },
  { 6419, 26, 47, 26, 0, -47 },
  { 6572, 28, 49, 24, -2, -48 },
  { 6744, 22, 47, 21, 4, -47 },
  { 6874, 29, 48, 30, 2, -47 },
  { 7048, 24, 47, 25, 6, -47 },
  { 7189, 41, 47, 41, 5, -47 },
  { 7430, 31, 47, 22, -4, -47 },
  { 7613, 23, 47, 21, 4, -47 },
  { 7749, 28, 47, 21, -3, -47 },
  { 7914, 24, 58, 18, -1, -47 },
  { 8088, 9, 47, 22, 7, -47 },
  { 8141, 24, 58, 18, -4, -47 },
  { 8315, 25, 24, 26, 1, -47 },
  { 8390, 19, 3, 19, -5, 6 },
  { 8398, 7, 10, 15, 10, -50 },
  { 8407, 24, 37, 26, 2, -36 },
  { 8518, 24, 51, 26, 0, -50 },
  { 8671, 19, 37, 19, 2, -36 },
  { 8759, 27, 51, 26, 2, -50 },
  { 8932, 20, 37, 23, 2, -36 },
  { 9025, 29, 66, 14, -8, -50 },
  { 9265, 27, 52, 26, -1, -36 },
  { 9441, 24, 50, 25, 0, -50 },
  { 9591, 14, 48, 11, 0, -48 },
  { 9675, 23, 64, 12, -9, -48 },
  { 9859, 24, 50, 22, 0, -50 },
  { 10009, 14, 50, 11, 0, -50 },
  { 10097, 36, 36, 38, 0, -36 },
  { 10259, 23, 36, 25, 0, -36 },
  { 10363, 22, 37, 25, 2, -36 },
  { 10465, 28, 51, 26, -3, -36 },
  { 10644, 24, 52, 26, 2, -36 },
  { 10800, 20, 36, 17, 0, -36 },
  { 10890, 21, 37, 19, -1, -36 },
  { 10988, 14, 44, 14, 1, -43 },
  { 11065, 23, 36, 25, 2, -35 },
  { 11169, 19, 35, 20, 4, -35 },
  { 11253, 32, 35, 33, 4, -35 },
  { 11393, 26, 35, 21, -3, -35 },
  { 11507, 31, 51, 21, -7, -35 },
  { 11705, 21, 35, 17, -2, -35 },
  { 11797, 23, 57, 21, 2, -47 },
  { 11961, 3, 66, 23, 10, -50 },
  { 11986, 23, 57, 21, -4, -47 },
  { 12150, 24, 7, 27, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC66PT7B_H_
