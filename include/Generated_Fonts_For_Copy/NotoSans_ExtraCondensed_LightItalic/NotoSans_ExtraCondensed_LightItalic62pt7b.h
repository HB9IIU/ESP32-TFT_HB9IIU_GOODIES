#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x00, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xC1, 0xE3, 0x83, 0xC7, 0x07,
  0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x86,
  0x07, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x38, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xF3, 0x0E, 0x01, 0xC3, 0x02,
  0x03, 0x83, 0x00, 0x03, 0x83, 0x00, 0x07, 0x83, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x86, 0x00,
  0x03, 0x8C, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xEC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x37, 0x80, 0x00, 0x33, 0xC0, 0x00, 0x31, 0xC0,
  0x00, 0x31, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0,
  0x00, 0xC1, 0xC0, 0x80, 0xC3, 0xC0, 0xC0, 0xC7, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0x80, 0x7F,
  0xC0, 0x0C, 0x01, 0xC7, 0x00, 0x70, 0x0E, 0x1C, 0x01, 0x80, 0x70, 0x70,
  0x0E, 0x01, 0xC0, 0xC0, 0x30, 0x0E, 0x03, 0x01, 0xC0, 0x38, 0x1C, 0x06,
  0x00, 0xE0, 0x70, 0x38, 0x07, 0x01, 0xC0, 0xC0, 0x1C, 0x07, 0x07, 0x00,
  0x70, 0x1C, 0x18, 0x01, 0xC0, 0x70, 0xE0, 0x06, 0x01, 0x83, 0x00, 0x38,
  0x0E, 0x1C, 0x00, 0xE0, 0x38, 0x60, 0x03, 0x80, 0xE3, 0x80, 0x0E, 0x03,
  0x0C, 0x1F, 0x38, 0x1C, 0x71, 0xFE, 0xE0, 0x71, 0x87, 0xFB, 0x83, 0x8E,
  0x38, 0x6E, 0x0E, 0x31, 0xC1, 0xF8, 0x71, 0xC7, 0x07, 0xE3, 0xC6, 0x38,
  0x1D, 0xFE, 0x38, 0xE0, 0x77, 0xF0, 0xC7, 0x01, 0xC7, 0x07, 0x1C, 0x07,
  0x00, 0x18, 0x70, 0x18, 0x00, 0xE1, 0x80, 0xE0, 0x07, 0x0E, 0x03, 0x80,
  0x1C, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x38, 0x03, 0x83, 0x80, 0xE0, 0x1C,
  0x0C, 0x07, 0x00, 0x70, 0x30, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x07,
  0x03, 0x80, 0x70, 0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x03, 0x07, 0x01, 0xC0, 0x0E, 0x38, 0x07, 0x00, 0x3F, 0xC0,
  0x38, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0F,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0,
  0x70, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x3C, 0x1C, 0x3C,
  0x38, 0x38, 0x70, 0x70, 0x71, 0xC0, 0xE1, 0xC7, 0x81, 0xE3, 0x8E, 0x01,
  0xCF, 0x3C, 0x03, 0x9C, 0x70, 0x07, 0x38, 0xE0, 0x0F, 0xE1, 0xC0, 0x0F,
  0xC3, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x38, 0x03, 0xF0, 0x70, 0x0E, 0xE0, 0xF0, 0x3D, 0xC0, 0xF9, 0xF3, 0xC1,
  0xFF, 0xC3, 0x81, 0xFE, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x38, 0xF1,
  0xE3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x04, 0x0C, 0x07, 0x0E, 0x03, 0xE7, 0x02, 0xFF,
  0x9F, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xE6, 0x01,
  0xE3, 0x81, 0xE1, 0xC1, 0xE0, 0x70, 0x20, 0x3C, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x33, 0xBF, 0xEF, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0x3E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0x80,
  0x70, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E,
  0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x38,
  0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00,
  0x71, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x78, 0x07, 0x80, 0xFC, 0x0F, 0xE0, 0xF7, 0x0F, 0x78, 0xF3, 0x9F, 0x1C,
  0xE0, 0xE2, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x83, 0xE0,
  0x07, 0x00, 0xF0, 0x01, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xE0, 0x1E, 0x00,
  0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x80,
  0x1F, 0x00, 0xF0, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xDE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x1C, 0x00, 0x06, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xF0, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x70,
  0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x80, 0x1F, 0x00, 0xF8, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x10, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x71, 0xFC, 0x00, 0xE7, 0xFE, 0x03, 0x9F, 0xFC, 0x07, 0x70, 0x3C, 0x0F,
  0x80, 0x78, 0x1F, 0x00, 0x70, 0x7C, 0x00, 0xE0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0xE0,
  0x38, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x70, 0x3C, 0x00, 0xF9, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x01, 0xE0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xF0,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0x80, 0x07, 0x83, 0xC0, 0x0F, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x78, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0xF0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x9F,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3E, 0x1E, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x38, 0x01, 0xE0, 0xE0,
  0x0F, 0x83, 0xC0, 0x7E, 0x0F, 0x83, 0xB8, 0x1F, 0xFD, 0xE0, 0x3F, 0xE7,
  0x00, 0x7E, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1C, 0x3E, 0x04, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x1F, 0xE1, 0xC3,
  0x80, 0xFF, 0x83, 0x86, 0x03, 0xC7, 0x07, 0x1C, 0x07, 0x0E, 0x0E, 0x30,
  0x1C, 0x1C, 0x1C, 0xE0, 0x70, 0x30, 0x39, 0xC0, 0xE0, 0xE0, 0x73, 0x03,
  0x81, 0xC0, 0xEE, 0x07, 0x03, 0x81, 0x9C, 0x0C, 0x06, 0x03, 0x38, 0x38,
  0x1C, 0x0E, 0x60, 0x70, 0x38, 0x1C, 0xC0, 0xC0, 0x70, 0x3B, 0x83, 0x80,
  0xC0, 0x67, 0x07, 0x03, 0x81, 0xCE, 0x0E, 0x07, 0x03, 0x9C, 0x1C, 0x0E,
  0x06, 0x38, 0x38, 0x3C, 0x1C, 0x60, 0x70, 0x70, 0x30, 0xC0, 0xE1, 0xE0,
  0xE1, 0x81, 0xC3, 0xC1, 0x83, 0x03, 0x8D, 0xC7, 0x06, 0x07, 0xF9, 0xFC,
  0x0C, 0x07, 0xE3, 0xF0, 0x18, 0x07, 0x83, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00,
  0x39, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x07,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00,
  0x78, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03, 0x80,
  0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1C, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0x70, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xF0, 0xE0, 0x07, 0xC0, 0x10, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x80, 0x07, 0xF7, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x3E, 0x00,
  0x70, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0x10, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x0E, 0x00, 0x3F, 0xF0, 0x70, 0x01,
  0xFF, 0x03, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0F,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x77, 0x00, 0x76, 0x00, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x03, 0xFC,
  0x03, 0xDC, 0x00, 0x07, 0x70, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x00, 0xF7, 0x80, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0xF3, 0x80, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x71, 0xE0, 0x1E, 0x38, 0x00, 0xE3,
  0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x38, 0x78, 0x07, 0x87, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x07, 0x83, 0x80, 0x38,
  0x38, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x70,
  0x38, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x0E,
  0x03, 0x87, 0x03, 0xC0, 0x3C, 0x07, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x38,
  0x0E, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0x01, 0xC0, 0x39, 0xC0, 0x38, 0x03,
  0x80, 0x77, 0x00, 0xF0, 0x0F, 0x00, 0xEE, 0x01, 0xC0, 0x1C, 0x01, 0xF8,
  0x03, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0x70, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x1C, 0x01,
  0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x01, 0xC0, 0x1F,
  0x80, 0x03, 0x80, 0x3B, 0x80, 0x07, 0x00, 0x77, 0x00, 0x1E, 0x00, 0xEE,
  0x00, 0x3C, 0x03, 0xDC, 0x00, 0x70, 0x07, 0x38, 0x00, 0xE0, 0x0E, 0x78,
  0x01, 0xC0, 0x1C, 0x70, 0x07, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xF1, 0xC0,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x87, 0x00, 0x70, 0x07, 0x0F, 0x01,
  0xE0, 0x1E, 0x0E, 0x03, 0x80, 0x3C, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x0E,
  0x00, 0xE0, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0xE0,
  0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x07, 0x0F, 0x00,
  0x70, 0x0E, 0x1C, 0x01, 0xE0, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x70, 0x07,
  0x00, 0x38, 0xE0, 0x0E, 0x00, 0x73, 0xC0, 0x3C, 0x00, 0xE7, 0x00, 0x78,
  0x01, 0xCE, 0x00, 0xE0, 0x03, 0xDC, 0x01, 0xC0, 0x03, 0xB8, 0x03, 0x80,
  0x07, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x1F, 0x80, 0x38, 0x00,
  0x3F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0xF0, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x1C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x0E,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xFB,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x70, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0F,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x3C,
  0x07, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x07, 0x07, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00,
  0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x70, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x3C, 0x07,
  0x80, 0x7C, 0x07, 0x00, 0xF8, 0x07, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x70,
  0x03, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xF0,
  0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x80, 0x03, 0xE0, 0x18, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x70,
  0x1E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1C,
  0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0xEF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xC0,
  0x1E, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x78, 0x01,
  0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x3C, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0xF0, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF0, 0x00, 0x73, 0x80, 0x03,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x80, 0x07,
  0x1C, 0x00, 0x3F, 0x00, 0x1E, 0x38, 0x00, 0x7E, 0x00, 0x38, 0x70, 0x01,
  0xDC, 0x00, 0x70, 0xE0, 0x03, 0xB8, 0x01, 0xE1, 0xC0, 0x07, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0xE0, 0x0F, 0x07, 0x00, 0x39, 0xC0, 0x1C, 0x0E, 0x00,
  0x63, 0x80, 0x38, 0x1C, 0x01, 0xC7, 0x00, 0xF0, 0x38, 0x03, 0x8C, 0x01,
  0xC0, 0x70, 0x0E, 0x18, 0x07, 0x80, 0xE0, 0x1C, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x60, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x78, 0x07, 0x01, 0xC3, 0x80,
  0xE0, 0x0E, 0x07, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x70,
  0x70, 0x01, 0xC3, 0x80, 0xE1, 0xE0, 0x03, 0x87, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x0E,
  0x38, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0x07, 0x70, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x38, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07, 0x81, 0xC0, 0x38,
  0x0E, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x70,
  0xF0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00,
  0x1C, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0xC0, 0x07,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0xC0,
  0x1C, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x78, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x07,
  0x06, 0x00, 0x08, 0x00, 0x01, 0xFC, 0x30, 0x0F, 0xF9, 0xC0, 0x7C, 0xF7,
  0x03, 0xC0, 0xDC, 0x1E, 0x03, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00,
  0x71, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3,
  0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x1E,
  0x0E, 0x00, 0x78, 0x38, 0x03, 0xE0, 0xE0, 0x0F, 0x83, 0xC0, 0x6E, 0x0F,
  0x03, 0xF0, 0x1F, 0x3D, 0xC0, 0x3F, 0xE7, 0x00, 0xFF, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x71, 0xFC, 0x00, 0xE7, 0xFC,
  0x01, 0xDE, 0x7C, 0x07, 0xF0, 0x78, 0x0E, 0xC0, 0x78, 0x1F, 0x00, 0xF0,
  0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0,
  0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00,
  0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0,
  0xF8, 0x03, 0x81, 0xF0, 0x0F, 0x03, 0xB0, 0x3C, 0x06, 0x79, 0xF0, 0x1C,
  0x7F, 0xC0, 0x38, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xC6, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x81, 0xF1, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x60, 0xF0, 0x01,
  0xFC, 0x70, 0x01, 0xFF, 0x38, 0x01, 0xF3, 0xDC, 0x01, 0xE0, 0x6E, 0x01,
  0xE0, 0x3F, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x70, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x00,
  0x1E, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x80, 0x70,
  0x07, 0xC0, 0x3C, 0x06, 0xC0, 0x1E, 0x06, 0xE0, 0x07, 0xCF, 0x70, 0x03,
  0xFF, 0x38, 0x00, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x3C, 0x1E, 0x0F, 0x01, 0xC3,
  0xC0, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x1C,
  0x00, 0xE7, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x07, 0xC3, 0x83, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0x03, 0xE1,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x60, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xF0, 0xC0, 0x07, 0xFC, 0xE0, 0x07, 0xCF, 0x70, 0x07,
  0x81, 0xB8, 0x07, 0x80, 0xDC, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x81, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x03, 0x80,
  0x3E, 0x01, 0xC0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x1F, 0x80, 0x1F,
  0x3D, 0xC0, 0x0F, 0xFC, 0xE0, 0x03, 0xFC, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x08, 0x01, 0xE0, 0x07, 0x03, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x1C,
  0x7F, 0x00, 0x77, 0xFE, 0x01, 0xDE, 0xFC, 0x0E, 0xC0, 0xF0, 0x3E, 0x01,
  0xC0, 0xF8, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0,
  0x1E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x1E, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x3C,
  0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01,
  0xC1, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81,
  0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0xE0, 0x0E, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xDF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xCE, 0x00, 0x1F, 0x1C, 0x00, 0x3C, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x71, 0xFC, 0x1F, 0xC0, 0x1D, 0xFF, 0x9F, 0xF8, 0x06, 0xF3, 0xEF, 0xBF,
  0x03, 0xB0, 0x3B, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0x70, 0x3C, 0x03, 0xE0,
  0x1C, 0x0F, 0x00, 0xF0, 0x07, 0x03, 0x80, 0x3C, 0x01, 0xC1, 0xE0, 0x0E,
  0x00, 0x70, 0x78, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0x0E, 0x07, 0x00,
  0x78, 0x03, 0x83, 0xC0, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x00, 0x38, 0x38,
  0x01, 0xC0, 0x1E, 0x0E, 0x00, 0x70, 0x07, 0x03, 0x80, 0x3C, 0x01, 0xC1,
  0xE0, 0x0E, 0x00, 0x70, 0x78, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0x0E,
  0x07, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0x1E, 0x0E, 0x00, 0x70, 0x07, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x78, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0x0F, 0x07, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x1E, 0x00, 0xE0, 0xF0,
  0x07, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x80, 0x07,
  0x1F, 0xC0, 0x1D, 0xFF, 0x80, 0x67, 0xBF, 0x03, 0xB0, 0x3C, 0x0F, 0x80,
  0x70, 0x3E, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0xF0,
  0x78, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0,
  0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07,
  0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0F,
  0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0xF0, 0x03, 0x83, 0xC0, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0x3E, 0x03, 0x81, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0xF0,
  0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00,
  0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0,
  0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x70, 0x3C, 0x07,
  0xCF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x0E, 0x3F, 0x80, 0x03, 0x9F, 0xF0, 0x00, 0xEF, 0x3E, 0x00,
  0x77, 0x07, 0x80, 0x1D, 0x80, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x1E, 0x00,
  0xEC, 0x0F, 0x00, 0x3B, 0xCF, 0x80, 0x0E, 0x7F, 0xC0, 0x07, 0x8F, 0xE0,
  0x01, 0xC0, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xFC, 0x30, 0x0F, 0xF9, 0xC0, 0x7C, 0xF7, 0x03, 0xC0, 0xDC,
  0x1E, 0x03, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70,
  0x01, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01,
  0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8F,
  0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x1E, 0x0E, 0x00, 0x78,
  0x38, 0x03, 0xE0, 0xE0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x03, 0xF0, 0x1F,
  0x3D, 0xC0, 0x7F, 0xE7, 0x00, 0xFF, 0x3C, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xA0, 0x38, 0xF8, 0x06, 0x7F, 0x00, 0xCF, 0xE0, 0x3B,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0x1E, 0x03, 0xC0, 0x20, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x80, 0x3C, 0x0F, 0x0F, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x81, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x10, 0x1F, 0xC0,
  0x7F, 0x00, 0x30, 0x00, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0,
  0x0E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC3,
  0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x78,
  0x38, 0x03, 0xC1, 0xC0, 0x3E, 0x0E, 0x03, 0xE0, 0x70, 0x3F, 0x03, 0xE7,
  0xB8, 0x0F, 0xF9, 0xC0, 0x7F, 0x8E, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x03,
  0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCE,
  0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E,
  0x70, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0x80, 0x39, 0xC0, 0x1F, 0x00,
  0x73, 0x80, 0x3E, 0x01, 0xE7, 0x00, 0x7C, 0x03, 0x8E, 0x01, 0xF8, 0x07,
  0x1C, 0x03, 0xF0, 0x1C, 0x38, 0x0E, 0xE0, 0x38, 0x70, 0x1D, 0xC0, 0xF0,
  0xE0, 0x33, 0x81, 0xC1, 0xC0, 0xE7, 0x03, 0x83, 0x81, 0xCE, 0x0E, 0x07,
  0x07, 0x1C, 0x1C, 0x0E, 0x0E, 0x38, 0x38, 0x1C, 0x18, 0x70, 0xE0, 0x38,
  0x70, 0xE1, 0xC0, 0x70, 0xE1, 0xC7, 0x00, 0xE3, 0x83, 0x0E, 0x01, 0xC7,
  0x06, 0x1C, 0x03, 0x8C, 0x0C, 0x70, 0x07, 0x38, 0x18, 0xE0, 0x0E, 0x70,
  0x33, 0x80, 0x1D, 0xC0, 0x67, 0x00, 0x3B, 0x80, 0xCE, 0x00, 0x76, 0x01,
  0xB8, 0x00, 0xDC, 0x07, 0x70, 0x01, 0xB8, 0x0E, 0xC0, 0x03, 0x60, 0x1F,
  0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x70, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01,
  0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x03, 0x83, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x08, 0x78, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFA, 0x00, 0x1F,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 44, 14, 1, -44 },
  { 73, 15, 16, 18, 6, -44 },
  { 103, 26, 44, 24, 0, -44 },
  { 246, 24, 51, 23, 0, -47 },
  { 399, 30, 46, 35, 3, -45 },
  { 572, 23, 46, 23, -1, -45 },
  { 705, 7, 16, 10, 6, -44 },
  { 719, 18, 54, 15, 1, -44 },
  { 841, 17, 54, 16, -4, -44 },
  { 956, 17, 18, 21, 7, -47 },
  { 995, 22, 29, 26, 2, -36 },
  { 1075, 10, 14, 11, -3, -6 },
  { 1093, 14, 3, 16, 1, -18 },
  { 1099, 5, 6, 11, 1, -6 },
  { 1103, 27, 44, 19, -3, -44 },
  { 1252, 22, 46, 23, 1, -45 },
  { 1379, 13, 44, 23, 7, -44 },
  { 1451, 25, 45, 23, -2, -45 },
  { 1592, 24, 46, 23, -1, -45 },
  { 1730, 24, 45, 23, -1, -45 },
  { 1865, 24, 45, 23, -1, -44 },
  { 2000, 23, 46, 23, 1, -45 },
  { 2133, 23, 44, 23, 2, -44 },
  { 2260, 24, 46, 23, -1, -45 },
  { 2398, 22, 46, 23, 0, -45 },
  { 2525, 11, 33, 11, 0, -33 },
  { 2571, 14, 41, 11, -3, -33 },
  { 2643, 22, 26, 26, 2, -35 },
  { 2715, 22, 16, 26, 2, -30 },
  { 2759, 22, 26, 26, 2, -35 },
  { 2831, 18, 45, 16, 1, -45 },
  { 2933, 31, 50, 34, 2, -45 },
  { 3127, 22, 44, 23, -4, -44 },
  { 3248, 25, 44, 25, 0, -44 },
  { 3386, 25, 46, 22, 2, -45 },
  { 3530, 26, 44, 27, 0, -44 },
  { 3673, 24, 44, 22, 0, -44 },
  { 3805, 25, 44, 20, 0, -44 },
  { 3943, 29, 46, 29, 2, -45 },
  { 4110, 30, 44, 29, 0, -44 },
  { 4275, 21, 44, 13, -3, -44 },
  { 4391, 22, 55, 11, -9, -44 },
  { 4543, 28, 44, 23, 0, -44 },
  { 4697, 15, 44, 20, 0, -44 },
  { 4780, 39, 44, 38, 0, -44 },
  { 4995, 31, 44, 30, 0, -44 },
  { 5166, 26, 46, 29, 2, -45 },
  { 5316, 24, 44, 23, 0, -44 },
  { 5448, 26, 56, 29, 2, -45 },
  { 5630, 24, 44, 24, 0, -44 },
  { 5762, 26, 46, 22, -2, -45 },
  { 5912, 21, 44, 20, 4, -44 },
  { 6028, 27, 45, 28, 2, -44 },
  { 6180, 23, 44, 23, 5, -44 },
  { 6307, 39, 44, 39, 4, -44 },
  { 6522, 29, 44, 21, -4, -44 },
  { 6682, 21, 44, 20, 4, -44 },
  { 6798, 27, 44, 20, -3, -44 },
  { 6947, 22, 54, 17, -1, -44 },
  { 7096, 9, 44, 20, 6, -44 },
  { 7146, 23, 54, 17, -4, -44 },
  { 7302, 23, 22, 24, 1, -44 },
  { 7366, 18, 3, 17, -5, 5 },
  { 7373, 7, 9, 14, 9, -47 },
  { 7381, 22, 35, 25, 2, -34 },
  { 7478, 23, 48, 24, 0, -47 },
  { 7616, 18, 35, 18, 2, -34 },
  { 7695, 25, 48, 25, 2, -47 },
  { 7845, 19, 35, 22, 2, -34 },
  { 7929, 28, 62, 13, -8, -47 },
  { 8146, 25, 49, 25, -1, -34 },
  { 8300, 22, 47, 24, 0, -47 },
  { 8430, 13, 45, 11, 0, -45 },
  { 8504, 21, 60, 11, -8, -45 },
  { 8662, 23, 47, 20, 0, -47 },
  { 8798, 13, 47, 10, 0, -47 },
  { 8875, 34, 34, 36, 0, -34 },
  { 9020, 22, 34, 24, 0, -34 },
  { 9114, 20, 35, 24, 2, -34 },
  { 9202, 26, 48, 24, -3, -34 },
  { 9358, 22, 49, 25, 2, -34 },
  { 9493, 19, 34, 16, 0, -34 },
  { 9574, 20, 35, 18, -1, -34 },
  { 9662, 14, 42, 13, 1, -41 },
  { 9736, 21, 34, 24, 2, -33 },
  { 9826, 18, 33, 19, 4, -33 },
  { 9901, 31, 33, 31, 3, -33 },
  { 10029, 25, 33, 19, -3, -33 },
  { 10133, 29, 48, 20, -6, -33 },
  { 10307, 20, 33, 16, -2, -33 },
  { 10390, 22, 54, 20, 2, -44 },
  { 10539, 3, 62, 22, 9, -47 },
  { 10563, 22, 54, 20, -4, -44 },
  { 10712, 22, 6, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC62PT7B_H_
