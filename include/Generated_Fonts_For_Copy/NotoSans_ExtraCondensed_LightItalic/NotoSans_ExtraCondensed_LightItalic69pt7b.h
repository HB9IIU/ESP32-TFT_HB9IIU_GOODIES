#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x1C,
  0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78,
  0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0,
  0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xDF, 0xC0, 0x1F, 0x18, 0x38, 0x07, 0x83, 0x02, 0x00, 0xE0, 0x60, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x83, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0xE1, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0xB0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x03,
  0x0F, 0x00, 0x00, 0x61, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x0C, 0x0F, 0x00, 0x01, 0x81, 0xC0, 0x40, 0x30, 0x78, 0x0C,
  0x06, 0x3E, 0x01, 0xF1, 0xDF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0x00, 0xFF, 0x80, 0x07, 0x00, 0x71, 0xE0, 0x07, 0x00, 0x70, 0x70, 0x03,
  0x80, 0x78, 0x38, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x3C, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0,
  0x70, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x38, 0x01, 0xC0, 0x38,
  0x38, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x70, 0x0E,
  0x0E, 0x00, 0x38, 0x07, 0x0E, 0x00, 0x1C, 0x03, 0x87, 0x00, 0x0E, 0x03,
  0x87, 0x00, 0x0E, 0x01, 0xC3, 0x83, 0xE7, 0x00, 0xE3, 0x87, 0xFB, 0x80,
  0xE1, 0xC7, 0xFF, 0xC0, 0x71, 0xC3, 0x87, 0xE0, 0x78, 0xE3, 0x83, 0xF0,
  0x38, 0xE3, 0xC1, 0xDC, 0x38, 0x71, 0xC0, 0xEE, 0x3C, 0x70, 0xE0, 0x77,
  0xFC, 0x38, 0xE0, 0x39, 0xFC, 0x38, 0x70, 0x1C, 0x78, 0x1C, 0x78, 0x0E,
  0x00, 0x1C, 0x38, 0x07, 0x00, 0x0E, 0x1C, 0x03, 0x80, 0x0E, 0x0E, 0x01,
  0xC0, 0x07, 0x0F, 0x00, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x03, 0x83, 0x80,
  0x70, 0x03, 0x81, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x1C,
  0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x03, 0xC0, 0x38, 0x01,
  0xC1, 0xC0, 0x3C, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0x79, 0xE0, 0x1E, 0x00,
  0x3F, 0xE0, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x03, 0xC1, 0xC1, 0xC0,
  0xE0, 0xF0, 0x78, 0x38, 0x78, 0x1E, 0x1E, 0x1C, 0x03, 0x87, 0x0F, 0x00,
  0xF1, 0xC3, 0x80, 0x3C, 0xF1, 0xE0, 0x0F, 0x38, 0x78, 0x01, 0xDE, 0x1C,
  0x00, 0x7F, 0x07, 0x00, 0x1F, 0xC3, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xE0, 0x78, 0x03,
  0xF8, 0x1E, 0x01, 0xFE, 0x07, 0xC0, 0xF3, 0xC0, 0xFF, 0xF8, 0xF0, 0x1F,
  0xFC, 0x3C, 0x03, 0xFE, 0x07, 0x80, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0xF1,
  0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x20, 0x38, 0x0E, 0x0E, 0x03, 0xE3, 0x80,
  0xFC, 0xC1, 0xCF, 0xF7, 0xF0, 0x7F, 0xFC, 0x07, 0xF0, 0x03, 0xE0, 0x01,
  0xD8, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x7C, 0x38, 0x3E, 0x07, 0x07, 0x01,
  0xC0, 0x80, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x07, 0x01,
  0xE0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0,
  0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x70,
  0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x78,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xF8, 0x3D, 0xE3, 0xE7, 0x9F, 0x1C, 0xF8, 0xF3, 0xC3, 0xC4, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x20, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0x80,
  0x7C, 0x00, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x01, 0x00, 0x0F, 0x80, 0x30, 0x03, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x70, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x08, 0x00, 0x7C, 0x01, 0x80, 0x1F,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xF8, 0x60, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x80, 0x03, 0xC7, 0xF8, 0x01, 0xE7, 0xFE, 0x00,
  0xE7, 0xFF, 0x80, 0xF7, 0x03, 0xE0, 0x7F, 0x00, 0xF0, 0x3F, 0x00, 0x78,
  0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x87,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x78,
  0x00, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x79,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x0F, 0x80,
  0x78, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xE7, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x1C, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x78, 0x38, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3F, 0x07, 0x80,
  0x3F, 0x81, 0xE0, 0x3B, 0x80, 0xF8, 0x3D, 0xC0, 0x3F, 0xFD, 0xE0, 0x1F,
  0xF8, 0xF0, 0x03, 0xF8, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x02, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7C, 0x7E, 0x03, 0x01, 0xF0, 0x40, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x07, 0xC0, 0x38, 0x38, 0x03, 0xFF, 0x07, 0x0F, 0x00, 0xFF,
  0xC0, 0xE1, 0xC0, 0x3C, 0x38, 0x1C, 0x38, 0x0E, 0x07, 0x03, 0x8E, 0x03,
  0xC1, 0xC0, 0x71, 0xC0, 0x70, 0x38, 0x0E, 0x38, 0x1C, 0x07, 0x03, 0x8E,
  0x03, 0x80, 0xE0, 0x71, 0xC0, 0xE0, 0x38, 0x0E, 0x38, 0x1C, 0x07, 0x01,
  0xCE, 0x03, 0x80, 0xE0, 0x39, 0xC0, 0xE0, 0x1C, 0x07, 0x38, 0x1C, 0x07,
  0x01, 0xC7, 0x03, 0x80, 0xE0, 0x38, 0xE0, 0x70, 0x1C, 0x07, 0x38, 0x1C,
  0x07, 0x80, 0xC7, 0x03, 0x80, 0xE0, 0x38, 0xE0, 0x70, 0x1C, 0x07, 0x1C,
  0x0E, 0x07, 0x80, 0xC3, 0x81, 0xC0, 0xF0, 0x38, 0x70, 0x38, 0x1E, 0x06,
  0x0E, 0x07, 0x07, 0xC1, 0xC1, 0xC0, 0xE0, 0xF8, 0x70, 0x38, 0x1E, 0x33,
  0x0E, 0x07, 0x03, 0xFE, 0x7F, 0x80, 0xE0, 0x3F, 0x8F, 0xE0, 0x1C, 0x03,
  0xE0, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x01, 0xF0,
  0x06, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1C,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0x80, 0x7E, 0x00, 0x38,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x01,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x3F,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x78, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x38,
  0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x07, 0x81, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xF3, 0xE0, 0x03, 0xF0, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x60, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x70, 0x3F, 0x80, 0x03, 0x80, 0x3E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x7E, 0x00,
  0x3C, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x06, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0x7F, 0xE0, 0x78,
  0x00, 0x7F, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xF4, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x43, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xE7, 0xC0, 0x00,
  0x03, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xEE, 0x00, 0x00,
  0x1F, 0x9C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x77, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x00, 0x03, 0xBC, 0x00, 0xF7, 0x00,
  0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x00,
  0xF7, 0x80, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0x00, 0x01, 0xE7,
  0x80, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x01, 0xE7, 0x00, 0x03, 0xC7, 0x00,
  0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x78,
  0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x1E, 0x00, 0x78, 0x38, 0x03, 0xC1,
  0xC0, 0x07, 0x03, 0x80, 0x38, 0x3C, 0x00, 0x70, 0x38, 0x07, 0x83, 0xC0,
  0x0F, 0x03, 0x80, 0x70, 0x3C, 0x00, 0xF0, 0x38, 0x0F, 0x03, 0xC0, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x01, 0xE0, 0x38, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0x83,
  0xC0, 0x70, 0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x87, 0x80,
  0xF0, 0x01, 0xC0, 0x38, 0x70, 0x0F, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0xF0,
  0x03, 0xC0, 0x3C, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0xDE, 0x00, 0xE0, 0x03,
  0x80, 0x3D, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0x80,
  0x3F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xC0, 0x07, 0x00, 0x3F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x1F,
  0xC0, 0x00, 0xE0, 0x03, 0xB8, 0x00, 0x1C, 0x00, 0x77, 0x80, 0x07, 0x80,
  0x1E, 0xF0, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0x1E, 0x00, 0x79, 0xC0, 0x03,
  0x80, 0x0E, 0x38, 0x00, 0x70, 0x01, 0xC7, 0x00, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x00, 0x38,
  0x38, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x0F, 0x00,
  0x3C, 0x1E, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x0F,
  0x00, 0x3C, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0xF0, 0x1C,
  0x07, 0x00, 0x1C, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x78, 0x3C, 0x00, 0xF0,
  0x07, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0x1C, 0x1C, 0x00,
  0x70, 0x03, 0xC3, 0x80, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x03,
  0x8E, 0x00, 0x38, 0x00, 0x7B, 0xC0, 0x0F, 0x00, 0x0F, 0x78, 0x01, 0xE0,
  0x01, 0xEE, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x07, 0x00, 0x03, 0xB8, 0x01,
  0xE0, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x01, 0xF8,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1C,
  0x0F, 0xC0, 0x03, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x78, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x80, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xCF,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1C, 0x0F, 0xC0, 0x03, 0x80, 0x7C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x70,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x03, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00,
  0x38, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0x00,
  0x3E, 0x00, 0x10, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x20, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x38, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xE7, 0x00,
  0x01, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0xC0, 0x01, 0xE3, 0x80, 0x03, 0xF8, 0x00, 0x78, 0x70, 0x00, 0x77, 0x00,
  0x0F, 0x0E, 0x00, 0x0E, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x9C, 0x00, 0x78,
  0x38, 0x00, 0x77, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0xF0, 0x03, 0xC0, 0xE0,
  0x03, 0x9C, 0x00, 0x78, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x03, 0x80, 0x1E,
  0x70, 0x03, 0xC0, 0x70, 0x03, 0x8E, 0x00, 0x78, 0x0E, 0x00, 0x71, 0xC0,
  0x0E, 0x01, 0xC0, 0x1C, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x87, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x83, 0x80, 0x70, 0x07, 0x80, 0xE0, 0x70, 0x1E, 0x00, 0xF0, 0x1C,
  0x0E, 0x03, 0x80, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x00, 0x78, 0x1C, 0x07, 0x03, 0x80, 0x0F, 0x07, 0x80, 0xE0, 0xF0,
  0x01, 0xE0, 0xE0, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x03, 0x87, 0x80, 0x07,
  0x87, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xE0, 0x0E, 0x1C, 0x00, 0x1E, 0x3C,
  0x01, 0xC7, 0x80, 0x03, 0xC7, 0x00, 0x38, 0xF0, 0x00, 0x79, 0xE0, 0x07,
  0x3C, 0x00, 0x0F, 0x38, 0x00, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x3C, 0xE0,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x00,
  0xF7, 0x00, 0x1D, 0xE0, 0x00, 0x1D, 0xC0, 0x03, 0xBC, 0x00, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0x87, 0x80, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x70, 0x07, 0x80, 0xE0, 0x0F,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00,
  0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x0E, 0x06, 0x07, 0x00, 0x1F, 0xC3, 0x80, 0x3F, 0xF1,
  0xC0, 0x3F, 0xFC, 0xE0, 0x3E, 0x0E, 0xF0, 0x3E, 0x03, 0x70, 0x1E, 0x00,
  0xF8, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0xC0, 0x78, 0x0F,
  0xC0, 0x3C, 0x0E, 0xE0, 0x1F, 0xFE, 0x70, 0x07, 0xFE, 0x38, 0x01, 0xFE,
  0x1C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x87, 0xF0, 0x00, 0xE3, 0xFE,
  0x00, 0x79, 0xFF, 0xC0, 0x1E, 0xE0, 0xF8, 0x07, 0xF0, 0x1E, 0x01, 0xF8,
  0x07, 0x80, 0x7C, 0x00, 0xE0, 0x3E, 0x00, 0x38, 0x0F, 0x80, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0E,
  0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x07, 0xE0,
  0x0F, 0x01, 0xD8, 0x07, 0x80, 0x77, 0x03, 0xE0, 0x1C, 0xFF, 0xF0, 0x06,
  0x3F, 0xF8, 0x03, 0x87, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x02, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x40, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x7F, 0xE7, 0x80, 0x07,
  0xFF, 0xBC, 0x00, 0x7C, 0x1D, 0xE0, 0x07, 0xC0, 0x6E, 0x00, 0x3C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0,
  0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x1F,
  0x01, 0xB8, 0x00, 0x78, 0x1D, 0xC0, 0x03, 0xFF, 0xCE, 0x00, 0x0F, 0xFC,
  0x70, 0x00, 0x3F, 0xC3, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x83,
  0xE0, 0x1C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xE0,
  0x0F, 0x8F, 0x00, 0xF8, 0x78, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x18, 0x0F, 0xCF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x70, 0x00, 0xFF, 0xC7, 0x00, 0x1F, 0xFE, 0x70, 0x03, 0xE0, 0xEF,
  0x00, 0x7C, 0x06, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0E,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x07,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0,
  0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0xFC, 0x01, 0xE0,
  0x0F, 0xC0, 0x1E, 0x01, 0xF8, 0x00, 0xF0, 0x3B, 0x80, 0x0F, 0xFF, 0x38,
  0x00, 0x7F, 0xE7, 0x80, 0x03, 0xFC, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x80, 0x0F,
  0x80, 0x0C, 0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC3, 0xF8, 0x00, 0xE7, 0xFE,
  0x00, 0x77, 0xFF, 0x80, 0x7F, 0x87, 0xC0, 0x3B, 0x01, 0xE0, 0x1F, 0x00,
  0x78, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1C, 0x07, 0xC0, 0x0E, 0x03, 0xC0,
  0x07, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x80,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E,
  0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xC0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x03, 0xC0,
  0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC1, 0xE0,
  0x00, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x1C, 0xF8, 0x00, 0x0E, 0xFC, 0x00, 0x0F, 0x7E, 0x00, 0x07, 0xF7,
  0x00, 0x03, 0xF3, 0x80, 0x01, 0xF1, 0xE0, 0x01, 0xF8, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x78, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x03, 0xC0,
  0x38, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0xE1, 0xFC, 0x0F, 0xE0, 0x03, 0x9F, 0xF8, 0x7F, 0xE0, 0x1E, 0xFF,
  0xE3, 0xFF, 0x80, 0x77, 0x07, 0xDC, 0x1F, 0x01, 0xD8, 0x0F, 0xE0, 0x3C,
  0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x03,
  0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x0E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x07, 0x81,
  0xC0, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0x70,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x0E, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xE1, 0xFC, 0x00,
  0x73, 0xFF, 0x00, 0x7B, 0xFF, 0xC0, 0x3B, 0xC3, 0xE0, 0x1D, 0x80, 0xF0,
  0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1C, 0x07, 0xC0, 0x0E, 0x03, 0xE0, 0x07,
  0x01, 0xE0, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C,
  0x00, 0x78, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x03,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0x83, 0xC0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x07,
  0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x3C,
  0x00, 0x0E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07,
  0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x3F, 0x80, 0x00, 0xE3,
  0xFE, 0x00, 0x07, 0x3F, 0xF8, 0x00, 0x7B, 0x83, 0xE0, 0x03, 0xB8, 0x0F,
  0x00, 0x1D, 0x80, 0x78, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0F, 0x00,
  0x7C, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF8,
  0x03, 0xC0, 0x0F, 0xC0, 0x3C, 0x00, 0x77, 0x03, 0xE0, 0x03, 0x9F, 0xFE,
  0x00, 0x1C, 0xFF, 0xE0, 0x01, 0xE3, 0xFC, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0x80, 0x3F,
  0xF1, 0xC0, 0x3F, 0xFC, 0xE0, 0x3E, 0x0E, 0xF0, 0x3E, 0x03, 0x70, 0x1E,
  0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x0E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0xC0, 0xF0,
  0x0F, 0xC0, 0x3C, 0x0E, 0xE0, 0x1F, 0xFE, 0xF0, 0x07, 0xFE, 0x78, 0x01,
  0xFE, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE1, 0xF8, 0x07, 0x3F, 0x80, 0x73,
  0xFC, 0x03, 0x9E, 0x20, 0x1D, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x08, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x80,
  0x0F, 0x03, 0x00, 0x7C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x03, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00,
  0x1C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x70, 0x3C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x07,
  0xC0, 0xE0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x1F, 0x80, 0xF0, 0x3B,
  0x80, 0xFF, 0xF3, 0x80, 0x7F, 0xE3, 0x80, 0x3F, 0xC7, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0, 0x70,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C,
  0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE7,
  0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xEF, 0x00, 0x1E, 0x00, 0x7B, 0xC0,
  0x0F, 0x80, 0x1E, 0xF0, 0x03, 0xE0, 0x07, 0x3C, 0x01, 0xF8, 0x03, 0xCF,
  0x00, 0x7E, 0x00, 0xE3, 0xC0, 0x3F, 0x80, 0x78, 0xF0, 0x0E, 0xE0, 0x1E,
  0x3C, 0x03, 0xB8, 0x07, 0x0F, 0x01, 0xCE, 0x03, 0xC3, 0xC0, 0x73, 0x80,
  0xE0, 0xF0, 0x3C, 0xE0, 0x38, 0x3C, 0x0E, 0x38, 0x1E, 0x0F, 0x03, 0x8E,
  0x07, 0x03, 0xC1, 0xC3, 0x83, 0xC0, 0xF0, 0x70, 0xE0, 0xE0, 0x3C, 0x3C,
  0x38, 0x38, 0x0E, 0x0E, 0x0E, 0x1E, 0x03, 0x83, 0x83, 0x87, 0x00, 0xE1,
  0xC0, 0xE3, 0xC0, 0x38, 0x70, 0x38, 0xE0, 0x0E, 0x3C, 0x0E, 0x38, 0x03,
  0x8E, 0x03, 0x9E, 0x00, 0xE3, 0x80, 0xE7, 0x00, 0x39, 0xC0, 0x39, 0xC0,
  0x0E, 0x70, 0x0E, 0xE0, 0x03, 0xBC, 0x07, 0xB8, 0x00, 0xEE, 0x01, 0xDE,
  0x00, 0x3B, 0x80, 0x77, 0x00, 0x0F, 0xC0, 0x1D, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x3C, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00,
  0x70, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xF2, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 49, 15, 1, -49 },
  { 93, 16, 18, 21, 7, -49 },
  { 129, 29, 49, 27, 0, -49 },
  { 307, 27, 56, 25, 0, -52 },
  { 496, 33, 51, 39, 3, -50 },
  { 707, 26, 51, 26, -1, -50 },
  { 873, 7, 18, 11, 7, -49 },
  { 889, 19, 60, 17, 2, -49 },
  { 1032, 20, 60, 17, -5, -49 },
  { 1182, 18, 21, 23, 8, -53 },
  { 1230, 25, 32, 29, 2, -40 },
  { 1330, 10, 16, 12, -3, -7 },
  { 1350, 15, 3, 18, 1, -20 },
  { 1356, 5, 6, 12, 1, -6 },
  { 1360, 30, 49, 22, -3, -49 },
  { 1544, 24, 51, 25, 1, -50 },
  { 1697, 14, 49, 25, 8, -49 },
  { 1783, 27, 50, 25, -2, -50 },
  { 1952, 27, 51, 25, -1, -50 },
  { 2125, 27, 50, 25, -1, -50 },
  { 2294, 27, 50, 25, -1, -49 },
  { 2463, 25, 51, 25, 2, -50 },
  { 2623, 26, 49, 25, 2, -49 },
  { 2783, 27, 51, 25, -1, -50 },
  { 2956, 25, 51, 25, 0, -50 },
  { 3116, 12, 37, 12, 0, -37 },
  { 3172, 15, 46, 12, -3, -37 },
  { 3259, 25, 29, 29, 2, -39 },
  { 3350, 25, 18, 29, 2, -33 },
  { 3407, 25, 29, 29, 2, -39 },
  { 3498, 20, 50, 18, 1, -50 },
  { 3623, 35, 56, 38, 2, -50 },
  { 3868, 26, 49, 25, -5, -49 },
  { 4028, 28, 49, 28, 0, -49 },
  { 4200, 27, 51, 25, 3, -50 },
  { 4373, 29, 49, 30, 0, -49 },
  { 4551, 27, 49, 24, 0, -49 },
  { 4717, 27, 49, 23, 0, -49 },
  { 4883, 32, 51, 33, 2, -50 },
  { 5087, 33, 49, 32, 0, -49 },
  { 5290, 24, 49, 15, -4, -49 },
  { 5437, 24, 62, 12, -10, -49 },
  { 5623, 31, 49, 26, 0, -49 },
  { 5813, 17, 49, 22, 0, -49 },
  { 5918, 44, 49, 43, 0, -49 },
  { 6188, 35, 49, 34, 0, -49 },
  { 6403, 29, 51, 32, 2, -50 },
  { 6588, 27, 49, 26, 0, -49 },
  { 6754, 29, 62, 32, 2, -50 },
  { 6979, 27, 49, 27, 0, -49 },
  { 7145, 29, 51, 25, -2, -50 },
  { 7330, 22, 49, 22, 5, -49 },
  { 7465, 31, 50, 31, 2, -49 },
  { 7659, 25, 49, 26, 6, -49 },
  { 7813, 43, 49, 43, 5, -49 },
  { 8077, 32, 49, 23, -4, -49 },
  { 8273, 23, 49, 22, 5, -49 },
  { 8414, 29, 49, 22, -3, -49 },
  { 8592, 26, 60, 19, -2, -49 },
  { 8787, 10, 49, 23, 7, -49 },
  { 8849, 25, 60, 19, -4, -49 },
  { 9037, 26, 25, 27, 1, -49 },
  { 9119, 20, 3, 19, -6, 6 },
  { 9127, 8, 11, 16, 10, -53 },
  { 9138, 25, 38, 28, 2, -37 },
  { 9257, 26, 53, 27, 0, -52 },
  { 9430, 20, 38, 20, 2, -37 },
  { 9525, 29, 53, 28, 2, -52 },
  { 9718, 21, 38, 24, 2, -37 },
  { 9818, 31, 70, 14, -9, -53 },
  { 10090, 28, 54, 28, -1, -37 },
  { 10279, 25, 52, 27, 0, -52 },
  { 10442, 14, 50, 12, 0, -50 },
  { 10530, 24, 67, 12, -9, -50 },
  { 10731, 25, 52, 23, 0, -52 },
  { 10894, 15, 52, 12, 0, -52 },
  { 10992, 38, 37, 40, 0, -37 },
  { 11168, 25, 37, 27, 0, -37 },
  { 11284, 23, 38, 26, 2, -37 },
  { 11394, 29, 53, 27, -3, -37 },
  { 11587, 25, 53, 28, 2, -37 },
  { 11753, 21, 37, 18, 0, -37 },
  { 11851, 22, 38, 20, -1, -37 },
  { 11956, 15, 46, 14, 1, -45 },
  { 12043, 24, 38, 27, 2, -37 },
  { 12157, 20, 37, 21, 4, -37 },
  { 12250, 34, 37, 35, 4, -37 },
  { 12408, 27, 37, 22, -3, -37 },
  { 12533, 32, 54, 22, -7, -37 },
  { 12749, 22, 37, 18, -2, -37 },
  { 12851, 24, 60, 22, 2, -49 },
  { 13031, 4, 70, 25, 10, -53 },
  { 13066, 24, 60, 22, -4, -49 },
  { 13246, 25, 7, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC69PT7B_H_
