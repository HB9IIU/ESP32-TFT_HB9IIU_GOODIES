#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0x43, 0x08, 0x20, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x4D, 0x3C, 0xA2, 0x8A, 0x69, 0x00, 0x02, 0x20,
  0x4C, 0x11, 0x02, 0x20, 0x4C, 0x7F, 0xC2, 0x20, 0x4C, 0x19, 0x02, 0x20,
  0x44, 0x19, 0x0F, 0xF8, 0x44, 0x19, 0x02, 0x20, 0x44, 0x09, 0x82, 0x20,
  0x00, 0x01, 0x00, 0x40, 0x10, 0x3F, 0x1A, 0x44, 0x83, 0x20, 0xC8, 0x34,
  0x07, 0x00, 0xC0, 0x18, 0x0A, 0x02, 0xC0, 0x90, 0x24, 0x09, 0x04, 0xCF,
  0xE1, 0xE0, 0x10, 0x04, 0x02, 0x00, 0x08, 0x00, 0xE0, 0x89, 0x08, 0xCC,
  0x44, 0x44, 0x22, 0x21, 0x12, 0x18, 0x90, 0xCD, 0x34, 0x4B, 0xF2, 0x92,
  0xE5, 0x12, 0x48, 0x82, 0xC4, 0x24, 0x21, 0x23, 0x11, 0x11, 0x88, 0x88,
  0x48, 0xC3, 0xC0, 0x02, 0x03, 0xC0, 0x98, 0x66, 0x19, 0x86, 0x41, 0x90,
  0x68, 0x0E, 0x03, 0x01, 0xC0, 0xB3, 0x64, 0xB1, 0x2C, 0x7A, 0x0C, 0x83,
  0x21, 0xCC, 0xD1, 0xE4, 0x5F, 0xA8, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x08,
  0x30, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C,
  0x18, 0x10, 0x00, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x60, 0xC0, 0x10, 0x32, 0x46, 0x93, 0xE5, 0x1A, 0x66, 0x08, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x32, 0x26, 0x4C, 0xF8, 0xF0, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x02,
  0x07, 0x86, 0x66, 0x32, 0x1B, 0x0D, 0x86, 0x83, 0x41, 0xE0, 0xB0, 0x50,
  0x28, 0x34, 0x1A, 0x09, 0x0C, 0x84, 0x46, 0x32, 0x0E, 0x00, 0x1C, 0xE6,
  0xB6, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0x43, 0x0C,
  0x00, 0x01, 0x01, 0xF8, 0x21, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0x7F, 0x80, 0x01, 0x01, 0xF8, 0x21, 0x80, 0x30, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x81, 0xE0, 0x3C, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x22, 0x1C, 0x7E, 0x00, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0xE0, 0x14, 0x04, 0x80, 0xB0, 0x26, 0x0C, 0x81, 0x10, 0x42,
  0x08, 0xC2, 0x18, 0xC2, 0x1F, 0xF7, 0xFE, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x07, 0xE1, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0xB0,
  0x1F, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x10, 0xE3, 0xF0, 0x00, 0x01, 0x41, 0xE0, 0x80, 0x40, 0x30, 0x08, 0x06,
  0x01, 0x00, 0x5E, 0x3D, 0x8C, 0x33, 0x04, 0x81, 0x20, 0xC8, 0x32, 0x08,
  0x82, 0x21, 0x8C, 0xC1, 0xE0, 0x3F, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x00, 0x02, 0x03, 0xE1, 0x8C, 0x41, 0x30, 0x4C,
  0x11, 0x0C, 0x42, 0x1B, 0x03, 0x81, 0xE0, 0xC8, 0x43, 0x30, 0x48, 0x12,
  0x04, 0x81, 0x20, 0xCC, 0x21, 0xF0, 0x02, 0x03, 0xE1, 0x88, 0x43, 0x30,
  0xC8, 0x32, 0x0D, 0x83, 0x60, 0xD8, 0x62, 0x18, 0xFA, 0x19, 0x80, 0x40,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0xC3, 0xE0, 0x18, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x60, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x21, 0x84, 0x10, 0x80, 0x00, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x30, 0x30, 0x38, 0x38, 0x08, 0x00, 0x04, 0x3F, 0x21, 0x01, 0x01, 0x01,
  0x02, 0x06, 0x04, 0x08, 0x18, 0x30, 0x20, 0x20, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x03, 0xF0, 0x60, 0xC2, 0x02, 0x20, 0x12, 0x00, 0x91, 0xE5,
  0x19, 0x28, 0x99, 0x48, 0x8E, 0x44, 0x62, 0x23, 0x33, 0x29, 0x11, 0x48,
  0x8A, 0x6C, 0x91, 0x98, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0xC0, 0x70, 0x14, 0x05, 0x03, 0x40, 0x90, 0x64, 0x11, 0x04,
  0x43, 0x10, 0x84, 0x7F, 0x10, 0x4C, 0x13, 0x04, 0x81, 0x60, 0x50, 0x1C,
  0x04, 0x0F, 0xC1, 0x0C, 0x21, 0x8C, 0x31, 0x86, 0x20, 0xC4, 0x11, 0x86,
  0x3F, 0x07, 0xE0, 0x86, 0x10, 0x46, 0x08, 0xC1, 0x10, 0x22, 0x0C, 0x41,
  0x18, 0xE3, 0xF0, 0x00, 0x00, 0x80, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x88, 0x1F, 0x00, 0x0F, 0xC1, 0x18, 0x21,
  0x8C, 0x11, 0x82, 0x20, 0x44, 0x09, 0x81, 0x30, 0x26, 0x0C, 0x81, 0x90,
  0x36, 0x04, 0xC1, 0x90, 0x22, 0x0C, 0x43, 0x19, 0xC3, 0xE0, 0x00, 0x0F,
  0xE1, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x3F, 0x87,
  0xE0, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0xF8, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x07, 0xE0, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x00, 0x00, 0x80, 0x7F, 0x0C, 0x11, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC1, 0xEC, 0x24, 0xC0,
  0x48, 0x04, 0x80, 0xCC, 0x0C, 0xC0, 0x8C, 0x08, 0x61, 0x83, 0xF8, 0x0C,
  0x18, 0x40, 0xC2, 0x04, 0x30, 0x21, 0x83, 0x08, 0x18, 0x40, 0xC6, 0x04,
  0x3F, 0xE1, 0xFF, 0x08, 0x18, 0x40, 0x86, 0x04, 0x30, 0x21, 0x03, 0x08,
  0x18, 0x40, 0x86, 0x04, 0x30, 0x60, 0x1F, 0x82, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x3E, 0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x0B, 0x03, 0x80, 0x0C, 0x30,
  0x86, 0x08, 0x41, 0x8C, 0x19, 0x81, 0x30, 0x12, 0x03, 0x60, 0x3C, 0x02,
  0xC0, 0x36, 0x02, 0x60, 0x66, 0x06, 0x20, 0x42, 0x04, 0x30, 0x43, 0x0C,
  0x10, 0xC1, 0x00, 0x0C, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40,
  0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0xF8, 0x0C, 0x01, 0x86, 0x01,
  0xC3, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x50, 0xA0, 0x78, 0x50, 0x2C, 0x6C,
  0x34, 0x36, 0x12, 0x13, 0x19, 0x09, 0x89, 0x84, 0xCC, 0xC6, 0x64, 0x43,
  0x32, 0x21, 0x0A, 0x10, 0x85, 0x18, 0x43, 0x8C, 0x61, 0x84, 0x30, 0xC2,
  0x00, 0x0C, 0x0C, 0x30, 0x20, 0xC0, 0x87, 0x86, 0x16, 0x18, 0x48, 0x41,
  0x21, 0x0C, 0x84, 0x32, 0x30, 0x8C, 0xC2, 0x32, 0x08, 0x48, 0x61, 0x21,
  0x85, 0x84, 0x16, 0x10, 0x70, 0x41, 0xC3, 0x03, 0x0C, 0x0C, 0x00, 0x01,
  0x00, 0xF8, 0x21, 0x88, 0x33, 0x02, 0x40, 0x58, 0x0B, 0x01, 0x40, 0x28,
  0x0F, 0x01, 0xE0, 0x3C, 0x05, 0x01, 0xA0, 0x34, 0x04, 0xC1, 0x98, 0x61,
  0x18, 0x3E, 0x00, 0x0F, 0x81, 0x18, 0x21, 0x0C, 0x31, 0x86, 0x20, 0xC4,
  0x11, 0x86, 0x30, 0x84, 0x70, 0xF8, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x21, 0x88, 0x33,
  0x02, 0x40, 0x58, 0x0B, 0x01, 0x40, 0x28, 0x0F, 0x01, 0xE0, 0x3C, 0x05,
  0x01, 0xA0, 0x34, 0x04, 0xC1, 0x98, 0x61, 0x18, 0x3E, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x0F, 0x81, 0x18, 0x21, 0x0C, 0x31, 0x86,
  0x20, 0x84, 0x11, 0x86, 0x31, 0x87, 0xE0, 0xF8, 0x13, 0x06, 0x60, 0xC4,
  0x10, 0x82, 0x18, 0x43, 0x18, 0x63, 0x04, 0x00, 0x01, 0x80, 0x7F, 0x0C,
  0x21, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0xC3,
  0x0F, 0xE0, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x00,
  0x10, 0x31, 0x02, 0x30, 0x23, 0x06, 0x20, 0x62, 0x04, 0x20, 0x46, 0x04,
  0x60, 0xC4, 0x0C, 0x40, 0x8C, 0x08, 0xC1, 0x8C, 0x18, 0x81, 0x08, 0x10,
  0x83, 0x0C, 0x60, 0x7C, 0x00, 0xC0, 0xF0, 0x3C, 0x0B, 0x06, 0xC1, 0x30,
  0xCC, 0x23, 0x18, 0xC6, 0x31, 0x0C, 0xC3, 0x20, 0xD8, 0x34, 0x0D, 0x03,
  0xC0, 0xE0, 0x38, 0x0C, 0x00, 0xC0, 0x81, 0xE0, 0xC0, 0xB0, 0x60, 0xD8,
  0x70, 0x4C, 0x28, 0x26, 0x14, 0x33, 0x1A, 0x11, 0x89, 0x18, 0xC4, 0x88,
  0x64, 0x44, 0x32, 0x26, 0x13, 0x12, 0x09, 0x0B, 0x04, 0x85, 0x02, 0x82,
  0x81, 0x41, 0xC0, 0xE1, 0xC0, 0x60, 0xE0, 0x30, 0x60, 0x00, 0x06, 0x18,
  0x30, 0x81, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0A, 0x00, 0xD0, 0x04, 0x80, 0x46, 0x06, 0x30,
  0x21, 0x83, 0x0C, 0x30, 0x60, 0xC1, 0xE0, 0x90, 0xC8, 0x44, 0x62, 0x21,
  0x20, 0x90, 0x50, 0x38, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x00, 0x0F, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x03, 0xFC, 0x00, 0x07, 0xC1, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0F, 0x80, 0x88,
  0x8C, 0xC4, 0x44, 0x44, 0x66, 0x62, 0x22, 0x22, 0x30, 0x07, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x0F, 0x80, 0x02, 0x00, 0xE0, 0x34, 0x04, 0x81, 0x98, 0x21, 0x0C, 0x21,
  0x06, 0x40, 0x58, 0x0C, 0xFF, 0xFE, 0xD9, 0x32, 0x04, 0x07, 0xB3, 0x18,
  0x86, 0x61, 0x90, 0x6C, 0x13, 0x04, 0x81, 0x20, 0xC8, 0x32, 0x08, 0x86,
  0x32, 0x87, 0x60, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x90,
  0x5E, 0x18, 0xCC, 0x13, 0x04, 0xC1, 0x20, 0xC8, 0x36, 0x0D, 0x82, 0x61,
  0x90, 0x66, 0x33, 0x88, 0x9C, 0x00, 0x06, 0x1F, 0x30, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC4, 0x78, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x81, 0x30, 0xF4, 0x31, 0x8C, 0x31, 0x86,
  0x20, 0xCC, 0x11, 0x82, 0x20, 0x44, 0x18, 0x83, 0x10, 0x42, 0x18, 0x65,
  0x07, 0x60, 0x04, 0x1F, 0x31, 0x61, 0x41, 0x43, 0xC6, 0xF8, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xC4, 0x7C, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x40, 0xF8, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x7B, 0x0C, 0x60, 0x86, 0x18, 0x61, 0x06, 0x30, 0x43, 0x04, 0x20, 0x42,
  0x0C, 0x20, 0xC2, 0x08, 0x21, 0x83, 0x28, 0x1D, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x08, 0x60, 0xFC, 0x00, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0xB0, 0x5E, 0x18, 0xC4, 0x33, 0x08, 0xC2, 0x20, 0x88, 0x66,
  0x19, 0x84, 0x41, 0x10, 0x44, 0x33, 0x0C, 0xC2, 0x00, 0x08, 0x30, 0x80,
  0x00, 0x21, 0x04, 0x10, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x30,
  0x00, 0x80, 0x30, 0x08, 0x00, 0x00, 0x00, 0x20, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x3C, 0x00, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x84, 0x42, 0x11, 0x84, 0xC3, 0x20, 0x90,
  0x2C, 0x0F, 0x07, 0x41, 0x90, 0x44, 0x11, 0x84, 0x63, 0x18, 0xC2, 0x00,
  0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0x43, 0x08, 0x20, 0x86, 0x18,
  0x41, 0x04, 0x30, 0xC0, 0x02, 0x08, 0x2F, 0x7C, 0x63, 0x19, 0x86, 0x33,
  0x08, 0x66, 0x10, 0x88, 0x61, 0x10, 0xC2, 0x61, 0x0C, 0xC2, 0x19, 0x04,
  0x22, 0x18, 0x44, 0x30, 0x98, 0x43, 0x30, 0x86, 0x00, 0x01, 0x05, 0xE1,
  0x8C, 0xC3, 0x30, 0x8C, 0x22, 0x08, 0x86, 0x61, 0x98, 0x44, 0x11, 0x04,
  0x43, 0x30, 0xCC, 0x20, 0x04, 0x0F, 0x8C, 0x4C, 0x34, 0x1A, 0x0F, 0x07,
  0x82, 0x81, 0x41, 0xA0, 0xD0, 0x48, 0x66, 0x61, 0xE0, 0x00, 0x81, 0x78,
  0x31, 0x86, 0x11, 0x82, 0x30, 0x44, 0x18, 0x83, 0x30, 0x66, 0x08, 0xC3,
  0x10, 0x63, 0x18, 0xE2, 0x1B, 0x82, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x00, 0x04, 0x07, 0xB3, 0x18, 0x86, 0x61, 0x90, 0x6C, 0x13, 0x04,
  0x81, 0x20, 0xC8, 0x32, 0x08, 0x86, 0x32, 0x87, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x01, 0x17, 0x18, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x0E, 0x1F, 0x20, 0x20,
  0x20, 0x20, 0x30, 0x18, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x8C, 0xF8, 0x10,
  0x8C, 0x47, 0x91, 0x8C, 0x42, 0x11, 0x8C, 0x42, 0x10, 0x87, 0x00, 0x20,
  0x90, 0xD8, 0x6C, 0x24, 0x12, 0x09, 0x0D, 0x86, 0xC2, 0x41, 0x21, 0x90,
  0xC8, 0xE7, 0xA0, 0x83, 0x86, 0x84, 0x8C, 0x88, 0x88, 0x98, 0x90, 0xB0,
  0xA0, 0xE0, 0xC0, 0xC0, 0x80, 0x86, 0x1C, 0x30, 0xA3, 0x8D, 0x14, 0x48,
  0xA2, 0x49, 0x22, 0x49, 0x16, 0x58, 0xA2, 0x85, 0x14, 0x30, 0xE1, 0x86,
  0x0C, 0x30, 0x41, 0x00, 0x18, 0xC6, 0x20, 0x98, 0x24, 0x0A, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x05, 0x82, 0x61, 0x88, 0x42, 0x30, 0xC0, 0x04, 0x18,
  0x20, 0x81, 0x0C, 0x08, 0x40, 0x46, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04,
  0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x01, 0xE0, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x07,
  0xE0, 0x03, 0x83, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08,
  0x0C, 0x18, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x03, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x0F, 0x00,
  0x70, 0x77, 0xF8, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 19, 6, 0, -19 },
  { 16, 6, 7, 8, 3, -19 },
  { 22, 11, 19, 11, 0, -19 },
  { 49, 10, 23, 10, 0, -21 },
  { 78, 13, 20, 15, 1, -20 },
  { 111, 10, 20, 10, 0, -20 },
  { 136, 2, 7, 4, 3, -19 },
  { 138, 7, 23, 7, 1, -19 },
  { 159, 8, 23, 7, -2, -19 },
  { 182, 7, 9, 9, 3, -21 },
  { 190, 10, 13, 11, 1, -16 },
  { 207, 4, 6, 5, -1, -3 },
  { 210, 5, 1, 7, 1, -8 },
  { 211, 2, 2, 5, 0, -2 },
  { 212, 11, 19, 8, -1, -19 },
  { 239, 9, 20, 10, 1, -20 },
  { 262, 6, 19, 10, 3, -19 },
  { 277, 11, 20, 10, -1, -20 },
  { 305, 11, 20, 10, -1, -20 },
  { 333, 11, 20, 10, -1, -20 },
  { 361, 11, 19, 10, -1, -19 },
  { 388, 10, 20, 10, 1, -20 },
  { 413, 10, 19, 10, 1, -19 },
  { 437, 10, 20, 10, 0, -20 },
  { 462, 10, 20, 10, 0, -20 },
  { 487, 5, 14, 5, 0, -14 },
  { 496, 6, 17, 5, -1, -14 },
  { 509, 10, 11, 11, 1, -15 },
  { 523, 10, 7, 11, 1, -13 },
  { 532, 10, 11, 11, 1, -15 },
  { 546, 8, 20, 7, 0, -20 },
  { 566, 13, 21, 15, 1, -19 },
  { 601, 10, 19, 10, -2, -19 },
  { 625, 11, 19, 11, 0, -19 },
  { 652, 11, 20, 10, 1, -20 },
  { 680, 11, 19, 12, 0, -19 },
  { 707, 11, 19, 10, 0, -19 },
  { 734, 11, 19, 9, 0, -19 },
  { 761, 12, 20, 13, 1, -20 },
  { 791, 13, 19, 12, 0, -19 },
  { 822, 9, 19, 6, -1, -19 },
  { 844, 10, 24, 5, -4, -19 },
  { 874, 12, 19, 10, 0, -19 },
  { 903, 7, 19, 9, 0, -19 },
  { 920, 17, 19, 17, 0, -19 },
  { 961, 14, 19, 13, 0, -19 },
  { 995, 11, 20, 13, 1, -20 },
  { 1023, 11, 19, 10, 0, -19 },
  { 1050, 11, 25, 13, 1, -20 },
  { 1085, 11, 19, 10, 0, -19 },
  { 1112, 12, 20, 10, -1, -20 },
  { 1142, 9, 19, 9, 2, -19 },
  { 1164, 12, 19, 12, 1, -19 },
  { 1193, 10, 19, 10, 2, -19 },
  { 1217, 17, 19, 17, 2, -19 },
  { 1258, 13, 19, 9, -2, -19 },
  { 1289, 9, 19, 9, 2, -19 },
  { 1311, 11, 19, 9, -1, -19 },
  { 1338, 10, 23, 8, -1, -19 },
  { 1367, 4, 19, 9, 3, -19 },
  { 1377, 10, 23, 8, -2, -19 },
  { 1406, 11, 10, 11, 0, -19 },
  { 1420, 8, 2, 8, -2, 2 },
  { 1422, 3, 5, 6, 4, -21 },
  { 1424, 10, 15, 11, 1, -15 },
  { 1443, 10, 21, 11, 0, -21 },
  { 1470, 8, 15, 8, 1, -15 },
  { 1485, 11, 21, 11, 1, -21 },
  { 1514, 8, 15, 10, 1, -15 },
  { 1529, 12, 27, 6, -3, -21 },
  { 1570, 12, 21, 11, -1, -15 },
  { 1602, 10, 21, 10, 0, -21 },
  { 1629, 6, 20, 5, 0, -20 },
  { 1644, 10, 26, 5, -4, -20 },
  { 1677, 10, 21, 9, 0, -21 },
  { 1704, 6, 21, 5, 0, -21 },
  { 1720, 15, 15, 16, 0, -15 },
  { 1749, 10, 15, 10, 0, -15 },
  { 1768, 9, 15, 10, 1, -15 },
  { 1785, 11, 21, 11, -1, -15 },
  { 1814, 10, 21, 11, 1, -15 },
  { 1841, 8, 15, 7, 0, -15 },
  { 1856, 8, 15, 8, 0, -15 },
  { 1871, 5, 18, 6, 1, -18 },
  { 1883, 9, 14, 10, 1, -14 },
  { 1899, 8, 14, 8, 2, -14 },
  { 1913, 13, 14, 14, 2, -14 },
  { 1936, 10, 14, 8, -1, -14 },
  { 1954, 13, 21, 9, -3, -14 },
  { 1989, 9, 14, 7, -1, -14 },
  { 2005, 9, 23, 9, 1, -19 },
  { 2031, 1, 27, 10, 4, -21 },
  { 2035, 10, 23, 9, -2, -19 },
  { 2064, 10, 3, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC27PT7B_H_
