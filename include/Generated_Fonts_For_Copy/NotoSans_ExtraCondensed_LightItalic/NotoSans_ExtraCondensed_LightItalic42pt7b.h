#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x0E, 0x06, 0x00, 0x31,
  0xCC, 0x73, 0x19, 0xC6, 0x61, 0x98, 0x66, 0x31, 0x8C, 0xC3, 0x30, 0xCC,
  0x20, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x10, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x0F, 0xFF, 0xC0, 0xC3,
  0x00, 0x61, 0x80, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x20, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x08, 0x1F, 0xFF, 0x81, 0x86, 0x00, 0xC2, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30,
  0x04, 0x30, 0x06, 0x18, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x01, 0xFE, 0x07, 0xFF, 0x06, 0x21, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x40, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x60, 0x01, 0x70, 0x01, 0x38, 0x03,
  0x18, 0x03, 0x18, 0x02, 0x18, 0x02, 0x18, 0x02, 0x38, 0x06, 0x30, 0x86,
  0x70, 0xFF, 0xE0, 0x7F, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x0F, 0x80, 0xE1, 0xD8, 0x0C, 0x18, 0xC1, 0x83, 0x0C, 0x18, 0x30,
  0xC3, 0x06, 0x0C, 0x30, 0x60, 0xC6, 0x06, 0x18, 0x60, 0x41, 0x8C, 0x0C,
  0x18, 0xC0, 0xC1, 0x98, 0x0C, 0x19, 0x80, 0xC3, 0x31, 0xEC, 0x33, 0x37,
  0xC2, 0x66, 0x3C, 0x66, 0x63, 0xEC, 0xCC, 0x37, 0x8C, 0xC3, 0x01, 0x88,
  0x30, 0x19, 0x83, 0x03, 0x18, 0x30, 0x31, 0x83, 0x06, 0x18, 0x60, 0x61,
  0x06, 0x0C, 0x30, 0x60, 0xC3, 0x0C, 0x18, 0x30, 0xC1, 0x81, 0x18, 0x30,
  0x1B, 0x87, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x0C, 0x70, 0x18, 0x60,
  0x61, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x19,
  0xC0, 0x3B, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x06, 0xC0, 0x19, 0x80,
  0x73, 0x0D, 0xC7, 0x3B, 0x06, 0x6E, 0x0C, 0xD8, 0x1B, 0x30, 0x1E, 0x60,
  0x38, 0xC0, 0x71, 0x80, 0xE3, 0x03, 0xC7, 0x0D, 0x8F, 0xF3, 0x8F, 0xC3,
  0x00, 0x33, 0x37, 0x66, 0x66, 0x4C, 0xC0, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x43, 0x0E, 0x40, 0xFB, 0xC3, 0xF8, 0xF0, 0x36, 0x0C,
  0x63, 0x8C, 0x20, 0xC0, 0x10, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x81, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x31, 0xC6, 0x38, 0xC3,
  0x18, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x71, 0xC1, 0x83, 0x0E, 0x0C,
  0x30, 0x31, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03,
  0x70, 0x0D, 0x80, 0x76, 0x01, 0xD8, 0x06, 0x60, 0x1B, 0x80, 0x6C, 0x03,
  0xB0, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03,
  0x0C, 0x1C, 0x38, 0xE0, 0x7F, 0x00, 0xF8, 0x00, 0x03, 0x0F, 0x1F, 0x3F,
  0x76, 0xE6, 0x86, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0,
  0xC0, 0xC0, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x10,
  0x1C, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0x60, 0x01, 0xB0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00,
  0x46, 0x00, 0x67, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x30, 0x60,
  0x18, 0x70, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x06, 0x03, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x20, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x10, 0x1C, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x8E,
  0x07, 0x7E, 0x0D, 0xDE, 0x1E, 0x0C, 0x38, 0x1C, 0x60, 0x19, 0xC0, 0x33,
  0x80, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x07, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x71, 0x80, 0xC3, 0x83, 0x83, 0x0E, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01,
  0xFC, 0x03, 0xFE, 0x07, 0x06, 0x0E, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x06, 0x0E, 0x0C, 0x06, 0x18, 0x07,
  0x70, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70,
  0x30, 0x60, 0x38, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x38, 0xC0, 0x30, 0xE0, 0x70, 0x7F, 0xE0, 0x3F, 0x80, 0x01,
  0xF8, 0x07, 0xF8, 0x1C, 0x38, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC6, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x70, 0x0C, 0xE0, 0x19, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xCE, 0x07, 0x0C, 0x1E, 0x1E, 0xEC, 0x1F, 0x98, 0x08, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x0E, 0x1C, 0x38, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x87, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x0F, 0xC1, 0xFE, 0x10, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xEF, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x60,
  0x30, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x01, 0x18, 0x0E,
  0x08, 0xC1, 0xF8, 0x44, 0x18, 0xC2, 0x61, 0x86, 0x33, 0x0C, 0x21, 0x90,
  0xC3, 0x0D, 0x86, 0x18, 0x6C, 0x20, 0xC3, 0x63, 0x04, 0x12, 0x18, 0x61,
  0xB0, 0xC3, 0x0D, 0x86, 0x18, 0x4C, 0x31, 0xC6, 0x61, 0x0C, 0x33, 0x0C,
  0xE3, 0x18, 0x7D, 0xF0, 0xC1, 0xC7, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0B, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x37, 0x00, 0x37, 0x00, 0x77, 0x00,
  0x67, 0x00, 0x67, 0x00, 0xC7, 0x00, 0xC7, 0x01, 0xC7, 0x01, 0x87, 0x01,
  0x87, 0x03, 0x07, 0x03, 0x07, 0x07, 0xFF, 0x07, 0xFF, 0x06, 0x07, 0x0E,
  0x07, 0x0C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30,
  0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0xC1, 0xC0, 0x60, 0x70, 0x70, 0x18, 0x38, 0x0C, 0x18, 0x06, 0x0C, 0x03,
  0x06, 0x03, 0x87, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x30, 0x70, 0x18, 0x1C, 0x0C, 0x06, 0x0E, 0x03, 0x87,
  0x01, 0xC3, 0x00, 0xE1, 0x80, 0x70, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x1C,
  0x30, 0x0C, 0x18, 0x0E, 0x0C, 0x1E, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0x81, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x30, 0xF0, 0x0C, 0x0E, 0x07, 0x01, 0x81, 0xC0,
  0x60, 0x60, 0x1C, 0x18, 0x07, 0x06, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C,
  0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x06, 0x18,
  0x03, 0x86, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x07, 0x0C, 0x01,
  0x83, 0x00, 0xE1, 0xC0, 0x30, 0x60, 0x1C, 0x18, 0x0E, 0x06, 0x07, 0x01,
  0x87, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0E, 0x03, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x01, 0xF8, 0xC0, 0x3F, 0x18, 0x00, 0xE3, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x38, 0x0C, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x70, 0x30,
  0x06, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06,
  0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x01, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0x80, 0x18, 0x18, 0x03, 0x81, 0x80, 0x30,
  0x38, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x70, 0x30, 0x06,
  0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00,
  0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x06, 0xE0, 0x0F, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x81, 0xC0, 0x70, 0x70, 0x0C,
  0x0C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x38, 0x01, 0xC6, 0x00, 0x31,
  0xC0, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x07, 0xF0, 0x00, 0xF6,
  0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x80, 0x60, 0x70, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0x80, 0x30, 0x00, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x6C, 0x0D, 0x80, 0x0F, 0x81, 0xB0, 0x03,
  0x60, 0x36, 0x00, 0x6C, 0x06, 0xC0, 0x1D, 0x81, 0xD8, 0x03, 0x70, 0x33,
  0x00, 0xEC, 0x06, 0x60, 0x19, 0x80, 0xCC, 0x07, 0x30, 0x19, 0x80, 0xC6,
  0x06, 0x30, 0x19, 0xC0, 0xC6, 0x06, 0x30, 0x18, 0xC0, 0xC6, 0x03, 0x18,
  0x30, 0xC0, 0xE3, 0x06, 0x18, 0x18, 0x61, 0x87, 0x03, 0x0E, 0x30, 0xC0,
  0x60, 0xCC, 0x18, 0x0C, 0x19, 0x83, 0x03, 0x83, 0x60, 0xE0, 0x60, 0x6C,
  0x18, 0x0C, 0x0F, 0x83, 0x01, 0x81, 0xE0, 0x60, 0x30, 0x3C, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x00, 0x03, 0x80, 0x18, 0x1C, 0x00,
  0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x70, 0x7C, 0x03, 0x03, 0x60, 0x18, 0x1B,
  0x00, 0xC0, 0xD8, 0x0E, 0x06, 0x60, 0x60, 0x73, 0x03, 0x03, 0x18, 0x18,
  0x18, 0xC0, 0xC0, 0xC6, 0x0E, 0x06, 0x30, 0x60, 0x70, 0xC3, 0x03, 0x06,
  0x18, 0x18, 0x30, 0xC0, 0xC1, 0x8E, 0x0E, 0x0C, 0x60, 0x60, 0x73, 0x03,
  0x01, 0x98, 0x18, 0x0D, 0xC0, 0xC0, 0x6C, 0x0E, 0x03, 0x60, 0x60, 0x1B,
  0x03, 0x00, 0xF8, 0x18, 0x03, 0xC0, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x60,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x38, 0x38, 0x0C, 0x07, 0x06,
  0x01, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x33, 0x80, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xE6, 0x00, 0x31, 0x80, 0x0C, 0xE0,
  0x03, 0x38, 0x01, 0x8E, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x18, 0x07,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0xC3, 0xC0, 0x60, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x18,
  0x0E, 0x0C, 0x07, 0x06, 0x03, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE0,
  0xC0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x31, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x38, 0x38, 0x0C, 0x07, 0x06,
  0x01, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x33, 0x80, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xE6, 0x00, 0x31, 0x80, 0x0C, 0xE0,
  0x03, 0x38, 0x01, 0xCE, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x18, 0x07,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xC3, 0xC0, 0x60, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x18, 0x0E, 0x0C, 0x07, 0x06, 0x03, 0x07, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x70, 0x70, 0xF0, 0x3F, 0xF0,
  0x1F, 0xC0, 0x0C, 0x60, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C,
  0x06, 0x0E, 0x03, 0x06, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xE0,
  0x60, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x18, 0x0E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00,
  0x60, 0xE0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x1C, 0x01,
  0x83, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x70, 0x06,
  0x0C, 0x01, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x38,
  0x30, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x07, 0x00, 0xE0,
  0xE0, 0x18, 0x1C, 0x07, 0x01, 0x80, 0xC0, 0x38, 0x38, 0x07, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xEC, 0x01,
  0x98, 0x07, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x03, 0x86,
  0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x61, 0xC0, 0xC3, 0x01, 0x8E,
  0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x37, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x36, 0x00, 0xE0, 0x19, 0x80, 0x70,
  0x06, 0x60, 0x1C, 0x03, 0xB8, 0x0D, 0x00, 0xCE, 0x03, 0x40, 0x33, 0x80,
  0xF0, 0x18, 0xE0, 0x6C, 0x06, 0x38, 0x1B, 0x03, 0x8E, 0x0C, 0xC0, 0xC3,
  0x83, 0x30, 0x30, 0xE0, 0xCC, 0x18, 0x38, 0x63, 0x06, 0x0C, 0x18, 0xC3,
  0x83, 0x0C, 0x30, 0xC0, 0xC3, 0x0C, 0x30, 0x30, 0xC3, 0x18, 0x0C, 0x60,
  0xC6, 0x03, 0x18, 0x33, 0x80, 0xCE, 0x0C, 0xC0, 0x33, 0x03, 0x30, 0x0C,
  0xC0, 0xD8, 0x03, 0x60, 0x36, 0x00, 0xD8, 0x0F, 0x80, 0x36, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x07, 0x00, 0xC0, 0xC0,
  0x1C, 0x38, 0x03, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x03,
  0x98, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0x80,
  0x30, 0x00, 0x60, 0x1D, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60, 0x71, 0x81,
  0x86, 0x0E, 0x18, 0x30, 0x71, 0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37,
  0x00, 0xD8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0xC3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x60, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x18, 0x61, 0x86, 0x18, 0x61, 0x87, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1B, 0x00, 0x37, 0x00,
  0xC6, 0x01, 0x8C, 0x06, 0x1C, 0x0C, 0x18, 0x30, 0x30, 0xE0, 0x71, 0x80,
  0x67, 0x00, 0xCC, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xF0, 0xE3, 0x18, 0x63,
  0x0C, 0x20, 0x00, 0xC1, 0x03, 0xF2, 0x07, 0x36, 0x0E, 0x1E, 0x1C, 0x0E,
  0x18, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x1C,
  0x60, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x70, 0xC0, 0x70, 0xE0, 0xF0, 0x61, 0xE0, 0x7F, 0x60, 0x3E, 0x60,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x38, 0x06, 0xFC, 0x0F, 0x8E,
  0x0D, 0x06, 0x0E, 0x06, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0C,
  0x30, 0x0C, 0x70, 0x1C, 0x70, 0x18, 0x70, 0x38, 0x70, 0x30, 0x78, 0x70,
  0xDF, 0xE0, 0xCF, 0xC0, 0x00, 0xE0, 0x1F, 0xC1, 0xC4, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x31, 0xC0, 0x3F, 0x60, 0x1C, 0xD8, 0x0E, 0x1E, 0x07,
  0x03, 0x81, 0x80, 0xE0, 0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x03, 0x07, 0x00,
  0xC1, 0x80, 0x70, 0x60, 0x18, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x80, 0xE0,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x07, 0x03, 0x01, 0xC0, 0xE0, 0xB0, 0x18,
  0x78, 0x07, 0xF6, 0x00, 0xF9, 0x80, 0x00, 0xE0, 0x1F, 0x81, 0xCE, 0x18,
  0x31, 0xC1, 0x8C, 0x0C, 0xC0, 0x66, 0x07, 0x70, 0x33, 0x03, 0x18, 0xF0,
  0xFF, 0x0F, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x04, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x40, 0x3F, 0x20, 0x1C, 0xD8, 0x0E, 0x1E, 0x07, 0x03, 0x81,
  0x80, 0xE0, 0xE0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x07, 0x01, 0xC1, 0x80,
  0x70, 0x60, 0x18, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xC0, 0x30,
  0x30, 0x0C, 0x0C, 0x07, 0x03, 0x01, 0xC0, 0xE0, 0xF0, 0x18, 0x78, 0x07,
  0xF6, 0x00, 0xF9, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x0C, 0x1C, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x60, 0x1B, 0xF0,
  0x3C, 0x70, 0xF0, 0x61, 0xC0, 0xC3, 0x81, 0x86, 0x07, 0x1C, 0x0E, 0x30,
  0x18, 0x60, 0x30, 0xC0, 0x61, 0x81, 0xC7, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x30, 0x18, 0x60, 0x71, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x38,
  0x1C, 0x60, 0x30, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x01,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x60,
  0x1C, 0xC0, 0x19, 0xC0, 0x19, 0x80, 0x1B, 0x80, 0x1F, 0x80, 0x3D, 0x80,
  0x39, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0x60, 0xC0,
  0x60, 0xE0, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0x00, 0x38, 0x38, 0x0D,
  0xF9, 0xF8, 0x36, 0x77, 0x38, 0x78, 0x78, 0x30, 0xE0, 0xE0, 0x61, 0x81,
  0xC0, 0xC3, 0x03, 0x81, 0x8E, 0x06, 0x07, 0x18, 0x0C, 0x0C, 0x30, 0x18,
  0x18, 0x60, 0x70, 0x30, 0xC0, 0xC0, 0x63, 0x81, 0x81, 0xC6, 0x03, 0x03,
  0x0C, 0x06, 0x06, 0x18, 0x1C, 0x0C, 0x70, 0x30, 0x18, 0xC0, 0x60, 0x71,
  0x80, 0xC0, 0xC3, 0x03, 0x81, 0x86, 0x06, 0x03, 0x1C, 0x0C, 0x06, 0x30,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x0D, 0xF8, 0x36, 0x38, 0x78, 0x30, 0xE0,
  0x61, 0xC0, 0xC3, 0x03, 0x8E, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30,
  0xC0, 0xE3, 0x81, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x70, 0x38, 0xC0,
  0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x0E, 0x30, 0x18, 0x00, 0x00,
  0xE0, 0x0F, 0xC0, 0x73, 0x83, 0x07, 0x1C, 0x0C, 0x60, 0x33, 0x00, 0xCC,
  0x03, 0x70, 0x0D, 0x80, 0x36, 0x01, 0xD8, 0x07, 0x60, 0x1B, 0x80, 0x6C,
  0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x38, 0x38, 0x61, 0xC1,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x6F, 0xC0, 0x36, 0x38, 0x0D,
  0x06, 0x03, 0x81, 0x80, 0xE0, 0x70, 0x30, 0x1C, 0x1C, 0x07, 0x07, 0x01,
  0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0xE0,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x07, 0x07, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x30, 0x1E, 0x1C, 0x0F, 0xFE, 0x03, 0x3F, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC1, 0x03, 0xF2, 0x07,
  0x36, 0x0E, 0x1E, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0,
  0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0xE0, 0xF0, 0x61,
  0xE0, 0x7F, 0x60, 0x3E, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x38, 0x27, 0x83, 0x7C, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0xF1, 0x83, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x81, 0xC3, 0xFE, 0x07, 0xF0, 0x00, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0xFE, 0xFE, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x3E, 0x1F, 0x00, 0x0C, 0x0E, 0x38, 0x1C, 0x60, 0x30, 0xC0, 0x61,
  0x80, 0xC3, 0x03, 0x8E, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x31, 0xC0,
  0xE3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x1C, 0x70, 0x38, 0xC0, 0x61,
  0x81, 0xC3, 0x03, 0x87, 0x0B, 0x0F, 0xF6, 0x0F, 0xD8, 0x00, 0xE0, 0x3F,
  0x01, 0xB8, 0x1D, 0xC0, 0xCE, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30, 0x61,
  0x83, 0x1C, 0x18, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80,
  0x7C, 0x03, 0xC0, 0x16, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x00, 0x60, 0x70,
  0x1B, 0x03, 0x81, 0x98, 0x1C, 0x0C, 0xC1, 0xE0, 0xE6, 0x0F, 0x06, 0x30,
  0xD8, 0x31, 0x86, 0xC3, 0x0C, 0x36, 0x18, 0x63, 0x31, 0xC7, 0x19, 0x8C,
  0x39, 0x8C, 0x61, 0xCC, 0x66, 0x0E, 0x63, 0x30, 0x76, 0x19, 0x83, 0x30,
  0xD8, 0x1B, 0x06, 0xC0, 0xD8, 0x3C, 0x06, 0xC1, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x18, 0x00, 0x07, 0x03, 0x81, 0x83,
  0x80, 0xC1, 0x80, 0x61, 0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x0E, 0x18,
  0x06, 0x0E, 0x06, 0x03, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x30, 0x1C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xF4, 0x00, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xF0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x3E, 0x02, 0xFF, 0x07, 0x07, 0xFC,
  0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 30, 9, 1, -30 },
  { 35, 10, 11, 13, 4, -30 },
  { 49, 17, 30, 17, 0, -30 },
  { 113, 16, 34, 15, 0, -32 },
  { 181, 20, 30, 24, 2, -30 },
  { 256, 15, 30, 16, 0, -30 },
  { 313, 4, 11, 7, 4, -30 },
  { 319, 12, 37, 10, 1, -30 },
  { 375, 12, 37, 11, -3, -30 },
  { 431, 11, 13, 14, 5, -32 },
  { 449, 15, 20, 17, 1, -25 },
  { 487, 6, 9, 8, -2, -4 },
  { 494, 9, 2, 11, 1, -12 },
  { 497, 3, 4, 7, 1, -4 },
  { 499, 18, 30, 13, -2, -30 },
  { 567, 14, 30, 15, 1, -30 },
  { 620, 8, 30, 15, 5, -30 },
  { 650, 16, 30, 15, -1, -30 },
  { 710, 17, 30, 15, -1, -30 },
  { 774, 17, 30, 15, -1, -30 },
  { 838, 17, 30, 15, -1, -30 },
  { 902, 15, 30, 15, 1, -30 },
  { 959, 16, 30, 15, 1, -30 },
  { 1019, 16, 30, 15, 0, -30 },
  { 1079, 15, 30, 15, 0, -30 },
  { 1136, 7, 22, 8, 0, -22 },
  { 1156, 9, 27, 8, -2, -22 },
  { 1187, 15, 18, 17, 1, -24 },
  { 1221, 15, 11, 17, 1, -20 },
  { 1242, 15, 18, 17, 1, -24 },
  { 1276, 12, 30, 11, 1, -30 },
  { 1321, 21, 34, 23, 1, -30 },
  { 1411, 16, 30, 15, -3, -30 },
  { 1471, 17, 30, 17, 0, -30 },
  { 1535, 16, 30, 15, 2, -30 },
  { 1595, 18, 30, 18, 0, -30 },
  { 1663, 17, 30, 15, 0, -30 },
  { 1727, 17, 30, 14, 0, -30 },
  { 1791, 19, 30, 20, 2, -30 },
  { 1863, 20, 30, 19, 0, -30 },
  { 1938, 14, 30, 9, -2, -30 },
  { 1991, 15, 38, 7, -6, -30 },
  { 2063, 19, 30, 16, 0, -30 },
  { 2135, 10, 30, 13, 0, -30 },
  { 2173, 27, 30, 26, 0, -30 },
  { 2275, 21, 30, 20, 0, -30 },
  { 2354, 18, 30, 20, 1, -30 },
  { 2422, 17, 30, 16, 0, -30 },
  { 2486, 18, 37, 20, 1, -30 },
  { 2570, 17, 30, 16, 0, -30 },
  { 2634, 17, 30, 15, -1, -30 },
  { 2698, 14, 30, 13, 3, -30 },
  { 2751, 19, 30, 19, 1, -30 },
  { 2823, 15, 30, 16, 4, -30 },
  { 2880, 26, 30, 26, 3, -30 },
  { 2978, 19, 30, 14, -2, -30 },
  { 3050, 14, 30, 14, 3, -30 },
  { 3103, 18, 30, 13, -2, -30 },
  { 3171, 15, 37, 12, -1, -30 },
  { 3241, 6, 30, 14, 4, -30 },
  { 3264, 16, 37, 12, -3, -30 },
  { 3338, 15, 15, 17, 1, -30 },
  { 3367, 12, 1, 12, -3, 4 },
  { 3369, 5, 7, 10, 6, -32 },
  { 3374, 16, 23, 17, 1, -23 },
  { 3420, 16, 32, 17, 0, -32 },
  { 3484, 13, 23, 12, 1, -23 },
  { 3522, 18, 32, 17, 1, -32 },
  { 3594, 13, 23, 15, 1, -23 },
  { 3632, 19, 42, 9, -5, -32 },
  { 3732, 18, 33, 17, -1, -23 },
  { 3807, 15, 32, 16, 0, -32 },
  { 3867, 9, 30, 7, 0, -30 },
  { 3901, 15, 40, 7, -6, -30 },
  { 3976, 16, 32, 14, 0, -32 },
  { 4040, 9, 32, 7, 0, -32 },
  { 4076, 23, 23, 24, 0, -23 },
  { 4143, 15, 23, 16, 0, -23 },
  { 4187, 14, 23, 16, 1, -23 },
  { 4228, 18, 33, 17, -2, -23 },
  { 4303, 16, 33, 17, 1, -23 },
  { 4369, 13, 23, 11, 0, -23 },
  { 4407, 14, 23, 12, -1, -23 },
  { 4448, 9, 28, 9, 1, -28 },
  { 4480, 15, 22, 16, 1, -22 },
  { 4522, 13, 22, 13, 2, -22 },
  { 4558, 21, 22, 21, 2, -22 },
  { 4616, 17, 22, 13, -2, -22 },
  { 4663, 19, 32, 13, -4, -22 },
  { 4739, 13, 22, 11, -1, -22 },
  { 4775, 15, 37, 13, 1, -30 },
  { 4845, 2, 42, 15, 6, -32 },
  { 4856, 15, 37, 13, -3, -30 },
  { 4926, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC42PT7B_H_
