#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0xE0, 0x29, 0x4C, 0xF5, 0x2B, 0x94,
  0xA0, 0x13, 0x58, 0xC2, 0x11, 0x5A, 0x62, 0x00, 0x4D, 0x75, 0xAF, 0xD5,
  0xAD, 0xB8, 0x35, 0x56, 0x4B, 0xBA, 0xF0, 0xF0, 0x12, 0x44, 0x48, 0x88,
  0x88, 0x40, 0x21, 0x11, 0x11, 0x22, 0x24, 0x80, 0x2F, 0xE0, 0x21, 0x3E,
  0x42, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80,
  0x35, 0x55, 0x99, 0x9A, 0xE0, 0x2E, 0xA4, 0x94, 0x80, 0x35, 0x11, 0x12,
  0x48, 0xE0, 0x35, 0x11, 0x61, 0x11, 0xE0, 0x11, 0x33, 0x59, 0xF2, 0x20,
  0x3A, 0x10, 0x86, 0x08, 0x42, 0xE0, 0x19, 0x10, 0xC5, 0x4A, 0x52, 0x60,
  0x78, 0x44, 0x22, 0x11, 0x08, 0x80, 0x32, 0x52, 0xA6, 0x4A, 0x52, 0xE0,
  0x35, 0x59, 0x57, 0x12, 0xC0, 0x40, 0x20, 0x20, 0x00, 0x94, 0x09, 0xB0,
  0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00, 0x61, 0x12, 0x44, 0x80,
  0x80, 0x18, 0x94, 0x57, 0xAE, 0xBB, 0x6A, 0x81, 0xC0, 0x08, 0xC6, 0x52,
  0x9D, 0x29, 0x88, 0x32, 0x52, 0x97, 0x2A, 0x52, 0xE0, 0x19, 0x10, 0x88,
  0x42, 0x10, 0x70, 0x32, 0x52, 0x94, 0xA6, 0x32, 0xE0, 0x3A, 0x10, 0x87,
  0x22, 0x10, 0xE0, 0x3A, 0x10, 0x87, 0x22, 0x10, 0x80, 0x1C, 0x84, 0x10,
  0x92, 0x28, 0xA2, 0x70, 0x25, 0x14, 0x92, 0x79, 0x28, 0xA4, 0x90, 0x31,
  0x22, 0x22, 0x24, 0xE0, 0x11, 0x11, 0x11, 0x22, 0x22, 0xC0, 0x2A, 0x54,
  0xC6, 0x32, 0x92, 0x90, 0x29, 0x24, 0xA4, 0xE0, 0x21, 0x22, 0x66, 0x66,
  0x66, 0x6A, 0xAA, 0xB4, 0x94, 0x24, 0x96, 0x59, 0x59, 0x69, 0xA6, 0x90,
  0x19, 0x52, 0x98, 0xC6, 0x32, 0x70, 0x32, 0x52, 0x95, 0x32, 0x10, 0x80,
  0x19, 0x52, 0x98, 0xC6, 0x32, 0x71, 0x0C, 0x32, 0x52, 0x95, 0x32, 0x92,
  0x90, 0x3A, 0x10, 0x82, 0x10, 0x42, 0xE0, 0xF4, 0x44, 0x48, 0x88, 0x80,
  0x25, 0x14, 0x92, 0x49, 0x28, 0xA4, 0x60, 0x99, 0x9A, 0xAC, 0xC8, 0x80,
  0x93, 0x26, 0x4D, 0xAB, 0x5A, 0xB6, 0x4C, 0x90, 0x24, 0xA2, 0x84, 0x10,
  0xC3, 0x14, 0x90, 0x9A, 0xAC, 0xC8, 0x88, 0x80, 0x78, 0x84, 0x42, 0x21,
  0x10, 0xE0, 0x32, 0x44, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x55, 0x40, 0x38,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x30, 0x21, 0x14, 0xA8, 0x80, 0xE0, 0xC0,
  0x7A, 0xA5, 0x29, 0x70, 0x24, 0x47, 0x55, 0x99, 0xE0, 0x74, 0x88, 0x86,
  0x08, 0x4A, 0xB5, 0x4A, 0x52, 0xE0, 0x75, 0xE8, 0x86, 0x0C, 0x21, 0x84,
  0x10, 0x42, 0x08, 0x20, 0x82, 0x30, 0x7A, 0xA5, 0x29, 0x70, 0x84, 0xC0,
  0x24, 0x65, 0x55, 0x99, 0xA0, 0x20, 0x24, 0xA4, 0x80, 0x08, 0x00, 0x21,
  0x08, 0x84, 0x21, 0x09, 0x80, 0x24, 0x45, 0x66, 0xAA, 0xA0, 0x29, 0x24,
  0xA4, 0x80, 0x7E, 0xA5, 0x54, 0xA9, 0x54, 0x80, 0x75, 0x59, 0x9A, 0x75,
  0x99, 0x96, 0x39, 0x4A, 0x94, 0xB9, 0x08, 0x80, 0x7A, 0xA5, 0x29, 0x70,
  0x84, 0x20, 0x74, 0x48, 0x88, 0x74, 0x42, 0x2C, 0x4D, 0x25, 0x26, 0x4A,
  0x95, 0x29, 0x70, 0xB7, 0x69, 0x00, 0xAE, 0xAE, 0xAC, 0xB2, 0x80, 0x29,
  0x88, 0x45, 0x68, 0x29, 0x4C, 0x62, 0x10, 0x88, 0x80, 0x65, 0x29, 0x80,
  0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x10, 0xFF, 0xF0, 0x21, 0x11, 0x11,
  0x22, 0x22, 0xC0, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 4, 1, -9 },
  { 7, 5, 9, 5, 0, -9 },
  { 13, 5, 10, 4, 0, -9 },
  { 20, 5, 9, 7, 1, -9 },
  { 26, 4, 9, 5, 0, -9 },
  { 31, 1, 4, 2, 1, -9 },
  { 32, 4, 11, 3, 0, -9 },
  { 38, 4, 11, 3, -1, -9 },
  { 44, 4, 3, 4, 1, -9 },
  { 46, 5, 6, 5, 0, -7 },
  { 50, 2, 3, 2, -1, -1 },
  { 51, 3, 1, 3, 0, -4 },
  { 52, 1, 1, 2, 0, -1 },
  { 53, 6, 9, 4, -1, -9 },
  { 60, 4, 9, 4, 0, -9 },
  { 65, 3, 9, 4, 1, -9 },
  { 69, 4, 9, 4, 0, -9 },
  { 74, 4, 9, 4, 0, -9 },
  { 79, 4, 9, 4, 0, -9 },
  { 84, 5, 9, 4, 0, -9 },
  { 90, 5, 9, 4, 0, -9 },
  { 96, 5, 9, 4, 0, -9 },
  { 102, 5, 9, 4, 0, -9 },
  { 108, 4, 9, 4, 0, -9 },
  { 113, 2, 6, 2, 0, -6 },
  { 115, 3, 8, 2, -1, -6 },
  { 118, 5, 5, 5, 0, -7 },
  { 122, 5, 3, 5, 0, -6 },
  { 124, 5, 5, 5, 0, -7 },
  { 128, 4, 9, 3, 0, -9 },
  { 133, 6, 10, 7, 0, -9 },
  { 141, 5, 9, 4, -1, -9 },
  { 147, 5, 9, 5, 0, -9 },
  { 153, 5, 9, 4, 0, -9 },
  { 159, 5, 9, 5, 0, -9 },
  { 165, 5, 9, 4, 0, -9 },
  { 171, 5, 9, 4, 0, -9 },
  { 177, 6, 9, 6, 0, -9 },
  { 184, 6, 9, 6, 0, -9 },
  { 191, 4, 9, 3, -1, -9 },
  { 196, 4, 11, 2, -2, -9 },
  { 202, 5, 9, 5, 0, -9 },
  { 208, 3, 9, 4, 0, -9 },
  { 212, 8, 9, 7, 0, -9 },
  { 221, 6, 9, 6, 0, -9 },
  { 228, 5, 9, 6, 0, -9 },
  { 234, 5, 9, 5, 0, -9 },
  { 240, 5, 11, 6, 0, -9 },
  { 247, 5, 9, 5, 0, -9 },
  { 253, 5, 9, 4, 0, -9 },
  { 259, 4, 9, 4, 1, -9 },
  { 264, 6, 9, 5, 0, -9 },
  { 271, 4, 9, 4, 1, -9 },
  { 276, 7, 9, 8, 1, -9 },
  { 284, 6, 9, 4, -1, -9 },
  { 291, 4, 9, 4, 1, -9 },
  { 296, 5, 9, 4, 0, -9 },
  { 302, 4, 11, 3, 0, -9 },
  { 308, 2, 9, 4, 1, -9 },
  { 311, 5, 11, 3, -1, -9 },
  { 318, 5, 5, 5, 0, -9 },
  { 322, 3, 1, 3, -1, 1 },
  { 323, 1, 2, 3, 2, -9 },
  { 324, 5, 6, 5, 0, -6 },
  { 328, 4, 9, 5, 0, -9 },
  { 333, 4, 6, 4, 0, -6 },
  { 336, 5, 9, 5, 0, -9 },
  { 342, 4, 6, 4, 0, -6 },
  { 345, 6, 12, 2, -2, -9 },
  { 354, 5, 9, 5, 0, -6 },
  { 360, 4, 9, 5, 0, -9 },
  { 365, 3, 9, 2, 0, -9 },
  { 369, 5, 12, 2, -2, -9 },
  { 377, 4, 9, 4, 0, -9 },
  { 382, 3, 9, 2, 0, -9 },
  { 386, 7, 6, 7, 0, -6 },
  { 392, 4, 6, 5, 0, -6 },
  { 395, 4, 6, 5, 0, -6 },
  { 398, 5, 9, 5, -1, -6 },
  { 404, 5, 9, 5, 0, -6 },
  { 410, 4, 6, 3, 0, -6 },
  { 413, 4, 6, 4, 0, -6 },
  { 416, 3, 8, 3, 0, -8 },
  { 419, 5, 6, 5, 0, -6 },
  { 423, 3, 6, 4, 1, -6 },
  { 426, 6, 6, 6, 1, -6 },
  { 431, 5, 6, 4, -1, -6 },
  { 435, 5, 9, 4, -1, -6 },
  { 441, 3, 6, 3, 0, -6 },
  { 444, 5, 11, 4, 0, -9 },
  { 451, 1, 12, 4, 2, -9 },
  { 453, 4, 11, 4, -1, -9 },
  { 459, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC12PT7B_H_
