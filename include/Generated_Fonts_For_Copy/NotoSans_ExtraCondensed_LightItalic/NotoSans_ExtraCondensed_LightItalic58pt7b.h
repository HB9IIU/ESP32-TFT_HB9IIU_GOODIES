#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCE, 0x0C, 0x60, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0x8C, 0x0C,
  0x60, 0x63, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E,
  0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18,
  0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30,
  0x30, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC1,
  0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x83, 0x80, 0x03, 0x03,
  0x80, 0x03, 0x03, 0x00, 0x07, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x0E, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38,
  0x00, 0x30, 0x38, 0x00, 0x30, 0x30, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70,
  0x00, 0x60, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0xC0, 0x7E, 0xDF, 0x01, 0xC6, 0x08, 0x0E, 0x18, 0x00, 0x70,
  0x60, 0x01, 0xC1, 0x80, 0x07, 0x04, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x20, 0x00, 0x39, 0x80, 0x00,
  0xF6, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x02, 0x70, 0x00, 0x18, 0xE0,
  0x00, 0x63, 0x80, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x10, 0x70, 0x00,
  0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0x83,
  0x82, 0x06, 0x3C, 0x0F, 0x1B, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x38,
  0x07, 0x78, 0x03, 0x00, 0xE3, 0x80, 0x70, 0x1C, 0x18, 0x06, 0x01, 0x81,
  0x80, 0xE0, 0x38, 0x18, 0x0C, 0x03, 0x81, 0x81, 0xC0, 0x30, 0x38, 0x18,
  0x07, 0x03, 0x83, 0x80, 0x70, 0x38, 0x30, 0x06, 0x03, 0x87, 0x00, 0x60,
  0x38, 0x60, 0x0E, 0x03, 0x0E, 0x00, 0xE0, 0x70, 0xC0, 0x0E, 0x07, 0x1C,
  0x00, 0xE0, 0x71, 0x80, 0x0C, 0x06, 0x38, 0x7C, 0xC0, 0xE3, 0x0F, 0xEC,
  0x0C, 0x71, 0xCE, 0xC1, 0xC6, 0x38, 0x6C, 0x1C, 0xE3, 0x07, 0xE3, 0x8C,
  0x70, 0x7F, 0xF1, 0xC6, 0x07, 0x7E, 0x18, 0xE0, 0x73, 0xC3, 0x8E, 0x06,
  0x00, 0x30, 0xC0, 0x60, 0x07, 0x1C, 0x06, 0x00, 0x61, 0xC0, 0xE0, 0x0E,
  0x1C, 0x0E, 0x00, 0xC1, 0x80, 0xE0, 0x1C, 0x18, 0x0C, 0x01, 0x83, 0x81,
  0xC0, 0x38, 0x38, 0x1C, 0x03, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x18, 0x06,
  0x03, 0x83, 0x80, 0xE0, 0x38, 0x30, 0x0C, 0x03, 0x87, 0x01, 0xC0, 0x18,
  0xE0, 0x18, 0x01, 0xFC, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0E, 0x3C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3B, 0x80, 0x01, 0xC7, 0x07, 0x0F, 0x1C, 0x1C, 0x78, 0x70, 0xE1,
  0xC1, 0xC3, 0x8E, 0x03, 0x8E, 0x38, 0x0E, 0x71, 0xC0, 0x39, 0xC7, 0x00,
  0xF6, 0x1C, 0x01, 0xF8, 0x70, 0x07, 0xC1, 0xC0, 0x1F, 0x0F, 0x00, 0x38,
  0x3C, 0x01, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x3F, 0x07, 0x81, 0xDC, 0x1F,
  0x1E, 0x70, 0x3F, 0xF1, 0xE0, 0x7F, 0x83, 0x80, 0x20, 0x00, 0x00, 0x3C,
  0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0xC0,
  0x70, 0xC0, 0xFD, 0xC3, 0x1F, 0xBF, 0x07, 0xFF, 0x03, 0xC0, 0x07, 0xC0,
  0x0E, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x30, 0x20, 0x38, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07,
  0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x70, 0x38,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73,
  0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E,
  0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0,
  0x1C, 0x07, 0x03, 0x80, 0x70, 0x78, 0x07, 0xDF, 0x00, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F,
  0xE1, 0xEE, 0x78, 0xEF, 0x0E, 0x60, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF0, 0x07, 0x81, 0xE0, 0x06, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0x03, 0xE0, 0x08, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x20, 0x07, 0x80,
  0x70, 0x3E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x28, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x19, 0xC0, 0x00, 0x73, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0x60, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x20, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x10,
  0x03, 0xC0, 0x3C, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0xE3, 0xFC, 0x03, 0x9F, 0xF8, 0x0E, 0xE1, 0xE0, 0x3E, 0x03, 0xC0,
  0xF0, 0x07, 0x07, 0xC0, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x81,
  0xC0, 0x0F, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xC0,
  0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xE3, 0x80, 0x01, 0xDE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFB, 0xC0,
  0x03, 0xC3, 0xC0, 0x0F, 0x03, 0x80, 0x3C, 0x03, 0x80, 0xF0, 0x07, 0x01,
  0xC0, 0x0F, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x83, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1F, 0x0F,
  0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xE1, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x3C, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78,
  0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C,
  0x38, 0x01, 0xE1, 0xE0, 0x1F, 0x07, 0x01, 0xF8, 0x3C, 0x1D, 0xC1, 0xFF,
  0xDC, 0x07, 0xFC, 0xE0, 0x1F, 0xC7, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x10, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xC1, 0xE0, 0x80, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0xFC, 0x1C, 0x18, 0x0F, 0xF8, 0x70, 0xE0,
  0x78, 0xE1, 0xC3, 0x01, 0x83, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x70, 0x70,
  0x70, 0x71, 0x81, 0x81, 0xC1, 0xCE, 0x0E, 0x06, 0x06, 0x38, 0x38, 0x38,
  0x18, 0xC0, 0xC0, 0xE0, 0x63, 0x07, 0x03, 0x83, 0x9C, 0x1C, 0x0C, 0x0E,
  0x70, 0x60, 0x70, 0x31, 0xC1, 0x81, 0xC1, 0xC6, 0x0E, 0x07, 0x07, 0x18,
  0x38, 0x38, 0x18, 0x60, 0xE0, 0xE0, 0xE1, 0x83, 0x83, 0x83, 0x06, 0x0E,
  0x1E, 0x0C, 0x38, 0x38, 0x58, 0x60, 0xE0, 0xE3, 0x63, 0x83, 0x81, 0xF9,
  0xFC, 0x0E, 0x07, 0xC3, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x20, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00,
  0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEF, 0x00, 0x07,
  0x70, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xE0, 0xFC, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x3C, 0x07, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x01, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0E, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE0,
  0x78, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x0F, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xE0, 0x20, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x8E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xE1, 0xFC, 0x00, 0xE0,
  0x3E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x80,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x70, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x70, 0x3E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0x01, 0xE0, 0x0F, 0x80, 0x08, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0xFC, 0x1C, 0x00, 0xFF, 0x87, 0x80, 0x1F, 0xF0, 0xF0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x07, 0x80, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x80, 0x38, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80,
  0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x78, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0xCF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF7,
  0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x6C, 0x00, 0x03, 0xB8, 0x07, 0x70, 0x00, 0x1F,
  0x80, 0x3B, 0x80, 0x01, 0xFC, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x0E, 0xE0,
  0x00, 0xF7, 0x00, 0x77, 0x00, 0x07, 0x78, 0x07, 0x38, 0x00, 0x3B, 0x80,
  0x39, 0xC0, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x0E, 0x70, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x1C, 0x1C, 0x01, 0xC1, 0x80, 0xE0, 0xE0, 0x0E, 0x0C, 0x07, 0x0F, 0x00,
  0xE0, 0x60, 0x70, 0x70, 0x07, 0x03, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x38,
  0x1C, 0x01, 0xC0, 0xE1, 0xC0, 0xE0, 0x1C, 0x07, 0x1C, 0x0E, 0x00, 0xE0,
  0x38, 0xE0, 0x70, 0x07, 0x01, 0xCE, 0x03, 0x80, 0x38, 0x0E, 0x70, 0x1C,
  0x01, 0xC0, 0x77, 0x00, 0xE0, 0x1C, 0x03, 0xB8, 0x0E, 0x00, 0xE0, 0x1F,
  0x80, 0x70, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x38, 0x07, 0xC0, 0x1C, 0x01,
  0xC0, 0x3E, 0x00, 0xE0, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x38, 0x07, 0xC0, 0x01, 0xC0, 0x3E, 0x00,
  0x0E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x00, 0x6E, 0x00, 0x38,
  0x07, 0x70, 0x01, 0xC0, 0x3B, 0x80, 0x0E, 0x01, 0xDC, 0x00, 0xE0, 0x0E,
  0xE0, 0x07, 0x00, 0x73, 0x80, 0x38, 0x07, 0x1C, 0x01, 0xC0, 0x38, 0xE0,
  0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x0E, 0x38, 0x07, 0x00, 0xF1, 0xC0, 0x38,
  0x07, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x1E, 0x01, 0xC1, 0xC0, 0xE0, 0x0E,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38, 0x07, 0x01, 0x81, 0xC0, 0x38, 0x0E,
  0x1C, 0x01, 0xC0, 0x70, 0xE0, 0x0E, 0x03, 0x87, 0x00, 0xE0, 0x1C, 0x38,
  0x07, 0x00, 0xE1, 0xC0, 0x38, 0x03, 0x1C, 0x01, 0xC0, 0x1C, 0xE0, 0x1E,
  0x00, 0xE7, 0x00, 0xE0, 0x07, 0x38, 0x07, 0x00, 0x39, 0xC0, 0x38, 0x01,
  0xDC, 0x01, 0xC0, 0x07, 0xE0, 0x1C, 0x00, 0x3F, 0x00, 0xE0, 0x01, 0xF8,
  0x07, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0xE0, 0x1C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x0F, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0x8F,
  0xE0, 0x07, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x03,
  0xC0, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38,
  0x0F, 0x00, 0xF0, 0x7E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x07, 0x03,
  0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xF0,
  0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0x8F, 0xE0, 0x07,
  0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x78, 0x1C, 0x00,
  0xF0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x1E,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x1F, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x78,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0x80,
  0xE0, 0x0F, 0x00, 0x20, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0x80,
  0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x70, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x78, 0x01, 0xF8, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x80,
  0x70, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x73, 0xC0, 0x03,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7B, 0x80, 0x03,
  0x80, 0x03, 0x9C, 0x00, 0x3C, 0x00, 0x3C, 0xE0, 0x01, 0xE0, 0x01, 0xC7,
  0x00, 0x1F, 0x00, 0x0E, 0x38, 0x00, 0xF8, 0x00, 0xE1, 0xC0, 0x06, 0xC0,
  0x07, 0x0E, 0x00, 0x76, 0x00, 0x78, 0x70, 0x03, 0xF0, 0x03, 0x83, 0x80,
  0x1B, 0x80, 0x1C, 0x1C, 0x01, 0xDC, 0x01, 0xC0, 0xE0, 0x0E, 0xE0, 0x0E,
  0x07, 0x00, 0xE7, 0x00, 0xF0, 0x38, 0x07, 0x38, 0x07, 0x01, 0xC0, 0x31,
  0xC0, 0x38, 0x0E, 0x03, 0x8E, 0x03, 0x80, 0x70, 0x1C, 0x70, 0x1C, 0x03,
  0x81, 0xC3, 0x81, 0xE0, 0x1C, 0x0E, 0x1C, 0x0E, 0x00, 0xE0, 0x60, 0xE0,
  0x70, 0x07, 0x07, 0x07, 0x07, 0x00, 0x38, 0x38, 0x38, 0x38, 0x01, 0xC3,
  0x81, 0xC3, 0xC0, 0x0E, 0x1C, 0x0E, 0x1C, 0x00, 0xE0, 0xC0, 0x60, 0xE0,
  0x07, 0x0E, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x18, 0x70, 0x01, 0xC7, 0x00,
  0xC7, 0x80, 0x0E, 0x38, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x31, 0xC0, 0x03,
  0x9C, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x0C, 0xE0, 0x00, 0xE6, 0x00, 0x6F,
  0x00, 0x07, 0x70, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0xF7, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00,
  0x78, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x38,
  0x1C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03,
  0x8E, 0x00, 0x18, 0xE0, 0x01, 0x9C, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x20, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x78, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x1C,
  0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0xE0, 0x00, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0xE0, 0xE1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x00, 0xFE, 0x38, 0x0F, 0xF9,
  0xC0, 0xF9, 0xCC, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0xF0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00,
  0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F,
  0x07, 0x00, 0xF8, 0x38, 0x0D, 0x81, 0xE0, 0x7C, 0x07, 0x8E, 0xE0, 0x3F,
  0xE7, 0x00, 0xFE, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x1F, 0x80, 0x39, 0xFF,
  0x00, 0xEF, 0x3C, 0x03, 0xF0, 0x78, 0x0F, 0x80, 0xE0, 0x3C, 0x03, 0x81,
  0xE0, 0x0E, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x83, 0xC0,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01,
  0xC0, 0xE0, 0x07, 0x07, 0x80, 0x38, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0x98, 0x78, 0x0E, 0x7F, 0xC0, 0x38, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0xF8, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x86,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFE,
  0x38, 0x01, 0xFF, 0x38, 0x03, 0xE7, 0x70, 0x07, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x3C, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07,
  0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x1F, 0x00, 0xE0, 0x36, 0x00, 0xF0, 0x7E, 0x00, 0x78, 0xEE,
  0x00, 0x7F, 0xCE, 0x00, 0x3F, 0x8C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xC0, 0x3E, 0x78, 0x1E, 0x0E, 0x0F, 0x01, 0xC3, 0x80, 0x71,
  0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x71, 0xC0,
  0x3C, 0x70, 0x1E, 0x1C, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFE, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x20, 0x78, 0x38, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0x00, 0x3F,
  0xE7, 0x00, 0x7C, 0xE6, 0x00, 0xF0, 0x36, 0x01, 0xE0, 0x3E, 0x01, 0xC0,
  0x1E, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x1C, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1C, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x03,
  0xE0, 0x1C, 0x06, 0xC0, 0x1E, 0x0F, 0xC0, 0x0F, 0x1D, 0xC0, 0x0F, 0xF9,
  0xC0, 0x07, 0xF1, 0xC0, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x1C, 0x00, 0xC0, 0x7C,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE7, 0xF0, 0x0E,
  0x7F, 0xC0, 0x77, 0xBE, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x0E,
  0x0F, 0x00, 0x70, 0x78, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01,
  0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x70,
  0x03, 0x87, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0x73,
  0x80, 0x03, 0xBC, 0x00, 0x1F, 0xF0, 0x01, 0xDB, 0x80, 0x0F, 0x9C, 0x00,
  0x7C, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x00, 0x01, 0x8F, 0xC1, 0xFC, 0x03, 0x9F, 0xE3, 0xFE, 0x03, 0xB9, 0xF7,
  0x9F, 0x03, 0xE0, 0x7E, 0x0F, 0x03, 0xC0, 0x7C, 0x07, 0x03, 0xC0, 0x78,
  0x07, 0x07, 0x80, 0x78, 0x07, 0x07, 0x80, 0x70, 0x07, 0x07, 0x00, 0x70,
  0x0F, 0x07, 0x00, 0x70, 0x0E, 0x0F, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0xE0,
  0x1C, 0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0,
  0x1C, 0x1C, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x38, 0x03, 0x80,
  0x38, 0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80, 0x38, 0x38, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x00, 0x70, 0x70, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x01, 0x8F, 0xE0, 0x1C, 0xFF, 0x80, 0xEF,
  0x7C, 0x07, 0xC0, 0xE0, 0x34, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xC0,
  0xF0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x78, 0x03, 0x83,
  0x80, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0x9E, 0x03, 0xC1,
  0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x78, 0xE0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x03,
  0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E,
  0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78,
  0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x78, 0x1C, 0x07, 0x8F, 0x80,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x30, 0xFC, 0x00, 0x39,
  0xFF, 0x00, 0x1D, 0xC7, 0x80, 0x0E, 0xC1, 0xE0, 0x07, 0xC0, 0x70, 0x03,
  0xC0, 0x38, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x70, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x78, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x07, 0x80, 0x38, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3C, 0x00, 0xEC,
  0x3C, 0x00, 0x77, 0xFC, 0x00, 0x71, 0xFC, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x38, 0x0F, 0xF9, 0xC0, 0xF9, 0xCC, 0x0F, 0x03, 0xE0,
  0xF0, 0x1F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0xF8, 0x38, 0x0D, 0x81,
  0xE0, 0xFC, 0x07, 0x8E, 0xE0, 0x3F, 0xE7, 0x00, 0xFE, 0x38, 0x00, 0x83,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0x8F, 0x81, 0xCF, 0xC0, 0xEF, 0xE0, 0x7E, 0x00, 0x36, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F,
  0x8F, 0x03, 0xC0, 0x20, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x40, 0x1E,
  0x0F, 0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0xFF, 0x1F,
  0xF1, 0xFF, 0x81, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE2, 0x07, 0xE0, 0x3F, 0x00,
  0x20, 0x00, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E,
  0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01,
  0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80,
  0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x07, 0x0F, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x03, 0xE0, 0xE0, 0x3C, 0x0E, 0x07, 0xC0,
  0xF1, 0xDC, 0x0F, 0xF9, 0xC0, 0x7F, 0x1C, 0x00, 0x80, 0x00, 0xE0, 0x03,
  0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0x60, 0x70, 0x18, 0x1C, 0x06, 0x0E, 0x01, 0x83, 0x80, 0x61, 0xC0,
  0x18, 0x70, 0x06, 0x1C, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x19, 0xC0, 0x06,
  0x70, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x70, 0x07, 0x80, 0x3B,
  0x80, 0x3C, 0x03, 0x9C, 0x03, 0xE0, 0x1C, 0xE0, 0x1E, 0x01, 0xC6, 0x00,
  0xF0, 0x0E, 0x30, 0x0F, 0x80, 0x71, 0x80, 0x6C, 0x07, 0x0C, 0x07, 0x60,
  0x38, 0x60, 0x3B, 0x01, 0x83, 0x01, 0x98, 0x1C, 0x38, 0x1C, 0xC0, 0xE1,
  0xC0, 0xC6, 0x0E, 0x0E, 0x0E, 0x30, 0x70, 0x70, 0x71, 0x83, 0x83, 0x83,
  0x0C, 0x38, 0x1C, 0x38, 0x61, 0xC0, 0xE1, 0x83, 0x1C, 0x07, 0x1C, 0x18,
  0xE0, 0x38, 0xE0, 0xC7, 0x01, 0xC6, 0x0E, 0x70, 0x0E, 0x70, 0x73, 0x80,
  0x73, 0x03, 0x98, 0x03, 0xB8, 0x1D, 0xC0, 0x1D, 0xC0, 0xEE, 0x00, 0xEC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x01,
  0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x71, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0xCE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x83, 0x80, 0x0F, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38,
  0x0F, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0x70,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x09, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE,
  0x00, 0x5F, 0xF8, 0x07, 0xE3, 0xF8, 0xFC, 0x07, 0xFF, 0x40, 0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 41, 13, 1, -41 },
  { 63, 13, 15, 17, 6, -41 },
  { 88, 24, 41, 23, 0, -41 },
  { 211, 22, 47, 21, 0, -44 },
  { 341, 28, 43, 33, 3, -42 },
  { 492, 22, 43, 22, -1, -42 },
  { 611, 6, 15, 10, 6, -41 },
  { 623, 17, 50, 14, 1, -41 },
  { 730, 16, 50, 15, -4, -41 },
  { 830, 16, 17, 20, 6, -44 },
  { 864, 21, 27, 24, 2, -34 },
  { 935, 8, 13, 10, -2, -6 },
  { 948, 13, 3, 15, 1, -17 },
  { 953, 4, 5, 10, 1, -5 },
  { 956, 25, 41, 18, -3, -41 },
  { 1085, 20, 43, 21, 1, -42 },
  { 1193, 12, 41, 21, 6, -41 },
  { 1255, 23, 42, 21, -2, -42 },
  { 1376, 23, 43, 21, -1, -42 },
  { 1500, 23, 42, 21, -1, -42 },
  { 1621, 23, 42, 21, -1, -41 },
  { 1742, 22, 43, 21, 1, -42 },
  { 1861, 22, 41, 21, 2, -41 },
  { 1974, 23, 43, 21, -1, -42 },
  { 2098, 21, 43, 21, 0, -42 },
  { 2211, 10, 31, 10, 0, -31 },
  { 2250, 13, 38, 10, -3, -31 },
  { 2312, 21, 25, 24, 2, -33 },
  { 2378, 21, 15, 24, 2, -28 },
  { 2418, 21, 25, 24, 2, -33 },
  { 2484, 17, 42, 15, 1, -42 },
  { 2574, 30, 47, 32, 1, -42 },
  { 2751, 21, 42, 21, -4, -42 },
  { 2862, 24, 41, 23, 0, -41 },
  { 2985, 23, 43, 21, 2, -42 },
  { 3109, 24, 41, 25, 0, -41 },
  { 3232, 23, 41, 20, 0, -41 },
  { 3350, 23, 41, 19, 0, -41 },
  { 3468, 27, 43, 27, 2, -42 },
  { 3614, 28, 41, 27, 0, -41 },
  { 3758, 19, 41, 12, -3, -41 },
  { 3856, 20, 52, 10, -8, -41 },
  { 3986, 26, 41, 22, 0, -41 },
  { 4120, 14, 41, 19, 0, -41 },
  { 4192, 37, 41, 36, 0, -41 },
  { 4382, 29, 41, 28, 0, -41 },
  { 4531, 24, 43, 27, 2, -42 },
  { 4660, 23, 41, 22, 0, -41 },
  { 4778, 24, 52, 27, 2, -42 },
  { 4934, 23, 41, 23, 0, -41 },
  { 5052, 25, 43, 21, -2, -42 },
  { 5187, 19, 41, 19, 4, -41 },
  { 5285, 25, 42, 26, 2, -41 },
  { 5417, 21, 41, 22, 5, -41 },
  { 5525, 37, 41, 36, 4, -41 },
  { 5715, 27, 41, 20, -3, -41 },
  { 5854, 20, 41, 19, 4, -41 },
  { 5957, 24, 41, 19, -2, -41 },
  { 6080, 21, 51, 16, -1, -42 },
  { 6214, 8, 42, 19, 6, -42 },
  { 6256, 21, 51, 16, -4, -42 },
  { 6390, 22, 21, 23, 1, -41 },
  { 6448, 17, 3, 16, -5, 5 },
  { 6455, 7, 9, 13, 8, -44 },
  { 6463, 21, 32, 23, 2, -31 },
  { 6547, 22, 45, 23, 0, -44 },
  { 6671, 17, 32, 17, 2, -31 },
  { 6739, 24, 45, 23, 2, -44 },
  { 6874, 18, 32, 21, 2, -31 },
  { 6946, 26, 58, 12, -7, -44 },
  { 7135, 24, 45, 23, -1, -31 },
  { 7270, 21, 44, 22, 0, -44 },
  { 7386, 12, 42, 10, 0, -42 },
  { 7449, 20, 56, 10, -8, -42 },
  { 7589, 21, 44, 19, 0, -44 },
  { 7705, 13, 44, 10, 0, -44 },
  { 7777, 32, 31, 34, 0, -31 },
  { 7901, 21, 31, 22, 0, -31 },
  { 7983, 19, 32, 22, 2, -31 },
  { 8059, 25, 44, 23, -3, -31 },
  { 8197, 21, 45, 23, 2, -31 },
  { 8316, 17, 31, 15, 0, -31 },
  { 8382, 19, 32, 17, -1, -31 },
  { 8458, 13, 39, 12, 1, -38 },
  { 8522, 20, 32, 22, 2, -31 },
  { 8602, 18, 31, 18, 3, -31 },
  { 8672, 29, 31, 29, 3, -31 },
  { 8785, 23, 31, 18, -3, -31 },
  { 8875, 27, 45, 18, -6, -31 },
  { 9027, 19, 31, 15, -2, -31 },
  { 9101, 20, 50, 19, 2, -41 },
  { 9226, 3, 58, 21, 9, -44 },
  { 9248, 21, 50, 18, -4, -41 },
  { 9380, 21, 6, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC58PT7B_H_
