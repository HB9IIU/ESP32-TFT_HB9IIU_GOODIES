#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xF0, 0x35, 0x76, 0xEA, 0xC0, 0x23, 0x64, 0x26, 0x6C,
  0x40, 0x6D, 0xAD, 0xF3, 0xAD, 0x60, 0x66, 0x65, 0xAA, 0xE0, 0xC0, 0x29,
  0x49, 0x24, 0x80, 0x24, 0x92, 0x52, 0x80, 0x5F, 0x00, 0x22, 0xF2, 0x20,
  0xC0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x75, 0x99, 0xAA, 0xC0, 0x75,
  0xA8, 0x71, 0x12, 0x48, 0xE0, 0x71, 0x16, 0x22, 0xC0, 0x12, 0x66, 0xA6,
  0x20, 0x74, 0xC2, 0x22, 0xC0, 0x34, 0x8E, 0x9A, 0xE0, 0x71, 0x22, 0x44,
  0x80, 0x75, 0x64, 0xAA, 0xE0, 0x79, 0x9A, 0x62, 0xC0, 0x40, 0x80, 0x40,
  0xA0, 0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0x64, 0xA8, 0x20,
  0x3A, 0x5F, 0x7D, 0xDA, 0x0C, 0x11, 0x33, 0x55, 0x90, 0x75, 0x56, 0x99,
  0xE0, 0x34, 0x48, 0x88, 0x60, 0x75, 0x55, 0x99, 0xE0, 0x74, 0x46, 0x88,
  0xE0, 0x74, 0x46, 0x88, 0x80, 0x3A, 0x21, 0x29, 0x49, 0xC0, 0x4A, 0x54,
  0xE9, 0x4A, 0x40, 0x32, 0x22, 0x44, 0xC0, 0x24, 0x94, 0x92, 0x80, 0x5A,
  0x98, 0x8A, 0x52, 0x80, 0x55, 0xAC, 0x45, 0x14, 0xD3, 0xB6, 0xAA, 0x80,
  0x4A, 0x5A, 0xDB, 0x4A, 0x40, 0x3A, 0x53, 0x19, 0x4B, 0x80, 0x75, 0x56,
  0x88, 0x80, 0x3A, 0x53, 0x19, 0x49, 0x84, 0x20, 0x75, 0x56, 0xAA, 0xA0,
  0x74, 0x44, 0x22, 0xE0, 0xEA, 0x49, 0x20, 0x4A, 0x55, 0x29, 0x4B, 0x80,
  0xBA, 0xAC, 0xC8, 0x80, 0xA6, 0x9E, 0xBA, 0xB2, 0x4A, 0x00, 0x29, 0x8C,
  0x42, 0x2A, 0x40, 0xBB, 0x49, 0x20, 0x72, 0x24, 0x48, 0xC0, 0x69, 0x29,
  0x24, 0xC0, 0xFE, 0x31, 0x12, 0x22, 0x22, 0xC0, 0x26, 0x90, 0xE0, 0x90,
  0x79, 0x9A, 0xE0, 0x44, 0x65, 0x59, 0xAE, 0x72, 0x4E, 0x11, 0x35, 0x99,
  0xAE, 0x77, 0x4E, 0x12, 0x22, 0x24, 0x44, 0x48, 0x79, 0x9A, 0xE2, 0xE0,
  0x44, 0x65, 0x5A, 0xAA, 0x45, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x44, 0x56,
  0x4C, 0xAA, 0x55, 0x6A, 0x7D, 0x5A, 0xAA, 0xA8, 0x75, 0xAA, 0xA0, 0x79,
  0x9A, 0xE0, 0x75, 0x9A, 0xE8, 0x80, 0x79, 0x9A, 0xE2, 0x20, 0x6A, 0x48,
  0xF1, 0x1C, 0x56, 0xA8, 0x55, 0xAA, 0xE0, 0xFA, 0x48, 0xDD, 0xAA, 0xA0,
  0x74, 0x4C, 0xA0, 0x4A, 0x88, 0x42, 0x23, 0x00, 0x69, 0x4C, 0x32, 0x44,
  0xC4, 0x48, 0x40, 0xFF, 0xC0, 0x31, 0x22, 0x32, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 4, 7, 4, 0, -7 },
  { 8, 4, 9, 4, 0, -8 },
  { 13, 5, 7, 6, 0, -7 },
  { 18, 4, 7, 4, 0, -7 },
  { 22, 1, 2, 2, 1, -7 },
  { 23, 3, 9, 2, 0, -7 },
  { 27, 3, 9, 3, -1, -7 },
  { 31, 3, 3, 3, 1, -8 },
  { 33, 4, 5, 4, 0, -6 },
  { 36, 1, 2, 2, 0, -1 },
  { 37, 2, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 0, -1 },
  { 39, 4, 7, 3, 0, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 2, 7, 4, 1, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 7, 4, 0, -7 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 4, 7, 4, 0, -7 },
  { 65, 4, 7, 4, 0, -7 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 4, 7, 4, 0, -7 },
  { 77, 4, 7, 4, 0, -7 },
  { 81, 2, 5, 2, 0, -5 },
  { 83, 2, 6, 2, 0, -5 },
  { 85, 4, 5, 4, 0, -6 },
  { 88, 4, 3, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -6 },
  { 93, 3, 7, 3, 0, -7 },
  { 96, 5, 8, 5, 0, -7 },
  { 101, 4, 7, 4, -1, -7 },
  { 105, 4, 7, 4, 0, -7 },
  { 109, 4, 7, 4, 0, -7 },
  { 113, 4, 7, 4, 0, -7 },
  { 117, 4, 7, 4, 0, -7 },
  { 121, 4, 7, 3, 0, -7 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 5, 7, 5, 0, -7 },
  { 135, 4, 7, 2, -1, -7 },
  { 139, 3, 9, 2, -1, -7 },
  { 143, 5, 7, 4, 0, -7 },
  { 148, 2, 7, 3, 0, -7 },
  { 150, 6, 7, 6, 0, -7 },
  { 156, 5, 7, 5, 0, -7 },
  { 161, 5, 7, 5, 0, -7 },
  { 166, 4, 7, 4, 0, -7 },
  { 170, 5, 9, 5, 0, -7 },
  { 176, 4, 7, 4, 0, -7 },
  { 180, 4, 7, 4, 0, -7 },
  { 184, 3, 7, 3, 1, -7 },
  { 187, 5, 7, 4, 0, -7 },
  { 192, 4, 7, 4, 1, -7 },
  { 196, 6, 7, 6, 1, -7 },
  { 202, 5, 7, 3, -1, -7 },
  { 207, 3, 7, 3, 1, -7 },
  { 210, 4, 7, 3, 0, -7 },
  { 214, 3, 9, 3, 0, -7 },
  { 218, 1, 7, 3, 1, -7 },
  { 219, 4, 9, 3, -1, -7 },
  { 224, 4, 3, 4, 0, -7 },
  { 226, 3, 1, 3, -1, 1 },
  { 227, 2, 2, 2, 1, -8 },
  { 228, 4, 5, 4, 0, -5 },
  { 231, 4, 8, 4, 0, -8 },
  { 235, 3, 5, 3, 0, -5 },
  { 237, 4, 8, 4, 0, -8 },
  { 241, 3, 5, 4, 0, -5 },
  { 243, 4, 10, 2, -1, -8 },
  { 248, 4, 7, 4, 0, -5 },
  { 252, 4, 8, 4, 0, -8 },
  { 256, 2, 7, 2, 0, -7 },
  { 258, 3, 9, 2, -1, -7 },
  { 262, 4, 8, 3, 0, -8 },
  { 266, 2, 8, 2, 0, -8 },
  { 268, 6, 5, 6, 0, -5 },
  { 272, 4, 5, 4, 0, -5 },
  { 275, 4, 5, 4, 0, -5 },
  { 278, 4, 7, 4, 0, -5 },
  { 282, 4, 7, 4, 0, -5 },
  { 286, 3, 5, 3, 0, -5 },
  { 288, 3, 5, 3, 0, -5 },
  { 290, 2, 7, 2, 0, -7 },
  { 292, 4, 5, 4, 0, -5 },
  { 295, 3, 5, 3, 1, -5 },
  { 297, 4, 5, 5, 1, -5 },
  { 300, 4, 5, 3, 0, -5 },
  { 303, 5, 7, 3, -1, -5 },
  { 308, 3, 5, 3, 0, -5 },
  { 310, 4, 9, 3, 0, -7 },
  { 315, 1, 10, 4, 1, -8 },
  { 317, 4, 9, 3, -1, -7 },
  { 322, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC10PT7B_H_
