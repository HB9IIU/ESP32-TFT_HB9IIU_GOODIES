#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x39, 0xC3, 0x8E, 0x1C, 0x70,
  0xE3, 0x87, 0x18, 0x31, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x06, 0x18, 0x30,
  0xC1, 0x8E, 0x1C, 0x60, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x60, 0x01,
  0x81, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x07,
  0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x03, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC1, 0xC0,
  0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x60, 0xE0, 0x03, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x70, 0x00,
  0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x83,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x38, 0xC3, 0x07, 0x0C,
  0x00, 0x70, 0xC0, 0x06, 0x08, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xE1,
  0x80, 0x06, 0x18, 0x00, 0x71, 0x00, 0x07, 0x30, 0x00, 0x3B, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x4E, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x08, 0x30, 0x01, 0x83, 0x00, 0x18, 0x70, 0x01, 0x87,
  0x08, 0x10, 0xE0, 0xC1, 0x1C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x0E, 0x07, 0xF0, 0x06, 0x07, 0x18, 0x07, 0x03,
  0x0E, 0x03, 0x03, 0x87, 0x03, 0x81, 0x83, 0x81, 0x81, 0xC1, 0xC1, 0xC0,
  0xE0, 0xE0, 0xC0, 0x60, 0x70, 0xE0, 0x30, 0x30, 0x60, 0x38, 0x18, 0x70,
  0x1C, 0x0C, 0x30, 0x0C, 0x0E, 0x38, 0x06, 0x07, 0x18, 0x03, 0x03, 0x1C,
  0x01, 0x81, 0x8C, 0x3C, 0xC1, 0xCE, 0x3F, 0x60, 0xC6, 0x39, 0xF0, 0xE7,
  0x38, 0xF8, 0x63, 0x18, 0x3C, 0x73, 0x9C, 0x1F, 0xF1, 0x8C, 0x0D, 0xF1,
  0xCE, 0x06, 0x00, 0xC7, 0x07, 0x00, 0xE3, 0x03, 0x80, 0x61, 0x81, 0x80,
  0x71, 0xC0, 0xC0, 0x30, 0xE0, 0x60, 0x38, 0x60, 0x70, 0x18, 0x30, 0x38,
  0x1C, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0E, 0x06, 0x0E, 0x06, 0x03, 0x06,
  0x07, 0x01, 0x87, 0x03, 0x00, 0xC7, 0x03, 0x80, 0x7F, 0x03, 0x80, 0x1F,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0x8E, 0x00,
  0x61, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03,
  0x83, 0x80, 0x70, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x03,
  0x18, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xE6, 0x00, 0x38, 0xE1, 0xC7, 0x1C, 0x39, 0xC3,
  0x86, 0x70, 0x31, 0xCE, 0x07, 0x3B, 0x80, 0xE6, 0x70, 0x1D, 0xCE, 0x01,
  0xF1, 0x80, 0x3E, 0x30, 0x07, 0x86, 0x00, 0x70, 0xC0, 0x1E, 0x1C, 0x07,
  0xC3, 0x81, 0xDC, 0x78, 0x73, 0x87, 0xFC, 0x70, 0x7F, 0x0F, 0x03, 0x00,
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x20,
  0xE0, 0xE3, 0x03, 0xCC, 0x13, 0xF7, 0xC3, 0xFF, 0x07, 0x00, 0x3E, 0x01,
  0xD8, 0x0E, 0x30, 0xF0, 0xE1, 0x81, 0x80, 0x07, 0x00, 0x10, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x0E,
  0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x6F, 0xFE, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x38, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x0C, 0x1C, 0x03, 0x0E, 0x00, 0xC3,
  0x80, 0x30, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCC, 0x00, 0x67, 0x00, 0x39, 0xC0, 0x0E,
  0x70, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x31, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x60, 0xE0, 0x38, 0x38, 0x1C, 0x07, 0x07, 0x01, 0xC7, 0x80,
  0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x07,
  0xE1, 0xFC, 0x7B, 0x9C, 0x77, 0x0C, 0x43, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0x0F, 0x00, 0x30, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x00, 0x78, 0x7C, 0x03, 0x00, 0xE0, 0x10, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x20, 0x07, 0x01, 0x80, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0x80, 0x00,
  0xDC, 0x00, 0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80,
  0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01, 0xC1,
  0x80, 0x1C, 0x1C, 0x00, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x60, 0x30, 0x06,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x30,
  0x18, 0x03, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x20, 0x07, 0x01, 0xC0, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x20, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x9F, 0xC0, 0x3B, 0xFE, 0x03, 0x70, 0xF0,
  0x7C, 0x07, 0x07, 0xC0, 0x70, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x87, 0x80, 0x3F, 0xF0, 0x01,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3C, 0x3C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70,
  0x07, 0x03, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xE0, 0x0C, 0x07, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x3C, 0x70, 0x00, 0xEF,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x78, 0xE0, 0x07,
  0x87, 0x80, 0x78, 0x1C, 0x07, 0x80, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0x60, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80,
  0x06, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1E, 0x01, 0xC0,
  0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x07, 0x8F, 0x01, 0xE0, 0xE0, 0x38, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x78, 0x70, 0x0F, 0x0F, 0x03, 0xE0, 0xE0,
  0xDC, 0x1F, 0xFB, 0x81, 0xFC, 0x60, 0x0E, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x41, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x70,
  0x78, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x60, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x38, 0xF8, 0x40,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0x80, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x0C, 0x18, 0x02, 0x01, 0x87, 0x01, 0xFC, 0x30, 0xC0, 0xFF,
  0x86, 0x38, 0x18, 0x60, 0xC6, 0x06, 0x0C, 0x18, 0xC1, 0xC3, 0x83, 0x38,
  0x30, 0x70, 0x66, 0x0E, 0x0C, 0x1C, 0xC1, 0x81, 0x83, 0x98, 0x30, 0x70,
  0x67, 0x0E, 0x0E, 0x0C, 0xC1, 0x81, 0x81, 0x98, 0x30, 0x30, 0x73, 0x06,
  0x0E, 0x0C, 0x61, 0xC1, 0xC1, 0x8C, 0x38, 0x30, 0x73, 0x87, 0x0E, 0x0C,
  0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x78, 0x61, 0xC1, 0x99, 0x98, 0x38, 0x3F,
  0x3E, 0x07, 0x03, 0x83, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x37, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x60, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x80, 0x70, 0x38, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80,
  0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01,
  0xC0, 0x78, 0x06, 0x07, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0x87,
  0xE0, 0x0E, 0x03, 0x80, 0x30, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x30,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x1C, 0x07, 0x01, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x0C, 0x01,
  0xE0, 0x20, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x30, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0x0F,
  0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x1C,
  0x01, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x1F,
  0x00, 0xF0, 0x02, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0xF8, 0xE0, 0x07, 0xF8, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x3E, 0x03, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x0E,
  0x00, 0x38, 0x06, 0x00, 0x1C, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x1C, 0x00,
  0x70, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x04, 0x78, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83,
  0x80, 0x03, 0x87, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xB0, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1B, 0x00, 0x03, 0xB0, 0x06, 0xC0, 0x00,
  0xFC, 0x03, 0xB0, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x3B, 0x80,
  0x06, 0x60, 0x0C, 0xE0, 0x03, 0xB8, 0x07, 0x38, 0x00, 0xCE, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x73, 0x80, 0x18, 0xE0, 0x1C, 0xE0, 0x0E, 0x30, 0x06,
  0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x38, 0x70, 0x0C, 0x38, 0x0E, 0x18, 0x03, 0x0E, 0x07, 0x0E,
  0x01, 0xC1, 0x81, 0xC3, 0x80, 0x70, 0x60, 0xE0, 0xE0, 0x1C, 0x18, 0x38,
  0x30, 0x06, 0x06, 0x0C, 0x1C, 0x03, 0x81, 0x87, 0x07, 0x00, 0xE0, 0x61,
  0x81, 0xC0, 0x38, 0x18, 0xE0, 0x70, 0x0E, 0x06, 0x30, 0x18, 0x03, 0x01,
  0x9C, 0x0E, 0x01, 0xC0, 0x76, 0x03, 0x80, 0x70, 0x1F, 0x80, 0xE0, 0x1C,
  0x07, 0xE0, 0x38, 0x07, 0x01, 0xF0, 0x0C, 0x01, 0x80, 0x7C, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x00, 0xF8, 0x00, 0xE0, 0x1F,
  0x00, 0x1C, 0x03, 0xE0, 0x03, 0x80, 0x6E, 0x00, 0x60, 0x0D, 0xC0, 0x1C,
  0x03, 0xB8, 0x03, 0x80, 0x73, 0x00, 0x70, 0x0E, 0x60, 0x0E, 0x01, 0x8C,
  0x01, 0x80, 0x71, 0xC0, 0x70, 0x0E, 0x38, 0x0E, 0x01, 0xC7, 0x01, 0xC0,
  0x38, 0x60, 0x38, 0x06, 0x0C, 0x06, 0x01, 0xC1, 0xC1, 0xC0, 0x38, 0x38,
  0x38, 0x07, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0xC0, 0x18, 0x0C, 0x38, 0x07,
  0x01, 0x87, 0x00, 0xE0, 0x38, 0xE0, 0x1C, 0x07, 0x1C, 0x03, 0x00, 0xE3,
  0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0x01, 0x9C, 0x03, 0x80, 0x33, 0x80, 0x70,
  0x07, 0x70, 0x0C, 0x00, 0xEC, 0x03, 0x80, 0x1F, 0x80, 0x70, 0x01, 0xF0,
  0x0E, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0xC0, 0x30, 0x00, 0xF0, 0x0E, 0x00,
  0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x0F, 0x0F, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x70,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01,
  0xC7, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x19, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07,
  0x01, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1F, 0x0F, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0x81, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x30, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x1C,
  0x06, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x1F, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x38,
  0x0E, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x19, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1F, 0x0F,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0x81, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x30, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xE0, 0x1C, 0x06, 0x01, 0xE0, 0x70, 0x1E, 0x03, 0x81, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x18, 0x00, 0xE0, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0,
  0x1C, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x80,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xC7, 0x80, 0x78, 0x06, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x08, 0x01, 0xE0,
  0x3C, 0x1F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x38, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60,
  0x01, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x70, 0x03, 0xC3, 0xE0, 0x07, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x07,
  0x60, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x03,
  0x86, 0x00, 0x38, 0x60, 0x03, 0x86, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00,
  0xE0, 0x60, 0x0E, 0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0x60,
  0x38, 0x06, 0x03, 0x80, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x60, 0x06,
  0x0E, 0x00, 0x60, 0xE0, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x38, 0x00,
  0x63, 0x80, 0x06, 0x30, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xB0, 0x00,
  0xE0, 0x01, 0xD8, 0x00, 0x70, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xEE, 0x00,
  0x3C, 0x00, 0x67, 0x00, 0x3E, 0x00, 0x73, 0x80, 0x1B, 0x00, 0x39, 0xC0,
  0x0D, 0x80, 0x38, 0xE0, 0x0E, 0xC0, 0x1C, 0x70, 0x06, 0x60, 0x0C, 0x38,
  0x03, 0x70, 0x0E, 0x1C, 0x03, 0xB8, 0x07, 0x0E, 0x01, 0x9C, 0x07, 0x07,
  0x01, 0xCE, 0x03, 0x83, 0x80, 0xE7, 0x01, 0x81, 0xC0, 0x63, 0x81, 0xC0,
  0xE0, 0x71, 0xC0, 0xE0, 0x70, 0x30, 0xE0, 0xE0, 0x38, 0x38, 0x70, 0x70,
  0x1C, 0x1C, 0x38, 0x30, 0x0E, 0x0C, 0x1C, 0x38, 0x07, 0x0E, 0x0E, 0x1C,
  0x03, 0x86, 0x06, 0x1C, 0x01, 0xC7, 0x03, 0x0E, 0x00, 0xE3, 0x81, 0x86,
  0x00, 0x71, 0x80, 0xC7, 0x00, 0x39, 0xC0, 0x63, 0x80, 0x1C, 0xC0, 0x33,
  0x80, 0x0E, 0xE0, 0x19, 0xC0, 0x07, 0x70, 0x0C, 0xC0, 0x03, 0xB0, 0x06,
  0xE0, 0x01, 0xF8, 0x03, 0x70, 0x00, 0xF8, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x01,
  0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x18, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xD8, 0x00, 0xE7, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0xE0, 0x0C,
  0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x60, 0x60, 0x60, 0x70,
  0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x70, 0x70,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x18, 0x01,
  0xC3, 0x80, 0x0C, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE3, 0x87, 0x1C, 0x38, 0x61, 0x83, 0x00, 0x18, 0x00,
  0x0F, 0xE7, 0x01, 0xFF, 0x70, 0x3C, 0x36, 0x07, 0x01, 0x60, 0xF0, 0x1E,
  0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0x87, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x06, 0x01, 0xE0, 0x70, 0x1E, 0x07,
  0x03, 0xE0, 0x78, 0x6E, 0x03, 0xFC, 0xC0, 0x1F, 0x8C, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x70, 0x03, 0x9F, 0xC0, 0x33, 0xFC, 0x03,
  0x61, 0xE0, 0x7C, 0x0E, 0x07, 0x80, 0x60, 0x78, 0x07, 0x07, 0x00, 0x70,
  0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80,
  0x38, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x6C, 0x0E, 0x06, 0xC3, 0xC0, 0xE7,
  0xF8, 0x0C, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xC1, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x20, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0xFE, 0x70, 0x07, 0xFD, 0xC0, 0x3C, 0x36,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x81, 0xC0, 0x1E, 0x07,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x60, 0x70, 0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x0F, 0x03, 0x80, 0x38, 0x06, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x3E,
  0x01, 0xE1, 0xB0, 0x03, 0xFC, 0xC0, 0x07, 0xE3, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x70, 0x70, 0x70, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xC7, 0x03, 0xC3, 0x9F, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x06, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFE, 0x70, 0x07, 0xFD, 0xC0, 0x3C, 0x36, 0x01, 0xC0, 0x58,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x60, 0x70, 0x01,
  0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x01,
  0x80, 0x1C, 0x06, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80,
  0x38, 0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x3E, 0x01, 0xE3, 0xB8,
  0x03, 0xFC, 0xC0, 0x07, 0xE7, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x02, 0x00, 0xE0, 0x0C, 0x07, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x3B,
  0xFC, 0x06, 0xFF, 0x80, 0xD8, 0x78, 0x3E, 0x07, 0x07, 0x80, 0xE0, 0xE0,
  0x1C, 0x1C, 0x03, 0x83, 0x80, 0x60, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x80,
  0x70, 0x60, 0x0E, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01,
  0xC1, 0x80, 0x38, 0x70, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07,
  0x06, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x1C,
  0x18, 0x03, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x01, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x00,
  0x70, 0xE0, 0x06, 0x0E, 0x00, 0x61, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xCE, 0x00, 0x1D, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x70,
  0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0x83, 0x00, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x30, 0x38, 0x03, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x1C, 0x06, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x19, 0xFC, 0x3F, 0x80,
  0xDF, 0xF3, 0xFE, 0x07, 0xC3, 0xB0, 0xF0, 0x7C, 0x0F, 0x03, 0x83, 0xC0,
  0x70, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x07, 0x0E, 0x01, 0xC0,
  0x38, 0x70, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x0C, 0x1C, 0x03, 0x80, 0xE0,
  0xC0, 0x18, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x70, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0x0C, 0x1C, 0x03, 0x00, 0xE0, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0,
  0x38, 0x70, 0x0E, 0x01, 0x83, 0x80, 0x70, 0x0C, 0x1C, 0x03, 0x00, 0xE0,
  0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x70, 0x0E, 0x01, 0x83, 0x80,
  0x70, 0x1C, 0x18, 0x03, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x67, 0xF8, 0x0D, 0xFF, 0x01, 0xB0, 0xF0,
  0x7C, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xC1,
  0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0C, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0C, 0x01, 0xC3, 0x80, 0x30, 0x70,
  0x0E, 0x0E, 0x01, 0xC1, 0x80, 0x38, 0x70, 0x06, 0x0E, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x80,
  0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x07, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x70,
  0x03, 0x98, 0x00, 0xE6, 0x00, 0x33, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0x8E, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x1C, 0x1C, 0x0E, 0x07, 0x87, 0x80,
  0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x1F,
  0xC0, 0x0C, 0xFF, 0x00, 0x36, 0x0E, 0x01, 0xF0, 0x38, 0x07, 0x80, 0x70,
  0x1E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x60, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x7C, 0x0E, 0x01, 0xB0, 0xF0, 0x06, 0x7F, 0x80,
  0x39, 0xFC, 0x00, 0xE0, 0x80, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0xE7, 0x01, 0xFF, 0x70, 0x3C, 0x36, 0x07, 0x01,
  0x60, 0xF0, 0x1E, 0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x87, 0x00, 0x18, 0x70,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0x60, 0x07, 0x06,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0,
  0x70, 0x1E, 0x07, 0x03, 0xE0, 0x78, 0x6E, 0x03, 0xFC, 0xC0, 0x1F, 0x9C,
  0x00, 0x41, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x06, 0x03,
  0x3F, 0x03, 0x7E, 0x03, 0x70, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0xF0, 0x20, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x40, 0x3C, 0x38, 0x3C, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC1, 0xFF, 0x3F, 0xE1,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC1, 0xF8, 0x08,
  0x00, 0x07, 0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xE0,
  0x1C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x0E, 0x0C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x0E, 0x0E, 0x01,
  0xC1, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07,
  0x06, 0x00, 0xE0, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x7C,
  0x0E, 0x1B, 0x81, 0xFF, 0x60, 0x1F, 0x8C, 0x00, 0x40, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0,
  0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x80, 0xE3, 0x00, 0xE7, 0x00, 0xE7, 0x00,
  0xEE, 0x00, 0xEE, 0x00, 0xEC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x01, 0xF8, 0x07, 0x80,
  0x6E, 0x01, 0xE0, 0x3B, 0x80, 0xF8, 0x0E, 0xE0, 0x36, 0x07, 0x38, 0x0F,
  0x81, 0xCE, 0x07, 0xE0, 0x63, 0x81, 0xB8, 0x38, 0xE0, 0xEE, 0x0E, 0x38,
  0x33, 0x83, 0x0E, 0x0C, 0xE1, 0xC3, 0x87, 0x38, 0x60, 0xE1, 0x8E, 0x38,
  0x38, 0xE3, 0x8E, 0x0E, 0x30, 0xE3, 0x03, 0x8C, 0x39, 0xC0, 0xE7, 0x0C,
  0x60, 0x39, 0x83, 0x38, 0x0E, 0xE0, 0xCE, 0x03, 0xB0, 0x33, 0x00, 0xEC,
  0x0D, 0xC0, 0x3F, 0x03, 0x60, 0x0D, 0x80, 0xD8, 0x03, 0x60, 0x3E, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xCE,
  0x00, 0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0,
  0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE1, 0x80, 0x07, 0x0E, 0x00, 0x70,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x81,
  0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x30, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x81, 0xF0, 0xFF, 0xF8, 0x07, 0xFD, 0x00,
  0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 38, 12, 1, -38 },
  { 54, 13, 14, 16, 5, -38 },
  { 77, 22, 38, 21, 0, -38 },
  { 182, 20, 43, 19, 0, -40 },
  { 290, 25, 39, 30, 3, -38 },
  { 412, 19, 39, 20, 0, -38 },
  { 505, 6, 14, 9, 5, -38 },
  { 516, 15, 46, 13, 1, -38 },
  { 603, 15, 46, 13, -4, -38 },
  { 690, 14, 16, 18, 6, -40 },
  { 718, 19, 25, 22, 2, -31 },
  { 778, 8, 12, 9, -2, -5 },
  { 790, 12, 3, 14, 1, -16 },
  { 795, 4, 5, 9, 1, -5 },
  { 798, 22, 38, 17, -2, -38 },
  { 903, 18, 39, 19, 1, -38 },
  { 991, 11, 38, 19, 6, -38 },
  { 1044, 22, 38, 19, -2, -38 },
  { 1149, 21, 39, 19, -1, -38 },
  { 1252, 21, 38, 19, -1, -38 },
  { 1352, 21, 39, 19, -1, -38 },
  { 1455, 20, 39, 19, 1, -38 },
  { 1553, 20, 38, 19, 2, -38 },
  { 1648, 21, 39, 19, -1, -38 },
  { 1751, 19, 39, 19, 0, -38 },
  { 1844, 9, 28, 9, 0, -28 },
  { 1876, 11, 35, 10, -2, -28 },
  { 1925, 19, 23, 22, 2, -30 },
  { 1980, 19, 14, 22, 2, -26 },
  { 2014, 19, 23, 22, 2, -30 },
  { 2069, 15, 38, 14, 1, -38 },
  { 2141, 27, 43, 29, 1, -38 },
  { 2287, 20, 38, 19, -4, -38 },
  { 2382, 22, 38, 21, 0, -38 },
  { 2487, 21, 39, 19, 2, -38 },
  { 2590, 22, 38, 23, 0, -38 },
  { 2695, 21, 38, 19, 0, -38 },
  { 2795, 21, 38, 17, 0, -38 },
  { 2895, 24, 39, 25, 2, -38 },
  { 3012, 25, 38, 24, 0, -38 },
  { 3131, 18, 38, 11, -3, -38 },
  { 3217, 19, 48, 9, -8, -38 },
  { 3331, 24, 38, 20, 0, -38 },
  { 3445, 13, 38, 17, 0, -38 },
  { 3507, 34, 38, 33, 0, -38 },
  { 3669, 27, 38, 26, 0, -38 },
  { 3798, 22, 39, 25, 2, -38 },
  { 3906, 21, 38, 20, 0, -38 },
  { 4006, 22, 47, 25, 2, -38 },
  { 4136, 21, 38, 21, 0, -38 },
  { 4236, 22, 39, 19, -1, -38 },
  { 4344, 18, 38, 17, 3, -38 },
  { 4430, 23, 39, 24, 2, -38 },
  { 4543, 20, 38, 20, 4, -38 },
  { 4638, 33, 38, 33, 4, -38 },
  { 4795, 25, 38, 18, -3, -38 },
  { 4914, 18, 38, 17, 4, -38 },
  { 5000, 22, 38, 17, -2, -38 },
  { 5105, 19, 46, 15, -1, -38 },
  { 5215, 8, 38, 17, 5, -38 },
  { 5253, 19, 46, 15, -3, -38 },
  { 5363, 20, 19, 21, 1, -38 },
  { 5411, 15, 2, 15, -4, 5 },
  { 5415, 6, 8, 12, 8, -40 },
  { 5421, 20, 30, 21, 1, -29 },
  { 5496, 20, 41, 21, 0, -40 },
  { 5599, 16, 30, 16, 1, -29 },
  { 5659, 22, 41, 21, 1, -40 },
  { 5772, 17, 30, 19, 1, -29 },
  { 5836, 24, 54, 11, -7, -41 },
  { 5998, 22, 42, 21, -1, -29 },
  { 6114, 19, 40, 20, 0, -40 },
  { 6209, 11, 38, 9, 0, -38 },
  { 6262, 18, 51, 9, -7, -38 },
  { 6377, 20, 40, 17, 0, -40 },
  { 6477, 11, 40, 9, 0, -40 },
  { 6532, 29, 29, 31, 0, -29 },
  { 6638, 19, 29, 20, 0, -29 },
  { 6707, 18, 30, 20, 1, -29 },
  { 6775, 22, 41, 21, -2, -29 },
  { 6888, 20, 42, 21, 1, -29 },
  { 6993, 16, 29, 14, 0, -29 },
  { 7051, 17, 30, 16, -1, -29 },
  { 7115, 11, 36, 11, 1, -35 },
  { 7165, 19, 29, 20, 1, -28 },
  { 7234, 16, 28, 16, 3, -28 },
  { 7290, 26, 28, 27, 3, -28 },
  { 7381, 21, 28, 17, -2, -28 },
  { 7455, 26, 41, 17, -6, -28 },
  { 7589, 17, 28, 14, -2, -28 },
  { 7649, 19, 46, 17, 1, -38 },
  { 7759, 3, 53, 19, 8, -40 },
  { 7779, 18, 46, 17, -3, -38 },
  { 7883, 19, 6, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC53PT7B_H_
