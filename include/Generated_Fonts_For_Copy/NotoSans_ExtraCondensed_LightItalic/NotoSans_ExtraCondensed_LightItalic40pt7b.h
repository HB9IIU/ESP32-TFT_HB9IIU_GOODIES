#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x00,
  0x00, 0x00, 0x40, 0xE0, 0xC0, 0xC0, 0x31, 0x98, 0xDC, 0x6C, 0x76, 0x33,
  0x19, 0x8D, 0x86, 0xC2, 0x63, 0x31, 0x80, 0x00, 0x61, 0x00, 0x21, 0x80,
  0x30, 0xC0, 0x18, 0x40, 0x08, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18,
  0x01, 0x0C, 0x8F, 0xFF, 0x80, 0xC2, 0x00, 0x43, 0x00, 0x61, 0x80, 0x30,
  0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x20, 0x04, 0x30, 0x3F, 0xFF, 0x1F,
  0xFF, 0x81, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0x40, 0x08, 0x60, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x0F, 0xE0, 0x7F, 0xE1, 0xCC, 0x43, 0x10, 0x06, 0x20,
  0x18, 0x40, 0x31, 0x80, 0x62, 0x00, 0x64, 0x00, 0xC8, 0x00, 0xD0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x05, 0xC0, 0x19, 0x80, 0x23,
  0x00, 0x46, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x31, 0x08, 0xC3, 0xFF, 0x03,
  0xFC, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x07, 0x00, 0xC3,
  0xF0, 0x30, 0x66, 0x06, 0x18, 0xC1, 0x82, 0x18, 0x30, 0xC3, 0x0C, 0x18,
  0x61, 0x83, 0x0C, 0x60, 0xC1, 0x8C, 0x18, 0x33, 0x03, 0x0C, 0x60, 0x61,
  0x98, 0x0C, 0x33, 0x3D, 0x84, 0xCC, 0xF1, 0x9B, 0x1E, 0x66, 0x63, 0xFC,
  0xD8, 0x6E, 0x33, 0x0C, 0x06, 0x61, 0x81, 0x88, 0x30, 0x33, 0x06, 0x0C,
  0x60, 0x81, 0x0C, 0x30, 0x61, 0x86, 0x08, 0x30, 0x83, 0x06, 0x30, 0x40,
  0xC6, 0x18, 0x19, 0x86, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xE0, 0x31, 0x81,
  0xC6, 0x06, 0x18, 0x18, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x19, 0xC0,
  0x66, 0x01, 0xB0, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xE0, 0x19, 0x8C,
  0xC6, 0x36, 0x18, 0xD8, 0x76, 0xC0, 0xDB, 0x03, 0x6C, 0x0F, 0x30, 0x1C,
  0xC0, 0xE3, 0x03, 0x8C, 0x1B, 0x3F, 0xCC, 0x7E, 0x38, 0x33, 0x76, 0x66,
  0x64, 0xCC, 0xC0, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x41,
  0x18, 0x73, 0x07, 0xEE, 0x1F, 0xC3, 0x80, 0xD0, 0x33, 0x0C, 0x30, 0x86,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x71, 0x86, 0x30, 0xC2, 0x18, 0xC0, 0xFF, 0xFF, 0x5F, 0x60, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x71, 0x81, 0x86, 0x0C, 0x18, 0x30, 0x31,
  0x80, 0xC6, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x9C, 0x06, 0x60, 0x19,
  0x80, 0x66, 0x01, 0x98, 0x0E, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x1C,
  0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x30, 0x30, 0xC1, 0xC3, 0x06, 0x0E, 0x30,
  0x1F, 0xC0, 0x7E, 0x00, 0x01, 0x83, 0xC3, 0xC3, 0xE3, 0xB7, 0x19, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x02, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00,
  0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x02, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x80, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x16, 0x00, 0x36, 0x00, 0x66, 0x00,
  0x6C, 0x00, 0xCC, 0x00, 0x8C, 0x01, 0x8C, 0x03, 0x1C, 0x03, 0x18, 0x06,
  0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x30, 0x30, 0x30, 0x60,
  0x30, 0x60, 0x30, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x80,
  0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x8C, 0x06, 0x7E, 0x0D, 0x8E, 0x1C, 0x0C, 0x38, 0x18, 0xE0,
  0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C,
  0x60, 0x30, 0xC0, 0x61, 0x81, 0x81, 0x87, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1C,
  0x30, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0E,
  0x18, 0x18, 0x30, 0x70, 0x31, 0xC0, 0x77, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0x60, 0x38, 0x60, 0x60, 0xE1, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x07,
  0x30, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x83, 0x83, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x71, 0xC3, 0x83, 0x0C, 0x0C, 0x70,
  0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30,
  0x1C, 0xC0, 0x73, 0x83, 0xC6, 0x1F, 0x1F, 0xD8, 0x3E, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x3F, 0xC0, 0xFC, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x83, 0x87, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x00, 0xC0, 0x00, 0x0F, 0x87, 0xF8, 0x43, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xFC, 0x00, 0xC0, 0xE0, 0x18, 0x06, 0x03, 0x00, 0x30, 0x60, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x18, 0x1F, 0x11, 0x87, 0xE1, 0x30, 0x66,
  0x13, 0x0C, 0x63, 0x21, 0x86, 0x36, 0x18, 0x43, 0x63, 0x0C, 0x36, 0x30,
  0xC3, 0x43, 0x0C, 0x2C, 0x21, 0x86, 0xC6, 0x18, 0x6C, 0x61, 0x84, 0xC6,
  0x38, 0xCC, 0x63, 0x88, 0xC3, 0x69, 0x8C, 0x3C, 0xF0, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x20, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xC1, 0x81, 0x83, 0x03,
  0x06, 0x0F, 0xFC, 0x1F, 0xF8, 0x70, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01,
  0x8C, 0x03, 0x38, 0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x3E, 0x00, 0x60,
  0x03, 0xE0, 0x03, 0xFC, 0x03, 0x0E, 0x07, 0x07, 0x06, 0x03, 0x06, 0x03,
  0x06, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x0E,
  0x0C, 0x1C, 0x1F, 0xF0, 0x1F, 0xF0, 0x18, 0x38, 0x18, 0x18, 0x18, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0x60, 0x18,
  0x60, 0x38, 0x60, 0x30, 0x60, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x7F, 0xC0, 0x70, 0x40, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xE0, 0x01, 0xFE, 0x00, 0xCF, 0x80, 0xE0, 0xE0, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x0E, 0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x61, 0xC0,
  0x70, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x38, 0x18, 0x78, 0x1F, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xFC, 0x07, 0x83, 0x01, 0xC0, 0x20, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x0F, 0xC3, 0x01, 0xF8,
  0x60, 0x03, 0x0C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x61,
  0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x0E, 0x01, 0x80,
  0xE0, 0x30, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x01, 0x83, 0x80, 0x70, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x0E, 0x01, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x07,
  0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x1C,
  0x03, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60,
  0x0C, 0x0C, 0x01, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x7A, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x60,
  0x30, 0x38, 0x1C, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18,
  0x60, 0x0E, 0x30, 0x03, 0x1C, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x0D, 0x80,
  0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x0E, 0x30, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xE0, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x18, 0x1C, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0xD8, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x6C,
  0x0D, 0x00, 0x36, 0x0C, 0x80, 0x3B, 0x06, 0x60, 0x1B, 0x03, 0x30, 0x1D,
  0x81, 0x98, 0x0C, 0xC0, 0xCC, 0x06, 0x60, 0xC6, 0x06, 0x30, 0x63, 0x03,
  0x30, 0x31, 0x83, 0x18, 0x18, 0xC1, 0x8C, 0x1C, 0x61, 0x86, 0x0C, 0x30,
  0xC7, 0x06, 0x18, 0xC3, 0x03, 0x0C, 0x61, 0x81, 0x86, 0x60, 0xC1, 0x83,
  0x30, 0x60, 0xC1, 0xB0, 0x60, 0x60, 0xD8, 0x30, 0x30, 0x7C, 0x18, 0x18,
  0x3C, 0x0C, 0x18, 0x1E, 0x06, 0x0C, 0x0E, 0x06, 0x00, 0x03, 0x80, 0x30,
  0x38, 0x03, 0x03, 0x80, 0x30, 0x78, 0x07, 0x07, 0x80, 0x60, 0x6C, 0x06,
  0x06, 0xC0, 0x60, 0x6C, 0x06, 0x0C, 0xC0, 0xE0, 0xCC, 0x0C, 0x0C, 0xC0,
  0xC0, 0xC6, 0x0C, 0x0C, 0x60, 0xC1, 0x86, 0x18, 0x18, 0x61, 0x81, 0x86,
  0x18, 0x18, 0x21, 0x83, 0x83, 0x38, 0x30, 0x33, 0x03, 0x03, 0x30, 0x30,
  0x33, 0x03, 0x03, 0x30, 0x70, 0x1F, 0x06, 0x01, 0xE0, 0x60, 0x1E, 0x06,
  0x01, 0xE0, 0x60, 0x1E, 0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xE0, 0x70, 0x60, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x1B, 0x80, 0x1D, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x63, 0x80, 0x31, 0xC0,
  0x38, 0x60, 0x18, 0x30, 0x18, 0x1C, 0x1C, 0x07, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xC0, 0x03, 0xFC, 0x03, 0x3E, 0x07, 0x06, 0x06, 0x07, 0x06, 0x07,
  0x06, 0x03, 0x06, 0x03, 0x0E, 0x07, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06,
  0x0C, 0x0C, 0x18, 0x1C, 0x18, 0x38, 0x1F, 0xF0, 0x1F, 0xC0, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xE0, 0x70, 0x60, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x1B, 0x80, 0x1D, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x73, 0x80, 0x30, 0xC0,
  0x38, 0x60, 0x18, 0x30, 0x18, 0x1C, 0x1C, 0x07, 0xFC, 0x01, 0xF8, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x03, 0x3E, 0x07, 0x06, 0x06,
  0x07, 0x06, 0x07, 0x06, 0x03, 0x06, 0x07, 0x0E, 0x07, 0x0C, 0x06, 0x0C,
  0x06, 0x0C, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x78, 0x1F, 0xF0, 0x1F,
  0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xE0, 0x30, 0x60, 0x70,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x70, 0xE0, 0x30, 0xC0,
  0x30, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xE0, 0xC0, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x20, 0x38, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0xC1, 0x80, 0x70, 0xE0, 0x18, 0x30, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x38, 0x70, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x38, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x38, 0x30, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x18, 0x38, 0x06, 0x0E, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x30, 0x38,
  0x1C, 0x06, 0x06, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x37, 0x00, 0x6E, 0x01, 0x9C, 0x03, 0x38, 0x0E, 0x70, 0x18,
  0xE0, 0x31, 0xC0, 0xC3, 0x81, 0x87, 0x07, 0x0E, 0x0C, 0x18, 0x38, 0x30,
  0x60, 0x60, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0,
  0x19, 0x80, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x01, 0xF0, 0x0E, 0x01, 0xF0, 0x07,
  0x00, 0xD8, 0x03, 0x80, 0x6C, 0x03, 0xC0, 0x66, 0x01, 0xE0, 0x33, 0x01,
  0xB0, 0x39, 0x80, 0xD8, 0x18, 0xC0, 0x6C, 0x0C, 0x60, 0x64, 0x0C, 0x30,
  0x32, 0x06, 0x18, 0x31, 0x07, 0x0C, 0x18, 0x83, 0x06, 0x0C, 0xC1, 0x83,
  0x0C, 0x61, 0x81, 0x86, 0x30, 0xC0, 0xC6, 0x18, 0xE0, 0x63, 0x0C, 0x60,
  0x31, 0x86, 0x30, 0x19, 0x83, 0x30, 0x0C, 0xC1, 0x98, 0x06, 0x40, 0xCC,
  0x03, 0x60, 0x6C, 0x01, 0xB0, 0x36, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x18, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x61,
  0xC0, 0x18, 0x60, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x1C,
  0x01, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x30, 0x00, 0xE0, 0x1F, 0x00, 0xD8, 0x0C, 0xC0, 0xE6,
  0x06, 0x30, 0x71, 0x83, 0x0C, 0x38, 0x61, 0x83, 0x1C, 0x18, 0xC0, 0xCE,
  0x03, 0x60, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x80, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x82, 0x03, 0xF8,
  0x00, 0xC3, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC1, 0x06, 0x18, 0x61, 0x86, 0x18, 0x60, 0xC3, 0x0C, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x36, 0x00, 0xCC, 0x03, 0x1C, 0x06, 0x18, 0x18, 0x30, 0x30, 0x30,
  0xC0, 0x61, 0x80, 0xC6, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0x80, 0xFF, 0xFF,
  0xFC, 0xCC, 0x66, 0x33, 0x10, 0x01, 0x80, 0x0F, 0xCC, 0x3C, 0xD0, 0x60,
  0xE1, 0x81, 0xC7, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x31,
  0x80, 0x63, 0x01, 0xCE, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0,
  0x61, 0x81, 0xC3, 0x03, 0x87, 0x0B, 0x07, 0xF6, 0x07, 0xC8, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x30, 0x1D, 0xF8, 0x36, 0x70, 0x78, 0x70, 0xE0, 0x61,
  0x80, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x31, 0x80,
  0x63, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x61,
  0xC1, 0xC2, 0x83, 0x0D, 0xDC, 0x19, 0xF0, 0x00, 0x00, 0xC0, 0x7F, 0x0F,
  0x20, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x86,
  0x03, 0xF3, 0x03, 0xCF, 0x01, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0xC0,
  0x70, 0x60, 0x30, 0x70, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x07, 0x0E,
  0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x70,
  0x30, 0x38, 0x1C, 0x2C, 0x07, 0x76, 0x01, 0xF2, 0x00, 0x00, 0xC0, 0x7F,
  0x0E, 0x31, 0xC3, 0x18, 0x33, 0x83, 0x30, 0x37, 0x03, 0x60, 0x66, 0x1C,
  0x7F, 0x8F, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x04, 0x7B, 0x83, 0xF8, 0x00, 0x01, 0x00, 0x01, 0xF0, 0x00,
  0xE4, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0B, 0x80, 0x03, 0xE0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFC, 0xC0, 0xF3, 0x40, 0x60, 0xE0,
  0x60, 0x70, 0x70, 0x38, 0x30, 0x1C, 0x18, 0x0C, 0x1C, 0x06, 0x0C, 0x03,
  0x06, 0x01, 0x83, 0x01, 0xC3, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60,
  0x38, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0x0F, 0x01, 0xFD, 0x80,
  0x7D, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x08, 0x0C, 0x07, 0x1C, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x20, 0x33, 0xE0, 0xD9, 0xC3, 0x83, 0x0E, 0x0C, 0x30, 0x31,
  0xC0, 0xC6, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x18,
  0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18,
  0xE0, 0x63, 0x01, 0x80, 0x03, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x0B, 0x80, 0x78, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x02, 0x1C, 0x18, 0x30, 0x60, 0x61, 0xC0,
  0xC3, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x37, 0x00, 0x7E,
  0x01, 0xEC, 0x03, 0x98, 0x07, 0x30, 0x0C, 0x60, 0x38, 0xE0, 0x60, 0xC0,
  0xC1, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x1C, 0x00, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x20, 0x37,
  0xE7, 0xE0, 0xD9, 0xF9, 0xC3, 0x83, 0x83, 0x0E, 0x0E, 0x0C, 0x30, 0x30,
  0x31, 0xC0, 0xC0, 0xC6, 0x07, 0x07, 0x18, 0x18, 0x18, 0x60, 0x60, 0x61,
  0x81, 0x81, 0x8C, 0x06, 0x06, 0x30, 0x30, 0x30, 0xC0, 0xC0, 0xC3, 0x03,
  0x03, 0x1C, 0x0C, 0x0C, 0x60, 0x70, 0x31, 0x81, 0x81, 0x86, 0x06, 0x06,
  0x18, 0x18, 0x18, 0xE0, 0x60, 0x63, 0x03, 0x03, 0x80, 0x00, 0x20, 0x33,
  0xE0, 0xD9, 0xC3, 0x83, 0x0E, 0x0C, 0x30, 0x31, 0xC0, 0xC6, 0x03, 0x18,
  0x1C, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03, 0x1C,
  0x0C, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x01, 0x80,
  0x01, 0xC0, 0x3F, 0x83, 0x9C, 0x38, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x66,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x3C, 0x03, 0xE0, 0x1B, 0x00,
  0xD8, 0x06, 0xC0, 0x66, 0x03, 0x30, 0x30, 0xC3, 0x87, 0xF8, 0x1F, 0x80,
  0x00, 0x0C, 0x01, 0x9F, 0x80, 0xD9, 0xC0, 0x78, 0x70, 0x38, 0x18, 0x18,
  0x0C, 0x1C, 0x06, 0x0E, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE1,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x1C, 0x06,
  0x0E, 0x06, 0x07, 0x07, 0x03, 0x83, 0x03, 0xFF, 0x01, 0x9F, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xCC, 0x38, 0xD0,
  0x60, 0xE1, 0x81, 0xC7, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x00, 0xCE, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x38,
  0xC0, 0x61, 0x81, 0xC3, 0x03, 0x87, 0x0F, 0x07, 0xF6, 0x07, 0xD8, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x30, 0xCF, 0x0D, 0xE0, 0xF0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0xE0, 0x3F, 0xC3, 0x86, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x31, 0x03, 0x8F, 0xF8,
  0x3F, 0x80, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x7F, 0x7F, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xF8, 0xF8, 0x1C, 0x0C, 0x60, 0x31, 0x81, 0xC6, 0x06, 0x18,
  0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x30, 0x31, 0xC0, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x61, 0x81, 0x8E, 0x06, 0x30, 0x38, 0xC0, 0xE3, 0x07, 0x0C,
  0x1C, 0x3F, 0xB0, 0x7C, 0xC0, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0,
  0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0xC3, 0x0C, 0x30, 0xC6, 0x0C, 0x60, 0xC6,
  0x0C, 0xC0, 0xCC, 0x05, 0x80, 0x58, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x00, 0xE0, 0x60, 0x3C, 0x06, 0x06, 0xC0, 0xE0, 0x6C, 0x0A, 0x0C, 0xC1,
  0xA0, 0xCC, 0x1A, 0x0C, 0xC1, 0x21, 0x8C, 0x32, 0x18, 0xC3, 0x63, 0x0C,
  0x66, 0x30, 0xC6, 0x63, 0x0C, 0xC6, 0x60, 0xCC, 0x66, 0x0C, 0xC6, 0x40,
  0xD8, 0x6C, 0x0D, 0x86, 0xC0, 0xD0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x07, 0x07, 0x06, 0x03, 0x0C,
  0x03, 0x1C, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xC0,
  0x0C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x60, 0x60, 0xE0, 0x70,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x07, 0x00, 0xC0, 0xC0, 0x18, 0x18,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x09, 0xC0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x04, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x80, 0x03, 0xC0, 0x17, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x03, 0xC0,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x02, 0xFF, 0x0F, 0x07, 0xF4, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 9, 11, 12, 4, -29 },
  { 43, 17, 29, 16, 0, -29 },
  { 105, 15, 32, 15, 0, -30 },
  { 165, 19, 29, 23, 2, -29 },
  { 234, 14, 29, 15, 0, -29 },
  { 285, 4, 11, 7, 4, -29 },
  { 291, 11, 35, 10, 1, -29 },
  { 340, 12, 35, 10, -3, -29 },
  { 393, 11, 12, 14, 4, -30 },
  { 410, 15, 18, 17, 1, -23 },
  { 444, 6, 9, 7, -2, -4 },
  { 451, 8, 2, 10, 1, -12 },
  { 453, 3, 4, 7, 1, -4 },
  { 455, 17, 29, 13, -2, -29 },
  { 517, 14, 29, 15, 1, -29 },
  { 568, 9, 29, 15, 4, -29 },
  { 601, 16, 29, 15, -1, -29 },
  { 659, 16, 29, 15, -1, -29 },
  { 717, 16, 29, 15, -1, -29 },
  { 775, 16, 29, 15, -1, -29 },
  { 833, 15, 29, 15, 1, -29 },
  { 888, 15, 29, 15, 1, -29 },
  { 943, 15, 29, 15, 0, -29 },
  { 998, 14, 29, 15, 0, -29 },
  { 1049, 7, 21, 7, 0, -21 },
  { 1068, 9, 26, 7, -2, -21 },
  { 1098, 15, 17, 17, 1, -23 },
  { 1130, 15, 10, 17, 1, -19 },
  { 1149, 15, 17, 17, 1, -23 },
  { 1181, 11, 29, 11, 1, -29 },
  { 1221, 20, 32, 22, 1, -29 },
  { 1301, 15, 29, 15, -3, -29 },
  { 1356, 16, 29, 16, 0, -29 },
  { 1414, 17, 29, 14, 1, -29 },
  { 1476, 17, 29, 18, 0, -29 },
  { 1538, 16, 29, 14, 0, -29 },
  { 1596, 16, 29, 13, 0, -29 },
  { 1654, 19, 29, 19, 1, -29 },
  { 1723, 19, 29, 18, 0, -29 },
  { 1792, 13, 29, 9, -2, -29 },
  { 1840, 14, 36, 7, -6, -29 },
  { 1903, 18, 29, 15, 0, -29 },
  { 1969, 10, 29, 13, 0, -29 },
  { 2006, 25, 29, 25, 0, -29 },
  { 2097, 20, 29, 19, 0, -29 },
  { 2170, 17, 29, 19, 1, -29 },
  { 2232, 16, 29, 15, 0, -29 },
  { 2290, 17, 36, 19, 1, -29 },
  { 2367, 16, 29, 16, 0, -29 },
  { 2425, 17, 29, 14, -1, -29 },
  { 2487, 13, 29, 13, 3, -29 },
  { 2535, 18, 29, 18, 1, -29 },
  { 2601, 15, 29, 15, 3, -29 },
  { 2656, 25, 29, 25, 3, -29 },
  { 2747, 18, 29, 13, -2, -29 },
  { 2813, 13, 29, 13, 3, -29 },
  { 2861, 17, 29, 13, -2, -29 },
  { 2923, 15, 35, 11, -1, -29 },
  { 2989, 6, 29, 13, 4, -29 },
  { 3011, 15, 35, 11, -3, -29 },
  { 3077, 15, 15, 16, 1, -29 },
  { 3106, 11, 2, 11, -3, 3 },
  { 3109, 4, 7, 9, 6, -31 },
  { 3113, 15, 22, 16, 1, -22 },
  { 3155, 15, 30, 16, 0, -30 },
  { 3212, 12, 22, 12, 1, -22 },
  { 3245, 17, 30, 16, 1, -30 },
  { 3309, 12, 22, 14, 1, -22 },
  { 3342, 18, 41, 8, -5, -31 },
  { 3435, 17, 32, 16, -1, -22 },
  { 3503, 14, 30, 15, 0, -30 },
  { 3556, 8, 29, 7, 0, -29 },
  { 3585, 13, 39, 7, -5, -29 },
  { 3649, 15, 30, 13, 0, -30 },
  { 3706, 9, 30, 7, 0, -30 },
  { 3740, 22, 22, 23, 0, -22 },
  { 3801, 14, 22, 15, 0, -22 },
  { 3840, 13, 22, 15, 1, -22 },
  { 3876, 17, 31, 16, -2, -22 },
  { 3942, 15, 31, 16, 1, -22 },
  { 4001, 12, 22, 10, 0, -22 },
  { 4034, 13, 22, 12, -1, -22 },
  { 4070, 8, 26, 8, 1, -26 },
  { 4096, 14, 21, 15, 1, -21 },
  { 4133, 12, 21, 12, 2, -21 },
  { 4165, 20, 21, 20, 2, -21 },
  { 4218, 16, 21, 13, -2, -21 },
  { 4260, 19, 31, 13, -4, -21 },
  { 4334, 13, 21, 10, -1, -21 },
  { 4369, 14, 35, 13, 1, -29 },
  { 4431, 2, 41, 14, 6, -31 },
  { 4442, 14, 35, 13, -3, -29 },
  { 4504, 15, 4, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC40PT7B_H_
