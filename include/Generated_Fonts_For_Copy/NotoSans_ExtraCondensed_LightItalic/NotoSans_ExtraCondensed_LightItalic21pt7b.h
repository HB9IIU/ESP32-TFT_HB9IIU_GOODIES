#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x00, 0x23, 0x00, 0x4A,
  0x55, 0x29, 0x00, 0x05, 0x84, 0x82, 0x41, 0x23, 0xFA, 0x90, 0x48, 0x48,
  0x24, 0x7F, 0x12, 0x09, 0x04, 0x84, 0x82, 0x40, 0x04, 0x04, 0x1F, 0x24,
  0x28, 0x28, 0x28, 0x18, 0x08, 0x14, 0x14, 0x14, 0x14, 0x94, 0xF8, 0x20,
  0x20, 0x38, 0x92, 0x24, 0x92, 0x24, 0x8A, 0x24, 0x89, 0x5E, 0x59, 0xEA,
  0x42, 0x91, 0x44, 0x51, 0x24, 0x91, 0x24, 0x30, 0x0E, 0x12, 0x12, 0x32,
  0x14, 0x14, 0x18, 0x30, 0x4B, 0x4A, 0x8A, 0x8C, 0x84, 0x8C, 0xF6, 0x56,
  0x80, 0x04, 0x20, 0x84, 0x20, 0x82, 0x10, 0x41, 0x04, 0x30, 0xC1, 0x04,
  0x10, 0x41, 0x80, 0x18, 0x20, 0x82, 0x08, 0x30, 0xC2, 0x08, 0x20, 0x86,
  0x10, 0x42, 0x08, 0x42, 0x00, 0x12, 0x45, 0x4E, 0x53, 0x20, 0x10, 0x20,
  0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x25, 0x28, 0xF8, 0x70, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x00, 0x0E, 0x13, 0x31, 0x21, 0x21, 0x63, 0x42, 0x42, 0x42,
  0x42, 0xC4, 0xC4, 0xC4, 0x48, 0x70, 0x19, 0x95, 0x21, 0x18, 0x84, 0x21,
  0x10, 0x84, 0x23, 0x00, 0x0F, 0x08, 0xC0, 0x20, 0x10, 0x10, 0x08, 0x0C,
  0x04, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0xF8, 0x1E, 0x23, 0x01,
  0x01, 0x02, 0x02, 0x0C, 0x38, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0xF0,
  0x03, 0x06, 0x06, 0x0A, 0x0A, 0x12, 0x24, 0x24, 0x44, 0x44, 0x8C, 0xFE,
  0x08, 0x08, 0x08, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x78, 0x04, 0x06,
  0x06, 0x06, 0x04, 0x04, 0x88, 0xF0, 0x07, 0x18, 0x10, 0x20, 0x20, 0x60,
  0x5C, 0x62, 0x42, 0x42, 0x42, 0xC6, 0x44, 0x4C, 0x78, 0x7F, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0xC0, 0x80,
  0x1E, 0x31, 0x21, 0x21, 0x23, 0x22, 0x1C, 0x18, 0x64, 0xC4, 0x86, 0x86,
  0x84, 0x84, 0x78, 0x1E, 0x32, 0x23, 0x21, 0x43, 0x42, 0x42, 0x66, 0x3A,
  0x02, 0x04, 0x04, 0x08, 0x18, 0xF0, 0x32, 0x00, 0x00, 0x00, 0x0C, 0x80,
  0x18, 0x80, 0x00, 0x00, 0x00, 0x01, 0x18, 0x84, 0x40, 0x02, 0x0C, 0x63,
  0x08, 0x0C, 0x06, 0x06, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0x80,
  0xC0, 0x60, 0x21, 0x8C, 0x20, 0x80, 0x3C, 0x10, 0x41, 0x04, 0x21, 0x0C,
  0x21, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x47,
  0x52, 0x99, 0x26, 0x49, 0x92, 0x69, 0x2A, 0x4A, 0xB4, 0x92, 0x20, 0x08,
  0x03, 0x10, 0x38, 0x00, 0x02, 0x0C, 0x18, 0x50, 0xA1, 0x44, 0x89, 0x22,
  0x7D, 0x8A, 0x14, 0x30, 0x60, 0x80, 0x1E, 0x08, 0x84, 0x66, 0x32, 0x11,
  0x08, 0x98, 0x78, 0x62, 0x21, 0x10, 0x88, 0x44, 0x24, 0x23, 0xE0, 0x0F,
  0x10, 0x20, 0x60, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0x78, 0x1E, 0x08, 0x84, 0x66, 0x12, 0x09, 0x04, 0x82, 0x43, 0x61,
  0x20, 0x90, 0xC8, 0x44, 0x64, 0x63, 0xC0, 0x1F, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x22, 0x3C, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0xF8, 0x1F, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x3E, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x0F, 0x88, 0x48, 0x0C, 0x04, 0x06, 0x02, 0x01, 0x0E, 0x81, 0x40,
  0xA0, 0x90, 0x48, 0x26, 0x11, 0xF8, 0x10, 0x44, 0x11, 0x0C, 0xC2, 0x20,
  0x88, 0x22, 0x08, 0xFC, 0x61, 0x10, 0x44, 0x11, 0x04, 0x42, 0x20, 0x88,
  0x20, 0x1E, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x3C, 0x00, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x88, 0x84, 0xC6,
  0x42, 0x41, 0x60, 0xA0, 0x70, 0x68, 0x24, 0x13, 0x08, 0x84, 0x44, 0x22,
  0x18, 0x10, 0x84, 0x62, 0x10, 0x84, 0x62, 0x10, 0x84, 0x43, 0xE0, 0x18,
  0x18, 0xC0, 0xC6, 0x0E, 0x70, 0x72, 0x83, 0x14, 0x28, 0xA1, 0x45, 0x12,
  0x48, 0xB2, 0x49, 0x12, 0x48, 0x94, 0x44, 0xA2, 0x46, 0x22, 0x31, 0x00,
  0x18, 0x63, 0x08, 0x61, 0x1C, 0x22, 0x84, 0x59, 0x09, 0x21, 0x24, 0x44,
  0x88, 0xB1, 0x14, 0x21, 0x84, 0x31, 0x06, 0x20, 0xC0, 0x0F, 0x18, 0x88,
  0x48, 0x34, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44,
  0x61, 0xE0, 0x1E, 0x13, 0x11, 0x31, 0x21, 0x21, 0x22, 0x26, 0x78, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x0F, 0x18, 0x88, 0x48, 0x34, 0x1A, 0x0A,
  0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x61, 0xE0, 0x20, 0x18,
  0x04, 0x02, 0x00, 0x1E, 0x13, 0x11, 0x31, 0x21, 0x21, 0x22, 0x3E, 0x68,
  0x48, 0x4C, 0x44, 0x44, 0x84, 0x84, 0x0F, 0x8C, 0x44, 0x02, 0x01, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x80, 0x40, 0x24, 0x33, 0xF0, 0x7E,
  0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x30,
  0x00, 0x20, 0x90, 0xC8, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84, 0x82, 0x41,
  0x21, 0x90, 0x88, 0x44, 0x63, 0xE0, 0x83, 0x82, 0x84, 0x84, 0x8C, 0x88,
  0x88, 0x90, 0x90, 0xB0, 0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x82, 0x1C, 0x30,
  0xA1, 0x85, 0x14, 0x48, 0xA2, 0x45, 0x32, 0x49, 0x12, 0x48, 0xA2, 0x85,
  0x24, 0x29, 0x61, 0x8A, 0x0C, 0x50, 0x43, 0x02, 0x18, 0x00, 0x18, 0xC2,
  0x20, 0x90, 0x24, 0x0A, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x05, 0x02, 0x40,
  0x90, 0x44, 0x11, 0x08, 0x40, 0x43, 0x42, 0x44, 0x44, 0x48, 0x48, 0x50,
  0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x1F, 0x80, 0xC0, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x03,
  0xF0, 0x1E, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0xC0, 0x93, 0x24, 0x92, 0x48, 0x92, 0x48, 0x1E,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x11, 0xE0, 0x0C, 0x0C, 0x14, 0x12, 0x22, 0x22, 0x41, 0xC1, 0xFC,
  0x94, 0x3E, 0xCD, 0x1E, 0x38, 0x50, 0xA1, 0x46, 0x89, 0x33, 0xA0, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42,
  0x46, 0xC4, 0xB8, 0x3D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0x00,
  0x01, 0x01, 0x01, 0x03, 0x02, 0x3E, 0x66, 0x46, 0xC6, 0x84, 0x84, 0x84,
  0x8C, 0x88, 0x98, 0xE8, 0x3D, 0x14, 0x61, 0x9B, 0x88, 0x20, 0x82, 0x0F,
  0x00, 0x01, 0xC0, 0xC0, 0x20, 0x08, 0x02, 0x03, 0xC0, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0xE0, 0x00, 0x1F, 0x33, 0x23, 0x63, 0x42, 0x42, 0x42, 0x46,
  0x44, 0x4C, 0x74, 0x04, 0x04, 0x08, 0x98, 0xF0, 0x18, 0x20, 0x40, 0x81,
  0x05, 0xCC, 0x91, 0x22, 0xC5, 0x0A, 0x34, 0x48, 0xA1, 0x42, 0x11, 0x01,
  0x22, 0x22, 0x64, 0x44, 0x48, 0x80, 0x02, 0x04, 0x00, 0x00, 0x60, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x87, 0x00,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x23, 0x26, 0x24, 0x28, 0x70, 0x68, 0x48,
  0x48, 0x48, 0x88, 0x8C, 0x18, 0x84, 0x21, 0x10, 0x84, 0x23, 0x10, 0x84,
  0x22, 0x10, 0x2E, 0xE3, 0x33, 0x22, 0x22, 0x22, 0x62, 0x24, 0x22, 0x44,
  0x24, 0x44, 0x44, 0x48, 0x44, 0x8C, 0x40, 0x2E, 0x64, 0x89, 0x16, 0x28,
  0x51, 0xA2, 0x45, 0x0A, 0x10, 0x3C, 0x89, 0x1C, 0x28, 0x50, 0xA1, 0x42,
  0x89, 0x33, 0xC0, 0x17, 0x0C, 0x44, 0x22, 0x13, 0x09, 0x0C, 0x84, 0x42,
  0x23, 0x31, 0x17, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x3E, 0xCD, 0x1C,
  0x38, 0x50, 0xA1, 0x46, 0x89, 0x33, 0xA0, 0x40, 0x82, 0x04, 0x08, 0x2C,
  0xC2, 0x08, 0x61, 0x04, 0x10, 0x42, 0x08, 0x00, 0x3D, 0x04, 0x10, 0x20,
  0x41, 0x82, 0x08, 0x6F, 0x00, 0x10, 0x8C, 0xF2, 0x10, 0x88, 0x42, 0x10,
  0x88, 0x30, 0x42, 0x8D, 0x12, 0x28, 0x50, 0xA3, 0x44, 0x89, 0x33, 0xA0,
  0x86, 0x18, 0xA2, 0x92, 0x4B, 0x28, 0xA3, 0x0C, 0x00, 0x84, 0x71, 0x8A,
  0x32, 0x4A, 0x49, 0x49, 0x2A, 0x29, 0x45, 0x30, 0xC6, 0x18, 0xC3, 0x10,
  0x00, 0x11, 0x12, 0x12, 0x14, 0x08, 0x18, 0x18, 0x28, 0x24, 0x44, 0xC4,
  0x08, 0xC2, 0x20, 0x98, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x02, 0x03, 0x00, 0x1E, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x60, 0x83, 0xE0, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x61, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC0, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x0C, 0x1C, 0x20, 0x81,
  0x02, 0x04, 0x10, 0x21, 0xC0, 0x41, 0x66, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 15, 5, 0, -15 },
  { 11, 5, 5, 6, 2, -15 },
  { 15, 9, 15, 8, 0, -15 },
  { 32, 8, 17, 8, 0, -16 },
  { 49, 10, 15, 12, 1, -15 },
  { 68, 8, 15, 8, 0, -15 },
  { 83, 2, 5, 3, 2, -15 },
  { 85, 6, 18, 5, 0, -15 },
  { 99, 6, 18, 5, -1, -15 },
  { 113, 6, 6, 7, 2, -16 },
  { 118, 7, 9, 9, 1, -12 },
  { 126, 3, 5, 4, -1, -2 },
  { 128, 5, 1, 5, 0, -6 },
  { 129, 2, 2, 4, 0, -2 },
  { 130, 9, 15, 7, -1, -15 },
  { 147, 8, 15, 8, 0, -15 },
  { 162, 5, 15, 8, 2, -15 },
  { 172, 9, 15, 8, -1, -15 },
  { 189, 8, 15, 8, 0, -15 },
  { 204, 8, 15, 8, 0, -15 },
  { 219, 8, 15, 8, 0, -15 },
  { 234, 8, 15, 8, 0, -15 },
  { 249, 8, 15, 8, 1, -15 },
  { 264, 8, 15, 8, 0, -15 },
  { 279, 8, 15, 8, 0, -15 },
  { 294, 4, 11, 4, 0, -11 },
  { 300, 5, 14, 4, -1, -11 },
  { 309, 7, 9, 9, 1, -12 },
  { 317, 7, 5, 9, 1, -10 },
  { 322, 7, 9, 9, 1, -12 },
  { 330, 6, 15, 6, 0, -15 },
  { 342, 10, 17, 12, 1, -15 },
  { 364, 7, 15, 8, -1, -15 },
  { 378, 9, 15, 8, 0, -15 },
  { 395, 8, 15, 8, 1, -15 },
  { 410, 9, 15, 9, 0, -15 },
  { 427, 8, 15, 7, 0, -15 },
  { 442, 8, 15, 7, 0, -15 },
  { 457, 9, 15, 10, 1, -15 },
  { 474, 10, 15, 10, 0, -15 },
  { 493, 7, 15, 4, -1, -15 },
  { 507, 7, 19, 4, -3, -15 },
  { 524, 9, 15, 8, 0, -15 },
  { 541, 5, 15, 7, 0, -15 },
  { 551, 13, 15, 13, 0, -15 },
  { 576, 11, 15, 10, 0, -15 },
  { 597, 9, 15, 10, 1, -15 },
  { 614, 8, 15, 8, 0, -15 },
  { 629, 9, 19, 10, 1, -15 },
  { 651, 8, 15, 8, 0, -15 },
  { 666, 9, 15, 8, -1, -15 },
  { 683, 7, 15, 7, 1, -15 },
  { 697, 9, 15, 9, 1, -15 },
  { 714, 8, 15, 8, 2, -15 },
  { 729, 13, 15, 13, 2, -15 },
  { 754, 10, 15, 7, -1, -15 },
  { 773, 8, 15, 7, 1, -15 },
  { 788, 9, 15, 7, -1, -15 },
  { 805, 7, 18, 6, 0, -15 },
  { 821, 3, 15, 7, 2, -15 },
  { 827, 7, 18, 6, -1, -15 },
  { 843, 8, 8, 8, 0, -15 },
  { 851, 6, 1, 6, -2, 2 },
  { 852, 2, 3, 5, 3, -16 },
  { 853, 7, 11, 8, 1, -11 },
  { 863, 8, 16, 8, 0, -16 },
  { 879, 6, 11, 6, 1, -11 },
  { 888, 8, 16, 8, 1, -16 },
  { 904, 6, 11, 7, 1, -11 },
  { 913, 10, 21, 4, -3, -16 },
  { 940, 8, 16, 8, 0, -11 },
  { 956, 7, 16, 8, 0, -16 },
  { 970, 4, 15, 4, 0, -15 },
  { 978, 7, 20, 4, -3, -15 },
  { 996, 8, 16, 7, 0, -16 },
  { 1012, 5, 16, 4, 0, -16 },
  { 1022, 12, 11, 12, 0, -11 },
  { 1039, 7, 11, 8, 0, -11 },
  { 1049, 7, 11, 8, 1, -11 },
  { 1059, 9, 16, 8, -1, -11 },
  { 1077, 7, 16, 8, 1, -11 },
  { 1091, 6, 11, 5, 0, -11 },
  { 1100, 6, 11, 6, 0, -11 },
  { 1109, 5, 14, 4, 0, -14 },
  { 1118, 7, 11, 8, 1, -11 },
  { 1128, 6, 11, 6, 1, -11 },
  { 1137, 11, 11, 11, 1, -11 },
  { 1153, 8, 11, 7, -1, -11 },
  { 1164, 10, 16, 7, -2, -11 },
  { 1184, 7, 11, 5, -1, -11 },
  { 1194, 7, 18, 7, 1, -15 },
  { 1210, 1, 21, 7, 3, -16 },
  { 1213, 7, 18, 7, -1, -15 },
  { 1229, 7, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC21PT7B_H_
