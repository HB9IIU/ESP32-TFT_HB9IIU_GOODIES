#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x7E, 0x59, 0xC0, 0xF5, 0xF0, 0xDF, 0x80, 0x6A, 0x80,
  0xF8, 0xC0, 0x74, 0xC0, 0x80, 0x80, 0x5A, 0xFE, 0xF0, 0x57, 0x57, 0x7D,
  0xE7, 0xFF, 0x56, 0xDF, 0xF7, 0x20, 0x30, 0xD0, 0xF0, 0xF0, 0x5A, 0x7F,
  0xC4, 0x5F, 0xFF, 0xF2, 0x60, 0xF6, 0xE0, 0xFB, 0xFA, 0xF2, 0xF0, 0xBE,
  0xE0, 0xEA, 0x55, 0xC0, 0xF3, 0x60, 0xF0, 0x9A, 0xDE, 0xAF, 0x60, 0xF6,
  0xE0, 0xFA, 0xF6, 0xE4, 0xFF, 0xE7, 0xDA, 0xB6, 0xE0, 0xEA, 0xBD, 0xAA,
  0xDB, 0xDA, 0x5A, 0xEA, 0x80, 0xF0, 0x56, 0x80, 0x70, 0x80, 0x80, 0xFC,
  0x6F, 0xC0, 0xE8, 0x2E, 0xEC, 0xEC, 0x29, 0x25, 0x80, 0xFF, 0x6F, 0xC0,
  0x70, 0x15, 0xC0, 0x66, 0xC0, 0xF8, 0xFF, 0x80, 0xFC, 0xFC, 0xFE, 0xFD,
  0xE8, 0xEC, 0xF0, 0xFC, 0xE8, 0xF7, 0x00, 0xE8, 0x69, 0x60, 0xE8, 0x5A,
  0x80, 0xFC, 0x56, 0x80, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 2, 4, 2, 0, -4 },
  { 4, 2, 5, 2, 0, -5 },
  { 6, 3, 4, 3, 0, -4 },
  { 8, 2, 4, 2, 0, -4 },
  { 9, 1, 1, 1, 0, -4 },
  { 10, 2, 5, 2, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 2, 2, 1, -5 },
  { 14, 2, 3, 2, 0, -4 },
  { 15, 1, 2, 1, 0, -1 },
  { 16, 1, 1, 2, 0, -2 },
  { 17, 1, 1, 1, 0, -1 },
  { 18, 2, 4, 2, 0, -4 },
  { 19, 2, 4, 2, 0, -4 },
  { 20, 1, 4, 2, 1, -4 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 2, 4, 2, 0, -4 },
  { 27, 2, 4, 2, 0, -4 },
  { 28, 2, 4, 2, 0, -4 },
  { 29, 1, 3, 1, 0, -3 },
  { 30, 1, 4, 1, 0, -3 },
  { 31, 2, 2, 2, 0, -3 },
  { 32, 2, 2, 2, 0, -3 },
  { 33, 2, 2, 2, 0, -3 },
  { 34, 2, 4, 2, 0, -4 },
  { 35, 3, 5, 3, 0, -4 },
  { 37, 2, 4, 2, 0, -4 },
  { 38, 2, 4, 2, 0, -4 },
  { 39, 3, 4, 2, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 2, 4, 2, 0, -4 },
  { 44, 2, 4, 2, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 3, 4, 3, 0, -4 },
  { 49, 2, 4, 1, 0, -4 },
  { 50, 2, 5, 1, -1, -4 },
  { 52, 3, 4, 2, 0, -4 },
  { 54, 1, 4, 2, 0, -4 },
  { 55, 4, 4, 4, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 3, 5, 3, 0, -4 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 2, 4, 2, 1, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 2, 4, 2, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 2, 5, 2, 0, -4 },
  { 77, 1, 4, 2, 1, -4 },
  { 78, 2, 5, 2, 0, -4 },
  { 80, 2, 2, 2, 0, -4 },
  { 81, 1, 1, 2, 0, 0 },
  { 82, 1, 1, 1, 1, -5 },
  { 83, 2, 3, 2, 0, -3 },
  { 84, 2, 5, 2, 0, -5 },
  { 86, 2, 3, 2, 0, -3 },
  { 87, 3, 5, 2, 0, -5 },
  { 89, 2, 3, 2, 0, -3 },
  { 90, 3, 6, 1, -1, -5 },
  { 93, 2, 4, 2, 0, -3 },
  { 94, 2, 5, 2, 0, -5 },
  { 96, 1, 4, 1, 0, -4 },
  { 97, 2, 5, 1, -1, -4 },
  { 99, 2, 5, 2, 0, -5 },
  { 101, 1, 5, 1, 0, -5 },
  { 102, 3, 3, 3, 0, -3 },
  { 104, 2, 3, 2, 0, -3 },
  { 105, 2, 3, 2, 0, -3 },
  { 106, 2, 4, 2, 0, -3 },
  { 107, 2, 4, 2, 0, -3 },
  { 108, 2, 3, 2, 0, -3 },
  { 109, 2, 3, 2, 0, -3 },
  { 110, 1, 4, 1, 0, -4 },
  { 111, 2, 3, 2, 0, -3 },
  { 112, 2, 3, 2, 0, -3 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 2, 3, 2, 0, -3 },
  { 116, 3, 4, 2, -1, -3 },
  { 118, 2, 3, 2, 0, -3 },
  { 119, 2, 5, 2, 0, -4 },
  { 121, 1, 6, 2, 1, -5 },
  { 122, 2, 5, 2, 0, -4 },
  { 124, 2, 1, 2, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC6PT7B_H_
