#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0xE0, 0x33, 0x23, 0x63, 0x62, 0x66, 0x46, 0x46, 0xC4, 0xC4, 0x01, 0x8C,
  0x06, 0x20, 0x11, 0x80, 0xC6, 0x03, 0x10, 0x08, 0xC0, 0x23, 0x0F, 0xFF,
  0x3F, 0xFC, 0x11, 0x80, 0xC4, 0x02, 0x10, 0x08, 0xC0, 0x62, 0x01, 0x88,
  0x3F, 0xF8, 0xFF, 0xE0, 0xC4, 0x02, 0x30, 0x18, 0xC0, 0x62, 0x01, 0x08,
  0x04, 0x60, 0x31, 0x00, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0F, 0xF0, 0xC9,
  0x0C, 0xC0, 0x64, 0x02, 0x20, 0x11, 0x00, 0xC8, 0x06, 0xC0, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x98, 0x04, 0xC0, 0x22, 0x01, 0x10, 0x09,
  0x80, 0x8C, 0x44, 0xC3, 0xFC, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x1C, 0x04, 0x7C, 0x18, 0x88, 0x23, 0x10, 0xC4, 0x21, 0x18, 0x46, 0x31,
  0x88, 0x43, 0x30, 0x86, 0x41, 0x09, 0x82, 0x32, 0x7C, 0x6D, 0x99, 0x92,
  0x3E, 0x6C, 0x58, 0x90, 0x83, 0x61, 0x04, 0xC2, 0x19, 0x8C, 0x22, 0x18,
  0xC4, 0x23, 0x08, 0xC6, 0x11, 0x98, 0x36, 0x30, 0x78, 0x03, 0xC0, 0x7C,
  0x04, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x0D, 0x80, 0xD0,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0x63, 0x62, 0x36, 0x32, 0xC3, 0x6C, 0x14,
  0xC1, 0xC8, 0x18, 0x81, 0x8C, 0x3C, 0xE6, 0xC7, 0xCC, 0x32, 0x66, 0x64,
  0x44, 0xC0, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30,
  0x18, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x00, 0x02,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x00, 0x0C, 0x04, 0x22, 0x1D,
  0x13, 0xF8, 0xC0, 0xB0, 0xC8, 0xC6, 0x02, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x33, 0x26, 0x4C, 0x80, 0xFF,
  0xFC, 0x6F, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x03, 0x80, 0xF8, 0x31, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x19, 0x03, 0x60,
  0x6C, 0x0D, 0x81, 0xA0, 0x2C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0x90,
  0x32, 0x06, 0x41, 0x88, 0x31, 0x8C, 0x33, 0x03, 0xC0, 0x06, 0x18, 0xF3,
  0xEC, 0xD1, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x60,
  0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x01, 0xE0, 0x3F, 0x81, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xE0, 0x7F,
  0x81, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x38, 0x0F, 0x00, 0x78, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE3, 0x0E, 0x1F, 0xC0,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x05, 0x00, 0x48, 0x06, 0xC0,
  0x26, 0x03, 0x30, 0x31, 0x01, 0x18, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0xC1,
  0x04, 0x18, 0x60, 0xC3, 0xFF, 0xBF, 0xFC, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0xF8, 0x1F, 0xC1, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xE0, 0x33, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xE3, 0x0E, 0x1F, 0xC0, 0x00, 0xF0, 0x3F, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x60, 0x6F, 0x85, 0x18,
  0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18,
  0xC1, 0x8C, 0x30, 0x66, 0x07, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x03, 0xC0, 0x7F, 0x0C, 0x31, 0x81,
  0x18, 0x11, 0x81, 0x18, 0x31, 0x83, 0x18, 0x60, 0xCE, 0x0D, 0x80, 0x70,
  0x0F, 0x03, 0x98, 0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x04, 0x80, 0x48, 0x0C,
  0xC0, 0xCC, 0x18, 0x63, 0x83, 0xF0, 0x03, 0xC0, 0x7E, 0x0C, 0x21, 0x83,
  0x18, 0x31, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x73, 0x06,
  0x30, 0xA1, 0xFE, 0x1E, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x70, 0x8E, 0x0F, 0x80, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xE3, 0x00, 0x02, 0x03, 0x07, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x0C, 0x00, 0x0F, 0x07, 0xE1, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x06, 0x03, 0x80, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0xC0, 0x80, 0xC0, 0x60, 0xC0, 0x10, 0xC0, 0x08, 0x40, 0x06, 0x61,
  0xF3, 0x21, 0x91, 0xB1, 0x88, 0xD8, 0x8C, 0x48, 0xC6, 0x24, 0x42, 0x16,
  0x21, 0x1B, 0x31, 0x8D, 0x18, 0xC4, 0x8C, 0x46, 0x46, 0x62, 0x23, 0x3B,
  0x10, 0xE7, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1D, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xB0, 0x1B, 0x01, 0xB0, 0x13, 0x03, 0x30, 0x33, 0x06, 0x30, 0x63,
  0x04, 0x30, 0xC3, 0x0F, 0xF1, 0xFF, 0x18, 0x33, 0x03, 0x30, 0x33, 0x03,
  0x60, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0x80, 0x3F, 0x81, 0x0E, 0x18,
  0x30, 0xC0, 0x86, 0x04, 0x30, 0x61, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x18,
  0x3F, 0x03, 0x1C, 0x18, 0x30, 0xC0, 0x86, 0x06, 0x20, 0x33, 0x01, 0x18,
  0x18, 0xC0, 0xC6, 0x0E, 0x20, 0x63, 0xFE, 0x1F, 0xC0, 0x00, 0xF0, 0x1F,
  0xC1, 0xC2, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xE4, 0x07, 0xE0,
  0x07, 0x80, 0x1F, 0xC0, 0x43, 0x83, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0,
  0xC2, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x03, 0x30, 0x18, 0xC0,
  0x63, 0x01, 0x8C, 0x06, 0x20, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x60,
  0xC1, 0x06, 0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x3F, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC1, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x00, 0xF8, 0x07, 0xFC, 0x1C, 0x08, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x0F,
  0x98, 0x1F, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x11, 0x80, 0x63, 0x00, 0xC6,
  0x01, 0x86, 0x02, 0x0C, 0x0C, 0x0E, 0x38, 0x0F, 0xF0, 0x06, 0x03, 0x06,
  0x03, 0x04, 0x02, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x08,
  0x04, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x1F, 0xFC, 0x30, 0x18, 0x30,
  0x18, 0x30, 0x18, 0x30, 0x18, 0x20, 0x10, 0x60, 0x30, 0x60, 0x30, 0x60,
  0x30, 0x60, 0x30, 0x40, 0x20, 0xC0, 0x60, 0xC0, 0x60, 0x07, 0xE0, 0xFC,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x07, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x78, 0x0F, 0x00, 0x06, 0x06, 0x0C, 0x18, 0x10, 0x60, 0x60, 0xC0, 0xC3,
  0x01, 0x8C, 0x03, 0x18, 0x04, 0x60, 0x19, 0x80, 0x36, 0x00, 0x6C, 0x00,
  0xB8, 0x03, 0xF0, 0x07, 0x60, 0x0C, 0xC0, 0x18, 0x80, 0x21, 0x80, 0xC3,
  0x01, 0x86, 0x03, 0x0C, 0x06, 0x08, 0x08, 0x18, 0x30, 0x30, 0x60, 0x60,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x2C, 0x06, 0xC1, 0x60, 0x34, 0x1B, 0x01, 0x60,
  0xD8, 0x1B, 0x06, 0xC0, 0x98, 0x26, 0x0C, 0xC3, 0x30, 0x44, 0x18, 0x86,
  0x60, 0xC4, 0x23, 0x06, 0x23, 0x18, 0x21, 0x10, 0xC3, 0x09, 0x84, 0x18,
  0x4C, 0x60, 0xC2, 0xC3, 0x04, 0x16, 0x18, 0x20, 0xE0, 0x83, 0x07, 0x04,
  0x18, 0x30, 0x60, 0x06, 0x01, 0x83, 0x00, 0x81, 0xC0, 0x41, 0xE0, 0x60,
  0xF0, 0x30, 0x78, 0x18, 0x24, 0x08, 0x12, 0x0C, 0x19, 0x86, 0x0C, 0xC3,
  0x06, 0x61, 0x82, 0x30, 0x83, 0x08, 0xC1, 0x84, 0x60, 0xC3, 0x30, 0x61,
  0x98, 0x20, 0xC8, 0x30, 0x2C, 0x18, 0x16, 0x0C, 0x0B, 0x06, 0x07, 0x02,
  0x03, 0x83, 0x01, 0xC1, 0x80, 0x60, 0x01, 0xE0, 0x0F, 0xE0, 0x61, 0x83,
  0x03, 0x18, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80, 0x36,
  0x00, 0xD8, 0x02, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x33,
  0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0xC1, 0x83, 0x07, 0x38, 0x0F, 0xC0,
  0x07, 0x80, 0x3F, 0x01, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61,
  0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x20, 0xC3, 0x1C, 0x1F, 0xC0, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x61, 0x83, 0x03, 0x18, 0x0C,
  0x60, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x02,
  0x40, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x03,
  0x30, 0x18, 0xC0, 0xC1, 0x83, 0x07, 0x38, 0x0F, 0xC0, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x07, 0x00, 0x3F, 0x01,
  0x0C, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x03, 0x18, 0x18, 0xC1,
  0x86, 0x0C, 0x20, 0xC3, 0xFC, 0x1F, 0x80, 0xCC, 0x06, 0x20, 0x21, 0x83,
  0x0C, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x20, 0x63, 0x03, 0x18, 0x18, 0x00,
  0xF0, 0x0F, 0xF0, 0x60, 0x83, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC2,
  0x03, 0x0E, 0x78, 0x3F, 0xC0, 0x7F, 0xEF, 0xFC, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x0C, 0x06, 0x10, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3,
  0x01, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x41, 0x01,
  0x86, 0x03, 0x0C, 0x06, 0x18, 0x08, 0x20, 0x30, 0xC0, 0x61, 0x80, 0xC3,
  0x01, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x18, 0xE0, 0x1F, 0x80, 0xC0,
  0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0xC1,
  0x8C, 0x30, 0xC3, 0x0C, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0xD8,
  0x0D, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x30, 0x1B, 0x01, 0x80, 0xD8, 0x1C, 0x0C, 0x80, 0xE0, 0x64, 0x07, 0x03,
  0x20, 0x78, 0x31, 0x02, 0xC1, 0x88, 0x36, 0x18, 0x41, 0xB0, 0xC2, 0x09,
  0x86, 0x10, 0xCC, 0x60, 0x84, 0x43, 0x04, 0x62, 0x10, 0x23, 0x11, 0x81,
  0x10, 0x8C, 0x09, 0x84, 0xC0, 0x48, 0x26, 0x06, 0xC1, 0x20, 0x36, 0x0B,
  0x01, 0xA0, 0x58, 0x0F, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x80, 0xC0, 0x1C,
  0x06, 0x00, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x31, 0x80,
  0x63, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xA0, 0x03, 0x60, 0x0C, 0xC0, 0x19, 0x80,
  0x63, 0x00, 0x86, 0x03, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x60, 0x30, 0x60,
  0x2C, 0x0D, 0x81, 0x30, 0x66, 0x08, 0xC3, 0x18, 0x43, 0x18, 0x22, 0x04,
  0xC0, 0x90, 0x16, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xF0, 0x3F, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xFC, 0x00, 0xC2, 0x10,
  0x86, 0x31, 0x8C, 0x61, 0x08, 0x43, 0x18, 0xC6, 0x10, 0x84, 0x31, 0x8C,
  0x63, 0x03, 0xF0, 0x3F, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0xFC, 0x00, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x58, 0x0D, 0x81, 0x88, 0x18, 0xC3, 0x0C, 0x30, 0x46, 0x06,
  0x40, 0x6C, 0x03, 0xFF, 0xC0, 0xCC, 0x62, 0x30, 0x07, 0x10, 0xFB, 0x18,
  0x73, 0x06, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x4C, 0x0C, 0xC0,
  0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x38, 0xE5, 0x87, 0xD0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x9C, 0x0B,
  0xE1, 0xE3, 0x1C, 0x31, 0x83, 0x18, 0x31, 0x03, 0x30, 0x33, 0x03, 0x30,
  0x32, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0C, 0x60, 0xCD, 0x38, 0xDF,
  0x00, 0x07, 0xC3, 0xE1, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x62, 0x1F, 0x80,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x01, 0xCC, 0x0F, 0xB0, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0x61, 0x81,
  0x86, 0x06, 0x30, 0x10, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0xC1,
  0x83, 0x06, 0x0C, 0x38, 0x39, 0x60, 0x79, 0x00, 0x07, 0x83, 0xF1, 0x8C,
  0xC3, 0x20, 0xD8, 0x36, 0x19, 0x0E, 0xFE, 0x3E, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x62, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x68, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x78, 0x03, 0xF0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x01, 0xC4, 0x0F,
  0xB0, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30,
  0x10, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC1, 0x83, 0x06, 0x0C,
  0x38, 0x39, 0x60, 0x79, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x20, 0xC0, 0xFF, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xDC, 0x0B, 0xE1, 0xC3, 0x1C, 0x31,
  0x83, 0x18, 0x21, 0x02, 0x30, 0x63, 0x06, 0x30, 0x62, 0x04, 0x60, 0xC6,
  0x0C, 0x60, 0xC6, 0x0C, 0x40, 0x8C, 0x18, 0xC1, 0x80, 0x06, 0x0C, 0x10,
  0x00, 0x00, 0x03, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20,
  0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x3C,
  0x07, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC3, 0x08, 0x21, 0x86, 0x18, 0xC1, 0x98, 0x11, 0x01, 0x30, 0x36,
  0x03, 0xE0, 0x3A, 0x03, 0x30, 0x63, 0x06, 0x30, 0x63, 0x06, 0x30, 0x41,
  0x0C, 0x18, 0xC1, 0x80, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x08,
  0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10,
  0x60, 0xC0, 0x09, 0xC3, 0x82, 0xFB, 0xF1, 0xC3, 0x8C, 0x60, 0xC3, 0x18,
  0x30, 0xC6, 0x08, 0x31, 0x06, 0x0C, 0xC1, 0x82, 0x30, 0x60, 0x8C, 0x10,
  0x62, 0x0C, 0x19, 0x83, 0x06, 0x60, 0xC1, 0x18, 0x30, 0xC6, 0x08, 0x31,
  0x06, 0x0C, 0xC1, 0x83, 0x30, 0x60, 0x80, 0x09, 0xC0, 0xBE, 0x1C, 0x31,
  0xC3, 0x18, 0x31, 0x82, 0x10, 0x23, 0x06, 0x30, 0x63, 0x06, 0x20, 0x46,
  0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x08, 0xC1, 0x8C, 0x18, 0x07, 0x81,
  0xF8, 0x63, 0x18, 0x33, 0x06, 0xC0, 0xD8, 0x1A, 0x03, 0xC0, 0x78, 0x0B,
  0x03, 0x60, 0x6C, 0x0D, 0x83, 0x30, 0x66, 0x18, 0x66, 0x0F, 0x80, 0x04,
  0xE0, 0x2F, 0x83, 0xC6, 0x1C, 0x30, 0xC0, 0x86, 0x04, 0x20, 0x63, 0x03,
  0x18, 0x18, 0xC0, 0xC4, 0x06, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC1, 0x86,
  0x1C, 0x69, 0xC3, 0x7C, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x00, 0x07, 0x10, 0xFB, 0x18, 0x73, 0x06,
  0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x38, 0xE5, 0x87, 0x90, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x09, 0xC2, 0xF1,
  0xE0, 0x70, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x87, 0xF3, 0x04,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x8E, 0x3F, 0x00, 0x08, 0x10, 0x60, 0xC1, 0xEF,
  0xCC, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x04,
  0x0C, 0x1E, 0x00, 0x10, 0x22, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x40, 0x98,
  0x33, 0x06, 0x60, 0xCC, 0x19, 0x02, 0x60, 0xCC, 0x19, 0x83, 0x30, 0xE6,
  0x18, 0xED, 0x0F, 0x60, 0xC0, 0xF0, 0x6C, 0x1B, 0x04, 0xC3, 0x30, 0xCC,
  0x63, 0x18, 0xCC, 0x33, 0x0C, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x30, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3, 0x82, 0xC2, 0x86, 0xC2,
  0x86, 0xC6, 0x8C, 0xC4, 0x8C, 0xCD, 0x88, 0xCD, 0x98, 0xC9, 0x98, 0xD9,
  0x90, 0xD1, 0xB0, 0xF1, 0xA0, 0xB1, 0xE0, 0xA1, 0xE0, 0xE1, 0xC0, 0xC1,
  0xC0, 0xC1, 0x80, 0x08, 0x18, 0x61, 0x83, 0x18, 0x18, 0xC0, 0xCC, 0x02,
  0x40, 0x16, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x16, 0x01, 0xB0,
  0x19, 0x80, 0xC4, 0x0C, 0x20, 0xC1, 0x86, 0x0C, 0x00, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0x80, 0xC3, 0x00, 0x86, 0x01, 0x18,
  0x02, 0x30, 0x04, 0xC0, 0x09, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x50, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0xE1,
  0xF8, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x10, 0x1E, 0x03, 0x80, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xE0, 0x0F, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x70, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x38, 0x0F, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x0F, 0x00, 0x7C, 0x1C, 0x7F, 0x81,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 24, 7, 0, -24 },
  { 25, 8, 9, 10, 3, -24 },
  { 34, 14, 24, 13, 0, -24 },
  { 76, 13, 27, 12, 0, -25 },
  { 120, 15, 24, 19, 2, -24 },
  { 165, 12, 24, 12, 0, -24 },
  { 201, 4, 9, 5, 3, -24 },
  { 206, 9, 29, 8, 1, -24 },
  { 239, 9, 29, 8, -2, -24 },
  { 272, 9, 10, 11, 4, -25 },
  { 284, 12, 15, 14, 1, -19 },
  { 307, 4, 7, 6, -1, -3 },
  { 311, 7, 2, 9, 1, -10 },
  { 313, 3, 3, 6, 0, -3 },
  { 315, 15, 24, 10, -2, -24 },
  { 360, 11, 24, 12, 1, -24 },
  { 393, 7, 24, 12, 4, -24 },
  { 414, 13, 24, 12, -1, -24 },
  { 453, 13, 24, 12, -1, -24 },
  { 492, 13, 24, 12, -1, -24 },
  { 531, 13, 24, 12, -1, -24 },
  { 570, 12, 24, 12, 1, -24 },
  { 606, 12, 24, 12, 1, -24 },
  { 642, 12, 24, 12, 0, -24 },
  { 678, 12, 24, 12, 0, -24 },
  { 714, 6, 18, 6, 0, -18 },
  { 728, 8, 22, 6, -2, -18 },
  { 750, 12, 14, 14, 1, -19 },
  { 771, 12, 9, 14, 1, -16 },
  { 785, 12, 14, 14, 1, -19 },
  { 806, 10, 24, 9, 0, -24 },
  { 836, 17, 27, 18, 1, -24 },
  { 894, 12, 24, 12, -2, -24 },
  { 930, 13, 24, 13, 0, -24 },
  { 969, 13, 24, 12, 1, -24 },
  { 1008, 14, 24, 14, 0, -24 },
  { 1050, 13, 24, 12, 0, -24 },
  { 1089, 13, 24, 11, 0, -24 },
  { 1128, 15, 24, 16, 1, -24 },
  { 1173, 16, 24, 15, 0, -24 },
  { 1221, 11, 24, 7, -2, -24 },
  { 1254, 12, 30, 6, -5, -24 },
  { 1299, 15, 24, 12, 0, -24 },
  { 1344, 8, 24, 11, 0, -24 },
  { 1368, 21, 24, 20, 0, -24 },
  { 1431, 17, 24, 16, 0, -24 },
  { 1482, 14, 24, 16, 1, -24 },
  { 1524, 13, 24, 12, 0, -24 },
  { 1563, 14, 30, 16, 1, -24 },
  { 1616, 13, 24, 13, 0, -24 },
  { 1655, 14, 24, 12, -1, -24 },
  { 1697, 11, 24, 11, 2, -24 },
  { 1730, 15, 24, 15, 1, -24 },
  { 1775, 12, 24, 12, 3, -24 },
  { 1811, 21, 24, 21, 2, -24 },
  { 1874, 15, 24, 11, -2, -24 },
  { 1919, 11, 24, 11, 2, -24 },
  { 1952, 14, 24, 11, -1, -24 },
  { 1994, 12, 29, 9, -1, -24 },
  { 2038, 5, 24, 11, 3, -24 },
  { 2053, 12, 29, 9, -2, -24 },
  { 2097, 12, 12, 13, 1, -24 },
  { 2115, 10, 1, 9, -3, 3 },
  { 2117, 4, 5, 7, 5, -25 },
  { 2120, 12, 18, 13, 1, -18 },
  { 2147, 12, 25, 13, 0, -25 },
  { 2185, 10, 18, 10, 1, -18 },
  { 2208, 14, 25, 13, 1, -25 },
  { 2252, 10, 18, 12, 1, -18 },
  { 2275, 15, 33, 7, -4, -25 },
  { 2337, 14, 26, 13, -1, -18 },
  { 2383, 12, 25, 13, 0, -25 },
  { 2421, 7, 24, 6, 0, -24 },
  { 2442, 11, 32, 6, -4, -24 },
  { 2486, 12, 25, 11, 0, -25 },
  { 2524, 7, 25, 6, 0, -25 },
  { 2546, 18, 18, 19, 0, -18 },
  { 2587, 12, 18, 13, 0, -18 },
  { 2614, 11, 18, 13, 1, -18 },
  { 2639, 13, 26, 13, -1, -18 },
  { 2682, 12, 26, 13, 1, -18 },
  { 2721, 10, 18, 8, 0, -18 },
  { 2744, 10, 18, 10, 0, -18 },
  { 2767, 7, 22, 7, 1, -22 },
  { 2787, 11, 18, 13, 1, -18 },
  { 2812, 10, 18, 10, 2, -18 },
  { 2835, 16, 18, 17, 2, -18 },
  { 2871, 13, 18, 10, -1, -18 },
  { 2901, 15, 26, 10, -3, -18 },
  { 2950, 11, 18, 8, -1, -18 },
  { 2975, 12, 29, 11, 1, -24 },
  { 3019, 2, 33, 12, 5, -25 },
  { 3028, 11, 29, 11, -2, -24 },
  { 3068, 12, 3, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC33PT7B_H_
