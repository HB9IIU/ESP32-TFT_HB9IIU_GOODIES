#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x1C,
  0x3C, 0xF0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x06, 0x18, 0x18, 0xE0, 0xE3, 0x83, 0x8C,
  0x0C, 0x30, 0x30, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x07, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x30, 0x00,
  0x30, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x0E, 0x00,
  0x06, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0xC0,
  0x01, 0xC0, 0xC0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x70, 0x30,
  0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xF3, 0x3E, 0x03, 0x86, 0x08, 0x0E,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1,
  0x80, 0x03, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1E, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0x3C, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xBC, 0x00, 0x03, 0x38, 0x00, 0x06, 0x38, 0x00, 0x18, 0x70, 0x00,
  0x30, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x07, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x20, 0x30, 0xE0, 0x60, 0xC3,
  0xC0, 0xFD, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x3F, 0xC0, 0x0E, 0x01, 0xCE,
  0x00, 0x60, 0x1C, 0x38, 0x07, 0x01, 0xC1, 0xC0, 0x30, 0x0E, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x18, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x1C, 0x0C, 0x03,
  0x80, 0xC0, 0xE0, 0x1C, 0x06, 0x0E, 0x00, 0xE0, 0x70, 0x70, 0x06, 0x03,
  0x87, 0x00, 0x70, 0x1C, 0x38, 0x03, 0x80, 0xE3, 0x80, 0x1C, 0x06, 0x1C,
  0x00, 0xE0, 0x71, 0xC0, 0x07, 0x03, 0x8E, 0x1F, 0x30, 0x18, 0xE1, 0xFD,
  0x81, 0xC7, 0x1C, 0xEC, 0x0E, 0x71, 0xC3, 0x70, 0xE3, 0x9C, 0x1F, 0x87,
  0x38, 0xE0, 0xFC, 0x71, 0xCE, 0x07, 0x7F, 0x1C, 0x70, 0x39, 0xF0, 0xE3,
  0x01, 0xC0, 0x0E, 0x38, 0x0C, 0x00, 0x71, 0xC0, 0x60, 0x07, 0x0E, 0x07,
  0x00, 0x38, 0x60, 0x38, 0x03, 0x87, 0x01, 0xC0, 0x1C, 0x38, 0x0E, 0x01,
  0xC1, 0xC0, 0x60, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38, 0x07, 0x03,
  0x01, 0x80, 0x70, 0x18, 0x1C, 0x03, 0x80, 0xC0, 0xE0, 0x38, 0x06, 0x0E,
  0x01, 0xC0, 0x38, 0x70, 0x1C, 0x01, 0xC7, 0x00, 0xE0, 0x07, 0xF0, 0x0E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x79, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xCE, 0x01, 0x07, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x38,
  0x70, 0xE0, 0x71, 0xE3, 0x80, 0xE3, 0x87, 0x01, 0xE7, 0x1C, 0x01, 0xDC,
  0x38, 0x03, 0xB8, 0x70, 0x07, 0xE0, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0xF8, 0x1C, 0x03, 0xF0, 0x3C,
  0x0E, 0xF0, 0x7C, 0x78, 0xE0, 0x7F, 0xE1, 0xC0, 0x7F, 0x83, 0xC0, 0x18,
  0x00, 0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x18, 0xE3,
  0x8E, 0x30, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xC1, 0x80, 0xF1, 0x80, 0x7D, 0x8F, 0x1F, 0xFF, 0x07, 0xFF, 0x07, 0x80,
  0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xE0, 0x78, 0x70, 0xF0, 0x70, 0x60, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x27, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0xE0, 0x0E,
  0x07, 0x00, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x80, 0x38,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x79, 0xE0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x00,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x0F, 0x0F, 0x00, 0x7D, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x03,
  0xF0, 0x7E, 0x0F, 0xE1, 0xEE, 0x3C, 0xEF, 0x9E, 0xE1, 0xC4, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x70,
  0x1E, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xF3, 0xF0, 0x07, 0x01, 0xE0, 0x08, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x40, 0x0F, 0x80, 0xF0, 0x7E, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x50, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xCE, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x78, 0x03,
  0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x02, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x80, 0x1F, 0x00, 0xF0, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xF9, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x71, 0xFC, 0x03, 0x9F,
  0xF8, 0x0E, 0xF1, 0xF0, 0x3F, 0x03, 0xC0, 0xF8, 0x07, 0x87, 0xC0, 0x1E,
  0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x3E,
  0x7C, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07,
  0x03, 0x80, 0x0F, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x70,
  0x00, 0xF1, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC7, 0x80, 0x0F, 0x03, 0xC0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x3F, 0x0F, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x38, 0x0F,
  0x00, 0xE0, 0x38, 0x03, 0x81, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0,
  0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x38, 0x07, 0xE0, 0xF0, 0x3F,
  0x03, 0xE1, 0xDC, 0x07, 0xFE, 0x70, 0x0F, 0xF3, 0xC0, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xC3,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0xC0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE7, 0xE0, 0x80, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0x70, 0x0F, 0xE0, 0xE0, 0xC0,
  0x3F, 0xE1, 0xC3, 0x80, 0xF1, 0x83, 0x87, 0x03, 0x87, 0x07, 0x0C, 0x0E,
  0x0E, 0x0E, 0x38, 0x18, 0x1C, 0x1C, 0x60, 0x70, 0x30, 0x38, 0xC0, 0xE0,
  0xE0, 0x63, 0x83, 0x81, 0xC0, 0xC7, 0x07, 0x03, 0x81, 0x8C, 0x0C, 0x06,
  0x07, 0x18, 0x38, 0x1C, 0x0E, 0x70, 0x70, 0x38, 0x18, 0xE0, 0xE0, 0x70,
  0x31, 0xC1, 0x80, 0xC0, 0xE3, 0x83, 0x03, 0x81, 0x86, 0x06, 0x07, 0x03,
  0x0C, 0x1C, 0x1E, 0x0E, 0x18, 0x38, 0x3C, 0x18, 0x30, 0x30, 0x58, 0x70,
  0x60, 0x61, 0xB1, 0xC1, 0xC0, 0xE6, 0x67, 0x03, 0x81, 0xFC, 0xFC, 0x03,
  0x01, 0xE0, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x04, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C,
  0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80,
  0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xF0,
  0x3E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x1E, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x03, 0xE0, 0x0E, 0x00,
  0xF0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0xF0, 0x78, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x0F,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xDE, 0x00, 0x7C,
  0x02, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x02,
  0x00, 0x1F, 0x9E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1E,
  0x0F, 0xC0, 0x0E, 0x01, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80,
  0x03, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0xF0, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x3C, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03, 0x80, 0x3E, 0x01,
  0xC0, 0x3E, 0x00, 0xE0, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0xFF,
  0x00, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0x04, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x07, 0x00, 0x1F, 0xF0, 0x70, 0x03,
  0xFE, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x07, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x10,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x01,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF7, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x01,
  0xDC, 0x00, 0x07, 0x70, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x1D, 0xC0, 0x00,
  0xF7, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x0E,
  0x38, 0x03, 0x8C, 0x00, 0x39, 0xE0, 0x1E, 0x30, 0x01, 0xC7, 0x00, 0x70,
  0xE0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x07, 0x0F, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x38, 0x1E, 0x0E,
  0x00, 0xE0, 0xE0, 0x70, 0x78, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0x1C, 0x0E,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x38, 0x1C, 0x01, 0xC0, 0xE1, 0xC0, 0xF0,
  0x0F, 0x03, 0x87, 0x03, 0x80, 0x38, 0x0E, 0x38, 0x0E, 0x00, 0xE0, 0x38,
  0xE0, 0x38, 0x03, 0x80, 0xE7, 0x00, 0xE0, 0x0E, 0x03, 0x9C, 0x07, 0x80,
  0x78, 0x0E, 0xE0, 0x1C, 0x01, 0xC0, 0x3B, 0x80, 0x70, 0x07, 0x00, 0x7C,
  0x01, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03,
  0x80, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x3F, 0x00,
  0x0F, 0x00, 0xFC, 0x00, 0x38, 0x03, 0xF0, 0x00, 0xE0, 0x0F, 0xC0, 0x03,
  0x80, 0x3F, 0x00, 0x0E, 0x01, 0xCC, 0x00, 0x78, 0x07, 0x38, 0x01, 0xC0,
  0x1C, 0xE0, 0x07, 0x00, 0x73, 0x80, 0x1C, 0x01, 0xCE, 0x00, 0x70, 0x0E,
  0x38, 0x03, 0xC0, 0x38, 0x70, 0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x03, 0x87,
  0x00, 0xE0, 0x1E, 0x1C, 0x07, 0x80, 0x70, 0x70, 0x1C, 0x01, 0xC1, 0xC0,
  0x70, 0x07, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x07, 0x00, 0xF0, 0x38, 0x3C,
  0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x0E, 0x0E, 0x00,
  0xE0, 0x1C, 0x38, 0x07, 0x00, 0x71, 0xE0, 0x1C, 0x01, 0xC7, 0x00, 0x70,
  0x07, 0x1C, 0x01, 0xC0, 0x1C, 0x70, 0x0F, 0x00, 0x39, 0xC0, 0x38, 0x00,
  0xEE, 0x00, 0xE0, 0x03, 0xB8, 0x03, 0x80, 0x0E, 0xE0, 0x0E, 0x00, 0x3B,
  0x80, 0x78, 0x00, 0xEE, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x07, 0xC0,
  0x1C, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC3,
  0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0xCE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x78, 0x00,
  0x07, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xE0,
  0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0,
  0x0E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1E, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x78, 0x07, 0x00,
  0xF0, 0x07, 0x01, 0xE0, 0x0F, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x07,
  0x00, 0x1E, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x0F, 0x01,
  0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x0E, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x3C, 0x07,
  0x80, 0x38, 0x07, 0x00, 0x78, 0x07, 0x01, 0xF0, 0x07, 0x0F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38,
  0x07, 0x80, 0x38, 0x07, 0x80, 0x78, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x70, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0x80, 0x60, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x02, 0x00, 0x0F, 0x00, 0xC0, 0x0F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x1E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x81,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70,
  0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80, 0x38, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE7,
  0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1D, 0xC0,
  0x00, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x80, 0x03, 0x9C, 0x00, 0x1E, 0x00,
  0x1E, 0x70, 0x00, 0xF8, 0x00, 0x71, 0xC0, 0x03, 0xE0, 0x01, 0xC7, 0x00,
  0x0F, 0x80, 0x0F, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x70, 0x01, 0xF8, 0x01,
  0xE1, 0xC0, 0x06, 0xE0, 0x07, 0x07, 0x00, 0x3B, 0x80, 0x1C, 0x1C, 0x00,
  0xEE, 0x00, 0xF0, 0x70, 0x07, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0xE0, 0x1E,
  0x07, 0x00, 0x63, 0x80, 0x70, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x70, 0x0E,
  0x38, 0x0F, 0x01, 0xC0, 0x70, 0xE0, 0x38, 0x07, 0x01, 0xC3, 0x81, 0xE0,
  0x1C, 0x06, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x30, 0x1C, 0x01, 0xC0, 0xE0,
  0xC0, 0xF0, 0x07, 0x07, 0x03, 0x03, 0x80, 0x1C, 0x1C, 0x0C, 0x1E, 0x00,
  0x70, 0x70, 0x30, 0x70, 0x01, 0xC3, 0x80, 0xC1, 0xC0, 0x07, 0x0E, 0x03,
  0x0F, 0x00, 0x1C, 0x70, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x70, 0xE0, 0x01,
  0xC7, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x1C,
  0xF0, 0x00, 0x77, 0x00, 0x73, 0x80, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0x0F,
  0x70, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x7F,
  0x00, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x38,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0x77,
  0x00, 0x0F, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x3C,
  0x38, 0x03, 0x83, 0x80, 0x78, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x38, 0x1C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x1D,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x10, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9E, 0x00, 0x0F,
  0x70, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x06, 0x0E, 0x0C, 0x0C, 0x00, 0x7E,
  0x1C, 0x07, 0xFC, 0x60, 0x3F, 0x7B, 0x81, 0xF0, 0x6E, 0x07, 0x80, 0xF8,
  0x3C, 0x03, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0E, 0x01, 0xF0,
  0x38, 0x07, 0xC0, 0xF0, 0x37, 0x01, 0xE3, 0x9C, 0x07, 0xFC, 0x60, 0x0F,
  0xE3, 0x80, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x7F, 0x00, 0x73,
  0xFE, 0x03, 0x9C, 0xF8, 0x0E, 0xC0, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x07,
  0x03, 0xC0, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x3C, 0x38, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x01, 0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x70, 0x7C, 0x03, 0xC1, 0xF0, 0x0E,
  0x07, 0xE0, 0x78, 0x19, 0xC7, 0xC0, 0xE7, 0xFE, 0x03, 0x8F, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFC, 0xE0, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xE3, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xF8,
  0xF0, 0x03, 0xFF, 0x70, 0x03, 0xF7, 0xB8, 0x03, 0xE0, 0xDC, 0x01, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1E,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x0E, 0x03,
  0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xE0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x3C,
  0x03, 0x80, 0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0F,
  0x80, 0x3C, 0x0D, 0xC0, 0x0F, 0x1C, 0xC0, 0x07, 0xFC, 0x60, 0x01, 0xFC,
  0x70, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3E, 0x3C,
  0x1E, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x3C,
  0x01, 0xCE, 0x00, 0xF3, 0x80, 0x39, 0xC0, 0x1E, 0x70, 0x0F, 0x1C, 0x0F,
  0x8F, 0x3F, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x04, 0x1F, 0x0E,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1B, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0x80, 0x1F,
  0xF9, 0x80, 0x1F, 0xBD, 0xC0, 0x1F, 0x06, 0xE0, 0x0E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x01,
  0xF0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xF8, 0x03, 0x80, 0x7C, 0x01, 0xE0,
  0x6E, 0x00, 0x78, 0xEE, 0x00, 0x3F, 0xE7, 0x00, 0x0F, 0xE3, 0x80, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x0F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x3F, 0x80, 0x3B,
  0xFE, 0x03, 0xBE, 0xF8, 0x1D, 0x81, 0xC0, 0xF8, 0x0E, 0x07, 0x80, 0x70,
  0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x78, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x78, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x03, 0x80, 0x00, 0x20, 0x03, 0x80,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1B, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x38, 0x1E, 0x00, 0xE0, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07,
  0x1C, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFB, 0x80, 0x07, 0xCF, 0x00, 0x1E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x78, 0x03, 0x81, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0x01, 0x8F, 0xE0, 0xFE, 0x00, 0xCF, 0xF8, 0xFF, 0x80,
  0xEF, 0x3E, 0xF7, 0xE0, 0x7E, 0x0F, 0xE0, 0xF0, 0x3E, 0x03, 0xE0, 0x38,
  0x1E, 0x01, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x07,
  0x07, 0x80, 0x78, 0x03, 0x83, 0x80, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x01,
  0xC1, 0xE0, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x70, 0x70, 0x07, 0x80,
  0x38, 0x38, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x1C, 0x1E, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0x70, 0x07, 0x07, 0x00, 0x70, 0x07, 0x83, 0x80, 0x38,
  0x03, 0x81, 0xC0, 0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x00, 0xE0, 0xE0, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0x07, 0x07, 0x00,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x01, 0xC1, 0xC0,
  0x1E, 0x00, 0xE0, 0x01, 0x8F, 0xE0, 0x0C, 0xFF, 0x80, 0xEF, 0xBE, 0x07,
  0xE0, 0x70, 0x3E, 0x03, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0xF0, 0x07,
  0x07, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1E, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1C,
  0x1C, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x9F, 0x03, 0xC0,
  0xF0, 0x70, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x3C, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C,
  0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x0F, 0x0F, 0x03, 0xC0,
  0xF9, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x38,
  0xFE, 0x00, 0x18, 0xFF, 0x80, 0x1C, 0xE7, 0xC0, 0x0E, 0xC0, 0xF0, 0x07,
  0xC0, 0x78, 0x03, 0xE0, 0x1C, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x07, 0x00,
  0xF0, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x38, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0E, 0x00, 0xFC, 0x0F, 0x00, 0x77, 0x1F, 0x00, 0x3B, 0xFF, 0x00, 0x38,
  0xFF, 0x00, 0x1C, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x1C, 0x07, 0xFE, 0x60, 0x3F, 0x7B, 0x81, 0xE0, 0x6E, 0x07, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0E, 0x01, 0xF0,
  0x38, 0x07, 0xC0, 0xF0, 0x37, 0x01, 0xE3, 0xBC, 0x07, 0xFC, 0xE0, 0x0F,
  0xE3, 0x80, 0x04, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x8F, 0xC0, 0x67, 0xF0, 0x3B, 0xF8,
  0x0E, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0x87,
  0x83, 0xC0, 0x20, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x08,
  0x03, 0xC1, 0xE1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x01,
  0xFF, 0x1F, 0xF9, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x10,
  0x3F, 0x81, 0xFC, 0x01, 0x00, 0x07, 0x00, 0x78, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00,
  0xF0, 0x38, 0x07, 0x81, 0xC0, 0x7C, 0x0E, 0x06, 0xE0, 0x78, 0xF6, 0x03,
  0xFF, 0x30, 0x0F, 0xF3, 0x80, 0x0C, 0x00, 0x00, 0xF0, 0x01, 0xDC, 0x00,
  0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x1D,
  0xC0, 0x1E, 0x00, 0xE7, 0x00, 0x78, 0x03, 0x9C, 0x03, 0xE0, 0x1E, 0x70,
  0x0F, 0x80, 0x71, 0xC0, 0x36, 0x01, 0xC7, 0x01, 0xF8, 0x0E, 0x1C, 0x07,
  0xE0, 0x38, 0x70, 0x3B, 0x80, 0xE1, 0xC0, 0xEE, 0x07, 0x07, 0x03, 0x38,
  0x1C, 0x1C, 0x1C, 0xE0, 0xE0, 0x70, 0x73, 0x83, 0x81, 0xC3, 0x8E, 0x0E,
  0x07, 0x0E, 0x38, 0x70, 0x1C, 0x30, 0xE1, 0xC0, 0x71, 0xC3, 0x8E, 0x01,
  0x87, 0x0E, 0x38, 0x06, 0x38, 0x38, 0xE0, 0x18, 0xE0, 0xE7, 0x00, 0xE3,
  0x03, 0x9C, 0x03, 0x9C, 0x0E, 0x60, 0x0E, 0x70, 0x3B, 0x80, 0x3B, 0x80,
  0xEE, 0x00, 0xEE, 0x03, 0xF0, 0x03, 0xB0, 0x0D, 0xC0, 0x0F, 0xC0, 0x36,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x79, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xEE, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x87, 0x00, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x0F,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x38,
  0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x0F, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x09, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00, 0x7E,
  0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x40, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 43, 13, 1, -43 },
  { 71, 14, 16, 18, 6, -43 },
  { 99, 25, 43, 24, 0, -43 },
  { 234, 23, 49, 22, 0, -46 },
  { 375, 29, 44, 34, 3, -43 },
  { 535, 23, 44, 23, -1, -43 },
  { 662, 6, 16, 10, 6, -43 },
  { 674, 18, 52, 15, 1, -43 },
  { 791, 17, 52, 15, -4, -43 },
  { 902, 16, 18, 20, 7, -46 },
  { 938, 21, 28, 25, 2, -35 },
  { 1012, 9, 14, 11, -3, -6 },
  { 1028, 13, 3, 16, 1, -18 },
  { 1033, 4, 6, 11, 1, -6 },
  { 1036, 26, 43, 19, -3, -43 },
  { 1176, 21, 44, 22, 1, -43 },
  { 1292, 12, 43, 22, 7, -43 },
  { 1357, 24, 43, 22, -2, -43 },
  { 1486, 23, 44, 22, -1, -43 },
  { 1613, 23, 43, 22, -1, -43 },
  { 1737, 24, 44, 22, -1, -43 },
  { 1869, 22, 44, 22, 1, -43 },
  { 1990, 22, 43, 22, 2, -43 },
  { 2109, 24, 44, 22, -1, -43 },
  { 2241, 22, 44, 22, 0, -43 },
  { 2362, 10, 32, 11, 0, -32 },
  { 2402, 14, 40, 11, -3, -32 },
  { 2472, 21, 26, 25, 2, -34 },
  { 2541, 21, 16, 25, 2, -29 },
  { 2583, 21, 26, 25, 2, -34 },
  { 2652, 17, 43, 16, 1, -43 },
  { 2744, 31, 48, 33, 1, -43 },
  { 2930, 22, 43, 22, -4, -43 },
  { 3049, 24, 43, 24, 0, -43 },
  { 3178, 24, 45, 22, 2, -44 },
  { 3313, 25, 43, 26, 0, -43 },
  { 3448, 24, 43, 21, 0, -43 },
  { 3577, 24, 43, 20, 0, -43 },
  { 3706, 28, 45, 28, 2, -44 },
  { 3864, 29, 43, 28, 0, -43 },
  { 4020, 20, 43, 13, -3, -43 },
  { 4128, 21, 54, 11, -9, -43 },
  { 4270, 27, 43, 23, 0, -43 },
  { 4416, 15, 43, 19, 0, -43 },
  { 4497, 38, 43, 37, 0, -43 },
  { 4702, 30, 43, 29, 0, -43 },
  { 4864, 25, 44, 28, 2, -43 },
  { 5002, 24, 43, 23, 0, -43 },
  { 5131, 25, 53, 28, 2, -43 },
  { 5297, 24, 43, 23, 0, -43 },
  { 5426, 25, 44, 22, -2, -43 },
  { 5564, 20, 43, 19, 4, -43 },
  { 5672, 26, 44, 27, 2, -43 },
  { 5815, 22, 43, 22, 5, -43 },
  { 5934, 38, 43, 38, 4, -43 },
  { 6139, 27, 43, 20, -3, -43 },
  { 6285, 20, 43, 19, 4, -43 },
  { 6393, 25, 43, 19, -2, -43 },
  { 6528, 22, 53, 17, -1, -43 },
  { 6674, 9, 43, 20, 6, -43 },
  { 6723, 22, 53, 17, -4, -43 },
  { 6869, 22, 22, 24, 1, -43 },
  { 6930, 17, 3, 17, -5, 5 },
  { 6937, 7, 10, 14, 9, -46 },
  { 6946, 22, 33, 24, 2, -32 },
  { 7037, 22, 47, 24, 0, -46 },
  { 7167, 17, 33, 18, 2, -32 },
  { 7238, 25, 47, 24, 2, -46 },
  { 7385, 18, 33, 21, 2, -32 },
  { 7460, 27, 60, 12, -8, -46 },
  { 7663, 25, 46, 24, -1, -32 },
  { 7807, 21, 46, 23, 0, -46 },
  { 7928, 13, 44, 10, 0, -44 },
  { 8000, 21, 58, 11, -8, -44 },
  { 8153, 22, 46, 20, 0, -46 },
  { 8280, 13, 46, 10, 0, -46 },
  { 8355, 33, 32, 35, 0, -32 },
  { 8487, 21, 32, 23, 0, -32 },
  { 8571, 19, 33, 23, 2, -32 },
  { 8650, 25, 46, 24, -3, -32 },
  { 8794, 22, 46, 24, 2, -32 },
  { 8921, 18, 32, 15, 0, -32 },
  { 8993, 19, 33, 18, -1, -32 },
  { 9072, 13, 40, 13, 1, -39 },
  { 9137, 21, 33, 23, 2, -32 },
  { 9224, 18, 32, 18, 3, -32 },
  { 9296, 30, 32, 30, 3, -32 },
  { 9416, 24, 32, 19, -3, -32 },
  { 9512, 28, 47, 19, -6, -32 },
  { 9677, 19, 32, 15, -2, -32 },
  { 9753, 21, 52, 19, 2, -43 },
  { 9890, 3, 60, 21, 9, -46 },
  { 9913, 21, 52, 19, -4, -43 },
  { 10050, 21, 6, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC60PT7B_H_
