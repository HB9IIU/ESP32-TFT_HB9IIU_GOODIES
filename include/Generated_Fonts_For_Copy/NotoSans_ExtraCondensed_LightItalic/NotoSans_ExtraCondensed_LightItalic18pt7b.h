#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x24, 0x44, 0x04, 0xC0, 0x59, 0xAA, 0xA0, 0x0A,
  0x14, 0x48, 0xA7, 0xE4, 0x8A, 0x14, 0xFC, 0x91, 0x44, 0x89, 0x00, 0x08,
  0x10, 0xF9, 0x44, 0x86, 0x0C, 0x08, 0x18, 0x28, 0x91, 0x4F, 0x84, 0x08,
  0x00, 0x31, 0x29, 0x24, 0x92, 0x89, 0x45, 0x5A, 0xB3, 0xA9, 0x15, 0x14,
  0x8A, 0x49, 0x2C, 0x60, 0x1C, 0x92, 0x49, 0x28, 0xC3, 0x15, 0x96, 0x38,
  0xA6, 0xEC, 0x6A, 0x80, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x81, 0x04, 0x10, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x42,
  0x21, 0x10, 0x21, 0x3E, 0x4D, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08,
  0x20, 0x29, 0x60, 0xF0, 0x70, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x28, 0x89, 0x14, 0x48, 0x91,
  0x22, 0x85, 0x12, 0x24, 0x87, 0x00, 0x36, 0xA2, 0x22, 0x44, 0x44, 0x48,
  0x80, 0x1E, 0x13, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0xFC, 0x3C, 0x4C, 0x08, 0x10, 0x41, 0x0C, 0x04, 0x08, 0x10, 0x20,
  0x4F, 0x00, 0x06, 0x08, 0x30, 0xA1, 0x44, 0x92, 0x24, 0x89, 0xF8, 0x20,
  0x81, 0x00, 0x1E, 0x40, 0x81, 0x04, 0x0E, 0x02, 0x02, 0x04, 0x08, 0x20,
  0x4F, 0x00, 0x0E, 0x20, 0x81, 0x04, 0x0B, 0x19, 0x22, 0x85, 0x0A, 0x22,
  0x47, 0x00, 0x7C, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21, 0x04, 0x20, 0x80,
  0x1C, 0x44, 0x89, 0x12, 0x45, 0x0C, 0x24, 0x89, 0x0A, 0x14, 0x47, 0x00,
  0x1C, 0x48, 0x8A, 0x14, 0x48, 0x91, 0x1E, 0x04, 0x10, 0x20, 0x8E, 0x00,
  0x24, 0x00, 0x00, 0x90, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x04, 0x66,
  0x20, 0x40, 0xC0, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x19,
  0x88, 0x00, 0x38, 0x20, 0x42, 0x08, 0x42, 0x08, 0x41, 0x00, 0x10, 0xC0,
  0x07, 0x06, 0x21, 0x04, 0x81, 0x4E, 0x52, 0x95, 0x29, 0x4A, 0x94, 0xA5,
  0x49, 0xB2, 0x00, 0x40, 0x11, 0x03, 0x80, 0x04, 0x30, 0xC3, 0x14, 0x52,
  0x4F, 0x25, 0x14, 0x61, 0x84, 0x1C, 0x44, 0x89, 0x12, 0x24, 0x9E, 0x22,
  0x44, 0x89, 0x14, 0x6F, 0x00, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x07, 0x00, 0x1C, 0x22, 0x22, 0x21, 0x21, 0x22, 0x42,
  0x42, 0x42, 0x44, 0x44, 0x88, 0xF0, 0x1E, 0x40, 0x81, 0x02, 0x04, 0x1F,
  0x20, 0x40, 0x81, 0x04, 0x0F, 0x80, 0x1E, 0x40, 0x81, 0x02, 0x04, 0x1F,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x00, 0x1F, 0x21, 0x40, 0x40, 0x80, 0x80,
  0x8E, 0x82, 0x84, 0x84, 0x84, 0x84, 0x78, 0x10, 0x90, 0x88, 0x44, 0x22,
  0x11, 0x09, 0xF8, 0x84, 0x42, 0x21, 0x11, 0x10, 0x88, 0x40, 0x1C, 0x21,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0xF0, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x70, 0x11, 0x22,
  0x24, 0x24, 0x28, 0x30, 0x50, 0x70, 0x48, 0x48, 0x48, 0x88, 0x8C, 0x12,
  0x22, 0x22, 0x44, 0x44, 0x48, 0xF0, 0x10, 0x26, 0x0C, 0xC1, 0x98, 0x53,
  0x0A, 0x62, 0x94, 0x52, 0x8A, 0x4A, 0x49, 0x51, 0x32, 0x46, 0x48, 0x88,
  0x10, 0x98, 0x4C, 0x25, 0x22, 0x91, 0x49, 0x24, 0x92, 0x4A, 0x23, 0x11,
  0x90, 0xC8, 0x40, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A,
  0x14, 0x4F, 0x00, 0x1C, 0x44, 0x89, 0x12, 0x24, 0xD3, 0x38, 0x40, 0x81,
  0x04, 0x08, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A,
  0x14, 0x4F, 0x04, 0x04, 0x08, 0x1C, 0x44, 0x89, 0x12, 0x24, 0x93, 0x38,
  0x48, 0x91, 0x24, 0x48, 0x80, 0x1E, 0x41, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x4F, 0x00, 0xFC, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x20, 0x80, 0x22, 0x85, 0x0A, 0x14, 0x28, 0xA1, 0x42, 0x85, 0x12,
  0x24, 0x4F, 0x00, 0x86, 0x18, 0xA2, 0x92, 0x4A, 0x28, 0xA3, 0x0C, 0x20,
  0x80, 0x42, 0x38, 0x62, 0x84, 0x28, 0xA4, 0x8C, 0x49, 0x48, 0x94, 0x89,
  0x48, 0xA5, 0x0A, 0x50, 0xA5, 0x0C, 0x60, 0xC6, 0x00, 0x11, 0x11, 0x12,
  0x12, 0x0C, 0x08, 0x08, 0x18, 0x28, 0x28, 0x48, 0x44, 0x84, 0x45, 0x14,
  0x92, 0x51, 0x46, 0x10, 0x41, 0x04, 0x10, 0x80, 0x1F, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x40, 0xF8, 0x1C, 0x42, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x38, 0xAA, 0xA5, 0x55,
  0x40, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x38, 0x08, 0x30, 0x51, 0x24, 0x48, 0x60, 0x80, 0xF8, 0xA4, 0x1A, 0x4C,
  0x8A, 0x24, 0x48, 0x91, 0x46, 0x48, 0xF0, 0x10, 0x20, 0x81, 0x02, 0xC6,
  0x88, 0xA1, 0x42, 0x89, 0x12, 0x2C, 0x96, 0x00, 0x1C, 0x82, 0x10, 0x41,
  0x08, 0x20, 0x41, 0xC0, 0x01, 0x01, 0x01, 0x02, 0x1A, 0x26, 0x22, 0x44,
  0x44, 0x44, 0x44, 0x8C, 0x48, 0x78, 0x18, 0x92, 0x51, 0x59, 0x88, 0x20,
  0x41, 0xE0, 0x03, 0x04, 0x04, 0x08, 0x1C, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1A, 0x4C, 0x8A, 0x24,
  0x48, 0x91, 0x46, 0x48, 0xF0, 0x20, 0x41, 0x1E, 0x00, 0x10, 0x42, 0x08,
  0x2C, 0xD2, 0x51, 0x45, 0x14, 0x52, 0x8A, 0x20, 0x12, 0x02, 0x22, 0x44,
  0x44, 0x48, 0x80, 0x04, 0x10, 0x02, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x10, 0xC0, 0x10, 0x20, 0x81, 0x02, 0x24, 0x8A, 0x28, 0x50,
  0xE1, 0x42, 0x88, 0x91, 0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x44, 0x88,
  0x2D, 0x8D, 0x92, 0x45, 0x11, 0x44, 0x91, 0x24, 0x89, 0x22, 0x88, 0xA2,
  0x40, 0x2C, 0xD2, 0x51, 0x45, 0x14, 0x52, 0x8A, 0x20, 0x18, 0x92, 0x51,
  0x45, 0x18, 0x61, 0x49, 0xC0, 0x16, 0x1B, 0x11, 0x21, 0x21, 0x22, 0x22,
  0x22, 0x64, 0x58, 0x40, 0x40, 0x40, 0x80, 0x1A, 0x4C, 0x8A, 0x24, 0x48,
  0x91, 0x46, 0x48, 0xF0, 0x20, 0x40, 0x82, 0x00, 0x29, 0x88, 0x84, 0x21,
  0x08, 0x84, 0x00, 0x39, 0x14, 0x10, 0x20, 0xC1, 0x04, 0x13, 0x80, 0x22,
  0x72, 0x24, 0x44, 0x48, 0x8E, 0x22, 0x44, 0x92, 0x24, 0x48, 0x91, 0x24,
  0x88, 0xF0, 0x8C, 0x65, 0x29, 0x52, 0x98, 0xC4, 0x00, 0x88, 0xC4, 0xA6,
  0x53, 0x2A, 0xA5, 0x52, 0xA9, 0x98, 0xCC, 0x44, 0x00, 0x22, 0x24, 0x50,
  0xC1, 0x82, 0x0A, 0x14, 0x49, 0x90, 0x10, 0x88, 0x84, 0x42, 0x41, 0x20,
  0xA0, 0x50, 0x28, 0x18, 0x0C, 0x04, 0x02, 0x02, 0x07, 0x00, 0x1C, 0x90,
  0x82, 0x10, 0x42, 0x08, 0x43, 0xC0, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x30, 0xE0, 0x40, 0x81, 0x04, 0x08, 0x10, 0x18, 0xFF, 0xFF, 0xC0, 0x18,
  0x20, 0x82, 0x08, 0x20, 0x83, 0x08, 0x41, 0x04, 0x20, 0x82, 0x30, 0xF6,
  0x20,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 4, 5, 5, 2, -13 },
  { 11, 7, 13, 7, 0, -13 },
  { 23, 7, 15, 7, 0, -14 },
  { 37, 9, 13, 10, 1, -13 },
  { 52, 6, 13, 7, 0, -13 },
  { 62, 2, 5, 3, 2, -13 },
  { 64, 6, 16, 4, 0, -13 },
  { 76, 5, 16, 5, -1, -13 },
  { 86, 5, 6, 6, 2, -14 },
  { 90, 6, 9, 7, 1, -11 },
  { 97, 3, 4, 3, -1, -2 },
  { 99, 4, 1, 5, 0, -5 },
  { 100, 2, 2, 3, 0, -2 },
  { 101, 8, 13, 6, -1, -13 },
  { 114, 7, 13, 7, 0, -13 },
  { 126, 4, 13, 7, 2, -13 },
  { 133, 8, 13, 7, -1, -13 },
  { 146, 7, 13, 7, 0, -13 },
  { 158, 7, 13, 7, 0, -13 },
  { 170, 7, 13, 7, 0, -13 },
  { 182, 7, 13, 7, 0, -13 },
  { 194, 6, 13, 7, 1, -13 },
  { 204, 7, 13, 7, 0, -13 },
  { 216, 7, 13, 7, 0, -13 },
  { 228, 3, 10, 3, 0, -10 },
  { 232, 4, 12, 3, -1, -10 },
  { 238, 6, 7, 7, 1, -10 },
  { 244, 6, 5, 7, 1, -9 },
  { 248, 6, 7, 7, 1, -10 },
  { 254, 6, 13, 5, 0, -13 },
  { 264, 10, 15, 10, 0, -13 },
  { 283, 6, 13, 7, -1, -13 },
  { 293, 7, 13, 7, 0, -13 },
  { 305, 7, 13, 7, 1, -13 },
  { 317, 8, 13, 8, 0, -13 },
  { 330, 7, 13, 6, 0, -13 },
  { 342, 7, 13, 6, 0, -13 },
  { 354, 8, 13, 9, 1, -13 },
  { 367, 9, 13, 8, 0, -13 },
  { 382, 6, 13, 4, -1, -13 },
  { 392, 7, 16, 3, -3, -13 },
  { 406, 8, 13, 7, 0, -13 },
  { 419, 4, 13, 6, 0, -13 },
  { 426, 11, 13, 11, 0, -13 },
  { 444, 9, 13, 9, 0, -13 },
  { 459, 7, 13, 8, 1, -13 },
  { 471, 7, 13, 7, 0, -13 },
  { 483, 7, 16, 8, 1, -13 },
  { 497, 7, 13, 7, 0, -13 },
  { 509, 7, 13, 6, 0, -13 },
  { 521, 6, 13, 6, 1, -13 },
  { 531, 7, 13, 8, 1, -13 },
  { 543, 6, 13, 7, 2, -13 },
  { 553, 12, 13, 11, 1, -13 },
  { 573, 8, 13, 6, -1, -13 },
  { 586, 6, 13, 6, 1, -13 },
  { 596, 8, 13, 6, -1, -13 },
  { 609, 6, 16, 5, 0, -13 },
  { 621, 2, 13, 6, 2, -13 },
  { 625, 6, 16, 5, -1, -13 },
  { 637, 7, 7, 7, 0, -13 },
  { 644, 5, 1, 5, -1, 1 },
  { 645, 2, 3, 4, 3, -14 },
  { 646, 7, 10, 7, 0, -10 },
  { 655, 7, 14, 7, 0, -14 },
  { 668, 6, 10, 5, 0, -10 },
  { 676, 8, 14, 7, 0, -14 },
  { 690, 6, 10, 6, 0, -10 },
  { 698, 8, 18, 4, -2, -14 },
  { 716, 7, 14, 7, 0, -10 },
  { 729, 6, 14, 7, 0, -14 },
  { 740, 4, 13, 3, 0, -13 },
  { 747, 6, 17, 3, -2, -13 },
  { 760, 7, 14, 6, 0, -14 },
  { 773, 4, 14, 3, 0, -14 },
  { 780, 10, 10, 10, 0, -10 },
  { 793, 6, 10, 7, 0, -10 },
  { 801, 6, 10, 7, 0, -10 },
  { 809, 8, 14, 7, -1, -10 },
  { 823, 7, 14, 7, 0, -10 },
  { 836, 5, 10, 5, 0, -10 },
  { 843, 6, 10, 5, 0, -10 },
  { 851, 4, 12, 4, 0, -12 },
  { 857, 7, 10, 7, 0, -10 },
  { 866, 5, 10, 5, 1, -10 },
  { 873, 9, 10, 9, 1, -10 },
  { 885, 7, 10, 6, -1, -10 },
  { 894, 9, 14, 6, -2, -10 },
  { 910, 6, 10, 5, -1, -10 },
  { 918, 7, 16, 6, 0, -13 },
  { 932, 1, 18, 6, 3, -14 },
  { 935, 6, 16, 6, -1, -13 },
  { 947, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC18PT7B_H_
