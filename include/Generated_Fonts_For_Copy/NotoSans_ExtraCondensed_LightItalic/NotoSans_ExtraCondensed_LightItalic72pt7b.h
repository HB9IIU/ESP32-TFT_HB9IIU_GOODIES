#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x38, 0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07,
  0x0E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xE1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x60, 0xE0, 0x0F, 0x06, 0x04, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x0C, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x3C,
  0x18, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1E, 0x30, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0D, 0xF0, 0x00,
  0x00, 0xCF, 0x80, 0x00, 0x0C, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03,
  0x03, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x07, 0x80, 0x80, 0x60, 0xF0,
  0x0E, 0x06, 0x1F, 0x00, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xE0, 0x07, 0xFC, 0x00, 0x38, 0x01, 0xE3, 0xC0, 0x07,
  0x00, 0x78, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x03, 0xC0, 0xE0,
  0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x70, 0x03,
  0x80, 0x78, 0x1C, 0x00, 0x70, 0x0F, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0xE0,
  0x03, 0xC0, 0x38, 0x1C, 0x00, 0x70, 0x07, 0x07, 0x00, 0x0E, 0x00, 0xE1,
  0xE0, 0x01, 0xC0, 0x3C, 0x38, 0x00, 0x38, 0x07, 0x0F, 0x00, 0x07, 0x00,
  0xE1, 0xC0, 0x00, 0xE0, 0x3C, 0x78, 0x3F, 0x3C, 0x07, 0x0E, 0x1F, 0xF7,
  0x80, 0xE3, 0xC7, 0xFE, 0xF0, 0x3C, 0x70, 0xE1, 0xFE, 0x07, 0x1E, 0x38,
  0x1D, 0xC1, 0xE3, 0x8F, 0x03, 0xB8, 0x38, 0xF1, 0xC0, 0x77, 0x8E, 0x1C,
  0x38, 0x0E, 0xFF, 0xC7, 0x8E, 0x01, 0xCF, 0xF0, 0xE1, 0xC0, 0x38, 0xF8,
  0x3C, 0x78, 0x07, 0x00, 0x07, 0x0E, 0x01, 0xE0, 0x01, 0xE1, 0xC0, 0x3C,
  0x00, 0x38, 0x38, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0xE0, 0x01, 0xC1, 0xC0,
  0x1C, 0x00, 0x78, 0x38, 0x03, 0x80, 0x0E, 0x07, 0x00, 0xF0, 0x03, 0xC0,
  0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x70, 0x03,
  0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0xF0,
  0x07, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x00, 0xE0,
  0xE0, 0x07, 0x00, 0x1C, 0x3C, 0x01, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0x00,
  0x7F, 0xC0, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x78,
  0x00, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xE0, 0x70, 0x78, 0x1C, 0x0E, 0x1E,
  0x03, 0xC3, 0xC3, 0xC0, 0x78, 0x78, 0xF0, 0x0F, 0x0E, 0x1E, 0x00, 0xE3,
  0xC7, 0x80, 0x1E, 0x70, 0xF0, 0x03, 0xDE, 0x1E, 0x00, 0x7B, 0xC3, 0x80,
  0x07, 0xF0, 0x70, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xF8, 0x1E, 0x00,
  0xFF, 0x03, 0xC0, 0x3D, 0xE0, 0x7C, 0x0F, 0x1C, 0x07, 0xFF, 0xC3, 0xC0,
  0x7F, 0xF0, 0x78, 0x07, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x04, 0x07, 0x00, 0x60, 0x70, 0x0F, 0x87, 0x00, 0xFE, 0x60,
  0x61, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0x38, 0x01, 0xE3, 0x80, 0x3C, 0x1C, 0x07, 0xC1, 0xC0, 0x78,
  0x0E, 0x03, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x13, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x03,
  0xC0, 0x07, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07,
  0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0,
  0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xF7, 0x87, 0xCE,
  0x1F, 0x1C, 0x7C, 0x79, 0xF0, 0xF1, 0x81, 0xE2, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0x9F, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x78,
  0x03, 0xE0, 0x02, 0x00, 0x1E, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x3E, 0x00, 0xE0, 0x0F, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1C, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x80, 0x38, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3E, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x03, 0xE0,
  0x0E, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x86, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x0F, 0x80, 0x0F, 0x1F, 0xF8, 0x03, 0xCF, 0xFF, 0x00, 0xF7, 0xFF, 0xC0,
  0x3B, 0x80, 0xF8, 0x1F, 0xC0, 0x1E, 0x07, 0xE0, 0x07, 0x81, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C,
  0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0, 0xF8,
  0x03, 0xF8, 0x1E, 0x01, 0xDC, 0x07, 0xE1, 0xEF, 0x00, 0xFF, 0xF3, 0xC0,
  0x1F, 0xF8, 0xF0, 0x03, 0xFC, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x07, 0x80, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0x70, 0x00, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xCF, 0xE0, 0x30, 0x0F, 0x81, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x78, 0x01, 0xFE,
  0x07, 0x07, 0x00, 0x7F, 0xF0, 0x70, 0x70, 0x0F, 0x9E, 0x07, 0x0E, 0x01,
  0xE0, 0xE0, 0x70, 0xE0, 0x1C, 0x0E, 0x07, 0x1E, 0x03, 0x81, 0xE0, 0x71,
  0xC0, 0x78, 0x1C, 0x07, 0x1C, 0x07, 0x01, 0xC0, 0x73, 0xC0, 0xE0, 0x1C,
  0x07, 0x38, 0x0E, 0x03, 0xC0, 0x73, 0x80, 0xE0, 0x38, 0x0E, 0x38, 0x1C,
  0x03, 0x80, 0xE7, 0x01, 0xC0, 0x38, 0x0E, 0x70, 0x1C, 0x07, 0x80, 0xE7,
  0x03, 0xC0, 0x70, 0x1E, 0x70, 0x38, 0x07, 0x01, 0xC7, 0x03, 0x80, 0xF0,
  0x1C, 0xF0, 0x38, 0x0F, 0x01, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0xE0, 0x78,
  0x1E, 0x03, 0x8E, 0x07, 0x81, 0xE0, 0x38, 0xE0, 0x78, 0x1E, 0x07, 0x0E,
  0x07, 0x83, 0xE0, 0x70, 0xE0, 0x78, 0x3E, 0x0E, 0x0E, 0x03, 0x86, 0xE1,
  0xC0, 0xE0, 0x3C, 0xE6, 0x3C, 0x0E, 0x03, 0xFC, 0x7F, 0x80, 0xE0, 0x1F,
  0x87, 0xF0, 0x0E, 0x00, 0xF0, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0xF0,
  0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x01,
  0xE0, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0xF0,
  0x00, 0x70, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x78,
  0x07, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xE0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x7C, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x7E, 0x01, 0xE0, 0x07,
  0xE0, 0x0F, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE7, 0xE0, 0x01, 0xF8, 0x02, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x01,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00,
  0x1F, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x7E,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x10, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFC,
  0x1E, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x07, 0xFF, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x0E, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1C, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xDF, 0xC0, 0x00,
  0x01, 0xFD, 0xE0, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xDE, 0x00, 0x00, 0x7B,
  0xC0, 0x07, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0xF3, 0x80, 0x00, 0x3D, 0xE0, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x80,
  0x0F, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x01,
  0xE3, 0x80, 0x00, 0xF3, 0xC0, 0x07, 0x8E, 0x00, 0x03, 0x8F, 0x00, 0x1E,
  0x38, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xF0, 0x01, 0xC3,
  0x80, 0x03, 0xC7, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x38,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0,
  0x0F, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x3C,
  0x0F, 0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x70, 0x1E,
  0x00, 0x38, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0xC0,
  0x07, 0x80, 0x70, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xC1, 0xC0, 0x3C, 0x00,
  0x78, 0x07, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x71, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0x00, 0xF0,
  0x07, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0x77, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xDE, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x7B, 0x80,
  0x01, 0xE0, 0x07, 0xB8, 0x00, 0x3C, 0x00, 0x73, 0xC0, 0x03, 0xC0, 0x0F,
  0x3C, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x0F, 0x3C, 0x00, 0x38,
  0x00, 0xF1, 0xC0, 0x07, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x00, 0x1E,
  0x0E, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0xF0,
  0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0xF0,
  0x1E, 0x00, 0x78, 0x07, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x1E, 0x00, 0x78,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x70, 0x07, 0x83, 0xC0,
  0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x03, 0x83, 0xC0, 0x0F, 0x00, 0x38,
  0x38, 0x00, 0xF0, 0x03, 0xC7, 0x80, 0x0E, 0x00, 0x3C, 0x78, 0x01, 0xE0,
  0x03, 0xC7, 0x80, 0x1E, 0x00, 0x1C, 0x78, 0x01, 0xE0, 0x01, 0xC7, 0x00,
  0x1C, 0x00, 0x1C, 0xF0, 0x01, 0xC0, 0x01, 0xEF, 0x00, 0x3C, 0x00, 0x1E,
  0xF0, 0x03, 0xC0, 0x01, 0xEF, 0x00, 0x3C, 0x00, 0x0E, 0xE0, 0x03, 0x80,
  0x00, 0xFE, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03,
  0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x3C, 0x03, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x38, 0x07,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xC0, 0xFE, 0x00, 0x3C, 0x03, 0xE0, 0x03,
  0xC0, 0x1F, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0x3E, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0xF8, 0x00, 0x20, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x30, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x70,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x70,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3B, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xDC, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE7, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x7B, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0x9E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xC7, 0x80, 0x1E, 0x03, 0xC0, 0x0E, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x83, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x1C,
  0x03, 0xC0, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x07, 0x00,
  0xF0, 0x03, 0x80, 0xF0, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x81, 0xC0, 0x78,
  0x00, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x70, 0x3C, 0x00,
  0x38, 0x1C, 0x03, 0x81, 0xE0, 0x01, 0xC1, 0xE0, 0x1C, 0x1E, 0x00, 0x0E,
  0x0F, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x03, 0x87,
  0x80, 0x38, 0x78, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0xC0,
  0x0E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x71, 0xE0, 0x00, 0x78, 0xE0, 0x03,
  0x8E, 0x00, 0x03, 0xCF, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0xE7,
  0x80, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xC0, 0x03, 0xDC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x3C, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1C,
  0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x70, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x78,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x0E, 0x0E,
  0x07, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x70, 0x07, 0xFF, 0x1C, 0x03,
  0xFB, 0xE7, 0x01, 0xF0, 0x3B, 0xC0, 0xF8, 0x06, 0xE0, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xF0,
  0x3C, 0x01, 0xFC, 0x07, 0x80, 0x6E, 0x01, 0xF0, 0x73, 0x80, 0x3F, 0xFC,
  0xE0, 0x0F, 0xFE, 0x38, 0x01, 0xFE, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x3F, 0xE0,
  0x03, 0xCF, 0xFE, 0x00, 0x73, 0xEF, 0xC0, 0x1E, 0xE0, 0x7C, 0x03, 0xF8,
  0x07, 0x80, 0x7E, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0,
  0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80,
  0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0xC0, 0x1F, 0x01,
  0xDC, 0x03, 0xC0, 0x3B, 0xC1, 0xF0, 0x07, 0x3F, 0xFC, 0x00, 0xE3, 0xFF,
  0x00, 0x38, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFC, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x08, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0xFF, 0x87,
  0x00, 0x07, 0xFF, 0x3C, 0x00, 0x3F, 0xBE, 0xF0, 0x01, 0xF0, 0x3B, 0xC0,
  0x0F, 0x80, 0x6E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x1F, 0x80,
  0x07, 0x80, 0xEE, 0x00, 0x1F, 0x07, 0x38, 0x00, 0x3F, 0xFC, 0xE0, 0x00,
  0xFF, 0xE3, 0x80, 0x01, 0xFE, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x3F, 0x01, 0xF0,
  0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x1C,
  0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x78, 0x07, 0xE1, 0xE0, 0x7E,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x08, 0x1F,
  0x00, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xE2, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x87, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x03, 0xFF, 0x8E,
  0x00, 0x3F, 0xBE, 0x70, 0x03, 0xE0, 0x77, 0x80, 0x3E, 0x01, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x7E,
  0x00, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x77, 0x00, 0x1F, 0x07, 0x78, 0x00,
  0xFF, 0xFB, 0xC0, 0x03, 0xFF, 0x9E, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x00, 0x1F, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0xFF, 0xC0, 0x0F,
  0x7F, 0xF8, 0x03, 0xBF, 0xFE, 0x00, 0xEE, 0x07, 0x80, 0x7E, 0x00, 0xF0,
  0x1F, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x1E, 0x00,
  0x1C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C,
  0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x38, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x8F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x20, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0xC0,
  0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x1D,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0xF0, 0x00, 0x1F, 0x9E, 0x00,
  0x03, 0xE1, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xE3, 0xFE, 0x0F, 0xFC, 0x00, 0xE7,
  0xFF, 0x1F, 0xFE, 0x00, 0xEF, 0xBF, 0xBE, 0xFE, 0x01, 0xFC, 0x0F, 0xF8,
  0x1E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07,
  0x80, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x38, 0xFF, 0xC0, 0x0E, 0x7F,
  0xF0, 0x03, 0xBF, 0xFE, 0x01, 0xEE, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1F,
  0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0xF8, 0x00, 0xE0,
  0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1C,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00,
  0x38, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x38,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0xFC, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x38, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0xE0, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0xFF, 0x80, 0x01, 0xC7, 0xFF, 0x00, 0x07, 0x3C,
  0xFC, 0x00, 0x1D, 0xC0, 0xF8, 0x00, 0xFE, 0x01, 0xE0, 0x03, 0xF0, 0x07,
  0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0,
  0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1F,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFE, 0x03, 0xE0, 0x03, 0xDC, 0x1F,
  0x00, 0x0E, 0x7F, 0xF8, 0x00, 0x38, 0xFF, 0xC0, 0x01, 0xE1, 0xFE, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x70, 0x07,
  0xFF, 0x1C, 0x03, 0xFB, 0xE7, 0x01, 0xF0, 0x3B, 0xC0, 0xF8, 0x07, 0xE0,
  0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C,
  0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0,
  0xF0, 0x03, 0xF0, 0x3C, 0x01, 0xFC, 0x07, 0x80, 0xEE, 0x01, 0xF0, 0x77,
  0x80, 0x7F, 0xFD, 0xE0, 0x0F, 0xFE, 0x78, 0x01, 0xFE, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x8F, 0xE0,
  0x0E, 0x7F, 0x80, 0x3B, 0xFE, 0x01, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xE3, 0xE0, 0x1E, 0x00, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x02, 0x00, 0x3E, 0x07, 0x00,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0E,
  0x00, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0E,
  0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x0F, 0xC0, 0xF0, 0x07, 0xC0, 0x78, 0x06, 0xE0, 0x3E,
  0x0F, 0x70, 0x0F, 0xFF, 0x78, 0x07, 0xFF, 0x38, 0x01, 0xFF, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0E, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x00, 0x07, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0x78, 0x00, 0xF8, 0x01,
  0xEF, 0x00, 0x3F, 0x00, 0x3D, 0xE0, 0x07, 0xE0, 0x0F, 0x3C, 0x00, 0xFC,
  0x01, 0xE7, 0x80, 0x3B, 0x80, 0x38, 0xF0, 0x07, 0x70, 0x0F, 0x1E, 0x01,
  0xEE, 0x01, 0xE3, 0xC0, 0x39, 0xC0, 0x38, 0x78, 0x0F, 0x38, 0x0F, 0x0F,
  0x01, 0xC7, 0x01, 0xC1, 0xE0, 0x38, 0xE0, 0x78, 0x3C, 0x0F, 0x1C, 0x0F,
  0x07, 0x81, 0xC3, 0x81, 0xC0, 0xF0, 0x78, 0x70, 0x78, 0x1E, 0x0E, 0x0E,
  0x0E, 0x03, 0xC1, 0xC1, 0xC3, 0xC0, 0x78, 0x78, 0x38, 0x78, 0x0F, 0x0E,
  0x07, 0x0E, 0x01, 0xE3, 0xC0, 0xE3, 0xC0, 0x3C, 0x70, 0x1C, 0x70, 0x07,
  0x8E, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x1E, 0x70, 0x1E, 0x70,
  0x03, 0xDE, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x7B, 0x80, 0x0F, 0x70, 0x0F,
  0x70, 0x01, 0xDE, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x07, 0x70,
  0x07, 0x70, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x07, 0x80,
  0x03, 0x80, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x00,
  0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x02, 0x1F, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x04, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7E, 0x1F, 0xE0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFA, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 51, 16, 1, -51 },
  { 97, 17, 18, 21, 7, -51 },
  { 136, 30, 51, 28, 0, -51 },
  { 328, 28, 59, 26, 0, -55 },
  { 535, 35, 53, 41, 3, -52 },
  { 767, 27, 53, 27, -1, -52 },
  { 946, 8, 18, 12, 7, -51 },
  { 964, 20, 62, 18, 2, -51 },
  { 1119, 20, 62, 18, -5, -51 },
  { 1274, 20, 22, 24, 8, -55 },
  { 1329, 25, 33, 30, 3, -42 },
  { 1433, 11, 16, 13, -3, -7 },
  { 1455, 16, 3, 19, 1, -21 },
  { 1461, 5, 7, 13, 1, -7 },
  { 1466, 31, 51, 23, -3, -51 },
  { 1664, 24, 53, 26, 2, -52 },
  { 1823, 15, 51, 26, 8, -51 },
  { 1919, 29, 52, 26, -2, -52 },
  { 2108, 28, 53, 26, -1, -52 },
  { 2294, 28, 52, 26, -1, -52 },
  { 2476, 28, 52, 26, -1, -51 },
  { 2658, 26, 53, 26, 2, -52 },
  { 2831, 27, 51, 26, 2, -51 },
  { 3004, 28, 53, 26, -1, -52 },
  { 3190, 26, 53, 26, 0, -52 },
  { 3363, 12, 39, 13, 0, -39 },
  { 3422, 16, 48, 13, -3, -39 },
  { 3518, 26, 31, 30, 2, -41 },
  { 3619, 25, 19, 30, 3, -35 },
  { 3679, 25, 31, 30, 3, -41 },
  { 3776, 21, 52, 19, 1, -52 },
  { 3913, 36, 58, 39, 2, -52 },
  { 4174, 26, 52, 26, -5, -52 },
  { 4343, 29, 51, 29, 0, -51 },
  { 4528, 29, 53, 26, 3, -52 },
  { 4721, 30, 51, 32, 0, -51 },
  { 4913, 28, 51, 25, 0, -51 },
  { 5092, 29, 51, 24, 0, -51 },
  { 5277, 33, 53, 34, 3, -52 },
  { 5496, 35, 51, 33, 0, -51 },
  { 5720, 24, 51, 15, -4, -51 },
  { 5873, 25, 64, 13, -10, -51 },
  { 6073, 33, 51, 27, 0, -51 },
  { 6284, 18, 51, 23, 0, -51 },
  { 6399, 46, 51, 44, 0, -51 },
  { 6693, 36, 51, 35, 0, -51 },
  { 6923, 30, 53, 34, 3, -52 },
  { 7122, 28, 51, 27, 0, -51 },
  { 7301, 30, 64, 34, 3, -52 },
  { 7541, 28, 51, 28, 0, -51 },
  { 7720, 30, 53, 26, -2, -52 },
  { 7919, 24, 51, 23, 5, -51 },
  { 8072, 32, 52, 32, 2, -51 },
  { 8280, 27, 51, 27, 6, -51 },
  { 8453, 45, 51, 45, 5, -51 },
  { 8740, 33, 51, 24, -4, -51 },
  { 8951, 24, 51, 23, 5, -51 },
  { 9104, 30, 51, 23, -3, -51 },
  { 9296, 27, 63, 20, -2, -52 },
  { 9509, 11, 52, 24, 7, -52 },
  { 9581, 27, 63, 20, -5, -52 },
  { 9794, 27, 26, 28, 1, -51 },
  { 9882, 21, 3, 20, -6, 6 },
  { 9890, 8, 11, 16, 11, -55 },
  { 9901, 26, 40, 29, 2, -39 },
  { 10031, 27, 56, 28, 0, -55 },
  { 10220, 21, 40, 21, 2, -39 },
  { 10325, 30, 56, 29, 2, -55 },
  { 10535, 22, 40, 25, 2, -39 },
  { 10645, 32, 72, 15, -9, -55 },
  { 10933, 29, 56, 29, -1, -39 },
  { 11136, 26, 55, 28, 0, -55 },
  { 11315, 15, 52, 13, 0, -52 },
  { 11413, 24, 69, 13, -9, -52 },
  { 11620, 27, 55, 24, 0, -55 },
  { 11806, 16, 55, 12, 0, -55 },
  { 11916, 40, 39, 42, 0, -39 },
  { 12111, 26, 39, 28, 0, -39 },
  { 12238, 24, 40, 28, 2, -39 },
  { 12358, 30, 56, 28, -3, -39 },
  { 12568, 26, 56, 29, 2, -39 },
  { 12750, 22, 39, 18, 0, -39 },
  { 12858, 23, 40, 21, -1, -39 },
  { 12973, 16, 48, 15, 1, -47 },
  { 13069, 25, 39, 28, 2, -38 },
  { 13191, 21, 38, 22, 4, -38 },
  { 13291, 35, 38, 36, 4, -38 },
  { 13458, 28, 38, 23, -3, -38 },
  { 13591, 34, 55, 23, -7, -38 },
  { 13825, 23, 38, 19, -2, -38 },
  { 13935, 25, 62, 23, 2, -51 },
  { 14129, 3, 72, 26, 11, -55 },
  { 14156, 26, 62, 23, -5, -51 },
  { 14358, 25, 7, 30, 3, -29 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC72PT7B_H_
