#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1,
  0x02, 0x0C, 0x18, 0x20, 0x00, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x63, 0x62,
  0x66, 0x66, 0x46, 0x44, 0xC4, 0xCC, 0x01, 0x88, 0x08, 0xC0, 0xC4, 0x06,
  0x20, 0x23, 0x01, 0x10, 0x18, 0x87, 0xFF, 0x04, 0x60, 0x62, 0x02, 0x30,
  0x11, 0x81, 0x88, 0x08, 0x43, 0xFF, 0x9F, 0xFC, 0x21, 0x01, 0x18, 0x18,
  0x80, 0xC4, 0x04, 0x60, 0x22, 0x03, 0x10, 0x00, 0x00, 0x80, 0x08, 0x01,
  0xC0, 0xFF, 0x0D, 0x11, 0x90, 0x11, 0x01, 0x10, 0x11, 0x01, 0xA0, 0x1A,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x05, 0x80, 0x4C, 0x04, 0xC0, 0x4C, 0x08,
  0xC0, 0x88, 0x89, 0x8F, 0xF0, 0x1C, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1C,
  0x0C, 0x6C, 0x11, 0x98, 0x62, 0x30, 0x84, 0x63, 0x18, 0xC4, 0x21, 0x98,
  0x42, 0x20, 0x84, 0x81, 0x1B, 0x3A, 0x24, 0xDC, 0x5B, 0x39, 0x24, 0x7E,
  0xC8, 0xC1, 0x31, 0x86, 0x43, 0x08, 0x84, 0x31, 0x08, 0x42, 0x31, 0x8C,
  0x62, 0x08, 0x8C, 0x13, 0x10, 0x3C, 0x00, 0x03, 0xC0, 0xD8, 0x31, 0x06,
  0x20, 0xC4, 0x11, 0x82, 0x30, 0x64, 0x0D, 0x81, 0xE0, 0x38, 0x0F, 0x03,
  0x60, 0x4C, 0x58, 0x9E, 0x1B, 0xC3, 0x58, 0x3A, 0x06, 0x40, 0xCC, 0x39,
  0x8D, 0x9F, 0x30, 0x2D, 0xB4, 0xB6, 0x01, 0x81, 0x81, 0x80, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10,
  0x0C, 0x00, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x00, 0x04, 0x02,
  0x13, 0x1F, 0xB1, 0xF8, 0xE0, 0xD0, 0xC4, 0x43, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x87, 0xFF, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0x26, 0x4C, 0x80, 0xFE, 0x6F,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0x81, 0xD8, 0x21, 0x0C, 0x31,
  0x06, 0x60, 0xC8, 0x1B, 0x03, 0x60, 0x4C, 0x09, 0x03, 0x60, 0x6C, 0x0D,
  0x81, 0xB0, 0x24, 0x0C, 0x81, 0x90, 0x22, 0x0C, 0x41, 0x0C, 0x61, 0x98,
  0x1E, 0x00, 0x06, 0x1C, 0x79, 0xAE, 0x49, 0x83, 0x06, 0x08, 0x10, 0x60,
  0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x10, 0x00, 0x03,
  0xE0, 0x7B, 0x81, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x03, 0xE0, 0x7B, 0x81, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x01, 0xF0, 0x0F, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x61,
  0xC3, 0xF8, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xA0, 0x0B, 0x00,
  0xD8, 0x04, 0xC0, 0x64, 0x02, 0x60, 0x23, 0x03, 0x18, 0x10, 0x81, 0x84,
  0x18, 0x60, 0x83, 0x0C, 0x18, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xF8, 0x07, 0xF0, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x18, 0x61, 0xC3, 0xF8, 0x00, 0x01, 0xE0, 0xE4, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0D, 0xE1, 0x6E, 0x70, 0xCE,
  0x0D, 0x81, 0xB0, 0x36, 0x04, 0x80, 0x90, 0x32, 0x06, 0x60, 0x8C, 0x31,
  0xCC, 0x1F, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0xE6, 0x08, 0x31, 0x83, 0x18, 0x31, 0x83, 0x18,
  0x31, 0x86, 0x18, 0x60, 0xDC, 0x07, 0x00, 0xF0, 0x1B, 0x07, 0x18, 0x60,
  0xCC, 0x0C, 0xC0, 0xC8, 0x0C, 0x80, 0xCC, 0x0C, 0xC1, 0x86, 0x30, 0x3E,
  0x00, 0x07, 0xC0, 0xEE, 0x0C, 0x61, 0x82, 0x10, 0x33, 0x03, 0x30, 0x33,
  0x03, 0x20, 0x22, 0x06, 0x20, 0x63, 0x0E, 0x39, 0xE1, 0xF4, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x08, 0xE0, 0xF8, 0x00,
  0x1C, 0x61, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x38,
  0xC0, 0x03, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x20,
  0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x02, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x08, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x0C, 0x01, 0x00,
  0x00, 0x0F, 0x86, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x00, 0xF8, 0x03, 0x8C, 0x06, 0x02,
  0x0C, 0x03, 0x08, 0x03, 0x10, 0x01, 0x30, 0x61, 0x21, 0xF1, 0x23, 0x31,
  0x62, 0x31, 0x46, 0x23, 0x44, 0x23, 0xC4, 0x62, 0xCC, 0x62, 0x8C, 0x46,
  0x8C, 0xC4, 0x88, 0xC4, 0x8D, 0x48, 0x87, 0x78, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3B, 0x80, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0B, 0x00, 0xB0, 0x1B, 0x01, 0x30, 0x33, 0x03, 0x30,
  0x63, 0x06, 0x30, 0x43, 0x0C, 0x30, 0xFF, 0x1F, 0xF1, 0x83, 0x10, 0x33,
  0x03, 0x30, 0x36, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x30, 0x07, 0xC0, 0x3F,
  0x83, 0x06, 0x18, 0x30, 0xC1, 0x84, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x30,
  0xC3, 0x07, 0xF0, 0x7F, 0x83, 0x0E, 0x18, 0x30, 0xC1, 0x84, 0x0C, 0x60,
  0x63, 0x03, 0x18, 0x18, 0xC1, 0x84, 0x1C, 0x7F, 0xC3, 0xF8, 0x00, 0x01,
  0xF8, 0x3C, 0xC3, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x38, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x3F, 0x83, 0x0E, 0x18, 0x30, 0xC1, 0x84, 0x04, 0x20,
  0x23, 0x01, 0x18, 0x08, 0xC0, 0x44, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C,
  0xC0, 0xC4, 0x06, 0x60, 0x33, 0x03, 0x18, 0x18, 0x81, 0x84, 0x18, 0x7F,
  0x83, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xF0, 0x7F, 0x83, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x7F,
  0x83, 0xFC, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xBC, 0x18,
  0x10, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x07, 0xCC, 0x0F, 0x98, 0x02, 0x30, 0x0C, 0x60,
  0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0x82, 0x03, 0x06, 0x06, 0x07, 0x1C,
  0x07, 0xF0, 0x00, 0x06, 0x02, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x41, 0x00, 0x82, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x10, 0x7F, 0xE1,
  0xFF, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x10, 0x18, 0x60, 0x30, 0xC0,
  0x61, 0x80, 0x82, 0x01, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x00, 0x07,
  0xE0, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x3F, 0x00, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x07,
  0x80, 0xF0, 0x00, 0x06, 0x0C, 0x10, 0x30, 0xC1, 0x83, 0x0C, 0x0C, 0x60,
  0x21, 0x80, 0x8C, 0x06, 0x60, 0x19, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x80,
  0x3B, 0x00, 0xCC, 0x03, 0x30, 0x08, 0x40, 0x61, 0x81, 0x86, 0x06, 0x18,
  0x18, 0x60, 0x40, 0x83, 0x03, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x40, 0x40, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x60, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xA0, 0xB0, 0x1E, 0x0B, 0x01,
  0x61, 0xB0, 0x36, 0x1B, 0x03, 0x61, 0xB0, 0x64, 0x13, 0x06, 0xC3, 0x30,
  0xCC, 0x33, 0x0C, 0xC3, 0x31, 0x88, 0x23, 0x18, 0x82, 0x31, 0x18, 0x63,
  0x31, 0x86, 0x12, 0x18, 0x61, 0x61, 0x04, 0x14, 0x10, 0x41, 0xC3, 0x0C,
  0x18, 0x30, 0xC1, 0x83, 0x00, 0x06, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0F,
  0x02, 0x0F, 0x02, 0x0B, 0x06, 0x0B, 0x06, 0x19, 0x06, 0x19, 0x04, 0x19,
  0x8C, 0x11, 0x8C, 0x31, 0x8C, 0x30, 0x8C, 0x30, 0x88, 0x30, 0x98, 0x20,
  0xD8, 0x60, 0xD8, 0x60, 0xD8, 0x60, 0x50, 0x40, 0x70, 0x40, 0x70, 0xC0,
  0x70, 0xC0, 0x60, 0x03, 0xE0, 0x1D, 0xE0, 0xC1, 0x82, 0x06, 0x18, 0x08,
  0xC0, 0x33, 0x00, 0x8C, 0x02, 0x60, 0x09, 0x80, 0x66, 0x01, 0x90, 0x06,
  0xC0, 0x1B, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06,
  0x30, 0x30, 0x61, 0x81, 0xCE, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x03,
  0x0C, 0x18, 0x20, 0xC1, 0x84, 0x0C, 0x20, 0x63, 0x02, 0x18, 0x30, 0xC1,
  0x84, 0x18, 0x61, 0x83, 0xF8, 0x1E, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0xE0,
  0x1D, 0xE0, 0xC1, 0x82, 0x06, 0x18, 0x08, 0xC0, 0x33, 0x00, 0x8C, 0x02,
  0x60, 0x09, 0x80, 0x66, 0x01, 0x90, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x30, 0x30, 0x61, 0xC1, 0xCE,
  0x03, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0xC0, 0x3F, 0x03, 0x0C, 0x18, 0x20, 0xC1, 0x84, 0x0C, 0x20, 0x63, 0x06,
  0x18, 0x30, 0xC1, 0x84, 0x18, 0x63, 0x83, 0xF8, 0x19, 0x80, 0xCC, 0x04,
  0x20, 0x61, 0x03, 0x0C, 0x18, 0x60, 0xC3, 0x04, 0x18, 0x60, 0x43, 0x03,
  0x00, 0x03, 0xF8, 0x3D, 0xC3, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x1C, 0x73,
  0xC3, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x00, 0x08,
  0x0C, 0x60, 0x31, 0x80, 0xC6, 0x02, 0x18, 0x18, 0x40, 0x63, 0x01, 0x8C,
  0x04, 0x30, 0x10, 0x80, 0xC2, 0x03, 0x18, 0x0C, 0x60, 0x21, 0x81, 0x84,
  0x06, 0x30, 0x18, 0xC0, 0x43, 0x01, 0x0C, 0x0C, 0x30, 0x30, 0xC1, 0x81,
  0x8C, 0x03, 0xE0, 0x00, 0x80, 0x38, 0x06, 0x80, 0x68, 0x0C, 0x80, 0xC8,
  0x18, 0x81, 0x88, 0x10, 0x83, 0x08, 0x30, 0x86, 0x08, 0x60, 0x84, 0x08,
  0xC0, 0x88, 0x09, 0x80, 0x98, 0x0B, 0x00, 0xB0, 0x0A, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x00, 0x40, 0x20, 0x14, 0x06, 0x03, 0x40, 0x60, 0x34, 0x06,
  0x06, 0x40, 0xE0, 0x64, 0x0A, 0x04, 0x41, 0xA0, 0xC4, 0x12, 0x0C, 0x41,
  0x21, 0x84, 0x32, 0x18, 0x42, 0x21, 0x04, 0x62, 0x30, 0xC6, 0x23, 0x0C,
  0x46, 0x60, 0xCC, 0x66, 0x0C, 0x86, 0x40, 0xD8, 0x6C, 0x0D, 0x86, 0xC0,
  0xD0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x00, 0x02, 0x06, 0x04, 0x08, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x66,
  0x00, 0xCC, 0x00, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xD0, 0x01, 0xA0, 0x06, 0x40, 0x0C, 0xC0, 0x31, 0x80, 0x43,
  0x01, 0x86, 0x02, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x00, 0x40, 0x6C, 0x09,
  0x83, 0x30, 0x46, 0x18, 0xC2, 0x18, 0xC3, 0x10, 0x26, 0x04, 0x80, 0xB0,
  0x14, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xF0, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0F,
  0xC0, 0xC6, 0x10, 0x84, 0x31, 0x8C, 0x61, 0x08, 0x43, 0x18, 0xC6, 0x30,
  0x84, 0x21, 0x8C, 0x60, 0x03, 0xF0, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x0F, 0xC0, 0x02, 0x00,
  0x70, 0x07, 0x00, 0xD8, 0x09, 0x81, 0x88, 0x30, 0xC3, 0x0C, 0x60, 0x46,
  0x06, 0xC0, 0x68, 0x03, 0xFF, 0xC0, 0xD9, 0x92, 0x0F, 0xB1, 0xCA, 0x30,
  0x63, 0x06, 0x60, 0x66, 0x04, 0x60, 0x4C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0,
  0x8C, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x8E, 0x50, 0x79, 0x00, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0xBE, 0x1E, 0x61,
  0xC3, 0x18, 0x31, 0x83, 0x10, 0x33, 0x03, 0x30, 0x32, 0x02, 0x20, 0x66,
  0x06, 0x60, 0x66, 0x0C, 0x60, 0xC6, 0x18, 0xF3, 0x8D, 0xF0, 0x0F, 0x8E,
  0x4C, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xC8, 0x7C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC1, 0xF6, 0x1C, 0xA1, 0x83, 0x0C, 0x18,
  0xC0, 0xC6, 0x04, 0x30, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x30,
  0x61, 0x83, 0x0C, 0x18, 0x61, 0xC3, 0x94, 0x0F, 0x20, 0x0F, 0x86, 0x33,
  0x0C, 0xC3, 0x60, 0xD8, 0x64, 0x1B, 0x3C, 0xFC, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x88, 0x7E, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x0F,
  0x00, 0x38, 0x00, 0x03, 0xEC, 0x1C, 0xA0, 0xC1, 0x83, 0x06, 0x18, 0x18,
  0x60, 0x41, 0x81, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x02, 0x0C, 0x18,
  0x30, 0x60, 0xC3, 0x83, 0x0E, 0x0E, 0x50, 0x1E, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x08, 0x30, 0x3F, 0x80, 0x38, 0x00, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x5F, 0x1E, 0x63,
  0x84, 0x60, 0x8C, 0x11, 0x06, 0x60, 0xCC, 0x19, 0x82, 0x20, 0xCC, 0x19,
  0x83, 0x30, 0x66, 0x08, 0x83, 0x30, 0x66, 0x0C, 0x06, 0x1C, 0x10, 0x00,
  0x00, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1,
  0x82, 0x04, 0x18, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x01, 0xE0, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x83,
  0x18, 0x61, 0x8C, 0x19, 0x81, 0x10, 0x13, 0x03, 0x60, 0x3E, 0x02, 0xE0,
  0x32, 0x06, 0x20, 0x63, 0x06, 0x30, 0x43, 0x04, 0x30, 0xC1, 0x0C, 0x18,
  0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06,
  0x0C, 0x18, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0x0B, 0xCF, 0x87,
  0x9E, 0x61, 0xC7, 0x0C, 0x61, 0x83, 0x18, 0x60, 0x84, 0x18, 0x23, 0x06,
  0x18, 0xC1, 0x06, 0x30, 0xC1, 0x88, 0x30, 0x46, 0x0C, 0x31, 0x82, 0x0C,
  0x60, 0x83, 0x18, 0x60, 0xC4, 0x18, 0x23, 0x06, 0x18, 0xC1, 0x06, 0x00,
  0x0B, 0xE3, 0xCC, 0x70, 0x8C, 0x11, 0x86, 0x20, 0xCC, 0x19, 0x83, 0x30,
  0x44, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x10, 0x66, 0x0C, 0xC1, 0x80,
  0x0F, 0x86, 0x33, 0x0C, 0xC1, 0x60, 0x58, 0x14, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x02, 0xC1, 0xB0, 0x4C, 0x33, 0x98, 0x7C, 0x00, 0x05, 0xF0,
  0x69, 0x83, 0x86, 0x18, 0x30, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x10, 0x80, 0x84, 0x0C, 0x60, 0x63, 0x02, 0x18, 0x30, 0xC3, 0x0F, 0x38,
  0x6F, 0x83, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x0F, 0xB1, 0xCA, 0x30, 0x63, 0x06, 0x60, 0x66, 0x04, 0x40, 0x4C,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x8C, 0x38, 0xC3, 0x8E,
  0x50, 0x7B, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x0B, 0xC7, 0x91, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x00, 0x0F, 0xC6, 0x23, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x62, 0x38, 0xFC, 0x00, 0x08,
  0x61, 0x84, 0x7C, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC2,
  0x08, 0x30, 0xF0, 0x10, 0x66, 0x0C, 0xC1, 0x98, 0x22, 0x0C, 0xC1, 0x98,
  0x33, 0x06, 0x40, 0x88, 0x33, 0x06, 0x60, 0xCC, 0x11, 0x86, 0x31, 0xC6,
  0x78, 0x7B, 0x00, 0x81, 0xC0, 0xE0, 0x50, 0x68, 0x24, 0x32, 0x11, 0x18,
  0x8C, 0x4C, 0x26, 0x12, 0x0B, 0x05, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0xC1,
  0x83, 0xC3, 0x86, 0xC3, 0x86, 0xC3, 0x84, 0xC7, 0x8C, 0xC5, 0x88, 0xCD,
  0x98, 0x89, 0x98, 0x89, 0x90, 0x99, 0xB0, 0x91, 0xA0, 0xB1, 0xE0, 0xA1,
  0x60, 0xA1, 0x40, 0xE1, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0x18, 0x30, 0x86,
  0x0C, 0x60, 0xCC, 0x0C, 0x80, 0x58, 0x05, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0A, 0x01, 0xB0, 0x33, 0x03, 0x30, 0x61, 0x04, 0x10, 0xC1, 0x80, 0x06,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x40, 0x61, 0x80, 0xC2, 0x01, 0x8C,
  0x03, 0x10, 0x06, 0x60, 0x04, 0xC0, 0x09, 0x00, 0x16, 0x00, 0x28, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x0F, 0xC0,
  0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x18, 0x06, 0x03, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x3C, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x81, 0xE0, 0x38, 0x01, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xF0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x70, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x38,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x1F, 0xE3, 0x83, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 23, 7, 0, -23 },
  { 22, 8, 8, 10, 3, -23 },
  { 30, 13, 23, 13, 0, -23 },
  { 68, 12, 26, 12, 0, -24 },
  { 107, 15, 23, 18, 2, -23 },
  { 151, 11, 23, 12, 0, -23 },
  { 183, 3, 8, 5, 3, -23 },
  { 186, 9, 28, 8, 1, -23 },
  { 218, 9, 28, 8, -2, -23 },
  { 250, 9, 9, 11, 3, -24 },
  { 261, 11, 15, 13, 1, -19 },
  { 282, 4, 7, 6, -1, -3 },
  { 286, 7, 1, 8, 1, -9 },
  { 287, 3, 3, 6, 0, -3 },
  { 289, 14, 23, 10, -2, -23 },
  { 330, 11, 23, 12, 1, -23 },
  { 362, 7, 23, 12, 3, -23 },
  { 383, 13, 23, 12, -1, -23 },
  { 421, 13, 23, 12, -1, -23 },
  { 459, 13, 23, 12, -1, -23 },
  { 497, 13, 23, 12, -1, -23 },
  { 535, 11, 23, 12, 1, -23 },
  { 567, 12, 23, 12, 1, -23 },
  { 602, 12, 23, 12, 0, -23 },
  { 637, 12, 23, 12, 0, -23 },
  { 672, 6, 17, 6, 0, -17 },
  { 685, 8, 21, 6, -2, -17 },
  { 706, 11, 14, 13, 1, -18 },
  { 726, 11, 8, 13, 1, -15 },
  { 737, 11, 14, 13, 1, -18 },
  { 757, 10, 23, 8, 0, -23 },
  { 786, 16, 26, 18, 1, -23 },
  { 838, 12, 23, 12, -2, -23 },
  { 873, 13, 23, 13, 0, -23 },
  { 911, 13, 23, 12, 1, -23 },
  { 949, 13, 23, 14, 0, -23 },
  { 987, 13, 23, 11, 0, -23 },
  { 1025, 13, 23, 11, 0, -23 },
  { 1063, 15, 23, 15, 1, -23 },
  { 1107, 15, 23, 15, 0, -23 },
  { 1151, 11, 23, 7, -2, -23 },
  { 1183, 12, 29, 6, -5, -23 },
  { 1227, 14, 23, 12, 0, -23 },
  { 1268, 8, 23, 10, 0, -23 },
  { 1291, 20, 23, 20, 0, -23 },
  { 1349, 16, 23, 16, 0, -23 },
  { 1395, 14, 23, 15, 1, -23 },
  { 1436, 13, 23, 12, 0, -23 },
  { 1474, 14, 28, 15, 1, -23 },
  { 1523, 13, 23, 12, 0, -23 },
  { 1561, 13, 23, 11, -1, -23 },
  { 1599, 11, 23, 10, 2, -23 },
  { 1631, 14, 23, 14, 1, -23 },
  { 1672, 12, 23, 12, 3, -23 },
  { 1707, 20, 23, 20, 2, -23 },
  { 1765, 15, 23, 11, -2, -23 },
  { 1809, 11, 23, 10, 2, -23 },
  { 1841, 13, 23, 10, -1, -23 },
  { 1879, 12, 28, 9, -1, -23 },
  { 1921, 5, 23, 11, 3, -23 },
  { 1936, 12, 28, 9, -2, -23 },
  { 1978, 12, 12, 13, 1, -23 },
  { 1996, 10, 1, 9, -3, 3 },
  { 1998, 3, 5, 7, 5, -24 },
  { 2000, 12, 17, 13, 1, -17 },
  { 2026, 12, 24, 13, 0, -24 },
  { 2062, 9, 17, 9, 1, -17 },
  { 2082, 13, 24, 13, 1, -24 },
  { 2121, 10, 17, 11, 1, -17 },
  { 2143, 14, 32, 7, -4, -24 },
  { 2199, 14, 25, 13, -1, -17 },
  { 2243, 11, 24, 12, 0, -24 },
  { 2276, 7, 23, 6, 0, -23 },
  { 2297, 11, 31, 6, -4, -23 },
  { 2340, 12, 24, 11, 0, -24 },
  { 2376, 7, 24, 5, 0, -24 },
  { 2397, 18, 17, 19, 0, -17 },
  { 2436, 11, 17, 12, 0, -17 },
  { 2460, 10, 17, 12, 1, -17 },
  { 2482, 13, 24, 13, -1, -17 },
  { 2521, 12, 25, 13, 1, -17 },
  { 2559, 10, 17, 8, 0, -17 },
  { 2581, 10, 17, 9, 0, -17 },
  { 2603, 6, 21, 7, 1, -21 },
  { 2619, 11, 17, 12, 1, -17 },
  { 2643, 9, 17, 10, 2, -17 },
  { 2663, 16, 17, 16, 2, -17 },
  { 2697, 12, 17, 10, -1, -17 },
  { 2723, 15, 25, 10, -3, -17 },
  { 2770, 10, 17, 8, -1, -17 },
  { 2792, 11, 28, 10, 1, -23 },
  { 2831, 1, 32, 11, 5, -24 },
  { 2835, 11, 28, 10, -2, -23 },
  { 2874, 12, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC32PT7B_H_
