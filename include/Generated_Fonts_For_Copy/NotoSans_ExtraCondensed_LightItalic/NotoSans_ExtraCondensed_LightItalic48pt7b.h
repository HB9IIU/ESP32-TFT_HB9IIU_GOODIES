#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x38, 0xE6, 0x1D, 0xC3,
  0x38, 0x66, 0x1C, 0xC3, 0x98, 0x67, 0x0C, 0xC1, 0x98, 0x73, 0x0C, 0x61,
  0x80, 0x00, 0x18, 0x70, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x38, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x01, 0x83, 0x00, 0x18, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x61, 0xC0, 0x0C, 0x18, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xE6, 0x30, 0x38, 0x80, 0x0E, 0x10, 0x01,
  0xC2, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x1C, 0x40, 0x01,
  0x98, 0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0x38, 0x00, 0x27, 0x00, 0x04, 0x70, 0x01,
  0x8E, 0x00, 0x31, 0xC0, 0x04, 0x38, 0x00, 0x87, 0x00, 0x30, 0xC0, 0x06,
  0x38, 0x20, 0xCE, 0x07, 0x97, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x04, 0x0F, 0xC0, 0x30, 0x3B, 0x80, 0xE0, 0xE3, 0x01, 0x81, 0x86,
  0x07, 0x07, 0x0C, 0x0C, 0x0C, 0x18, 0x38, 0x18, 0x30, 0x60, 0x70, 0x61,
  0xC0, 0xC0, 0xC3, 0x01, 0x81, 0x8E, 0x03, 0x07, 0x18, 0x06, 0x0C, 0x70,
  0x1C, 0x18, 0xC0, 0x30, 0x33, 0x8F, 0x60, 0xE6, 0x3F, 0xC1, 0x9C, 0xC7,
  0x87, 0x33, 0x8F, 0x8C, 0xE6, 0x1B, 0x39, 0x98, 0x37, 0xE7, 0x30, 0x63,
  0x0C, 0x60, 0xC0, 0x39, 0x81, 0x80, 0x63, 0x03, 0x01, 0xC6, 0x06, 0x03,
  0x0C, 0x1C, 0x0E, 0x38, 0x30, 0x18, 0x70, 0x60, 0x70, 0xC0, 0xC0, 0xC1,
  0x83, 0x03, 0x83, 0x06, 0x06, 0x06, 0x1C, 0x1C, 0x0E, 0x30, 0x30, 0x0F,
  0xC0, 0xC0, 0x1F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x00,
  0x3B, 0x80, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0C, 0x1C, 0x06, 0x0C,
  0x03, 0x06, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x31, 0x80, 0x1D,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x03,
  0x98, 0x01, 0x8E, 0x19, 0xC7, 0x1D, 0xC1, 0x8C, 0xC0, 0xC6, 0xE0, 0x77,
  0x70, 0x1B, 0x30, 0x0F, 0x98, 0x07, 0x8C, 0x03, 0xC6, 0x01, 0xC3, 0x00,
  0xF1, 0xC0, 0xF8, 0xE0, 0xCC, 0x3F, 0xC7, 0x0F, 0xC3, 0x80, 0x39, 0x9C,
  0xE7, 0x31, 0x8C, 0xE6, 0x31, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0xE0, 0x06, 0x04,
  0x30, 0x79, 0x80, 0xFD, 0xE1, 0xFF, 0x07, 0x00, 0x68, 0x06, 0x60, 0x61,
  0x87, 0x0C, 0x10, 0x70, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0E, 0x18,
  0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x70, 0xE0, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C,
  0x1C, 0x07, 0x0C, 0x03, 0x8E, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x63, 0x80,
  0x31, 0xC0, 0x18, 0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x18,
  0xE0, 0x1C, 0x70, 0x0C, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x07, 0x03,
  0x83, 0x81, 0x81, 0xC1, 0xC0, 0x71, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0xF0, 0x7C, 0x7E, 0x3D, 0x9C, 0x6E, 0x39, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x0C, 0x0E, 0x00, 0x80, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xC0, 0xE0, 0x10, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0xC0, 0x78, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00,
  0x0F, 0x80, 0x03, 0x70, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00,
  0xCE, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x61, 0xC0, 0x1C,
  0x38, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x06, 0x07, 0x01, 0xC0,
  0xE0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x1C, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1D, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x06, 0x03, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x1F, 0x80, 0xDF, 0xF0, 0x76, 0x1C, 0x1F, 0x03,
  0x07, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x70, 0xE0,
  0x1C, 0x38, 0x06, 0x0E, 0x03, 0x81, 0x81, 0xC0, 0x70, 0xE0, 0x0F, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0E, 0x0F, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x0C,
  0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x18, 0x18, 0x0E, 0x06,
  0x03, 0x01, 0xC1, 0xC0, 0x38, 0xE0, 0x0E, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0x00, 0x38, 0xE0, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x00, 0xC3,
  0x80, 0x38, 0xE0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38, 0xC0,
  0x0E, 0x30, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x38, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x70, 0x70,
  0x70, 0x38, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x00,
  0xC7, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x1C, 0x60, 0x0E, 0x30,
  0x07, 0x18, 0x07, 0x8E, 0x07, 0x87, 0x07, 0xC1, 0xE7, 0x60, 0xFF, 0x70,
  0x1E, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x02, 0x07, 0x07, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x40, 0x38, 0x07,
  0x80, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xC1,
  0xFF, 0x82, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xCF, 0x00, 0x0E, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC3, 0x01, 0xF0, 0x61, 0x81, 0xFC, 0x31,
  0x81, 0x8C, 0x38, 0xC1, 0x86, 0x1C, 0xE1, 0x83, 0x0C, 0x60, 0xC3, 0x86,
  0x30, 0xC1, 0x83, 0x18, 0x60, 0xC1, 0x98, 0x30, 0x60, 0xCC, 0x30, 0x70,
  0xC6, 0x18, 0x30, 0x63, 0x0C, 0x18, 0x31, 0x86, 0x0C, 0x19, 0xC3, 0x0E,
  0x18, 0xC1, 0x87, 0x0C, 0x60, 0xC7, 0x0C, 0x30, 0x62, 0xC6, 0x18, 0x3B,
  0x6E, 0x0C, 0x1F, 0x3E, 0x06, 0x02, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x40, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x76, 0x00, 0x33, 0x00, 0x39, 0x80, 0x18, 0xC0, 0x0C, 0x60,
  0x0E, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x06, 0x03, 0x83, 0x01, 0xC1,
  0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x18,
  0x06, 0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0x67, 0x00, 0x33,
  0x80, 0x19, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0x81, 0xE0, 0x18, 0x0E, 0x03,
  0x80, 0x60, 0x38, 0x07, 0x03, 0x00, 0x70, 0x30, 0x07, 0x07, 0x00, 0x60,
  0x70, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x0F, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xC1, 0xE0, 0x1C, 0x07,
  0x01, 0xC0, 0x30, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x18, 0x03, 0x83, 0x80,
  0x38, 0x38, 0x03, 0x83, 0x00, 0x38, 0x30, 0x03, 0x07, 0x00, 0x70, 0x70,
  0x07, 0x07, 0x00, 0xE0, 0x60, 0x1C, 0x06, 0x0F, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF0, 0x20,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x78, 0x10, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0x83, 0xC0, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0x03, 0x00, 0x70, 0x30, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x03, 0x83, 0x00, 0x38, 0x30, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x78, 0x06, 0x3F, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x78, 0x06, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x3F, 0x8E, 0x01,
  0xFE, 0x38, 0x07, 0xF0, 0xE0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x3C, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x38, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x18,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x01,
  0xC0, 0x06, 0x03, 0x80, 0x1C, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x18,
  0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00,
  0x18, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x03,
  0x80, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x0E, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x3C,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x38, 0x03, 0x81, 0xC0, 0x0E,
  0x07, 0x00, 0x30, 0x38, 0x00, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x39, 0xC0, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xE7,
  0x00, 0x07, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x1C,
  0x06, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0D, 0x80, 0x03, 0x60, 0x36, 0x00, 0x1D,
  0x80, 0xD8, 0x00, 0x7E, 0x07, 0x60, 0x03, 0xB8, 0x1D, 0x80, 0x0E, 0xC0,
  0x76, 0x00, 0x33, 0x01, 0x98, 0x01, 0xDC, 0x06, 0x70, 0x06, 0x70, 0x39,
  0xC0, 0x39, 0xC0, 0xE7, 0x00, 0xC6, 0x03, 0x1C, 0x07, 0x18, 0x0C, 0x70,
  0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x0E, 0x07, 0x0C, 0x1C,
  0x30, 0x18, 0x30, 0x60, 0xC0, 0x60, 0xC3, 0x87, 0x03, 0x83, 0x0C, 0x1C,
  0x0E, 0x0C, 0x70, 0x60, 0x38, 0x31, 0xC1, 0x80, 0xC0, 0xC6, 0x0E, 0x03,
  0x03, 0x38, 0x38, 0x1C, 0x0C, 0xC0, 0xE0, 0x70, 0x37, 0x03, 0x01, 0x80,
  0xD8, 0x0C, 0x06, 0x03, 0xE0, 0x70, 0x18, 0x0F, 0x01, 0xC0, 0xE0, 0x3C,
  0x07, 0x03, 0x80, 0xE0, 0x18, 0x00, 0x01, 0xE0, 0x03, 0x01, 0xE0, 0x07,
  0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x03, 0xE0, 0x06, 0x03, 0xE0, 0x06,
  0x03, 0x70, 0x0E, 0x03, 0x70, 0x0E, 0x07, 0x30, 0x0C, 0x07, 0x30, 0x0C,
  0x07, 0x30, 0x1C, 0x06, 0x30, 0x1C, 0x06, 0x38, 0x1C, 0x0E, 0x38, 0x18,
  0x0E, 0x18, 0x18, 0x0C, 0x18, 0x38, 0x0C, 0x18, 0x38, 0x0C, 0x1C, 0x38,
  0x1C, 0x1C, 0x30, 0x1C, 0x1C, 0x30, 0x18, 0x0C, 0x70, 0x18, 0x0C, 0x70,
  0x38, 0x0C, 0x60, 0x38, 0x0E, 0x60, 0x38, 0x0E, 0x60, 0x30, 0x06, 0xE0,
  0x30, 0x06, 0xE0, 0x70, 0x06, 0xC0, 0x70, 0x06, 0xC0, 0x70, 0x07, 0xC0,
  0x60, 0x07, 0xC0, 0x60, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3C, 0x1E, 0x03, 0x80,
  0xE0, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x18,
  0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x06,
  0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x06, 0x03, 0xC0, 0x70, 0x78, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x06, 0x0F, 0x00,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x18, 0x07, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x60, 0x60, 0x1C, 0x1C,
  0x03, 0x83, 0x80, 0xE0, 0x70, 0x3C, 0x0C, 0x0F, 0x01, 0x8F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3C, 0x1E, 0x03,
  0x80, 0xE0, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00,
  0x18, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0,
  0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x06, 0x03, 0xC0, 0x70, 0x78, 0x03,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x06, 0x0F, 0x00, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x18, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x1C, 0x1C, 0x03, 0x83, 0x00, 0x60, 0x60, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0xE0, 0x70, 0x38, 0x0C, 0x1E, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0E, 0x38,
  0x01, 0x87, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0xC1, 0xC0, 0x38, 0x38,
  0x06, 0x07, 0x00, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x18, 0x07, 0x03, 0x00, 0xE0, 0xE0, 0x0C, 0x1C, 0x01, 0xC0, 0x00, 0x1F,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3C, 0x06, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x08, 0x03, 0xC0, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x38, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x18, 0x0C,
  0x01, 0xC0, 0x60, 0x0C, 0x03, 0x80, 0xE0, 0x1E, 0x0E, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80,
  0x0C, 0xE0, 0x07, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C,
  0x38, 0x07, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xE0, 0x30, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x30, 0x0E, 0x1C, 0x03, 0x86,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xE6, 0x00,
  0x3B, 0x80, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0xE0, 0x07, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x73, 0x80, 0x3C, 0x00,
  0xC7, 0x00, 0x78, 0x03, 0x8E, 0x01, 0xF0, 0x06, 0x18, 0x03, 0x60, 0x1C,
  0x30, 0x06, 0xC0, 0x38, 0x60, 0x1D, 0x80, 0x60, 0xC0, 0x33, 0x01, 0xC1,
  0x80, 0x66, 0x03, 0x03, 0x01, 0x8C, 0x0E, 0x06, 0x03, 0x38, 0x1C, 0x0C,
  0x0E, 0x70, 0x30, 0x18, 0x18, 0xE0, 0xE0, 0x30, 0x31, 0xC1, 0x80, 0x60,
  0xC3, 0x87, 0x00, 0xC1, 0x87, 0x0E, 0x01, 0x87, 0x0E, 0x18, 0x03, 0x0C,
  0x18, 0x70, 0x06, 0x18, 0x30, 0xC0, 0x0C, 0x70, 0x63, 0x80, 0x18, 0xC0,
  0xC7, 0x00, 0x33, 0x81, 0x8C, 0x00, 0x66, 0x03, 0x38, 0x00, 0xCC, 0x06,
  0x60, 0x01, 0xB8, 0x0D, 0xC0, 0x03, 0x60, 0x1B, 0x80, 0x07, 0xC0, 0x36,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0xC0, 0x38, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x07, 0x07, 0x00,
  0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x31, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x03, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0C, 0x00, 0x70,
  0x07, 0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC3, 0x01, 0xC1, 0x80, 0xE0,
  0xC0, 0xE0, 0x60, 0x70, 0x30, 0x70, 0x18, 0x30, 0x0E, 0x38, 0x07, 0x18,
  0x03, 0x9C, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xC1, 0x83, 0x87, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xE1, 0xC3, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x0E,
  0x1C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x31, 0xC0, 0x1C,
  0x30, 0x06, 0x0E, 0x03, 0x83, 0x80, 0xC0, 0x60, 0x70, 0x1C, 0x38, 0x03,
  0x0C, 0x00, 0xC7, 0x00, 0x39, 0x80, 0x06, 0xE0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE7, 0x1C, 0xE3, 0x1C, 0x61, 0x00, 0xF0, 0x00, 0x7F, 0x30,
  0x7C, 0xDC, 0x1C, 0x1E, 0x0E, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60,
  0x0E, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x0F, 0x06, 0x07, 0x81, 0xC3,
  0x60, 0x7F, 0x98, 0x0F, 0xC6, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x31, 0xE0, 0x1D, 0xFC, 0x07, 0xE7, 0x81,
  0xA0, 0x60, 0x78, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x1C, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x30, 0x07, 0x1C,
  0x01, 0x87, 0x00, 0xE1, 0xE0, 0x30, 0x78, 0x1C, 0x1B, 0x0E, 0x0E, 0xFF,
  0x03, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0x30, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x20,
  0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xF9, 0xC0, 0x1F, 0xDC, 0x07, 0xCD,
  0xC0, 0x70, 0x78, 0x0E, 0x07, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0x80,
  0x30, 0x38, 0x03, 0x03, 0x80, 0x70, 0x30, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x0E, 0x03, 0xC0,
  0x60, 0x78, 0x07, 0x0D, 0x80, 0x7F, 0x98, 0x03, 0xF1, 0x80, 0x00, 0xF8,
  0x03, 0xF8, 0x1E, 0x38, 0x38, 0x70, 0xE0, 0x63, 0x80, 0xC6, 0x01, 0x9C,
  0x07, 0x38, 0x0C, 0x60, 0x39, 0xC0, 0xE3, 0x87, 0x87, 0xFE, 0x0F, 0xE0,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x10, 0x3F, 0xE0, 0x3F, 0xC0, 0x00,
  0x00, 0x34, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF3, 0x00, 0xF3, 0x70, 0x1C, 0x1E,
  0x03, 0x81, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x0C, 0x0E, 0x00,
  0xC0, 0xE0, 0x1C, 0x0C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x03, 0x81, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x30, 0x38,
  0x07, 0x03, 0x80, 0x70, 0x38, 0x0F, 0x03, 0x80, 0xF0, 0x18, 0x1E, 0x01,
  0xC3, 0x60, 0x1F, 0xEE, 0x00, 0xFC, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0xC0, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC7,
  0x80, 0xEF, 0xE0, 0x7E, 0x78, 0x3C, 0x1C, 0x1C, 0x06, 0x0E, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0x80, 0x61, 0xC0, 0x30, 0xE0, 0x38,
  0x70, 0x1C, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0E, 0x03, 0x86, 0x01,
  0xC3, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xE0, 0x38, 0x60, 0x1C, 0x30,
  0x0C, 0x38, 0x06, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x04, 0x1C, 0x0E, 0x07, 0x07, 0x01, 0x81, 0xC0, 0x60, 0xE0, 0x38, 0x70,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC7, 0x00, 0x33, 0x80, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xBC, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x0F, 0x38, 0x03, 0x86,
  0x00, 0xC1, 0x80, 0x30, 0x70, 0x0C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x01, 0x3E, 0x0F, 0x01, 0x9F, 0xCF,
  0xF0, 0x6E, 0x77, 0x3C, 0x1E, 0x0F, 0x83, 0x07, 0x03, 0xC0, 0xC3, 0xC0,
  0xE0, 0x30, 0xE0, 0x38, 0x0C, 0x38, 0x0C, 0x03, 0x0C, 0x03, 0x01, 0xC3,
  0x00, 0xC0, 0x71, 0xC0, 0x70, 0x18, 0x70, 0x1C, 0x06, 0x1C, 0x06, 0x01,
  0x86, 0x01, 0x80, 0xE1, 0x80, 0xE0, 0x38, 0xE0, 0x38, 0x0C, 0x38, 0x0E,
  0x03, 0x0C, 0x03, 0x01, 0xC3, 0x00, 0xC0, 0x71, 0xC0, 0x70, 0x1C, 0x70,
  0x1C, 0x06, 0x1C, 0x06, 0x01, 0x86, 0x01, 0x80, 0xE1, 0x80, 0x60, 0x38,
  0xE0, 0x38, 0x0C, 0x38, 0x0E, 0x03, 0x00, 0x01, 0x1E, 0x03, 0x3F, 0x81,
  0xB9, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x78, 0x1C, 0x38, 0x0E, 0x1C, 0x07,
  0x0C, 0x03, 0x86, 0x01, 0x87, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0,
  0x30, 0x60, 0x18, 0x70, 0x0C, 0x38, 0x0E, 0x18, 0x07, 0x0C, 0x03, 0x0E,
  0x01, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x30, 0xE0, 0x18,
  0x70, 0x1C, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0x8E, 0x07, 0x07, 0x0E,
  0x07, 0x1C, 0x07, 0x1C, 0x03, 0x38, 0x03, 0x38, 0x03, 0x30, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60, 0x06, 0x60, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0x60,
  0x70, 0x70, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x47, 0x80, 0x19, 0xFC,
  0x01, 0xB8, 0xE0, 0x1B, 0x06, 0x01, 0xE0, 0x70, 0x3C, 0x07, 0x03, 0xC0,
  0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x30, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xC0, 0xE0, 0x1C, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x1C, 0x03, 0x81,
  0xE0, 0x30, 0x1E, 0x07, 0x01, 0xB0, 0xE0, 0x1B, 0xFC, 0x03, 0x9F, 0x80,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x30, 0x78, 0xDC, 0x1C,
  0x1E, 0x0E, 0x07, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0C, 0x38, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x3C, 0x38, 0x0F, 0x06, 0x07, 0x81, 0xC3, 0x60, 0x7F, 0xB8,
  0x0F, 0xCE, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x19, 0xF0, 0x6F, 0xC1, 0xB0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0x8E, 0x0E, 0x02, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0xC0, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0xFF, 0x3F, 0xC3, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x0F, 0xC1, 0xF0, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x61, 0xC0, 0x30, 0xE0, 0x38, 0x60,
  0x1C, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0E, 0x03, 0x86, 0x01, 0xC3,
  0x00, 0xC3, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x1C, 0x30, 0x0C,
  0x18, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0xC3, 0x87, 0xC0, 0xFF,
  0x60, 0x3F, 0x30, 0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0,
  0x73, 0x01, 0x8C, 0x0E, 0x30, 0x30, 0xC0, 0xC3, 0x07, 0x0C, 0x18, 0x30,
  0xE0, 0xC3, 0x03, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0D,
  0xC0, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xC0, 0x38, 0x0F, 0x80, 0x70, 0x1F, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0xEC,
  0x0F, 0x81, 0x98, 0x1B, 0x07, 0x30, 0x36, 0x0E, 0x60, 0xCC, 0x18, 0xC1,
  0x98, 0x71, 0x87, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0xC7, 0x0C, 0x61,
  0x8C, 0x18, 0xC3, 0x38, 0x33, 0x86, 0x60, 0x66, 0x0C, 0xC0, 0xCC, 0x1B,
  0x81, 0xB0, 0x36, 0x03, 0x60, 0x6C, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x07, 0xC0, 0x38, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x01, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x70,
  0x03, 0x1C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x1B, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x0E, 0x1C, 0x01,
  0x83, 0x80, 0x70, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x1C, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00,
  0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x38, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x66,
  0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xE0,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 34, 11, 1, -34 },
  { 44, 11, 12, 14, 5, -34 },
  { 61, 20, 34, 19, 0, -34 },
  { 146, 19, 39, 18, 0, -36 },
  { 239, 23, 36, 27, 2, -35 },
  { 343, 17, 35, 18, 0, -35 },
  { 418, 5, 12, 8, 5, -34 },
  { 426, 14, 42, 12, 1, -34 },
  { 500, 13, 42, 12, -3, -34 },
  { 569, 13, 15, 16, 5, -37 },
  { 594, 17, 22, 20, 2, -28 },
  { 641, 7, 11, 9, -2, -5 },
  { 651, 10, 2, 13, 1, -14 },
  { 654, 3, 4, 9, 1, -4 },
  { 656, 20, 34, 15, -2, -34 },
  { 741, 17, 35, 18, 1, -35 },
  { 816, 10, 34, 18, 5, -34 },
  { 859, 20, 35, 18, -2, -35 },
  { 947, 19, 35, 18, -1, -35 },
  { 1031, 19, 35, 18, -1, -35 },
  { 1115, 19, 34, 18, -1, -34 },
  { 1196, 18, 35, 18, 1, -35 },
  { 1275, 18, 34, 18, 2, -34 },
  { 1352, 18, 35, 18, 0, -35 },
  { 1431, 17, 35, 18, 0, -35 },
  { 1506, 8, 26, 9, 0, -26 },
  { 1532, 11, 32, 9, -2, -26 },
  { 1576, 17, 20, 20, 2, -27 },
  { 1619, 17, 12, 20, 2, -23 },
  { 1645, 17, 20, 20, 2, -27 },
  { 1688, 14, 35, 13, 1, -35 },
  { 1750, 25, 39, 26, 1, -35 },
  { 1872, 17, 34, 18, -3, -34 },
  { 1945, 20, 34, 19, 0, -34 },
  { 2030, 19, 35, 17, 2, -35 },
  { 2114, 20, 34, 21, 0, -34 },
  { 2199, 19, 34, 17, 0, -34 },
  { 2280, 19, 34, 16, 0, -34 },
  { 2361, 22, 35, 23, 2, -35 },
  { 2458, 23, 34, 22, 0, -34 },
  { 2556, 17, 34, 10, -3, -34 },
  { 2629, 17, 43, 9, -7, -34 },
  { 2721, 22, 34, 18, 0, -34 },
  { 2815, 12, 34, 15, 0, -34 },
  { 2866, 30, 34, 30, 0, -34 },
  { 2994, 24, 34, 23, 0, -34 },
  { 3096, 20, 35, 23, 2, -35 },
  { 3184, 19, 34, 18, 0, -34 },
  { 3265, 20, 43, 23, 2, -35 },
  { 3373, 19, 34, 19, 0, -34 },
  { 3454, 20, 35, 17, -1, -35 },
  { 3542, 16, 34, 15, 3, -34 },
  { 3610, 21, 34, 22, 2, -34 },
  { 3700, 18, 34, 18, 4, -34 },
  { 3777, 31, 34, 30, 3, -34 },
  { 3909, 23, 34, 16, -3, -34 },
  { 4007, 17, 34, 16, 3, -34 },
  { 4080, 20, 34, 15, -2, -34 },
  { 4165, 17, 42, 13, -1, -34 },
  { 4255, 7, 34, 16, 5, -34 },
  { 4285, 17, 42, 13, -3, -34 },
  { 4375, 18, 17, 19, 1, -34 },
  { 4414, 14, 2, 14, -4, 4 },
  { 4418, 5, 8, 11, 7, -37 },
  { 4423, 18, 26, 19, 1, -26 },
  { 4482, 18, 36, 19, 0, -36 },
  { 4563, 15, 26, 14, 1, -26 },
  { 4612, 20, 36, 19, 1, -36 },
  { 4702, 15, 26, 17, 1, -26 },
  { 4751, 22, 49, 10, -6, -37 },
  { 4886, 20, 38, 19, -1, -26 },
  { 4981, 17, 36, 18, 0, -36 },
  { 5058, 10, 35, 8, 0, -35 },
  { 5102, 16, 47, 9, -6, -35 },
  { 5196, 18, 36, 16, 0, -36 },
  { 5277, 10, 36, 8, 0, -36 },
  { 5322, 26, 26, 28, 0, -26 },
  { 5407, 17, 26, 18, 0, -26 },
  { 5463, 16, 26, 18, 1, -26 },
  { 5515, 20, 37, 19, -2, -26 },
  { 5608, 18, 37, 19, 1, -26 },
  { 5692, 14, 26, 12, 0, -26 },
  { 5738, 16, 26, 14, -1, -26 },
  { 5790, 10, 32, 10, 1, -32 },
  { 5830, 17, 25, 19, 1, -25 },
  { 5884, 14, 25, 15, 3, -25 },
  { 5928, 23, 25, 24, 3, -25 },
  { 6000, 19, 25, 15, -2, -25 },
  { 6060, 23, 37, 15, -5, -25 },
  { 6167, 16, 25, 12, -2, -25 },
  { 6217, 17, 42, 15, 1, -34 },
  { 6307, 3, 49, 17, 7, -37 },
  { 6326, 17, 42, 15, -3, -34 },
  { 6416, 17, 5, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC48PT7B_H_
