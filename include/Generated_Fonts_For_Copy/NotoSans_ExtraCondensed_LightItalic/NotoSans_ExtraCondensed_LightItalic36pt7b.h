#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x60, 0xE0, 0x60, 0x31, 0x98, 0xCC, 0x44, 0x66, 0x33, 0x19, 0x88, 0x84,
  0x46, 0x63, 0x00, 0x00, 0xC6, 0x01, 0x08, 0x06, 0x30, 0x0C, 0x60, 0x10,
  0x80, 0x61, 0x00, 0xC6, 0x01, 0x0C, 0x1F, 0xFE, 0x0C, 0x60, 0x10, 0xC0,
  0x21, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x10, 0x0C, 0x60, 0xFF, 0xF1, 0xFF,
  0xE0, 0xC6, 0x01, 0x8C, 0x02, 0x10, 0x0C, 0x20, 0x18, 0xC0, 0x21, 0x80,
  0x42, 0x01, 0x8C, 0x00, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0xFE, 0x0E,
  0xDC, 0x32, 0x01, 0x88, 0x06, 0x20, 0x18, 0x80, 0x66, 0x01, 0x90, 0x03,
  0x40, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x02, 0xC0, 0x09, 0x80,
  0x66, 0x01, 0x18, 0x04, 0x60, 0x11, 0x88, 0x4C, 0x3B, 0x70, 0xFF, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x0E, 0x03, 0x0D, 0x83, 0x0C,
  0xC1, 0x8C, 0x61, 0x86, 0x30, 0xC2, 0x18, 0xC3, 0x0C, 0x61, 0x86, 0x60,
  0xC2, 0x30, 0x61, 0x30, 0x21, 0x99, 0xD0, 0xD9, 0xF8, 0x49, 0x9C, 0x6C,
  0x8F, 0x64, 0xC6, 0xE6, 0x43, 0x02, 0x21, 0x83, 0x30, 0xC1, 0x18, 0x41,
  0x8C, 0x20, 0x84, 0x30, 0xC2, 0x18, 0x41, 0x08, 0x60, 0x8C, 0x20, 0x6C,
  0x30, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0x8C, 0x0C, 0x60, 0xC3, 0x06,
  0x10, 0x31, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x80, 0xEC, 0x06, 0x63, 0x63, 0x13, 0x0D, 0xB0, 0x6D, 0x83, 0xCC,
  0x0E, 0x60, 0x63, 0x07, 0x18, 0x6C, 0xEE, 0x63, 0xE3, 0x00, 0x6D, 0xAD,
  0xB6, 0x90, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x04, 0x01, 0x08, 0xC3, 0xB1, 0x3F, 0xC3, 0x01, 0x41, 0x98,
  0xE2, 0x10, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x1F, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x61, 0x86, 0x30, 0xC6,
  0x18, 0xC0, 0xFF, 0xFE, 0x7D, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x7E, 0x0E, 0x30, 0xC3, 0x18, 0x31, 0x83, 0x30, 0x33, 0x03, 0x30, 0x36,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x2C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0xC3, 0x0C, 0x30, 0xEE, 0x07,
  0xC0, 0x06, 0x1C, 0x79, 0xB6, 0x79, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x80,
  0x01, 0xF0, 0x1F, 0xE0, 0x61, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x01, 0xF0,
  0x1F, 0xE0, 0x60, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x07, 0x80, 0x1F, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x20, 0x30, 0xE3, 0x83, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x68, 0x01, 0x60, 0x0D, 0x80, 0x66, 0x01, 0x98,
  0x0C, 0x40, 0x23, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0xC1, 0x82, 0x04, 0x18,
  0x30, 0x61, 0x81, 0x87, 0xFF, 0xBF, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x64, 0x00, 0xFE, 0x00, 0x8E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x40, 0x60, 0xE7, 0x81, 0xFE, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xC0,
  0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x19,
  0xE0, 0xDF, 0x87, 0x0E, 0x30, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x03,
  0x30, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x06, 0x18, 0x30, 0x77, 0x01,
  0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0xE0, 0xC1, 0x83, 0x02, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0x86, 0x06, 0x18, 0x18, 0x30, 0xC0, 0xC6, 0x01, 0xF0, 0x07, 0x00, 0x3E,
  0x03, 0x9C, 0x0C, 0x30, 0x60, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x01, 0x8C, 0x06, 0x30, 0x30, 0x73, 0x80, 0xFC, 0x00, 0x03, 0xE0,
  0x3F, 0x83, 0x8C, 0x18, 0x31, 0x81, 0x8C, 0x0C, 0x40, 0x66, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x38, 0x7F, 0xC1, 0xE6,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x8E, 0x07, 0xE0, 0x00, 0x0C, 0x31, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8C, 0x00, 0x03, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x60, 0x40, 0xC0, 0x00, 0x18, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x02, 0x00,
  0x00, 0x0F, 0x83, 0xF8, 0x41, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x38, 0x18, 0x18, 0x02, 0x04, 0x00,
  0xC3, 0x00, 0x31, 0x80, 0x04, 0x40, 0xE1, 0x30, 0xFC, 0x4C, 0x62, 0x12,
  0x10, 0x85, 0x8C, 0x63, 0x62, 0x18, 0xD0, 0x84, 0x34, 0x61, 0x0B, 0x18,
  0xC2, 0xC4, 0x31, 0xB1, 0x0C, 0x4C, 0x46, 0x32, 0x11, 0x88, 0x87, 0xBE,
  0x20, 0xC6, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xE3, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x02, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0,
  0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30, 0x61, 0xFF, 0x0F, 0xF8, 0xC0,
  0xC6, 0x06, 0x60, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E,
  0x00, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x18, 0x70, 0x30, 0x60, 0x60, 0x61,
  0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C, 0x0C, 0x10, 0x38, 0x60, 0x60, 0xC3,
  0x81, 0xFC, 0x03, 0x1C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x60, 0x30,
  0xC0, 0x63, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x70, 0xFF,
  0xC1, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0C, 0x10, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x3D, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x18, 0x70, 0x30, 0x60,
  0x60, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x10, 0x0C, 0x60,
  0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x38, 0xC0, 0x63, 0x01, 0xC6, 0x03, 0x0C, 0x0E, 0x18, 0x38, 0x30,
  0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x1F, 0xE0, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x7F, 0x83, 0xFE, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xE0, 0x40, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x23, 0x03, 0xE3, 0x81, 0xF1, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x83, 0x00, 0xC1,
  0x80, 0x60, 0xE0, 0x60, 0x3C, 0xF0, 0x0F, 0xF8, 0x00, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x60, 0x18, 0x30, 0x0C,
  0x18, 0x06, 0x0C, 0x03, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0xFF,
  0xE0, 0xC0, 0x20, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x60,
  0xC0, 0x30, 0x60, 0x18, 0x00, 0x07, 0xF0, 0x7F, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xE0, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x9C, 0x0F, 0x80, 0x40, 0x00, 0x06, 0x03,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x18, 0x0C, 0x38, 0x0C, 0x30,
  0x0C, 0x60, 0x0C, 0xC0, 0x08, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x39, 0x80, 0x39, 0x80, 0x31, 0x80, 0x31, 0x80, 0x30, 0xC0,
  0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x40, 0x60, 0xC0, 0x60,
  0xC0, 0x60, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x50, 0x03, 0xC1, 0xA0,
  0x0D, 0x83, 0x40, 0x1B, 0x06, 0xC0, 0x2C, 0x0D, 0x80, 0xD8, 0x13, 0x01,
  0xB0, 0x66, 0x06, 0x60, 0xCC, 0x0C, 0x81, 0x98, 0x33, 0x03, 0x30, 0x66,
  0x0C, 0x61, 0x8C, 0x18, 0xC3, 0x18, 0x31, 0x8C, 0x20, 0x63, 0x18, 0xC0,
  0x86, 0x61, 0x83, 0x0C, 0xC3, 0x06, 0x19, 0x06, 0x0C, 0x36, 0x18, 0x18,
  0x68, 0x30, 0x20, 0x70, 0x60, 0xC0, 0xE0, 0xC1, 0x81, 0x81, 0x80, 0x07,
  0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x1C, 0x03, 0x05, 0x81, 0x83, 0x60,
  0x60, 0xD8, 0x18, 0x36, 0x06, 0x0D, 0x81, 0x02, 0x20, 0xC1, 0x8C, 0x30,
  0x63, 0x0C, 0x18, 0xC3, 0x06, 0x31, 0x83, 0x04, 0x60, 0xC1, 0x18, 0x30,
  0x66, 0x0C, 0x19, 0x83, 0x06, 0xC1, 0x81, 0xB0, 0x60, 0x2C, 0x18, 0x0F,
  0x06, 0x03, 0xC1, 0x00, 0xE0, 0xC0, 0x38, 0x30, 0x0E, 0x00, 0x00, 0xF8,
  0x07, 0xF8, 0x1C, 0x38, 0x70, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00,
  0xD8, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x00, 0xCC,
  0x03, 0x18, 0x06, 0x18, 0x18, 0x30, 0x70, 0x7B, 0xC0, 0x7E, 0x00, 0x07,
  0xC0, 0x1F, 0xE0, 0x63, 0x81, 0x83, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0xC3,
  0x03, 0x0C, 0x0C, 0x20, 0x31, 0x81, 0x86, 0x06, 0x18, 0x30, 0x63, 0x83,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xF8, 0x1C, 0x38, 0x70, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8,
  0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x00, 0xCC, 0x03,
  0x18, 0x06, 0x18, 0x18, 0x30, 0x70, 0x7B, 0xC0, 0x7E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x07, 0xE0, 0x1F,
  0xE0, 0x61, 0x81, 0x83, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C,
  0x0C, 0x30, 0x31, 0x81, 0x86, 0x0E, 0x18, 0x70, 0x7F, 0x83, 0xF8, 0x0C,
  0x60, 0x31, 0x80, 0xC6, 0x03, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0xC0, 0x63, 0x01, 0x80, 0x00, 0xFC, 0x07, 0xFC, 0x1C,
  0x10, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x40, 0x70, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x03, 0x0C, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x18, 0x20, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xE0, 0xC0, 0x7B,
  0x80, 0x3F, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x33, 0x01, 0x98, 0x18, 0xC0, 0xC6, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x30,
  0x61, 0x83, 0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x33, 0x01, 0xB0, 0x0D,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x30,
  0x0F, 0x00, 0xC0, 0x3C, 0x07, 0x01, 0xB0, 0x1C, 0x06, 0xC0, 0x70, 0x1B,
  0x03, 0xC0, 0xCC, 0x0F, 0x03, 0x30, 0x6C, 0x18, 0xC1, 0xB0, 0x63, 0x04,
  0xC1, 0x8C, 0x33, 0x0C, 0x30, 0xCC, 0x30, 0xC6, 0x31, 0x83, 0x18, 0xC6,
  0x0C, 0x43, 0x18, 0x33, 0x0C, 0xC0, 0xCC, 0x33, 0x03, 0x20, 0xD8, 0x0D,
  0x82, 0x60, 0x36, 0x09, 0x80, 0xF0, 0x2C, 0x02, 0xC0, 0xB0, 0x0A, 0x02,
  0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01,
  0x81, 0x81, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x10, 0xC0, 0x0C, 0x60, 0x06,
  0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x20,
  0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x00, 0x60, 0x1B, 0x01, 0x98, 0x0C, 0xC0,
  0xC6, 0x06, 0x10, 0x60, 0x86, 0x06, 0x30, 0x33, 0x01, 0x98, 0x0D, 0x80,
  0x6C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0xF8, 0x1F, 0xC0, 0x86, 0x31, 0x8C, 0x61, 0x08, 0x63,
  0x18, 0xC6, 0x30, 0x84, 0x31, 0x8C, 0x63, 0x08, 0x43, 0x18, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0x4C, 0x06,
  0x60, 0x61, 0x83, 0x0C, 0x30, 0x61, 0x81, 0x98, 0x0C, 0xC0, 0x2C, 0x01,
  0x80, 0xFF, 0xFF, 0xF0, 0xC6, 0x62, 0x31, 0x07, 0xD8, 0x73, 0xC6, 0x0E,
  0x70, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x26, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x06, 0x60, 0x63, 0x03, 0x18, 0x38, 0xC3, 0xC3, 0x36,
  0x1F, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0D, 0xF0, 0x79, 0xC2, 0x86, 0x38, 0x31, 0x81, 0x8C,
  0x0C, 0x60, 0x62, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x66, 0x03,
  0x30, 0x19, 0x81, 0x8C, 0x0C, 0x50, 0xC6, 0xCC, 0x33, 0xC0, 0x07, 0xE1,
  0xC8, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0E, 0x40, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x07, 0xD8, 0x1C, 0xF0, 0x60, 0xE1, 0xC1, 0x83,
  0x03, 0x06, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x21, 0x80, 0xC3, 0x01,
  0x86, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0xC3, 0xC0,
  0xCD, 0x01, 0xF2, 0x00, 0x07, 0xC1, 0x8C, 0x61, 0x98, 0x33, 0x06, 0xC0,
  0xD8, 0x33, 0x0E, 0xCF, 0x1F, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0E, 0x60, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x07, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xF6, 0x07, 0x3C, 0x18, 0x38, 0x70, 0x60, 0xC0, 0xC1,
  0x81, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC3, 0x03, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0xF0, 0x33, 0x60,
  0x7D, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x81, 0x87, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0D, 0xF0, 0x79, 0xC3,
  0x86, 0x38, 0x31, 0x81, 0x8C, 0x08, 0x60, 0xC2, 0x06, 0x30, 0x31, 0x81,
  0x8C, 0x08, 0x60, 0xC2, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x08, 0x60, 0xC6,
  0x06, 0x30, 0x30, 0x06, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x40, 0xC0, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x07, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x18, 0x61, 0x82, 0x18, 0x30, 0xC1, 0x8C, 0x0C,
  0xC0, 0x6C, 0x02, 0x60, 0x37, 0x01, 0xF8, 0x0E, 0xC0, 0x66, 0x06, 0x10,
  0x30, 0xC1, 0x86, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x30, 0x03, 0x02,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0x0D, 0xF3, 0xE0, 0xB3, 0x67, 0x0C, 0x1C, 0x31, 0xC1, 0x83, 0x18,
  0x18, 0x31, 0x83, 0x02, 0x18, 0x30, 0x61, 0x03, 0x06, 0x30, 0x30, 0x63,
  0x02, 0x06, 0x30, 0x60, 0x43, 0x06, 0x0C, 0x60, 0x60, 0xC6, 0x06, 0x0C,
  0x60, 0xC0, 0xC6, 0x0C, 0x18, 0x60, 0xC1, 0x8C, 0x0C, 0x18, 0xC1, 0x81,
  0x80, 0x0D, 0xF0, 0x59, 0xC3, 0x86, 0x38, 0x31, 0x81, 0x8C, 0x08, 0x60,
  0xC2, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x08, 0x60, 0xC6, 0x06, 0x30, 0x31,
  0x81, 0x8C, 0x18, 0x60, 0xC6, 0x06, 0x30, 0x30, 0x07, 0xC0, 0xCE, 0x18,
  0x73, 0x03, 0x30, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x3C, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x87, 0x70, 0x3E,
  0x00, 0x03, 0x7C, 0x05, 0x9C, 0x0A, 0x18, 0x38, 0x30, 0x70, 0x60, 0xC0,
  0xC1, 0x81, 0x82, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x60,
  0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C, 0x0C, 0x14, 0x30, 0x6D, 0xC0, 0xCF,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x07, 0xD8, 0x73, 0xC6, 0x0E, 0x60, 0x63, 0x03,
  0x10, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x26, 0x03, 0x30, 0x19, 0x80, 0xCC,
  0x06, 0x60, 0x63, 0x03, 0x18, 0x38, 0xC3, 0xC3, 0x36, 0x1F, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x0D, 0xE1, 0x74, 0x38, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x00, 0x0F, 0xE3, 0x8C, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x19, 0xC3, 0xF0, 0x00, 0x0C, 0x18, 0x20, 0x41,
  0x8F, 0xDF, 0x98, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x06, 0x0C, 0x18, 0x34, 0x78, 0x18, 0x18, 0xC1, 0x84, 0x0C, 0x60, 0x63,
  0x03, 0x18, 0x10, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x30, 0xC1,
  0x8C, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3, 0x87, 0x7C, 0x1F, 0x60,
  0xC0, 0x78, 0x1B, 0x03, 0x60, 0xCC, 0x19, 0x86, 0x30, 0xC6, 0x10, 0xC6,
  0x18, 0xC3, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x34, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0xC0, 0xC0, 0xF0, 0x70, 0x6C, 0x1C, 0x1B, 0x07, 0x0C,
  0xC3, 0xC3, 0x30, 0xB0, 0xCC, 0x6C, 0x63, 0x1B, 0x18, 0xC4, 0xC4, 0x33,
  0x33, 0x0C, 0xCC, 0xC3, 0x63, 0x60, 0xD8, 0xD8, 0x34, 0x34, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x0C, 0x0C, 0x00, 0x06, 0x0E,
  0x0C, 0x18, 0x18, 0x60, 0x11, 0x80, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xC8, 0x01, 0x98,
  0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0xC0, 0x83, 0x81, 0x80, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0xC0, 0x20, 0x60, 0x10, 0x60, 0x08, 0x30, 0x04,
  0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE1,
  0xFC, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x18, 0x07, 0x80, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x1E, 0x00, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0xF0, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF0,
  0x08, 0x00, 0x10, 0x03, 0xF0, 0x71, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 26, 8, 0, -26 },
  { 27, 9, 10, 11, 3, -26 },
  { 39, 15, 26, 14, 0, -26 },
  { 88, 14, 29, 13, 0, -27 },
  { 139, 17, 26, 20, 2, -26 },
  { 195, 13, 26, 14, 0, -26 },
  { 238, 3, 10, 6, 4, -26 },
  { 242, 10, 32, 9, 1, -26 },
  { 282, 11, 32, 9, -3, -26 },
  { 326, 10, 10, 12, 4, -27 },
  { 339, 13, 17, 15, 1, -21 },
  { 367, 6, 9, 6, -2, -4 },
  { 374, 8, 2, 9, 1, -11 },
  { 376, 3, 3, 6, 0, -3 },
  { 378, 16, 26, 11, -2, -26 },
  { 430, 12, 26, 13, 1, -26 },
  { 469, 7, 26, 13, 4, -26 },
  { 492, 14, 26, 13, -1, -26 },
  { 538, 14, 26, 13, -1, -26 },
  { 584, 14, 26, 13, -1, -26 },
  { 630, 15, 26, 13, -1, -26 },
  { 679, 13, 26, 13, 1, -26 },
  { 722, 14, 26, 13, 1, -26 },
  { 768, 14, 26, 13, 0, -26 },
  { 814, 13, 26, 13, 0, -26 },
  { 857, 6, 19, 6, 0, -19 },
  { 872, 8, 24, 6, -2, -19 },
  { 896, 13, 15, 15, 1, -20 },
  { 921, 13, 9, 15, 1, -17 },
  { 936, 13, 15, 15, 1, -20 },
  { 961, 11, 26, 10, 0, -26 },
  { 997, 18, 29, 20, 1, -26 },
  { 1063, 13, 26, 13, -2, -26 },
  { 1106, 15, 26, 14, 0, -26 },
  { 1155, 15, 26, 13, 1, -26 },
  { 1204, 15, 26, 16, 0, -26 },
  { 1253, 14, 26, 13, 0, -26 },
  { 1299, 14, 26, 12, 0, -26 },
  { 1345, 17, 26, 17, 1, -26 },
  { 1401, 17, 26, 17, 0, -26 },
  { 1457, 12, 26, 8, -2, -26 },
  { 1496, 12, 33, 6, -5, -26 },
  { 1546, 16, 26, 14, 0, -26 },
  { 1598, 9, 26, 12, 0, -26 },
  { 1628, 23, 26, 22, 0, -26 },
  { 1703, 18, 26, 18, 0, -26 },
  { 1762, 15, 26, 17, 1, -26 },
  { 1811, 14, 26, 14, 0, -26 },
  { 1857, 15, 32, 17, 1, -26 },
  { 1917, 14, 26, 14, 0, -26 },
  { 1963, 15, 26, 13, -1, -26 },
  { 2012, 12, 26, 11, 2, -26 },
  { 2051, 16, 26, 16, 1, -26 },
  { 2103, 13, 26, 13, 3, -26 },
  { 2146, 22, 26, 23, 3, -26 },
  { 2218, 17, 26, 12, -2, -26 },
  { 2274, 13, 26, 12, 2, -26 },
  { 2317, 15, 26, 12, -1, -26 },
  { 2366, 13, 32, 10, -1, -26 },
  { 2418, 5, 26, 12, 4, -26 },
  { 2435, 13, 32, 10, -2, -26 },
  { 2487, 13, 13, 14, 1, -26 },
  { 2509, 10, 2, 10, -3, 3 },
  { 2512, 4, 6, 8, 5, -28 },
  { 2515, 13, 19, 14, 1, -19 },
  { 2546, 13, 27, 14, 0, -27 },
  { 2590, 11, 19, 11, 1, -19 },
  { 2617, 15, 27, 14, 1, -27 },
  { 2668, 11, 19, 13, 1, -19 },
  { 2695, 17, 37, 7, -5, -28 },
  { 2774, 15, 28, 14, -1, -19 },
  { 2827, 13, 27, 14, 0, -27 },
  { 2871, 8, 26, 6, 0, -26 },
  { 2897, 13, 35, 6, -5, -26 },
  { 2954, 13, 27, 12, 0, -27 },
  { 2998, 8, 27, 6, 0, -27 },
  { 3025, 20, 19, 21, 0, -19 },
  { 3073, 13, 19, 14, 0, -19 },
  { 3104, 12, 19, 14, 1, -19 },
  { 3133, 15, 27, 14, -2, -19 },
  { 3184, 13, 28, 14, 1, -19 },
  { 3230, 11, 19, 9, 0, -19 },
  { 3257, 11, 19, 11, 0, -19 },
  { 3284, 7, 24, 8, 1, -24 },
  { 3305, 13, 19, 14, 1, -19 },
  { 3336, 11, 19, 11, 2, -19 },
  { 3363, 18, 19, 18, 2, -19 },
  { 3406, 15, 19, 11, -2, -19 },
  { 3442, 17, 28, 11, -4, -19 },
  { 3502, 11, 19, 9, -1, -19 },
  { 3529, 13, 32, 11, 1, -26 },
  { 3581, 2, 36, 13, 5, -27 },
  { 3590, 12, 32, 11, -2, -26 },
  { 3638, 13, 4, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC36PT7B_H_
