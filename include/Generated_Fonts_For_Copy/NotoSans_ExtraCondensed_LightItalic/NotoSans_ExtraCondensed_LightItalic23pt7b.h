#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x80, 0x03, 0x18, 0x6D,
  0x24, 0x92, 0x92, 0x40, 0x04, 0x81, 0x20, 0x88, 0x24, 0x3F, 0xC4, 0x41,
  0x20, 0x48, 0x22, 0x09, 0x0F, 0xF1, 0x10, 0x48, 0x12, 0x04, 0x82, 0x40,
  0x02, 0x03, 0x07, 0xE4, 0x82, 0x41, 0x20, 0xA0, 0x30, 0x08, 0x06, 0x03,
  0x82, 0x41, 0x20, 0x92, 0x51, 0xF0, 0x20, 0x10, 0x00, 0x10, 0x05, 0x09,
  0x22, 0x24, 0x44, 0x91, 0x12, 0x22, 0x84, 0x57, 0x95, 0x36, 0xA5, 0x2C,
  0x85, 0x11, 0x22, 0x24, 0x88, 0x91, 0x12, 0x43, 0x80, 0x04, 0x0A, 0x13,
  0x12, 0x12, 0x12, 0x14, 0x18, 0x18, 0x28, 0x49, 0xC9, 0x86, 0x86, 0x84,
  0x8E, 0x72, 0x69, 0x29, 0x00, 0x06, 0x18, 0x20, 0x81, 0x04, 0x08, 0x30,
  0x40, 0x81, 0x02, 0x04, 0x18, 0x10, 0x20, 0x40, 0x81, 0x01, 0x00, 0x04,
  0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x41, 0x06, 0x00, 0x10, 0x31, 0x47, 0xF1, 0x05, 0x13, 0x00,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25, 0x28,
  0xF8, 0x70, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x06, 0x0F,
  0x11, 0x11, 0x21, 0x21, 0x21, 0x61, 0x41, 0x41, 0x43, 0x42, 0x42, 0xC6,
  0x44, 0x48, 0x78, 0x19, 0x72, 0x21, 0x08, 0x46, 0x21, 0x08, 0x46, 0x21,
  0x08, 0x07, 0x0E, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x03, 0x01,
  0x01, 0x01, 0x01, 0x81, 0x80, 0x80, 0x80, 0xFE, 0x00, 0x0E, 0x1D, 0x80,
  0x40, 0x30, 0x10, 0x08, 0x0C, 0x0C, 0x18, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x30, 0x11, 0x18, 0xF8, 0x00, 0x01, 0x81, 0x80, 0xC0, 0xA0, 0x50, 0x50,
  0x48, 0x24, 0x22, 0x33, 0x11, 0x10, 0x8F, 0xF0, 0x20, 0x30, 0x10, 0x08,
  0x00, 0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x01, 0xF0, 0x8C, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x22, 0x31, 0xF0, 0x07, 0x1D, 0x10, 0x20, 0x60,
  0x40, 0x40, 0xFC, 0xC4, 0xC6, 0x86, 0x86, 0x84, 0x84, 0x8C, 0x88, 0xF0,
  0x7F, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x80, 0x06, 0x0D, 0x8C, 0x64, 0x32, 0x19, 0x08, 0xCC,
  0x2C, 0x18, 0x12, 0x11, 0x90, 0x48, 0x24, 0x12, 0x09, 0x88, 0x78, 0x00,
  0x06, 0x1B, 0x31, 0x21, 0x21, 0x61, 0x61, 0x41, 0x63, 0x25, 0x1A, 0x02,
  0x02, 0x04, 0x0C, 0x18, 0xF0, 0x33, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC4, 0x22, 0x00, 0x01, 0x06, 0x18,
  0x60, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x06, 0x1C, 0x30, 0xC0, 0x80, 0x1C,
  0x6C, 0x08, 0x10, 0x20, 0x83, 0x04, 0x10, 0x40, 0x83, 0x04, 0x00, 0x00,
  0x20, 0xC0, 0x01, 0x01, 0xD8, 0x40, 0x98, 0x12, 0x02, 0x8F, 0x52, 0x4A,
  0x49, 0x91, 0x32, 0x46, 0x49, 0x49, 0x29, 0x65, 0x3F, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x40, 0xF0, 0x00, 0x01, 0x81, 0xC0, 0xA0, 0x50, 0x48, 0x24,
  0x32, 0x11, 0x08, 0x8F, 0xC4, 0x26, 0x12, 0x09, 0x05, 0x03, 0x81, 0x1F,
  0x88, 0x44, 0x22, 0x13, 0x09, 0x0C, 0x8C, 0x78, 0x23, 0x30, 0x90, 0x48,
  0x24, 0x32, 0x13, 0x19, 0xF0, 0x03, 0x06, 0xC4, 0x06, 0x02, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x7C,
  0x00, 0x1F, 0x04, 0x21, 0x0C, 0x43, 0x30, 0xC8, 0x32, 0x0C, 0x82, 0x20,
  0x98, 0x24, 0x19, 0x04, 0x43, 0x10, 0x8C, 0xC3, 0xE0, 0x1F, 0x88, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x7C, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0xF8, 0x1F, 0x88, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x3E, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x03, 0x83, 0xB1,
  0x00, 0xC0, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x21, 0xE8, 0x1A, 0x04,
  0x81, 0x20, 0x4C, 0x31, 0x08, 0x7E, 0x00, 0x18, 0x22, 0x0C, 0x41, 0x08,
  0x23, 0x04, 0x40, 0x88, 0x31, 0xFC, 0x20, 0x8C, 0x11, 0x06, 0x20, 0xC4,
  0x10, 0x82, 0x30, 0x44, 0x18, 0x1F, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0xF0, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x30, 0xE0, 0x18, 0xC4, 0x21, 0x10, 0x4C, 0x32, 0x09,
  0x02, 0x80, 0xE0, 0x3C, 0x1B, 0x04, 0x41, 0x10, 0x44, 0x11, 0x8C, 0x62,
  0x08, 0x18, 0x41, 0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C,
  0x3F, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x70, 0xC0, 0xA3, 0x83, 0xC5, 0x85,
  0x0B, 0x0A, 0x16, 0x24, 0x24, 0x58, 0xC9, 0x21, 0x12, 0x42, 0x28, 0x84,
  0x51, 0x08, 0xC6, 0x31, 0x88, 0x42, 0x10, 0x18, 0x31, 0x82, 0x18, 0x21,
  0x42, 0x34, 0x62, 0x44, 0x24, 0x42, 0x44, 0x26, 0x46, 0x2C, 0x42, 0x84,
  0x28, 0x42, 0x84, 0x28, 0xC3, 0x08, 0x10, 0x06, 0x0E, 0xC4, 0x24, 0x16,
  0x0A, 0x05, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x28, 0x14, 0x1A, 0x09,
  0x88, 0x78, 0x00, 0x1F, 0x08, 0xC4, 0x22, 0x13, 0x09, 0x0C, 0x84, 0x46,
  0x3E, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x06, 0x0E, 0xC4,
  0x24, 0x16, 0x0A, 0x05, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x28, 0x14,
  0x1A, 0x09, 0x88, 0x78, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x1F, 0x08, 0xC4,
  0x22, 0x13, 0x09, 0x0C, 0x84, 0x46, 0x3C, 0x32, 0x11, 0x08, 0x84, 0x42,
  0x23, 0x19, 0x04, 0x03, 0x03, 0xF1, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x32, 0x18, 0xFC,
  0x00, 0xFE, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x06, 0x08,
  0x10, 0x20, 0x40, 0x30, 0xC8, 0x22, 0x08, 0x82, 0x60, 0x90, 0x64, 0x11,
  0x04, 0x41, 0x30, 0xC8, 0x22, 0x08, 0x82, 0x21, 0x88, 0x41, 0xE0, 0x81,
  0x83, 0x82, 0x82, 0x84, 0x84, 0x8C, 0x88, 0x98, 0x90, 0x90, 0xA0, 0xA0,
  0xE0, 0xC0, 0xC0, 0x83, 0x0E, 0x0C, 0x28, 0x50, 0xA1, 0xC6, 0x86, 0x12,
  0x28, 0x48, 0xA2, 0x24, 0x88, 0x92, 0x62, 0x49, 0x0A, 0x24, 0x28, 0xA0,
  0xE2, 0x83, 0x0E, 0x0C, 0x30, 0x20, 0xC0, 0x08, 0x42, 0x20, 0x88, 0x24,
  0x0B, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x40, 0x90, 0x26, 0x11,
  0x84, 0x22, 0x08, 0x83, 0x0A, 0x14, 0x4C, 0x8A, 0x14, 0x30, 0x60, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x40, 0x1F, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x03,
  0xF8, 0x07, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x1F, 0x00,
  0xC4, 0x44, 0x44, 0x46, 0x22, 0x22, 0x22, 0x21, 0x0F, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0xF0, 0x04, 0x07, 0x06, 0x82, 0x43, 0x11, 0x09, 0x05,
  0x81, 0xFE, 0xC9, 0x10, 0x3D, 0x23, 0x43, 0x42, 0xC2, 0x82, 0x86, 0x84,
  0x84, 0x8C, 0x8C, 0xF4, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0xF8, 0xC4,
  0x63, 0x21, 0x90, 0x98, 0x48, 0x24, 0x12, 0x11, 0x09, 0x48, 0xBC, 0x00,
  0x3C, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x00, 0x80, 0x40,
  0x60, 0x20, 0x11, 0xE8, 0x8C, 0x84, 0x42, 0x61, 0x20, 0x90, 0xC8, 0x44,
  0x22, 0x31, 0x18, 0xF4, 0x00, 0x3C, 0xC5, 0x0E, 0x28, 0xDF, 0x20, 0x40,
  0x81, 0x02, 0x03, 0xC0, 0x00, 0xC0, 0x70, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0xF8, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x0E, 0x01, 0x00, 0x1E, 0x88,
  0xC8, 0x64, 0x26, 0x12, 0x09, 0x0C, 0x84, 0x42, 0x23, 0x11, 0x8F, 0xC0,
  0x40, 0x20, 0x10, 0x10, 0xF8, 0x20, 0x00, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x1F, 0x31, 0x31, 0x21, 0x21, 0x63, 0x42, 0x42, 0x42, 0x46, 0xC4, 0x84,
  0x08, 0xC0, 0x00, 0x08, 0x84, 0x21, 0x18, 0x84, 0x21, 0x18, 0x80, 0x01,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x80, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x11, 0x22, 0x24, 0x2C, 0x28, 0x78, 0x68, 0x48, 0x4C,
  0x4C, 0xC4, 0x84, 0x08, 0xC4, 0x21, 0x08, 0x84, 0x21, 0x18, 0x84, 0x21,
  0x18, 0x80, 0x3F, 0x71, 0x8C, 0xC8, 0x46, 0x42, 0x22, 0x31, 0x31, 0x09,
  0x08, 0x48, 0x46, 0x42, 0x22, 0x31, 0x31, 0x09, 0x08, 0xC0, 0x3F, 0x31,
  0x31, 0x21, 0x21, 0x63, 0x42, 0x42, 0x42, 0x46, 0xC4, 0x84, 0x3E, 0xC5,
  0x0A, 0x18, 0x30, 0x60, 0xC3, 0x85, 0x0A, 0x27, 0x80, 0x0F, 0x86, 0x21,
  0x8C, 0x43, 0x10, 0x8C, 0x22, 0x08, 0x82, 0x21, 0x88, 0x46, 0x21, 0x78,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x00, 0x3D, 0x23, 0x43, 0x42, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x8C, 0x8C, 0xFC, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x3E, 0x60, 0xC1, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x04, 0x00, 0x3E,
  0x41, 0x83, 0x02, 0x06, 0x06, 0x04, 0x08, 0x12, 0x27, 0x80, 0x10, 0x84,
  0xF2, 0x10, 0x84, 0x62, 0x10, 0x84, 0x61, 0x80, 0x63, 0x42, 0x42, 0x42,
  0x46, 0xC4, 0x84, 0x84, 0x84, 0x8C, 0x98, 0xE8, 0xC3, 0x8B, 0x16, 0x6C,
  0x9B, 0x34, 0x68, 0xA1, 0x43, 0x06, 0x00, 0xC6, 0x3C, 0x62, 0xCA, 0x6C,
  0xA4, 0xCA, 0x4D, 0x28, 0x92, 0x8A, 0x38, 0xA3, 0x0A, 0x50, 0xC6, 0x0C,
  0x60, 0x11, 0x88, 0x84, 0x81, 0x40, 0xC0, 0x60, 0x60, 0x28, 0x24, 0x12,
  0x11, 0x18, 0xC0, 0x08, 0x42, 0x10, 0x88, 0x22, 0x09, 0x02, 0x40, 0xA0,
  0x28, 0x0E, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0xE0,
  0x20, 0x00, 0x1F, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x60,
  0x40, 0xF8, 0x07, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0xC0,
  0x60, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x60, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x04, 0x03, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x60, 0x80,
  0xF1, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 6, 6, 7, 2, -16 },
  { 16, 10, 16, 9, 0, -16 },
  { 36, 9, 18, 8, 0, -17 },
  { 57, 11, 17, 13, 1, -17 },
  { 81, 8, 17, 9, 0, -17 },
  { 98, 3, 6, 4, 2, -16 },
  { 101, 7, 20, 6, 0, -16 },
  { 119, 7, 20, 6, -2, -16 },
  { 137, 7, 7, 8, 2, -18 },
  { 144, 8, 10, 10, 1, -13 },
  { 154, 3, 5, 4, -1, -2 },
  { 156, 5, 1, 6, 0, -7 },
  { 157, 2, 2, 4, 0, -2 },
  { 158, 10, 16, 7, -1, -16 },
  { 178, 8, 17, 8, 0, -17 },
  { 195, 5, 16, 8, 2, -16 },
  { 205, 9, 17, 8, -1, -17 },
  { 225, 9, 17, 8, 0, -17 },
  { 245, 9, 17, 8, 0, -17 },
  { 265, 9, 16, 8, 0, -16 },
  { 283, 8, 17, 8, 1, -17 },
  { 300, 8, 16, 8, 1, -16 },
  { 316, 9, 17, 8, 0, -17 },
  { 336, 8, 17, 8, 0, -17 },
  { 353, 4, 12, 4, 0, -12 },
  { 359, 5, 15, 4, -1, -12 },
  { 369, 8, 10, 10, 1, -13 },
  { 379, 8, 6, 10, 1, -11 },
  { 385, 8, 10, 10, 1, -13 },
  { 395, 7, 17, 6, 0, -17 },
  { 410, 11, 19, 13, 1, -17 },
  { 437, 9, 16, 8, -2, -16 },
  { 455, 9, 16, 9, 0, -16 },
  { 473, 9, 17, 8, 1, -17 },
  { 493, 10, 16, 10, 0, -16 },
  { 513, 9, 16, 8, 0, -16 },
  { 531, 9, 16, 8, 0, -16 },
  { 549, 10, 17, 11, 1, -17 },
  { 571, 11, 16, 11, 0, -16 },
  { 593, 8, 16, 5, -1, -16 },
  { 609, 8, 20, 4, -3, -16 },
  { 629, 10, 16, 9, 0, -16 },
  { 649, 6, 16, 7, 0, -16 },
  { 661, 15, 16, 14, 0, -16 },
  { 691, 12, 16, 11, 0, -16 },
  { 715, 9, 17, 11, 1, -17 },
  { 735, 9, 16, 9, 0, -16 },
  { 753, 9, 21, 11, 1, -17 },
  { 777, 9, 16, 9, 0, -16 },
  { 795, 10, 17, 8, -1, -17 },
  { 817, 7, 16, 7, 2, -16 },
  { 831, 10, 16, 10, 1, -16 },
  { 851, 8, 16, 9, 2, -16 },
  { 867, 14, 16, 14, 2, -16 },
  { 895, 10, 16, 8, -1, -16 },
  { 915, 7, 16, 7, 2, -16 },
  { 929, 10, 16, 7, -1, -16 },
  { 949, 9, 20, 6, -1, -16 },
  { 972, 4, 16, 8, 2, -16 },
  { 980, 8, 20, 6, -1, -16 },
  { 1000, 9, 8, 9, 0, -16 },
  { 1009, 7, 1, 6, -2, 2 },
  { 1010, 3, 4, 5, 3, -18 },
  { 1012, 8, 12, 9, 1, -12 },
  { 1024, 9, 17, 9, 0, -17 },
  { 1044, 6, 12, 7, 1, -12 },
  { 1053, 9, 17, 9, 1, -17 },
  { 1073, 7, 12, 8, 1, -12 },
  { 1084, 10, 24, 5, -3, -18 },
  { 1114, 9, 18, 9, 0, -12 },
  { 1135, 8, 17, 9, 0, -17 },
  { 1152, 5, 17, 4, 0, -17 },
  { 1163, 8, 23, 4, -3, -17 },
  { 1186, 8, 17, 8, 0, -17 },
  { 1203, 5, 17, 4, 0, -17 },
  { 1214, 13, 12, 13, 0, -12 },
  { 1234, 8, 12, 9, 0, -12 },
  { 1246, 7, 12, 9, 1, -12 },
  { 1257, 10, 17, 9, -1, -12 },
  { 1279, 8, 17, 9, 1, -12 },
  { 1296, 7, 12, 6, 0, -12 },
  { 1307, 7, 12, 7, 0, -12 },
  { 1318, 5, 15, 5, 0, -15 },
  { 1328, 8, 12, 9, 1, -12 },
  { 1340, 7, 12, 7, 1, -12 },
  { 1351, 12, 12, 12, 1, -12 },
  { 1369, 9, 12, 7, -1, -12 },
  { 1383, 10, 18, 7, -2, -12 },
  { 1406, 8, 12, 6, -1, -12 },
  { 1418, 8, 20, 7, 1, -16 },
  { 1438, 2, 24, 8, 3, -18 },
  { 1444, 8, 20, 7, -1, -16 },
  { 1464, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC23PT7B_H_
