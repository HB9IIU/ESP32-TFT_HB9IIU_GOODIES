#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x70, 0xF0, 0x78, 0x70, 0x3C, 0x38, 0x1E, 0x3C, 0x0E, 0x1E, 0x07,
  0x0E, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x18, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xCC, 0xFC, 0x03, 0xE3, 0x83,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xF0,
  0x30, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x86,
  0x00, 0x00, 0x78, 0xC0, 0x00, 0x0F, 0x98, 0x00, 0x00, 0xFB, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x6F, 0x00, 0x00,
  0x0C, 0xF0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0C, 0x1C,
  0x00, 0x01, 0x83, 0xC0, 0x00, 0x30, 0x78, 0x00, 0x06, 0x0F, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x06, 0x07, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x81, 0x00, 0xC1, 0xE0, 0x38, 0x18,
  0x78, 0x07, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x7F, 0xC0, 0x03, 0x80,
  0x3F, 0xF0, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0x70, 0x07, 0x07, 0x80, 0x1C,
  0x03, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x78,
  0x1E, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38, 0x07, 0x03, 0xC0, 0x0E, 0x01,
  0xC0, 0xE0, 0x07, 0x80, 0x70, 0x78, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x70,
  0x0F, 0x0F, 0x00, 0x1C, 0x03, 0x83, 0x80, 0x07, 0x00, 0xE1, 0xE0, 0x01,
  0xC0, 0x38, 0x70, 0x00, 0x70, 0x1E, 0x3C, 0x1F, 0x3C, 0x07, 0x0E, 0x1F,
  0xEE, 0x01, 0xC7, 0x8F, 0xFF, 0x80, 0xF1, 0xC3, 0x8F, 0xE0, 0x38, 0xF1,
  0xC1, 0xFC, 0x1E, 0x38, 0xF0, 0x77, 0x07, 0x1E, 0x38, 0x1D, 0xC3, 0x87,
  0x1E, 0x07, 0x7F, 0xE3, 0xC7, 0x01, 0xCF, 0xF0, 0xE1, 0xC0, 0x71, 0xF8,
  0x78, 0xE0, 0x1C, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x0F, 0x0E, 0x01, 0xC0,
  0x03, 0x87, 0x80, 0x70, 0x01, 0xE1, 0xC0, 0x1C, 0x00, 0x70, 0x70, 0x0F,
  0x00, 0x3C, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0xE0, 0x07, 0x83, 0xC0,
  0x38, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0xF0, 0x38, 0x07, 0x00, 0x38, 0x0E,
  0x01, 0xC0, 0x1E, 0x03, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x38, 0x03, 0xC0,
  0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x78, 0x03, 0x81, 0xC0, 0x1C,
  0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x1C, 0xF8, 0x03, 0x80, 0x07, 0xFC, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38,
  0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x38, 0x00,
  0x78, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xC7, 0x01, 0xC1, 0xE1, 0xE0, 0x70, 0xF0, 0x78,
  0x3C, 0x38, 0x0E, 0x0F, 0x1E, 0x03, 0xC3, 0x8F, 0x00, 0xF1, 0xE3, 0xC0,
  0x3C, 0x78, 0xE0, 0x07, 0x1C, 0x78, 0x01, 0xEF, 0x1E, 0x00, 0x7B, 0x87,
  0x00, 0x1F, 0xE1, 0xC0, 0x03, 0xF0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x1E, 0x00,
  0xFF, 0x07, 0x80, 0x7B, 0xC1, 0xF0, 0x3C, 0xF0, 0x3F, 0xFE, 0x1C, 0x07,
  0xFF, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x78,
  0xF1, 0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xE1,
  0xC3, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x80, 0xE0, 0x3C, 0x18, 0x07, 0xE7, 0x00, 0x7E, 0xE1, 0xE3, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xCE, 0x00,
  0xF1, 0xC0, 0x3C, 0x1C, 0x1F, 0x03, 0x81, 0xC0, 0x78, 0x10, 0x07, 0x80,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x13, 0xDF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xE3, 0xE0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x1E,
  0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00,
  0xF0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7C, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xEE, 0x0F, 0x3C, 0x7C, 0x79, 0xF0,
  0xF3, 0xC1, 0xC3, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x40,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x20, 0x00, 0xF8, 0x07, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x70, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x38,
  0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x80,
  0x03, 0xE0, 0x0E, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x02, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x3F, 0xC0, 0x0F, 0x3F, 0xF8, 0x03, 0xDF, 0xFF, 0x00, 0xEF,
  0x07, 0xC0, 0x7B, 0x00, 0xF8, 0x1F, 0x80, 0x1E, 0x07, 0xE0, 0x07, 0x81,
  0xF0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0,
  0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00,
  0x1F, 0x03, 0xC0, 0x0F, 0xC0, 0x78, 0x07, 0xF0, 0x1F, 0x03, 0xBC, 0x03,
  0xFF, 0xCF, 0x00, 0xFF, 0xE3, 0x80, 0x1F, 0xF1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x02, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x78, 0x07, 0x80, 0xFC, 0x0F, 0x80, 0xF8,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0x03, 0xE0, 0x20, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x0F, 0x80,
  0x70, 0x70, 0x03, 0xFE, 0x07, 0x07, 0x00, 0xFF, 0xE0, 0x70, 0xE0, 0x1E,
  0x0E, 0x07, 0x0E, 0x01, 0xC1, 0xE0, 0x71, 0xE0, 0x38, 0x1C, 0x07, 0x1C,
  0x07, 0x81, 0xC0, 0x71, 0xC0, 0x70, 0x1C, 0x0E, 0x3C, 0x0E, 0x03, 0x80,
  0xE3, 0x80, 0xE0, 0x38, 0x0E, 0x38, 0x1E, 0x03, 0x80, 0xE3, 0x81, 0xC0,
  0x38, 0x0E, 0x70, 0x1C, 0x07, 0x00, 0xE7, 0x01, 0xC0, 0x70, 0x1C, 0x70,
  0x38, 0x07, 0x01, 0xC7, 0x03, 0x80, 0xF0, 0x1C, 0x70, 0x38, 0x0E, 0x01,
  0xCF, 0x03, 0x80, 0xE0, 0x38, 0xE0, 0x78, 0x0E, 0x03, 0x8E, 0x07, 0x01,
  0xE0, 0x38, 0xE0, 0x70, 0x1E, 0x07, 0x0E, 0x07, 0x03, 0xC0, 0x70, 0xE0,
  0x70, 0x3C, 0x0E, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0xE0, 0x78, 0x6E, 0x1C,
  0x0E, 0x03, 0x8E, 0xE3, 0x80, 0xE0, 0x3F, 0xC7, 0xF8, 0x0E, 0x01, 0xF8,
  0x7E, 0x00, 0xE0, 0x0F, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x10, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xC0, 0x3F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xE0, 0x3F, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x03,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFC, 0x0E, 0x00, 0x3F, 0x00, 0x40, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x18,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0xF0,
  0x07, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x78, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1F, 0x00,
  0x38, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0x1E,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x04, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x7F,
  0xE0, 0xF0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x38, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x03,
  0x9F, 0x00, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x07,
  0xE7, 0x80, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x1E, 0xE0, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x00,
  0x07, 0x78, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0x03,
  0x9C, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xE0, 0x03, 0x9E, 0x00, 0x01, 0xCF,
  0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0xC0,
  0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x00, 0x79, 0xE0, 0x03,
  0x87, 0x00, 0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x01, 0xE1,
  0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x70,
  0x00, 0xE1, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x00,
  0x70, 0x78, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x38, 0x03, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x1C, 0x0F,
  0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x03,
  0x80, 0xF0, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x01, 0xE0,
  0x3C, 0x3C, 0x03, 0x80, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x70, 0x0F,
  0x0E, 0x01, 0xE0, 0x03, 0x80, 0x38, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xC7,
  0x00, 0x78, 0x01, 0xE0, 0x0E, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x73, 0x80,
  0x3C, 0x00, 0x70, 0x03, 0xBC, 0x01, 0xE0, 0x07, 0x80, 0x1D, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFE, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0x1C, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0x07, 0x38, 0x00, 0x3C, 0x00, 0x73, 0x80, 0x03,
  0xC0, 0x0F, 0x38, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0x80, 0x0F, 0x3C,
  0x00, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x01,
  0xE1, 0xC0, 0x07, 0x00, 0x1E, 0x1C, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0xF0, 0x01, 0xC1, 0xE0, 0x0F, 0x00, 0x3C, 0x0E,
  0x00, 0xE0, 0x03, 0xC0, 0xE0, 0x1E, 0x00, 0x3C, 0x0E, 0x01, 0xE0, 0x03,
  0x80, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x1C,
  0x00, 0x78, 0x07, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x3C, 0x00, 0x70, 0x07,
  0x83, 0xC0, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x07, 0x83, 0x80, 0x0F,
  0x00, 0x38, 0x78, 0x00, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x00, 0x38, 0x78,
  0x01, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x00, 0x3C, 0x70, 0x01, 0xE0, 0x03,
  0xCF, 0x00, 0x1C, 0x00, 0x1C, 0xF0, 0x01, 0xC0, 0x01, 0xCF, 0x00, 0x3C,
  0x00, 0x1C, 0xE0, 0x03, 0xC0, 0x01, 0xEE, 0x00, 0x3C, 0x00, 0x1F, 0xE0,
  0x03, 0x80, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3C, 0x0F, 0xC0, 0x03, 0xC0,
  0x3E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x38, 0x07, 0xE0, 0x07,
  0x83, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x38, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0x70, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x0C, 0x00, 0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3F, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x1D,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xEE, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x73, 0x80, 0x07, 0x81, 0xE0, 0x03, 0x9C, 0x00,
  0x78, 0x0E, 0x00, 0x3C, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC7, 0x00, 0x3C,
  0x03, 0x80, 0x1E, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xE1, 0xC0, 0x0F, 0x00,
  0xE0, 0x07, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x83, 0x80, 0x78, 0x01, 0xC0, 0x1C, 0x1C, 0x03, 0xC0, 0x0E, 0x01,
  0xE0, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xF0,
  0x38, 0x0F, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x38, 0x0E,
  0x07, 0x80, 0x07, 0x03, 0xC0, 0x70, 0x3C, 0x00, 0x38, 0x1C, 0x03, 0x83,
  0xC0, 0x01, 0xC1, 0xE0, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x78, 0x78, 0x00,
  0x3C, 0x38, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x00, 0x0F,
  0x1C, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x38, 0xF0, 0x00, 0x1E, 0x70, 0x01, 0xCF, 0x00, 0x00, 0xF7, 0x80,
  0x0E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x03,
  0xBC, 0x00, 0x01, 0xFE, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xEE,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x70, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x81, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x07,
  0x07, 0x03, 0x00, 0x1F, 0xC1, 0xC0, 0x1F, 0xFC, 0x70, 0x0F, 0xFF, 0x3C,
  0x07, 0xE1, 0xEE, 0x01, 0xE0, 0x1B, 0x80, 0xF0, 0x06, 0xE0, 0x7C, 0x01,
  0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x07,
  0xE0, 0x1E, 0x03, 0xB8, 0x07, 0xC1, 0xCE, 0x00, 0xFF, 0xE7, 0x80, 0x3F,
  0xF1, 0xC0, 0x07, 0xF8, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0xFE, 0x00, 0x3C, 0xFF, 0xC0, 0x0E, 0x7F, 0xF8, 0x07,
  0xBC, 0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x7E, 0x00, 0xF0, 0x1F, 0x00, 0x3C,
  0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x70, 0x3C, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0xF8,
  0x1D, 0xC0, 0x7C, 0x07, 0x70, 0x3E, 0x01, 0xCF, 0xFF, 0x00, 0x73, 0xFF,
  0x80, 0x38, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x20, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x01, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xC3, 0xC0, 0x03, 0xFF, 0x9E, 0x00, 0x3F, 0xFC, 0xF0,
  0x03, 0xF0, 0x77, 0x00, 0x1E, 0x01, 0xB8, 0x01, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x06, 0xE0,
  0x03, 0xC0, 0x77, 0x00, 0x1F, 0x07, 0x38, 0x00, 0xFF, 0xF3, 0xC0, 0x03,
  0xFF, 0x1C, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7C, 0x1E, 0x03, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x03, 0xC3, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x0F, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x02, 0x07, 0xC0, 0x30, 0x0F,
  0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xC2, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x8F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x38, 0x00,
  0x3F, 0xF1, 0xC0, 0x07, 0xFF, 0x9E, 0x00, 0x7E, 0x1E, 0xE0, 0x03, 0xC0,
  0x37, 0x00, 0x3C, 0x01, 0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x01, 0xF8, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xFC, 0x00, 0x78, 0x0E, 0xE0, 0x03, 0xE0,
  0xEF, 0x00, 0x1F, 0xFE, 0x78, 0x00, 0x7F, 0xE3, 0x80, 0x01, 0xFE, 0x1C,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x3C, 0x00, 0x30, 0x03, 0xE0, 0x01,
  0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x79, 0xFF, 0x80,
  0x39, 0xFF, 0xE0, 0x1D, 0xC1, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xC0, 0x3C,
  0x07, 0xC0, 0x0E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x9F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x3E, 0x00, 0x01, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xBC,
  0x00, 0x0F, 0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x7C,
  0x1C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x3C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE1, 0xFC, 0x07, 0xF0, 0x01,
  0xCF, 0xFC, 0x3F, 0xF8, 0x03, 0xBF, 0xFC, 0xFF, 0xF0, 0x0F, 0x70, 0x7B,
  0xC1, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xC0,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x70, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0xF0,
  0x01, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0xE1, 0xFE, 0x00, 0x71, 0xFF, 0x80, 0x39, 0xFF, 0xC0, 0x3D, 0xC1,
  0xF0, 0x1D, 0xC0, 0x78, 0x0E, 0xC0, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xE0,
  0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0x70,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0E,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0x83, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x73, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x0F,
  0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x00, 0xE3, 0xFF, 0x00,
  0x07, 0x3F, 0xFC, 0x00, 0x3B, 0xC3, 0xE0, 0x03, 0xD8, 0x0F, 0x80, 0x1F,
  0x80, 0x3C, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00,
  0x38, 0x03, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70,
  0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78,
  0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x1C,
  0xFF, 0xF0, 0x00, 0xE3, 0xFF, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xC0,
  0x1F, 0xFC, 0x70, 0x0F, 0xFF, 0x3C, 0x07, 0xE1, 0xEE, 0x01, 0xE0, 0x3B,
  0x80, 0xF0, 0x06, 0xE0, 0x78, 0x01, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83,
  0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3F,
  0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0xE0, 0x1E, 0x03, 0xF8, 0x07, 0xC1,
  0xDE, 0x01, 0xFF, 0xE7, 0x80, 0x3F, 0xF1, 0xC0, 0x07, 0xF8, 0x70, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE1, 0xF8, 0x07, 0x1F,
  0xC0, 0x39, 0xFE, 0x03, 0xDF, 0x20, 0x1D, 0xC0, 0x00, 0xEC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0xE0, 0x3C,
  0x00, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x81, 0x00, 0x1E,
  0x03, 0x80, 0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1C,
  0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x81, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00,
  0x78, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x78,
  0x07, 0xE0, 0x3E, 0x0E, 0xF0, 0x1F, 0xFF, 0x70, 0x07, 0xFF, 0x38, 0x01,
  0xFE, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3B, 0xC0, 0x07, 0xC0, 0x0F, 0x78,
  0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x39, 0xE0, 0x07, 0xE0, 0x0F,
  0x3C, 0x01, 0xDC, 0x01, 0xC7, 0x80, 0x3B, 0x80, 0x78, 0xF0, 0x07, 0x70,
  0x0F, 0x1E, 0x01, 0xCE, 0x01, 0xC3, 0xC0, 0x39, 0xC0, 0x78, 0x78, 0x0F,
  0x38, 0x0E, 0x0F, 0x01, 0xCF, 0x01, 0xC1, 0xE0, 0x39, 0xE0, 0x78, 0x3C,
  0x0E, 0x3C, 0x0E, 0x07, 0x81, 0xC7, 0x83, 0xC0, 0xF0, 0x78, 0xF0, 0x70,
  0x1E, 0x0E, 0x1E, 0x0E, 0x03, 0xC1, 0xC3, 0xC3, 0xC0, 0x78, 0x70, 0x70,
  0x70, 0x0F, 0x0E, 0x0E, 0x1E, 0x01, 0xE3, 0xC1, 0xC3, 0x80, 0x3C, 0x70,
  0x38, 0x70, 0x07, 0x8E, 0x07, 0x1E, 0x00, 0xF3, 0x80, 0xE3, 0x80, 0x1E,
  0x70, 0x1C, 0x70, 0x03, 0xDE, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x73, 0x80,
  0x0E, 0x70, 0x0E, 0xF0, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x3B,
  0x80, 0x07, 0x70, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x11, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x47, 0xFC, 0x00, 0x17,
  0xFF, 0xC0, 0x0D, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xE8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 51, 16, 1, -51 },
  { 97, 17, 19, 21, 7, -51 },
  { 138, 29, 51, 28, 0, -51 },
  { 323, 27, 58, 26, 0, -54 },
  { 519, 34, 52, 40, 3, -51 },
  { 740, 26, 52, 27, -1, -51 },
  { 909, 7, 19, 12, 7, -51 },
  { 926, 20, 62, 18, 2, -51 },
  { 1081, 20, 62, 18, -5, -51 },
  { 1236, 19, 21, 24, 8, -54 },
  { 1286, 26, 33, 29, 2, -42 },
  { 1394, 10, 16, 13, -3, -7 },
  { 1414, 16, 4, 19, 1, -21 },
  { 1422, 5, 7, 13, 1, -7 },
  { 1427, 30, 51, 22, -3, -51 },
  { 1619, 25, 52, 26, 1, -51 },
  { 1782, 15, 51, 26, 8, -51 },
  { 1878, 28, 51, 26, -2, -51 },
  { 2057, 27, 52, 26, -1, -51 },
  { 2233, 27, 51, 26, -1, -51 },
  { 2406, 28, 52, 26, -1, -51 },
  { 2588, 26, 52, 26, 2, -51 },
  { 2757, 27, 51, 26, 2, -51 },
  { 2930, 28, 52, 26, -1, -51 },
  { 3112, 26, 52, 26, 0, -51 },
  { 3281, 12, 38, 13, 0, -38 },
  { 3338, 16, 47, 13, -3, -38 },
  { 3432, 26, 30, 29, 2, -40 },
  { 3530, 26, 18, 29, 2, -34 },
  { 3589, 26, 30, 29, 2, -40 },
  { 3687, 21, 51, 19, 1, -51 },
  { 3821, 36, 57, 39, 2, -51 },
  { 4078, 26, 51, 26, -5, -51 },
  { 4244, 29, 51, 29, 0, -51 },
  { 4429, 28, 52, 26, 3, -51 },
  { 4611, 30, 51, 31, 0, -51 },
  { 4803, 28, 51, 25, 0, -51 },
  { 4982, 28, 51, 23, 0, -51 },
  { 5161, 32, 52, 34, 3, -51 },
  { 5369, 34, 51, 33, 0, -51 },
  { 5586, 24, 51, 15, -4, -51 },
  { 5739, 25, 64, 13, -10, -51 },
  { 5939, 32, 51, 27, 0, -51 },
  { 6143, 17, 51, 23, 0, -51 },
  { 6252, 45, 51, 44, 0, -51 },
  { 6539, 36, 51, 35, 0, -51 },
  { 6769, 30, 52, 33, 2, -51 },
  { 6964, 28, 51, 27, 0, -51 },
  { 7143, 30, 63, 33, 2, -51 },
  { 7380, 28, 51, 28, 0, -51 },
  { 7559, 30, 52, 25, -2, -51 },
  { 7754, 23, 51, 23, 5, -51 },
  { 7901, 31, 52, 32, 2, -51 },
  { 8103, 26, 51, 27, 6, -51 },
  { 8269, 45, 51, 44, 5, -51 },
  { 8556, 33, 51, 24, -4, -51 },
  { 8767, 24, 51, 23, 5, -51 },
  { 8920, 30, 51, 23, -3, -51 },
  { 9112, 26, 62, 20, -2, -51 },
  { 9314, 11, 51, 23, 7, -51 },
  { 9385, 25, 62, 20, -4, -51 },
  { 9579, 27, 26, 28, 1, -51 },
  { 9667, 21, 3, 20, -6, 6 },
  { 9675, 8, 11, 16, 10, -54 },
  { 9686, 26, 39, 28, 2, -38 },
  { 9813, 26, 55, 28, 0, -54 },
  { 9992, 21, 39, 21, 2, -38 },
  { 10095, 29, 55, 28, 2, -54 },
  { 10295, 22, 39, 25, 2, -38 },
  { 10403, 32, 71, 15, -9, -54 },
  { 10687, 29, 55, 28, -1, -38 },
  { 10887, 25, 54, 27, 0, -54 },
  { 11056, 15, 51, 12, 0, -51 },
  { 11152, 24, 68, 13, -9, -51 },
  { 11356, 26, 54, 23, 0, -54 },
  { 11532, 15, 54, 12, 0, -54 },
  { 11634, 39, 38, 41, 0, -38 },
  { 11820, 25, 38, 27, 0, -38 },
  { 11939, 23, 39, 27, 2, -38 },
  { 12052, 29, 54, 28, -3, -38 },
  { 12248, 26, 55, 28, 2, -38 },
  { 12427, 21, 38, 18, 0, -38 },
  { 12527, 23, 39, 21, -1, -38 },
  { 12640, 16, 48, 15, 1, -47 },
  { 12736, 25, 39, 27, 2, -38 },
  { 12858, 21, 38, 22, 4, -38 },
  { 12958, 35, 38, 36, 4, -38 },
  { 13125, 28, 38, 22, -3, -38 },
  { 13258, 33, 55, 23, -7, -38 },
  { 13485, 22, 38, 18, -2, -38 },
  { 13590, 25, 62, 23, 2, -51 },
  { 13784, 3, 71, 25, 11, -54 },
  { 13811, 24, 62, 23, -4, -51 },
  { 13997, 26, 8, 29, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC71PT7B_H_
