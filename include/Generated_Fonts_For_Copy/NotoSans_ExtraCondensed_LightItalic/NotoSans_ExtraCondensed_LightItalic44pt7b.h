#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x00,
  0x38, 0xE6, 0x18, 0xC3, 0x18, 0xE7, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0x61,
  0x08, 0x63, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x86,
  0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x04, 0x00, 0xC3, 0x03, 0xFF,
  0xF8, 0xFF, 0xFE, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x30, 0xC0,
  0x0C, 0x30, 0x02, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x1F,
  0xF8, 0x3D, 0x9C, 0x18, 0xC4, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x03,
  0x18, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x72, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x36, 0x00, 0x1B, 0x80, 0x08,
  0xC0, 0x04, 0x60, 0x02, 0x38, 0x03, 0x18, 0x01, 0x0C, 0x00, 0x86, 0x10,
  0x47, 0x0C, 0x67, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x03, 0x80, 0x10, 0x7E, 0x03,
  0x07, 0x30, 0x18, 0x31, 0x81, 0x83, 0x0C, 0x0C, 0x18, 0x60, 0xC1, 0xC3,
  0x06, 0x0C, 0x18, 0x60, 0x60, 0xC3, 0x03, 0x06, 0x30, 0x18, 0x31, 0x81,
  0x83, 0x18, 0x0C, 0x18, 0xC0, 0x60, 0xCC, 0x7B, 0x0C, 0x67, 0xF8, 0x66,
  0x63, 0xC7, 0x33, 0x1F, 0x33, 0x30, 0xDF, 0x39, 0x86, 0x71, 0x98, 0x30,
  0x1C, 0xC1, 0x80, 0xC6, 0x0C, 0x0E, 0x30, 0x60, 0x63, 0x06, 0x07, 0x18,
  0x30, 0x30, 0xC1, 0x83, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x81, 0x86, 0x0C,
  0x0C, 0x60, 0xC0, 0x77, 0x06, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xFC, 0x01,
  0x9C, 0x03, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x0C, 0x07, 0x0C, 0x06,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x03, 0x60, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1D, 0x80, 0x19, 0xC7, 0x30, 0xC6, 0x70,
  0xC6, 0x60, 0xEE, 0xE0, 0xEC, 0xC0, 0x6C, 0xC0, 0x78, 0xC0, 0x78, 0xC0,
  0x30, 0xC0, 0x70, 0xC0, 0xF8, 0xE1, 0xD8, 0x7F, 0x98, 0x7F, 0x1C, 0x39,
  0x8C, 0x67, 0x31, 0x8C, 0x62, 0x30, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x06, 0x0C, 0x60, 0xF6,
  0x33, 0xFF, 0x07, 0x81, 0xE0, 0x3B, 0x07, 0x30, 0xE1, 0x84, 0x1C, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x0E, 0x18, 0x70, 0xC3, 0x86, 0x0C, 0x30,
  0x61, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x03,
  0xF8, 0x0F, 0x70, 0x38, 0x70, 0x60, 0x61, 0xC0, 0xC3, 0x01, 0x8E, 0x03,
  0x18, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x73, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xCE, 0x01,
  0x98, 0x07, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x86,
  0x06, 0x0E, 0x1C, 0x0C, 0x30, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0x83, 0xC7,
  0xC7, 0x67, 0x37, 0x39, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x1E, 0x38, 0x06, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0xFF,
  0x80, 0xF1, 0xC0, 0x40, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x04, 0x07, 0x83,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xB0, 0x00, 0xF8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x77, 0x00,
  0x33, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x18, 0x70, 0x0C, 0x30,
  0x0C, 0x18, 0x06, 0x0C, 0x06, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x01,
  0x83, 0x80, 0xC1, 0x80, 0xE1, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x83, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x80, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0x01, 0xE1, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x33, 0xF0, 0x77, 0xF8, 0x6C, 0x38, 0x78, 0x18, 0x70, 0x1C, 0x60, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x38, 0xC0, 0x30, 0xE0, 0x70, 0xE0, 0x60, 0x70, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0xE3, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x70, 0x1C, 0x30, 0x0E, 0x18,
  0x07, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0x61, 0xC0,
  0x39, 0xC0, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x07, 0x38, 0x0E, 0x0C,
  0x06, 0x07, 0x06, 0x01, 0x87, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x38, 0xC0,
  0x1C, 0x60, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x0E, 0x03, 0x87, 0x83, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x78, 0x01, 0xFC, 0x03, 0x8E, 0x07, 0x06,
  0x06, 0x07, 0x0C, 0x07, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x18, 0x0E,
  0x18, 0x1E, 0x1C, 0x3E, 0x0F, 0xEE, 0x07, 0xCC, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x02, 0x07, 0x0F, 0x0E,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0xE0, 0x00, 0x80, 0x70, 0x1C,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x07, 0xC0, 0xFF,
  0x07, 0x3C, 0x20, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x00,
  0xC0, 0x18, 0x01, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x04, 0x18, 0x1E, 0x08, 0x60, 0x7E, 0x18, 0xC1, 0x8C, 0x23,
  0x06, 0x18, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x30, 0xC1, 0x86, 0x61,
  0x82, 0x0C, 0xC3, 0x0C, 0x19, 0x8C, 0x18, 0x62, 0x18, 0x30, 0xCC, 0x30,
  0xE1, 0x98, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x61, 0x8A, 0x30, 0xC3, 0x14,
  0x61, 0x87, 0xCF, 0x83, 0x07, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x20, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1B, 0x00, 0x1B, 0x00,
  0x33, 0x00, 0x33, 0x00, 0x73, 0x00, 0x63, 0x00, 0x63, 0x00, 0xC3, 0x00,
  0xC3, 0x01, 0xC3, 0x01, 0x83, 0x03, 0x83, 0x03, 0x03, 0x03, 0x03, 0x07,
  0xFF, 0x07, 0xFF, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x60, 0x03, 0xE0,
  0x03, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x30, 0x38, 0x0C, 0x07, 0x03, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x18, 0x07, 0x06, 0x01, 0xC1, 0x80, 0x60,
  0xE0, 0x38, 0x38, 0x0C, 0x0C, 0x0E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1C, 0x1C, 0x06, 0x03, 0x81, 0x80, 0x60, 0x60, 0x18, 0x38, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x06,
  0x01, 0xC1, 0x80, 0xE0, 0x60, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xC0, 0x78, 0x60, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x81, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x0C, 0x0E, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x01, 0x81, 0xC0, 0x30,
  0x30, 0x06, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x06, 0x0C,
  0x01, 0xC1, 0x80, 0x30, 0x70, 0x0E, 0x0E, 0x03, 0x81, 0x80, 0xE0, 0x30,
  0x38, 0x06, 0x1E, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xFE, 0x01, 0xF1, 0xF0, 0x38, 0x02, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x3F, 0x8C, 0x03, 0xF8, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x0C, 0x07, 0x80, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xC0,
  0x0E, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x18, 0x1C, 0x01, 0xC0,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0xC0, 0x0C, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x18,
  0x01, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80, 0x38,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x07, 0x03,
  0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x08, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x30, 0x38, 0x03, 0x03, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x60, 0xC0,
  0x06, 0x1C, 0x00, 0x63, 0x80, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0C, 0xE0,
  0x00, 0xDC, 0x00, 0x0D, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0xC0, 0x01, 0xCE,
  0x00, 0x18, 0xE0, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x07, 0x00, 0x30,
  0x70, 0x03, 0x03, 0x00, 0x70, 0x30, 0x07, 0x03, 0x00, 0x60, 0x38, 0x06,
  0x03, 0x80, 0x60, 0x18, 0x0E, 0x01, 0x80, 0xC0, 0x1C, 0x00, 0x01, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x60, 0x7C,
  0x00, 0x3E, 0x06, 0xC0, 0x06, 0xC0, 0x6C, 0x00, 0x6C, 0x06, 0xC0, 0x0E,
  0xC0, 0x6C, 0x00, 0xCC, 0x0E, 0xE0, 0x1D, 0xC0, 0xCE, 0x01, 0x98, 0x0C,
  0xE0, 0x39, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x73, 0x81, 0xC6, 0x06,
  0x38, 0x18, 0x60, 0xE3, 0x01, 0x86, 0x0C, 0x30, 0x18, 0x60, 0xC3, 0x03,
  0x86, 0x18, 0x70, 0x38, 0x61, 0x86, 0x03, 0x06, 0x30, 0x60, 0x30, 0x63,
  0x06, 0x03, 0x06, 0x60, 0x60, 0x70, 0x66, 0x0E, 0x06, 0x06, 0xE0, 0xC0,
  0x60, 0x6C, 0x0C, 0x06, 0x07, 0xC0, 0xC0, 0x60, 0x78, 0x1C, 0x0E, 0x07,
  0x81, 0xC0, 0xC0, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x0F, 0x00, 0x30,
  0x3C, 0x01, 0xC0, 0xF0, 0x06, 0x03, 0xC0, 0x18, 0x1F, 0x80, 0x60, 0x76,
  0x03, 0x81, 0x98, 0x0E, 0x06, 0x60, 0x30, 0x19, 0x80, 0xC0, 0xE6, 0x03,
  0x03, 0x1C, 0x1C, 0x0C, 0x30, 0x70, 0x30, 0xC1, 0x80, 0xC3, 0x06, 0x07,
  0x0C, 0x18, 0x18, 0x30, 0xE0, 0x60, 0xE3, 0x01, 0x81, 0x8C, 0x0E, 0x06,
  0x30, 0x38, 0x19, 0xC0, 0xC0, 0x67, 0x03, 0x01, 0xD8, 0x0C, 0x03, 0x60,
  0x70, 0x0D, 0x81, 0xC0, 0x36, 0x06, 0x00, 0xF8, 0x18, 0x03, 0xC0, 0x60,
  0x0F, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xC0, 0x3C, 0x78, 0x1C, 0x0E, 0x06, 0x01, 0x83, 0x80, 0x71, 0xC0, 0x1C,
  0x60, 0x07, 0x18, 0x00, 0xCE, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x07, 0x70,
  0x01, 0xD8, 0x00, 0x76, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00,
  0xEC, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xE0,
  0x30, 0x1C, 0x3C, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0x80, 0xC1, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x38, 0x0C, 0x1C, 0x06, 0x0C,
  0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x60, 0xC0, 0x70,
  0x60, 0x38, 0x30, 0x38, 0x38, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3C, 0x78, 0x1C, 0x0E, 0x06,
  0x01, 0x83, 0x80, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x18, 0x00, 0xCE, 0x00,
  0x73, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1B,
  0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x0E, 0x30, 0x03,
  0x0C, 0x01, 0xC3, 0x00, 0x60, 0xE0, 0x38, 0x1C, 0x3C, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xC1,
  0xE0, 0x60, 0x70, 0x30, 0x18, 0x38, 0x0C, 0x1C, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0x83, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x60, 0xC0, 0x70, 0x60, 0x70,
  0x30, 0x78, 0x3F, 0xF8, 0x1F, 0xF0, 0x0C, 0x70, 0x06, 0x18, 0x03, 0x0C,
  0x03, 0x86, 0x01, 0x83, 0x80, 0xC1, 0xC0, 0x60, 0xE0, 0x70, 0x30, 0x38,
  0x18, 0x18, 0x0C, 0x0C, 0x07, 0x06, 0x03, 0x87, 0x00, 0xC3, 0x80, 0x60,
  0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x1F, 0x7C, 0x0E, 0x02, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x30, 0x1C, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xFD, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0C, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x01, 0x81, 0x80, 0x38, 0x38, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x70, 0x30, 0x07, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x0E, 0x01, 0xC0,
  0xE0, 0x18, 0x06, 0x03, 0x80, 0x70, 0x70, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0,
  0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0,
  0xE0, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC3, 0x80, 0xC3,
  0x00, 0xC3, 0x00, 0xC7, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xCC, 0x00, 0xDC,
  0x00, 0xD8, 0x00, 0xD8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x76, 0x00, 0x60, 0x06, 0x60, 0x0E,
  0x00, 0xE6, 0x00, 0xE0, 0x0C, 0x60, 0x1E, 0x01, 0xC6, 0x01, 0xE0, 0x18,
  0x60, 0x1E, 0x01, 0x86, 0x03, 0x60, 0x38, 0x60, 0x36, 0x03, 0x06, 0x06,
  0x60, 0x70, 0x60, 0x66, 0x06, 0x06, 0x06, 0x60, 0x60, 0x60, 0xC6, 0x0E,
  0x06, 0x0C, 0x60, 0xC0, 0xE1, 0xC6, 0x1C, 0x0E, 0x18, 0x61, 0x80, 0xE1,
  0x86, 0x18, 0x0E, 0x30, 0x63, 0x80, 0xE3, 0x06, 0x30, 0x0E, 0x70, 0x63,
  0x00, 0xE6, 0x06, 0x60, 0x0E, 0x60, 0x66, 0x00, 0xEC, 0x06, 0xE0, 0x0E,
  0xC0, 0x6C, 0x00, 0xFC, 0x06, 0xC0, 0x0D, 0x80, 0x7C, 0x00, 0xD8, 0x0D,
  0x80, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x18,
  0x01, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C,
  0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x1D, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80, 0x01,
  0x8C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0,
  0x06, 0x03, 0x00, 0x70, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x03, 0x80,
  0x30, 0x00, 0x60, 0x0E, 0xC0, 0x39, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x0E,
  0x0E, 0x1C, 0x18, 0x38, 0x70, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x9C,
  0x03, 0x30, 0x06, 0xE0, 0x0D, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1,
  0x83, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x03, 0x30, 0x07, 0x38, 0x06, 0x18, 0x0E, 0x18, 0x0C,
  0x1C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06, 0xE0,
  0x03, 0xC0, 0x03, 0x7F, 0xFF, 0xFF, 0xC0, 0xE3, 0x1C, 0x63, 0x0C, 0x20,
  0x00, 0xE0, 0x03, 0xF3, 0x07, 0x9B, 0x0E, 0x0B, 0x1C, 0x0F, 0x18, 0x0E,
  0x18, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xF0, 0x60, 0xB0, 0x7F, 0xB0, 0x3E, 0x30,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x3C, 0x06, 0x7E, 0x06, 0xCF,
  0x0F, 0x87, 0x0F, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x07, 0x38, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x18, 0x70, 0x38,
  0x78, 0x70, 0xCF, 0xE0, 0xCF, 0xC0, 0x00, 0xF0, 0x1F, 0xC1, 0xE6, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x21, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x38, 0xC0, 0x3F, 0x30, 0x1E, 0x6C,
  0x0E, 0x0B, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0C,
  0x03, 0x87, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x01,
  0xC3, 0x80, 0x60, 0xE0, 0x18, 0x38, 0x06, 0x0E, 0x03, 0x83, 0x80, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x06, 0x0B, 0x01, 0xFC, 0xC0, 0x3E, 0x30, 0x00,
  0x00, 0xE0, 0x0F, 0xE0, 0x71, 0xC3, 0x87, 0x1C, 0x0C, 0x60, 0x33, 0x81,
  0xCC, 0x06, 0x30, 0x39, 0xC1, 0xC6, 0x0E, 0x1F, 0xF0, 0x7F, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x87, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x00,
  0x03, 0x90, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0x30, 0x1E, 0x6C, 0x0E, 0x0B, 0x03, 0x03, 0xC1, 0x80,
  0xE0, 0x60, 0x38, 0x38, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x30,
  0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x18, 0x38,
  0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x06, 0x1B,
  0x01, 0xFE, 0xC0, 0x3E, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x02, 0x03, 0x80, 0xF7,
  0xC0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x3C, 0x06, 0xFE, 0x07, 0xCE, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07,
  0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x0C,
  0x18, 0x0C, 0x38, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x30, 0x18, 0x30, 0x18,
  0x70, 0x18, 0x60, 0x38, 0x60, 0x38, 0x60, 0x30, 0xE0, 0x30, 0xE0, 0x70,
  0x01, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x0E,
  0x18, 0x0C, 0x38, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0xC0, 0x19, 0xC0, 0x1B,
  0x80, 0x1B, 0xC0, 0x1F, 0xC0, 0x3C, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x30, 0xE0, 0x70, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0,
  0x60, 0xC0, 0x70, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x38, 0x1C,
  0x06, 0xFE, 0x7E, 0x07, 0xCE, 0xE7, 0x0D, 0x07, 0x83, 0x0E, 0x07, 0x03,
  0x0E, 0x07, 0x03, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x03, 0x1C, 0x0E, 0x07,
  0x1C, 0x0E, 0x06, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x0E,
  0x38, 0x1C, 0x0E, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C,
  0x70, 0x18, 0x1C, 0x70, 0x38, 0x18, 0x60, 0x30, 0x18, 0x60, 0x30, 0x18,
  0x60, 0x30, 0x18, 0xE0, 0x70, 0x38, 0xE0, 0x70, 0x30, 0x00, 0x38, 0x06,
  0xFE, 0x07, 0xCE, 0x0D, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x06, 0x0C,
  0x06, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x0C, 0x38,
  0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x30, 0x18, 0x70, 0x18, 0x70, 0x18, 0x60,
  0x38, 0x60, 0x38, 0x60, 0x30, 0xE0, 0x30, 0xE0, 0x70, 0x00, 0xF0, 0x07,
  0xF0, 0x1C, 0x70, 0x70, 0x61, 0xC0, 0xC3, 0x01, 0xCE, 0x03, 0x98, 0x07,
  0x30, 0x0E, 0xE0, 0x1D, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0xB8,
  0x07, 0x70, 0x0C, 0xE0, 0x19, 0x80, 0x73, 0x00, 0xC7, 0x03, 0x8E, 0x06,
  0x0C, 0x1C, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x67, 0xE0, 0x1B,
  0x3C, 0x0F, 0x87, 0x03, 0xC0, 0xC0, 0xE0, 0x30, 0x38, 0x0C, 0x0C, 0x03,
  0x07, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC3,
  0x80, 0x70, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC1, 0xC0,
  0x70, 0x70, 0x18, 0x1C, 0x0E, 0x07, 0x87, 0x03, 0xBF, 0x80, 0xEF, 0xC0,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xF3, 0x07, 0x1B, 0x0E, 0x0B, 0x0C, 0x0F, 0x18, 0x0E, 0x18,
  0x0E, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x70, 0xE0, 0xF0, 0x60, 0xB0, 0x7F, 0xF0, 0x3E, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x38, 0x37, 0xC1, 0xFE,
  0x1B, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF0,
  0x0F, 0xF0, 0x71, 0xC3, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE2, 0x03,
  0x0F, 0xFC, 0x1F, 0xE0, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0xFE,
  0xFF, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0x07,
  0x80, 0x0C, 0x07, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x0E, 0x18,
  0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x30, 0x18, 0x70,
  0x18, 0x70, 0x18, 0x60, 0x38, 0x60, 0x38, 0x60, 0x30, 0xE0, 0x30, 0xE0,
  0x70, 0xC0, 0x70, 0xE0, 0xE0, 0xE1, 0xE0, 0x7F, 0x60, 0x7E, 0x60, 0xC0,
  0x3E, 0x03, 0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x30,
  0xC3, 0x86, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0x60, 0x67, 0x03, 0x30, 0x1B,
  0x80, 0xD8, 0x06, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x60, 0x38, 0x1D, 0x80, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E, 0x0E,
  0x60, 0xD8, 0x31, 0x83, 0x60, 0xC6, 0x0D, 0x86, 0x18, 0x66, 0x18, 0x61,
  0x98, 0xE1, 0x8C, 0x63, 0x06, 0x31, 0x8C, 0x18, 0xC6, 0x60, 0x66, 0x19,
  0x81, 0x98, 0x6E, 0x06, 0xC1, 0x30, 0x1B, 0x0C, 0xC0, 0x6C, 0x36, 0x01,
  0xE0, 0xD8, 0x07, 0x83, 0x60, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0,
  0xE0, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x03, 0x81, 0x81, 0x80, 0xC1, 0xC0,
  0x60, 0xC0, 0x38, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x1D,
  0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x06, 0x03,
  0x03, 0x03, 0x01, 0x83, 0x80, 0xE0, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03,
  0x00, 0x18, 0x38, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01,
  0xC6, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x0B, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xFE, 0x07, 0x1F, 0x3C, 0x0F, 0xE8,
  0x03, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 31, 10, 1, -31 },
  { 36, 11, 11, 13, 4, -31 },
  { 52, 18, 31, 17, 0, -31 },
  { 122, 17, 36, 16, 0, -33 },
  { 199, 21, 32, 25, 2, -32 },
  { 283, 16, 32, 17, 0, -32 },
  { 347, 5, 11, 7, 4, -31 },
  { 354, 13, 38, 11, 1, -31 },
  { 416, 12, 38, 11, -3, -31 },
  { 473, 12, 13, 15, 5, -33 },
  { 493, 15, 21, 18, 2, -26 },
  { 533, 7, 10, 8, -2, -4 },
  { 542, 9, 2, 11, 1, -13 },
  { 545, 3, 4, 8, 1, -4 },
  { 547, 19, 31, 14, -2, -31 },
  { 621, 15, 32, 16, 1, -32 },
  { 681, 9, 31, 16, 5, -31 },
  { 716, 18, 32, 16, -2, -32 },
  { 788, 17, 32, 16, -1, -32 },
  { 856, 17, 32, 16, -1, -32 },
  { 924, 18, 31, 16, -1, -31 },
  { 994, 16, 32, 16, 1, -32 },
  { 1058, 17, 31, 16, 1, -31 },
  { 1124, 17, 32, 16, 0, -32 },
  { 1192, 16, 32, 16, 0, -32 },
  { 1256, 8, 24, 8, 0, -24 },
  { 1280, 10, 30, 8, -2, -24 },
  { 1318, 16, 19, 18, 1, -25 },
  { 1356, 15, 11, 18, 2, -21 },
  { 1377, 15, 19, 18, 2, -25 },
  { 1413, 13, 32, 12, 1, -32 },
  { 1465, 23, 36, 24, 1, -32 },
  { 1569, 16, 32, 16, -3, -32 },
  { 1633, 18, 31, 18, 0, -31 },
  { 1703, 17, 32, 16, 2, -32 },
  { 1771, 19, 31, 19, 0, -31 },
  { 1845, 17, 31, 15, 0, -31 },
  { 1911, 17, 31, 14, 0, -31 },
  { 1977, 20, 32, 21, 2, -32 },
  { 2057, 21, 31, 20, 0, -31 },
  { 2139, 15, 31, 9, -2, -31 },
  { 2198, 15, 39, 8, -6, -31 },
  { 2272, 20, 31, 17, 0, -31 },
  { 2350, 11, 31, 14, 0, -31 },
  { 2393, 28, 31, 27, 0, -31 },
  { 2502, 22, 31, 21, 0, -31 },
  { 2588, 18, 32, 21, 2, -32 },
  { 2660, 17, 31, 17, 0, -31 },
  { 2726, 18, 39, 21, 2, -32 },
  { 2814, 17, 31, 17, 0, -31 },
  { 2880, 18, 32, 16, -1, -32 },
  { 2952, 14, 31, 14, 3, -31 },
  { 3007, 20, 31, 20, 1, -31 },
  { 3085, 16, 31, 16, 4, -31 },
  { 3147, 28, 31, 28, 3, -31 },
  { 3256, 21, 31, 15, -3, -31 },
  { 3338, 15, 31, 14, 3, -31 },
  { 3397, 19, 31, 14, -2, -31 },
  { 3471, 16, 39, 12, -1, -32 },
  { 3549, 7, 32, 15, 4, -32 },
  { 3577, 16, 39, 12, -3, -32 },
  { 3655, 16, 16, 17, 1, -31 },
  { 3687, 13, 2, 12, -4, 4 },
  { 3691, 5, 7, 10, 6, -34 },
  { 3696, 16, 24, 18, 1, -24 },
  { 3744, 16, 33, 17, 0, -33 },
  { 3810, 13, 24, 13, 1, -24 },
  { 3849, 18, 33, 18, 1, -33 },
  { 3924, 14, 24, 16, 1, -24 },
  { 3966, 20, 45, 9, -6, -34 },
  { 4079, 18, 35, 18, -1, -24 },
  { 4158, 16, 33, 17, 0, -33 },
  { 4224, 9, 32, 8, 0, -32 },
  { 4260, 15, 43, 8, -6, -32 },
  { 4341, 16, 33, 14, 0, -33 },
  { 4407, 10, 33, 7, 0, -33 },
  { 4449, 24, 24, 25, 0, -24 },
  { 4521, 16, 24, 17, 0, -24 },
  { 4569, 15, 24, 17, 1, -24 },
  { 4614, 18, 34, 17, -2, -24 },
  { 4691, 16, 34, 18, 1, -24 },
  { 4759, 13, 24, 11, 0, -24 },
  { 4798, 14, 24, 13, -1, -24 },
  { 4840, 9, 29, 9, 1, -29 },
  { 4873, 16, 23, 17, 1, -23 },
  { 4919, 13, 23, 13, 3, -23 },
  { 4957, 22, 23, 22, 2, -23 },
  { 5021, 17, 23, 14, -2, -23 },
  { 5070, 21, 34, 14, -5, -23 },
  { 5160, 15, 23, 11, -2, -23 },
  { 5204, 16, 38, 14, 1, -31 },
  { 5280, 2, 45, 16, 7, -34 },
  { 5292, 16, 38, 14, -3, -31 },
  { 5368, 15, 5, 18, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC44PT7B_H_
