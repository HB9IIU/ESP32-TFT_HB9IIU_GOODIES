#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0x81,
  0x06, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0E, 0x18, 0x00, 0x66, 0xCD, 0x9A,
  0x24, 0x58, 0xB3, 0x44, 0x01, 0x18, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x22,
  0x03, 0x10, 0xFF, 0xE7, 0xFF, 0x0C, 0x40, 0x46, 0x02, 0x20, 0x31, 0x01,
  0x18, 0x08, 0x83, 0xFF, 0x84, 0x60, 0x23, 0x03, 0x10, 0x18, 0x80, 0x8C,
  0x04, 0x40, 0x66, 0x00, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3E, 0x0F, 0x71,
  0x90, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x1A, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x05, 0x80, 0x48, 0x04, 0x80, 0x4C, 0x08, 0x80, 0x88, 0x89, 0x8F,
  0xF0, 0x38, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1E, 0x0C, 0x26, 0x10, 0xCC,
  0x61, 0x18, 0x86, 0x33, 0x08, 0x44, 0x10, 0x98, 0x21, 0x20, 0x46, 0xC5,
  0x89, 0x3F, 0x16, 0xCA, 0x49, 0x17, 0xB6, 0x20, 0x48, 0x41, 0x90, 0x82,
  0x23, 0x0C, 0xC6, 0x11, 0x88, 0x63, 0x10, 0x86, 0x63, 0x0C, 0x84, 0x0E,
  0x00, 0x07, 0xC0, 0x98, 0x31, 0x04, 0x60, 0x8C, 0x11, 0x82, 0x20, 0x4C,
  0x0F, 0x01, 0xC0, 0x30, 0x0F, 0x03, 0x66, 0xCC, 0xD0, 0x96, 0x1E, 0xC3,
  0xD0, 0x32, 0x06, 0x61, 0xCC, 0x68, 0xF9, 0x80, 0x6D, 0xA5, 0xB4, 0x01,
  0x81, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x00, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x20, 0x30,
  0x00, 0x08, 0x06, 0x03, 0x1D, 0x03, 0xF8, 0x60, 0xD0, 0xC8, 0x42, 0x01,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xFF, 0xFF,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x33, 0x26, 0x4C,
  0x80, 0xFC, 0x7F, 0x00, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x00, 0x07, 0x83, 0x31, 0x84, 0x41, 0x30, 0x48, 0x16,
  0x05, 0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xB0, 0x68, 0x1A, 0x04,
  0x83, 0x20, 0xC8, 0x22, 0x18, 0xCC, 0x1E, 0x00, 0x06, 0x3C, 0xD3, 0x6C,
  0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x41,
  0x83, 0x06, 0x08, 0x00, 0x07, 0xE0, 0xC3, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F,
  0xF8, 0x07, 0xE0, 0x61, 0x80, 0x04, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x17, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x0C, 0x30, 0x7F,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0B, 0x00, 0x90, 0x0C,
  0x80, 0x4C, 0x06, 0x60, 0x62, 0x02, 0x10, 0x31, 0x81, 0x0C, 0x18, 0x61,
  0x82, 0x08, 0x10, 0xFF, 0xE0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x07, 0xF8, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xFC, 0x04, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x0C, 0x30, 0x7F,
  0x00, 0x03, 0xE0, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x66, 0x0B, 0xE3, 0x86, 0x70, 0xCC, 0x09, 0x81, 0x30, 0x24, 0x0C, 0x81,
  0x90, 0x32, 0x0C, 0x61, 0x8C, 0x60, 0xF8, 0x00, 0x3F, 0xF0, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x31, 0x83, 0x10,
  0x31, 0x02, 0x18, 0x61, 0x86, 0x08, 0xC0, 0xF8, 0x0E, 0x01, 0xB0, 0x31,
  0x86, 0x18, 0xC0, 0x8C, 0x0C, 0x80, 0xC8, 0x0C, 0x80, 0x8C, 0x18, 0xE3,
  0x07, 0xE0, 0x07, 0xC1, 0x8C, 0x61, 0x8C, 0x13, 0x02, 0x60, 0x4C, 0x09,
  0x03, 0x20, 0x64, 0x0C, 0xC3, 0x98, 0xE1, 0xF4, 0x11, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x08, 0xC1, 0xF0, 0x00, 0x08, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x18, 0xC0, 0x04, 0x1C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x60, 0xC1,
  0x06, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x40, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x01, 0x00, 0x00, 0x1F, 0x84, 0x60, 0x08, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x01, 0xF8,
  0x03, 0x0C, 0x04, 0x06, 0x08, 0x02, 0x18, 0x02, 0x10, 0x03, 0x20, 0xF3,
  0x21, 0x33, 0x62, 0x22, 0x46, 0x22, 0x44, 0x62, 0xC4, 0x62, 0xCC, 0x46,
  0x88, 0x44, 0x88, 0xC4, 0x88, 0xCC, 0x89, 0x48, 0x8F, 0x70, 0x84, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x00, 0x60, 0x1C, 0x02, 0x80, 0x50, 0x1A, 0x02, 0x40, 0xC8, 0x19, 0x02,
  0x20, 0xC4, 0x10, 0x86, 0x10, 0xC2, 0x3F, 0xC6, 0x08, 0x81, 0x30, 0x26,
  0x05, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x40, 0x07, 0xE0, 0x63, 0x83, 0x0C,
  0x18, 0x30, 0x81, 0x84, 0x0C, 0x60, 0x43, 0x06, 0x18, 0x60, 0x8E, 0x0F,
  0xC0, 0x61, 0x83, 0x06, 0x18, 0x30, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x02,
  0x10, 0x30, 0x83, 0x0C, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x38, 0x83, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x10, 0x1F, 0x80, 0x07, 0xC0, 0x67, 0x83, 0x0C,
  0x18, 0x30, 0x81, 0x84, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0x80, 0xCC,
  0x06, 0x60, 0x33, 0x03, 0x18, 0x18, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x06,
  0x10, 0x30, 0x87, 0x0F, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x3F, 0xC3,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x43, 0xF8, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0xFC, 0x1C, 0x30, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x3C, 0xC0, 0x33,
  0x00, 0xCC, 0x03, 0x30, 0x08, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x18, 0x18,
  0x70, 0xC0, 0x7F, 0x00, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x10, 0x60, 0x60,
  0x80, 0xC1, 0x01, 0x86, 0x02, 0x0C, 0x04, 0x18, 0x18, 0x20, 0x30, 0xFF,
  0xE1, 0x80, 0x83, 0x01, 0x04, 0x06, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x20,
  0xC0, 0xC1, 0x01, 0x82, 0x03, 0x0C, 0x06, 0x18, 0x08, 0x00, 0x07, 0xE0,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x01, 0xF8, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x0F, 0x03, 0x00, 0x04, 0x0C, 0x30, 0x60, 0xC3, 0x03, 0x08, 0x08,
  0x60, 0x23, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x58, 0x03, 0x60, 0x0E,
  0x80, 0x33, 0x00, 0x8C, 0x02, 0x30, 0x18, 0xC0, 0x61, 0x01, 0x86, 0x04,
  0x18, 0x10, 0x60, 0xC0, 0x83, 0x03, 0x00, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x40, 0x40, 0xFF, 0xFE, 0x06, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x1E, 0x0A, 0x01, 0xE0, 0xA0, 0x14, 0x1A, 0x03, 0x41, 0xA0,
  0x2C, 0x12, 0x06, 0xC1, 0x30, 0x4C, 0x33, 0x0C, 0x83, 0x30, 0x88, 0x33,
  0x19, 0x82, 0x31, 0x18, 0x23, 0x31, 0x86, 0x33, 0x10, 0x63, 0x61, 0x06,
  0x36, 0x30, 0x43, 0xC3, 0x04, 0x3C, 0x30, 0xC1, 0x82, 0x0C, 0x18, 0x60,
  0x06, 0x03, 0x0E, 0x02, 0x0E, 0x06, 0x0E, 0x06, 0x0B, 0x06, 0x0B, 0x04,
  0x1B, 0x04, 0x19, 0x0C, 0x19, 0x0C, 0x11, 0x0C, 0x31, 0x88, 0x31, 0x88,
  0x31, 0x98, 0x20, 0x98, 0x20, 0x98, 0x60, 0x90, 0x60, 0xD0, 0x60, 0xF0,
  0x40, 0xF0, 0x40, 0x70, 0xC0, 0x60, 0xC0, 0x60, 0x03, 0xF0, 0x31, 0x83,
  0x06, 0x30, 0x31, 0x01, 0x98, 0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00,
  0xD0, 0x07, 0x80, 0x2C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x04, 0xC0, 0x66,
  0x02, 0x30, 0x30, 0x83, 0x06, 0x30, 0x1F, 0x00, 0x07, 0xC0, 0xCE, 0x0C,
  0x30, 0xC3, 0x08, 0x10, 0x83, 0x18, 0x31, 0x83, 0x18, 0x31, 0x06, 0x30,
  0xC3, 0xF8, 0x3E, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0xF0, 0x31, 0x83, 0x06, 0x30, 0x31,
  0x01, 0x98, 0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD0, 0x07, 0x80,
  0x2C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x04, 0xC0, 0x66, 0x02, 0x30, 0x30,
  0x83, 0x06, 0x30, 0x1F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0xC0, 0xCE, 0x0C, 0x30, 0xC3, 0x08, 0x30, 0x83, 0x18, 0x31,
  0x83, 0x18, 0x21, 0x06, 0x30, 0xC3, 0xF8, 0x33, 0x03, 0x30, 0x23, 0x06,
  0x30, 0x61, 0x06, 0x18, 0x41, 0x84, 0x18, 0xC1, 0x8C, 0x08, 0x03, 0xF8,
  0x30, 0xC3, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x0E, 0x38, 0x7F, 0x80, 0x7F, 0xC3,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x0C, 0x60, 0x21, 0x81, 0x84, 0x06, 0x10, 0x18, 0xC0,
  0x43, 0x03, 0x0C, 0x0C, 0x20, 0x30, 0x80, 0xC6, 0x02, 0x18, 0x18, 0x60,
  0x61, 0x01, 0x8C, 0x04, 0x30, 0x10, 0xC0, 0xC3, 0x03, 0x0C, 0x08, 0x30,
  0x60, 0x63, 0x01, 0xF8, 0x00, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x68, 0x19,
  0x03, 0x20, 0x44, 0x18, 0x82, 0x10, 0xC2, 0x18, 0x46, 0x08, 0xC1, 0x10,
  0x26, 0x04, 0x80, 0xB0, 0x16, 0x02, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x00,
  0x40, 0x60, 0x34, 0x06, 0x06, 0x40, 0xE0, 0x64, 0x0A, 0x04, 0x40, 0xE0,
  0xC4, 0x1E, 0x0C, 0x41, 0x61, 0x84, 0x36, 0x18, 0xC3, 0x61, 0x0C, 0x26,
  0x30, 0xC6, 0x63, 0x0C, 0x46, 0x60, 0xCC, 0x66, 0x0C, 0xC6, 0x40, 0xC8,
  0x6C, 0x0D, 0x84, 0xC0, 0xD0, 0x58, 0x0D, 0x05, 0x80, 0xF0, 0x50, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x04, 0x18, 0x08,
  0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xA0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xD0, 0x03, 0x20, 0x06,
  0x40, 0x18, 0x80, 0x21, 0x80, 0xC3, 0x01, 0x06, 0x06, 0x0C, 0x18, 0x18,
  0x00, 0x40, 0x68, 0x19, 0x02, 0x30, 0xC6, 0x10, 0xC6, 0x18, 0x83, 0x30,
  0x64, 0x05, 0x80, 0xA0, 0x1C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xF8, 0x40, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xFC,
  0x00, 0xC6, 0x10, 0x84, 0x21, 0x8C, 0x63, 0x08, 0x42, 0x18, 0xC6, 0x30,
  0x84, 0x21, 0x0C, 0x03, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x83, 0xF0, 0x00, 0x06, 0x00, 0xE0, 0x3C, 0x04, 0x81, 0x98,
  0x23, 0x0C, 0x21, 0x06, 0x60, 0x58, 0x0F, 0x01, 0x80, 0xFF, 0x80, 0x9B,
  0x22, 0x07, 0x01, 0xF4, 0x63, 0x98, 0x72, 0x0C, 0xC1, 0x98, 0x32, 0x06,
  0xC0, 0xD8, 0x13, 0x06, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xC6, 0x28, 0x7B,
  0x00, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x9C, 0x1B, 0xE1, 0xC6, 0x18, 0x21, 0x83, 0x30, 0x23, 0x02, 0x30, 0x22,
  0x06, 0x20, 0x66, 0x06, 0x60, 0x46, 0x0C, 0x60, 0xC6, 0x18, 0xF3, 0x0D,
  0xE0, 0x07, 0x07, 0xC6, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x06, 0x03, 0x01, 0xC8, 0x7C, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0xE4, 0x0F, 0xE0,
  0xC7, 0x0C, 0x38, 0x41, 0x86, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0x86, 0x0C, 0x30, 0x61, 0x03, 0x0C, 0x30, 0x61, 0x83, 0x14, 0x0F, 0x60,
  0x07, 0x07, 0xC6, 0x26, 0x16, 0x0B, 0x0D, 0x07, 0x8E, 0xFC, 0x60, 0x30,
  0x10, 0x08, 0x06, 0x03, 0x01, 0xC4, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x24, 0x03, 0xE0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x41, 0x8E, 0x18, 0x70, 0x83, 0x0C,
  0x18, 0x40, 0xC2, 0x06, 0x30, 0x31, 0x81, 0x0C, 0x18, 0x60, 0xC2, 0x06,
  0x18, 0x70, 0xC3, 0x06, 0x28, 0x1E, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x82, 0x0C, 0x1F, 0xC0, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x4E, 0x1F, 0xE3, 0x8C, 0x61, 0x8C, 0x31, 0x06,
  0x60, 0xCC, 0x11, 0x86, 0x20, 0xCC, 0x19, 0x82, 0x30, 0x44, 0x18, 0x83,
  0x30, 0x66, 0x08, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x86, 0x18, 0x41, 0x0C,
  0x30, 0x82, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x18, 0x0F, 0x00,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x63, 0x18, 0x66, 0x08, 0x81, 0x30, 0x6C, 0x0F, 0x81, 0x70, 0x36, 0x0C,
  0x41, 0x88, 0x31, 0x04, 0x30, 0x86, 0x30, 0xC6, 0x18, 0x06, 0x08, 0x10,
  0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20,
  0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0x01, 0x87, 0x0F, 0xEF, 0xC7, 0x1C,
  0x63, 0x0C, 0x31, 0x86, 0x18, 0x83, 0x0C, 0xC1, 0x06, 0x61, 0x82, 0x30,
  0xC3, 0x10, 0x61, 0x98, 0x20, 0xCC, 0x10, 0x46, 0x18, 0x22, 0x0C, 0x31,
  0x06, 0x19, 0x82, 0x0C, 0xC3, 0x04, 0x00, 0x01, 0xC3, 0xFC, 0x71, 0x8C,
  0x31, 0x86, 0x20, 0xCC, 0x19, 0x82, 0x30, 0xC4, 0x19, 0x83, 0x30, 0x46,
  0x08, 0x83, 0x10, 0x66, 0x0C, 0xC1, 0x00, 0x07, 0x07, 0xE1, 0x8C, 0xC3,
  0x60, 0xD8, 0x34, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x06, 0x81, 0xB0,
  0xCC, 0x33, 0x18, 0x7C, 0x00, 0x00, 0xE0, 0x6F, 0x83, 0x8C, 0x18, 0x20,
  0xC1, 0x84, 0x0C, 0x60, 0x43, 0x02, 0x10, 0x10, 0x81, 0x8C, 0x0C, 0x60,
  0x43, 0x06, 0x18, 0x30, 0xC3, 0x0F, 0x30, 0x6F, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x06, 0x01, 0xF4, 0x63,
  0x98, 0x72, 0x04, 0xC1, 0x90, 0x32, 0x06, 0xC0, 0xD8, 0x13, 0x02, 0x60,
  0xC8, 0x19, 0x87, 0x30, 0xC6, 0x38, 0x7B, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x01, 0x8D, 0xC7, 0x03, 0x01, 0x80, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x00, 0x0F, 0x0F, 0xCC, 0x24, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x30, 0x19, 0x18, 0xFC, 0x00, 0x18, 0x61, 0x04,
  0x7C, 0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x08, 0x38,
  0x30, 0x66, 0x08, 0xC3, 0x10, 0x66, 0x0C, 0xC1, 0x18, 0x22, 0x0C, 0x41,
  0x98, 0x33, 0x04, 0x61, 0x88, 0x31, 0x0E, 0x33, 0xC7, 0xD0, 0x81, 0xC1,
  0xA0, 0xD0, 0x48, 0x64, 0x22, 0x31, 0x10, 0x98, 0x4C, 0x24, 0x16, 0x0A,
  0x07, 0x03, 0x01, 0x80, 0xC3, 0x07, 0x06, 0x0A, 0x0C, 0x34, 0x38, 0x48,
  0x51, 0x91, 0xA3, 0x22, 0x44, 0x4C, 0x98, 0x99, 0x21, 0x22, 0x42, 0xC5,
  0x85, 0x0A, 0x0A, 0x1C, 0x1C, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x18, 0x70,
  0x86, 0x0C, 0xC0, 0xC8, 0x0D, 0x80, 0x50, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xA0, 0x1A, 0x03, 0x30, 0x33, 0x06, 0x30, 0x41, 0x0C, 0x18, 0x06, 0x0C,
  0x18, 0x30, 0x61, 0x81, 0x86, 0x06, 0x10, 0x18, 0xC0, 0x62, 0x01, 0x98,
  0x06, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0xA0, 0x07, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x0F, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0xF8,
  0x01, 0xE0, 0x70, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x07, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xF0, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x1C,
  0x01, 0xC0, 0xE0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x1E, 0x03, 0x80, 0x00, 0x10, 0x1F, 0x86, 0x1F,
  0xC0, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 22, 7, 0, -22 },
  { 21, 7, 8, 9, 3, -22 },
  { 28, 13, 22, 12, 0, -22 },
  { 64, 12, 26, 11, 0, -24 },
  { 103, 15, 22, 17, 1, -22 },
  { 145, 11, 22, 12, 0, -22 },
  { 176, 3, 8, 5, 3, -22 },
  { 179, 9, 27, 8, 1, -22 },
  { 210, 9, 27, 8, -2, -22 },
  { 241, 9, 10, 11, 3, -24 },
  { 253, 11, 14, 13, 1, -18 },
  { 273, 4, 7, 6, -1, -3 },
  { 277, 6, 1, 8, 1, -9 },
  { 278, 3, 3, 6, 0, -3 },
  { 280, 13, 22, 10, -1, -22 },
  { 316, 10, 22, 11, 1, -22 },
  { 344, 7, 22, 11, 3, -22 },
  { 364, 12, 22, 11, -1, -22 },
  { 397, 13, 22, 11, -1, -22 },
  { 433, 13, 22, 11, -1, -22 },
  { 469, 13, 22, 11, -1, -22 },
  { 505, 11, 22, 11, 1, -22 },
  { 536, 12, 22, 11, 1, -22 },
  { 569, 12, 22, 11, 0, -22 },
  { 602, 11, 22, 11, 0, -22 },
  { 633, 5, 17, 6, 0, -17 },
  { 644, 7, 21, 6, -1, -17 },
  { 663, 11, 14, 13, 1, -18 },
  { 683, 11, 8, 13, 1, -15 },
  { 694, 11, 14, 13, 1, -18 },
  { 714, 10, 22, 8, 0, -22 },
  { 742, 16, 25, 17, 1, -22 },
  { 792, 11, 22, 11, -2, -22 },
  { 823, 13, 22, 12, 0, -22 },
  { 859, 13, 22, 11, 1, -22 },
  { 895, 13, 22, 14, 0, -22 },
  { 931, 12, 22, 11, 0, -22 },
  { 964, 12, 22, 10, 0, -22 },
  { 997, 14, 22, 15, 1, -22 },
  { 1036, 15, 22, 14, 0, -22 },
  { 1078, 11, 22, 7, -2, -22 },
  { 1109, 10, 28, 6, -4, -22 },
  { 1144, 14, 22, 12, 0, -22 },
  { 1183, 8, 22, 10, 0, -22 },
  { 1205, 20, 22, 19, 0, -22 },
  { 1260, 16, 22, 15, 0, -22 },
  { 1304, 13, 22, 15, 1, -22 },
  { 1340, 12, 22, 12, 0, -22 },
  { 1373, 13, 27, 15, 1, -22 },
  { 1417, 12, 22, 12, 0, -22 },
  { 1450, 13, 22, 11, -1, -22 },
  { 1486, 10, 22, 10, 2, -22 },
  { 1514, 14, 22, 14, 1, -22 },
  { 1553, 11, 22, 12, 3, -22 },
  { 1584, 20, 22, 19, 2, -22 },
  { 1639, 15, 22, 10, -2, -22 },
  { 1681, 11, 22, 10, 2, -22 },
  { 1712, 13, 22, 10, -1, -22 },
  { 1748, 12, 27, 9, -1, -22 },
  { 1789, 5, 22, 10, 3, -22 },
  { 1803, 11, 27, 9, -2, -22 },
  { 1841, 11, 11, 12, 1, -22 },
  { 1857, 9, 1, 9, -3, 3 },
  { 1859, 3, 5, 7, 5, -24 },
  { 1861, 11, 17, 12, 1, -17 },
  { 1885, 12, 24, 12, 0, -24 },
  { 1921, 9, 17, 9, 1, -17 },
  { 1941, 13, 24, 12, 1, -24 },
  { 1980, 9, 17, 11, 1, -17 },
  { 2000, 14, 31, 6, -4, -24 },
  { 2055, 13, 24, 12, -1, -17 },
  { 2094, 11, 24, 12, 0, -24 },
  { 2127, 6, 22, 5, 0, -22 },
  { 2144, 11, 29, 5, -4, -22 },
  { 2184, 11, 24, 10, 0, -24 },
  { 2217, 7, 24, 5, 0, -24 },
  { 2238, 17, 17, 18, 0, -17 },
  { 2275, 11, 17, 12, 0, -17 },
  { 2299, 10, 17, 12, 1, -17 },
  { 2321, 13, 24, 12, -1, -17 },
  { 2360, 11, 24, 12, 1, -17 },
  { 2393, 9, 17, 8, 0, -17 },
  { 2413, 9, 17, 9, 0, -17 },
  { 2433, 6, 20, 7, 1, -20 },
  { 2448, 11, 16, 12, 1, -16 },
  { 2470, 9, 16, 9, 2, -16 },
  { 2488, 15, 16, 16, 2, -16 },
  { 2518, 12, 16, 10, -1, -16 },
  { 2542, 14, 24, 10, -3, -16 },
  { 2584, 10, 16, 8, -1, -16 },
  { 2604, 11, 27, 10, 1, -22 },
  { 2642, 1, 31, 11, 5, -24 },
  { 2646, 11, 27, 10, -2, -22 },
  { 2684, 11, 4, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC31PT7B_H_
