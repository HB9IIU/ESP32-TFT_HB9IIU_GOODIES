#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x60, 0xE0, 0x60, 0x63, 0x63, 0x63, 0x42, 0xC6, 0xC6, 0xC6, 0x84, 0x84,
  0x00, 0xC6, 0x01, 0x0C, 0x06, 0x10, 0x0C, 0x60, 0x10, 0xC0, 0x61, 0x00,
  0xC6, 0x0F, 0xFF, 0x1F, 0xFE, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x00, 0xC2,
  0x01, 0x8C, 0x02, 0x18, 0x0C, 0x20, 0xFF, 0xF9, 0xFF, 0xF0, 0xC2, 0x01,
  0x8C, 0x02, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x31, 0x80, 0x42, 0x01, 0x8C,
  0x00, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x7E, 0x07, 0xFC, 0x31, 0x10,
  0x8C, 0x06, 0x20, 0x18, 0x80, 0x62, 0x01, 0x98, 0x03, 0x40, 0x0D, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x02, 0xC0, 0x09, 0x80, 0x26, 0x00, 0x88,
  0x06, 0x20, 0x11, 0x80, 0x46, 0x21, 0x38, 0xE7, 0xC3, 0xFC, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0xC3, 0x30,
  0x20, 0x84, 0x18, 0x61, 0x0C, 0x18, 0x43, 0x04, 0x31, 0x83, 0x0C, 0x60,
  0xC3, 0x30, 0x30, 0xCC, 0x0C, 0x26, 0x02, 0x19, 0x9E, 0x86, 0xCD, 0xA1,
  0x36, 0x2C, 0xD9, 0x8F, 0xE6, 0xC3, 0x73, 0x30, 0x80, 0xC8, 0x20, 0x62,
  0x18, 0x19, 0x86, 0x0C, 0x61, 0x83, 0x18, 0x41, 0x86, 0x30, 0x61, 0x8C,
  0x30, 0x62, 0x0C, 0x19, 0x86, 0x03, 0xC0, 0x00, 0xC0, 0x1F, 0x81, 0x8C,
  0x0C, 0x60, 0x63, 0x02, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0x60, 0x26, 0x01,
  0xB0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x6C, 0x06, 0x63, 0x33, 0x1B, 0x0C,
  0xF0, 0x6D, 0x83, 0x6C, 0x0E, 0x60, 0x73, 0x03, 0x18, 0x3C, 0xC1, 0xE7,
  0xFB, 0x1F, 0x9C, 0x6D, 0xBD, 0xB6, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x08,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x06, 0x01, 0x08, 0x43, 0x90,
  0x75, 0xC3, 0xF1, 0xC0, 0xD8, 0x62, 0x30, 0xC0, 0x10, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x1F, 0x01, 0x8C, 0x18, 0x60,
  0xC1, 0x0C, 0x08, 0x60, 0x66, 0x02, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0,
  0x66, 0x03, 0x30, 0x1B, 0x00, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x81, 0x8C, 0x0C, 0x60, 0xC3, 0x06, 0x18, 0x70, 0xC3, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0x0E, 0x3E, 0x76, 0xE6, 0x46, 0x0C, 0x0C, 0x0C, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0x00, 0xF0, 0x07, 0xF0, 0x1C, 0x70, 0x20, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0xF0, 0x18, 0x30,
  0x20, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x80, 0xC1, 0xE7, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80, 0x12, 0x00, 0x6C,
  0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x10, 0x80, 0x63, 0x01, 0x86, 0x02,
  0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x81, 0x83, 0xFF, 0xCF, 0xFF,
  0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x03, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x40, 0x60, 0xF7, 0x81, 0xFE,
  0x00, 0x00, 0x78, 0x0F, 0xC0, 0xE0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xCF, 0x87, 0xDE, 0x38, 0x33,
  0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60,
  0x63, 0x03, 0x18, 0x38, 0xE1, 0x83, 0xB8, 0x0F, 0x80, 0x1F, 0xFC, 0x80,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x61,
  0x83, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x30,
  0x60, 0xC3, 0x01, 0xB8, 0x07, 0xC0, 0x1E, 0x01, 0xDC, 0x0E, 0x30, 0x70,
  0x61, 0x81, 0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x30,
  0x18, 0xE0, 0xC1, 0xCF, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0x8E,
  0x18, 0x31, 0xC1, 0x8C, 0x0C, 0x60, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC,
  0x06, 0x60, 0x33, 0x03, 0x98, 0x1C, 0xE1, 0x63, 0xF6, 0x0F, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x04,
  0xF0, 0x3F, 0x00, 0x04, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x8E, 0x30, 0x01, 0x01, 0xC0, 0xC0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x60,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x00, 0x38, 0x07, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x10, 0x00, 0x07, 0x0F, 0xE3, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x07,
  0x06, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x18, 0xC0,
  0x03, 0x10, 0x7C, 0x66, 0x19, 0x8C, 0x86, 0x31, 0x90, 0x86, 0x36, 0x30,
  0x84, 0xC6, 0x30, 0x90, 0x86, 0x32, 0x30, 0x86, 0xC6, 0x30, 0x98, 0xC6,
  0x13, 0x10, 0xC6, 0x62, 0x38, 0x8C, 0x67, 0x31, 0x8F, 0x3C, 0x30, 0xC7,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x8C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01, 0x98, 0x0C, 0xC0, 0xC6,
  0x06, 0x30, 0x31, 0x83, 0x0C, 0x18, 0x61, 0x83, 0x0F, 0xF8, 0xFF, 0xC6,
  0x06, 0x30, 0x33, 0x01, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1E, 0x00,
  0xF0, 0x06, 0x07, 0xF8, 0x0C, 0x38, 0x18, 0x38, 0x30, 0x30, 0x60, 0x61,
  0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0C, 0x18, 0x38, 0x60, 0xE0, 0xFF,
  0x81, 0xFE, 0x03, 0x0E, 0x0E, 0x0E, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30,
  0xC0, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x30, 0x70, 0xFF,
  0xC1, 0xFE, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x0E, 0x08, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x7B, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x06, 0x3C, 0x06, 0x0E,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x07, 0x0C, 0x07, 0x0C, 0x07,
  0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x60, 0x30,
  0x60, 0x70, 0x60, 0xE0, 0x61, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xFE,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFE, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xF0, 0x60, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x01, 0xF1, 0x81, 0xF9, 0xC0, 0x0C, 0xC0, 0x0C,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC7, 0x00, 0xC1, 0x80,
  0x60, 0xC0, 0x30, 0x70, 0x18, 0x1F, 0x78, 0x07, 0xFC, 0x00, 0x07, 0x00,
  0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x60, 0x7F,
  0xF8, 0x1F, 0xFE, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C,
  0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x18, 0x06, 0x06,
  0x01, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x00, 0x07, 0xF8, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x07, 0xF0, 0x00, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F, 0x00, 0xE0, 0x00, 0x07, 0x03,
  0x83, 0x03, 0x01, 0x83, 0x80, 0xC1, 0x80, 0x61, 0x80, 0x61, 0xC0, 0x30,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x03, 0x60, 0x01,
  0xF8, 0x00, 0xEC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0x60,
  0x0C, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x07, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x38, 0x00, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E,
  0x05, 0x80, 0x34, 0x0D, 0x80, 0x3C, 0x0D, 0x80, 0x6C, 0x0D, 0x80, 0x6C,
  0x0D, 0x80, 0xCC, 0x09, 0x80, 0xD8, 0x19, 0x81, 0x98, 0x19, 0x81, 0x98,
  0x19, 0x83, 0x18, 0x19, 0x83, 0x18, 0x31, 0x82, 0x30, 0x31, 0x86, 0x30,
  0x31, 0x86, 0x30, 0x31, 0x8C, 0x30, 0x30, 0x8C, 0x20, 0x60, 0x98, 0x60,
  0x60, 0x98, 0x60, 0x60, 0xB0, 0x60, 0x60, 0xB0, 0x60, 0x40, 0xE0, 0xC0,
  0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x07, 0x00, 0x60, 0xE0, 0x18, 0x1E,
  0x03, 0x03, 0xC0, 0x60, 0x58, 0x0C, 0x1B, 0x03, 0x03, 0x60, 0x60, 0x64,
  0x0C, 0x0C, 0xC1, 0x81, 0x18, 0x30, 0x63, 0x0C, 0x0C, 0x61, 0x81, 0x8C,
  0x30, 0x30, 0x86, 0x0C, 0x18, 0xC1, 0x83, 0x30, 0x30, 0x66, 0x06, 0x0C,
  0xC0, 0xC1, 0x98, 0x30, 0x1A, 0x06, 0x03, 0xC0, 0xC0, 0x78, 0x18, 0x0F,
  0x03, 0x01, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x00, 0x00, 0x70, 0x01, 0xFC,
  0x03, 0x8E, 0x06, 0x06, 0x0C, 0x07, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C,
  0xC0, 0x18, 0xC0, 0x18, 0xE0, 0x30, 0x60, 0x70, 0x60, 0xE0, 0x3B, 0xC0,
  0x1F, 0x80, 0x07, 0xF0, 0x0C, 0x78, 0x18, 0x30, 0x30, 0x60, 0x60, 0xE1,
  0x80, 0xC3, 0x03, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x60, 0xC0,
  0xC1, 0x87, 0x03, 0xFC, 0x0F, 0xF0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x01, 0xFC, 0x03, 0x8E, 0x06, 0x06, 0x0C,
  0x07, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xE0,
  0x30, 0x60, 0x70, 0x60, 0xE0, 0x3B, 0xC0, 0x1F, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x07, 0xF0, 0x0C,
  0x78, 0x18, 0x30, 0x30, 0x60, 0x60, 0xE1, 0x81, 0xC3, 0x03, 0x86, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x60, 0x60, 0xC1, 0xC1, 0x87, 0x03, 0xFC, 0x0F,
  0xE0, 0x18, 0xC0, 0x31, 0x80, 0x61, 0x80, 0xC3, 0x03, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0xC0, 0x61, 0x80, 0xC0, 0x00, 0x78,
  0x07, 0xFC, 0x1E, 0x18, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x80, 0xE1, 0xFF, 0x81, 0xFE,
  0x00, 0x7F, 0xF8, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x18,
  0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0x60, 0xC0, 0x7B, 0xC0, 0x3F, 0x00,
  0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06,
  0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x03, 0x0C,
  0x0C, 0x70, 0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xD8,
  0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x38,
  0x07, 0x80, 0x60, 0x1B, 0x00, 0xC0, 0x36, 0x03, 0x80, 0xCC, 0x05, 0x01,
  0x98, 0x1A, 0x03, 0x30, 0x34, 0x0C, 0x60, 0x48, 0x18, 0xC1, 0x90, 0x61,
  0x83, 0x60, 0xC3, 0x0C, 0xC1, 0x86, 0x19, 0x86, 0x0C, 0x23, 0x0C, 0x18,
  0xC6, 0x30, 0x31, 0x8C, 0x60, 0x66, 0x18, 0xC0, 0xCC, 0x33, 0x01, 0x90,
  0x66, 0x03, 0x60, 0xD8, 0x06, 0xC1, 0xB0, 0x0F, 0x03, 0x60, 0x1E, 0x07,
  0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x70,
  0x00, 0x03, 0x01, 0x81, 0x81, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x06,
  0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x38, 0x00, 0xC0, 0x3C, 0x06,
  0xC0, 0x6C, 0x0C, 0x61, 0xC6, 0x18, 0x63, 0x06, 0x30, 0x66, 0x06, 0x60,
  0x6C, 0x06, 0xC0, 0x78, 0x07, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0xC6, 0x31, 0x8C, 0x21, 0x8C, 0x63, 0x18, 0xC2, 0x10, 0xC6,
  0x31, 0x8C, 0x61, 0x0C, 0x63, 0x18, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xC0, 0xFC,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x30, 0x61,
  0x83, 0x04, 0x30, 0x31, 0x81, 0x98, 0x07, 0x80, 0x3C, 0x01, 0x80, 0xFF,
  0xFF, 0xF8, 0xE3, 0x08, 0x61, 0x0C, 0x03, 0xCC, 0x3F, 0xA1, 0xC3, 0x86,
  0x0E, 0x30, 0x38, 0xC0, 0xE7, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCC,
  0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x30, 0x30, 0xC1, 0xC3,
  0x07, 0x07, 0x6C, 0x1F, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0xF0, 0x37, 0xE0, 0xE1,
  0x83, 0x87, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0xC0,
  0x63, 0x01, 0x8C, 0x06, 0x30, 0x19, 0x80, 0xC6, 0x03, 0x18, 0x1C, 0x60,
  0x61, 0x43, 0x0D, 0x9C, 0x33, 0xE0, 0x03, 0xE1, 0xFC, 0x70, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0xC8, 0x1F, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x03, 0xCC, 0x1F, 0xF0, 0x70, 0xE0, 0xC1, 0xC3, 0x03, 0x86, 0x07,
  0x1C, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x63, 0x00, 0x86, 0x03, 0x0C,
  0x06, 0x18, 0x0C, 0x30, 0x38, 0x60, 0x60, 0xC1, 0xC1, 0x83, 0x81, 0xDB,
  0x03, 0xE6, 0x00, 0x03, 0xC1, 0xFC, 0x71, 0x8C, 0x13, 0x02, 0x60, 0xD8,
  0x1B, 0x06, 0x61, 0xDF, 0xE3, 0xF0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0xCE, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0E, 0x40,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF3, 0x03, 0xFA, 0x03, 0x0E, 0x06, 0x0E, 0x0C, 0x0E,
  0x0C, 0x0E, 0x1C, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x08,
  0x30, 0x18, 0x30, 0x18, 0x30, 0x18, 0x30, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x30, 0x70, 0x1D, 0xB0, 0x1F, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x81, 0x80, 0xFF, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0xF0, 0x6F, 0xC3, 0x86, 0x18, 0x31, 0xC1, 0x8C, 0x0C, 0x60,
  0x63, 0x03, 0x10, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x02, 0x10, 0x31,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x06, 0x30, 0x31, 0x81, 0x80, 0x02, 0x07,
  0x07, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x3E, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x1C, 0x30, 0x60, 0xC3, 0x03, 0x18, 0x18, 0xE0, 0x63,
  0x01, 0x98, 0x06, 0xC0, 0x17, 0x00, 0xDC, 0x03, 0xF0, 0x0E, 0xC0, 0x31,
  0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x0C, 0x0C, 0x30,
  0x30, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x60, 0xC0, 0xC0, 0x0C, 0xF1, 0xE0, 0xFF, 0xBF, 0x0A, 0x1C,
  0x30, 0xC1, 0xC3, 0x1C, 0x18, 0x31, 0x81, 0x83, 0x18, 0x18, 0x31, 0x83,
  0x03, 0x10, 0x30, 0x33, 0x03, 0x06, 0x30, 0x30, 0x63, 0x02, 0x06, 0x30,
  0x60, 0x66, 0x06, 0x04, 0x60, 0x60, 0xC6, 0x06, 0x0C, 0x60, 0xC0, 0xC6,
  0x0C, 0x0C, 0xC0, 0xC1, 0x8C, 0x0C, 0x18, 0x0C, 0xF0, 0x6F, 0xC2, 0x86,
  0x18, 0x31, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x31, 0x81, 0x8C,
  0x0C, 0x60, 0x63, 0x02, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x06,
  0x30, 0x31, 0x81, 0x80, 0x03, 0xC0, 0xFE, 0x1C, 0x71, 0x83, 0x30, 0x33,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0x77, 0x03, 0xE0, 0x03, 0x3C,
  0x03, 0x7E, 0x03, 0xC6, 0x03, 0x83, 0x07, 0x03, 0x07, 0x03, 0x06, 0x03,
  0x06, 0x03, 0x04, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06,
  0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x1C, 0x30, 0x36, 0xF0,
  0x33, 0xE0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0xCC, 0x3F, 0xA0,
  0xC3, 0x86, 0x0E, 0x30, 0x38, 0xC0, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x31,
  0x80, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x30, 0x30,
  0xC1, 0xC3, 0x07, 0x07, 0x6C, 0x1F, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0xE1, 0xBC, 0x2C, 0x07, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x00, 0x07, 0xC3, 0xFC, 0x60, 0x98, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0C, 0x03, 0x10, 0x63, 0x3C, 0x7E, 0x00, 0x0C, 0x0C, 0x08, 0x18, 0x1F,
  0x7E, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE8, 0xF0, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x20, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x60, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0xC6, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x38, 0xC1, 0xC6, 0x14,
  0x3B, 0xE0, 0xFB, 0x00, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x19, 0x83,
  0x30, 0xC6, 0x18, 0xC3, 0x18, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0xB0, 0x36,
  0x06, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x00, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x0B, 0x07, 0x06, 0xC1, 0x41, 0xB0, 0xD0, 0xCC, 0x34, 0x33,
  0x19, 0x08, 0xC6, 0x46, 0x31, 0x11, 0x8C, 0xC4, 0xC3, 0x31, 0x30, 0xD8,
  0x48, 0x36, 0x36, 0x0D, 0x0D, 0x83, 0xC3, 0x40, 0xF0, 0xF0, 0x38, 0x38,
  0x0E, 0x0E, 0x03, 0x03, 0x80, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0xC0, 0x33, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x68, 0x01, 0x98, 0x03, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x60, 0x81, 0x81, 0x87, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x18, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1A, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xF0, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xF8, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x03, 0xE0, 0x18, 0x00, 0x3C, 0x0B, 0xF8, 0x70,
  0xFF, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 26, 8, 0, -26 },
  { 27, 8, 9, 11, 4, -26 },
  { 36, 15, 26, 15, 0, -26 },
  { 85, 14, 30, 14, 0, -28 },
  { 138, 18, 27, 21, 2, -27 },
  { 199, 13, 27, 14, 0, -27 },
  { 243, 3, 9, 6, 4, -26 },
  { 247, 10, 32, 9, 1, -26 },
  { 287, 11, 32, 9, -3, -26 },
  { 331, 10, 11, 13, 4, -28 },
  { 345, 13, 18, 15, 1, -22 },
  { 375, 6, 9, 7, -2, -4 },
  { 382, 8, 2, 10, 1, -11 },
  { 384, 2, 3, 7, 1, -3 },
  { 385, 16, 26, 12, -2, -26 },
  { 437, 13, 27, 14, 1, -27 },
  { 481, 8, 26, 14, 4, -26 },
  { 507, 15, 27, 14, -1, -27 },
  { 558, 15, 27, 14, -1, -27 },
  { 609, 15, 27, 14, -1, -27 },
  { 660, 15, 26, 14, -1, -26 },
  { 709, 13, 27, 14, 1, -27 },
  { 753, 14, 26, 14, 1, -26 },
  { 799, 14, 27, 14, 0, -27 },
  { 847, 13, 27, 14, 0, -27 },
  { 891, 6, 20, 7, 0, -20 },
  { 906, 9, 25, 7, -2, -20 },
  { 935, 13, 16, 15, 1, -21 },
  { 961, 13, 10, 15, 1, -18 },
  { 978, 13, 16, 15, 1, -21 },
  { 1004, 10, 27, 10, 1, -27 },
  { 1038, 19, 30, 20, 1, -27 },
  { 1110, 13, 27, 14, -2, -27 },
  { 1154, 15, 26, 15, 0, -26 },
  { 1203, 15, 27, 13, 1, -27 },
  { 1254, 16, 26, 16, 0, -26 },
  { 1306, 15, 26, 13, 0, -26 },
  { 1355, 15, 26, 12, 0, -26 },
  { 1404, 17, 27, 17, 1, -27 },
  { 1462, 18, 26, 17, 0, -26 },
  { 1521, 13, 26, 8, -2, -26 },
  { 1564, 13, 33, 7, -5, -26 },
  { 1618, 17, 26, 14, 0, -26 },
  { 1674, 9, 26, 12, 0, -26 },
  { 1704, 24, 26, 23, 0, -26 },
  { 1782, 19, 26, 18, 0, -26 },
  { 1844, 16, 27, 17, 1, -27 },
  { 1898, 15, 26, 14, 0, -26 },
  { 1947, 16, 33, 17, 1, -27 },
  { 2013, 15, 26, 14, 0, -26 },
  { 2062, 15, 27, 13, -1, -27 },
  { 2113, 13, 26, 12, 2, -26 },
  { 2156, 16, 26, 17, 1, -26 },
  { 2208, 14, 26, 14, 3, -26 },
  { 2254, 23, 26, 23, 3, -26 },
  { 2329, 17, 26, 12, -2, -26 },
  { 2385, 12, 26, 12, 3, -26 },
  { 2424, 16, 26, 12, -2, -26 },
  { 2476, 14, 33, 10, -1, -27 },
  { 2534, 5, 26, 12, 4, -26 },
  { 2551, 13, 33, 10, -2, -27 },
  { 2605, 13, 13, 15, 1, -26 },
  { 2627, 11, 2, 10, -3, 3 },
  { 2630, 5, 6, 8, 5, -28 },
  { 2634, 14, 20, 15, 1, -20 },
  { 2669, 14, 28, 15, 0, -28 },
  { 2718, 11, 20, 11, 1, -20 },
  { 2746, 15, 28, 15, 1, -28 },
  { 2799, 11, 20, 13, 1, -20 },
  { 2827, 17, 37, 8, -5, -28 },
  { 2906, 16, 29, 15, -1, -20 },
  { 2964, 13, 28, 14, 0, -28 },
  { 3010, 8, 27, 6, 0, -27 },
  { 3037, 13, 36, 7, -5, -27 },
  { 3096, 14, 28, 12, 0, -28 },
  { 3145, 8, 28, 6, 0, -28 },
  { 3173, 20, 20, 21, 0, -20 },
  { 3223, 13, 20, 14, 0, -20 },
  { 3256, 12, 20, 14, 1, -20 },
  { 3286, 16, 29, 15, -2, -20 },
  { 3344, 14, 29, 15, 1, -20 },
  { 3395, 11, 20, 9, 0, -20 },
  { 3423, 11, 20, 11, 0, -20 },
  { 3451, 8, 24, 8, 1, -24 },
  { 3475, 13, 20, 14, 1, -20 },
  { 3508, 11, 20, 11, 2, -20 },
  { 3536, 18, 20, 19, 2, -20 },
  { 3581, 15, 20, 12, -2, -20 },
  { 3619, 18, 29, 12, -4, -20 },
  { 3685, 12, 20, 10, -1, -20 },
  { 3715, 13, 32, 12, 1, -26 },
  { 3767, 1, 37, 13, 6, -28 },
  { 3772, 13, 32, 12, -2, -26 },
  { 3824, 13, 4, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC37PT7B_H_
