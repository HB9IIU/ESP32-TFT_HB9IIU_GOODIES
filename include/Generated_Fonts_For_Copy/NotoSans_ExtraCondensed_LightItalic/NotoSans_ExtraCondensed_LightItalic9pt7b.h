#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xF0, 0x57, 0x6A, 0xCC, 0x2E, 0xA6, 0xF4, 0x43, 0xA9,
  0xF5, 0xB5, 0xC0, 0x2D, 0xAF, 0x78, 0xC0, 0x6A, 0x49, 0x20, 0x24, 0x92,
  0xB0, 0x7C, 0x4F, 0x44, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x2E, 0xDB,
  0x70, 0xD6, 0xA0, 0x64, 0x95, 0x30, 0x64, 0xA2, 0x70, 0x24, 0xBB, 0xD0,
  0x69, 0x13, 0x80, 0x34, 0x8E, 0xAA, 0xE0, 0x72, 0x24, 0x48, 0x2D, 0xAB,
  0x78, 0x2E, 0xD6, 0x70, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3,
  0x68, 0x44, 0xA8, 0x20, 0x7B, 0xF7, 0xDF, 0x41, 0x80, 0x13, 0x37, 0x59,
  0x75, 0x6A, 0xAE, 0x34, 0x48, 0x88, 0xE0, 0x75, 0x99, 0xAC, 0x74, 0x68,
  0x8C, 0x74, 0xE8, 0x88, 0x34, 0x48, 0xB9, 0x70, 0x55, 0x79, 0x9A, 0x69,
  0x49, 0x00, 0x25, 0x24, 0x94, 0x56, 0x4C, 0xAA, 0x5A, 0xB0, 0x45, 0x2D,
  0xAE, 0xAA, 0xA0, 0x4A, 0xAD, 0x6B, 0x50, 0x25, 0x59, 0x99, 0xE0, 0x75,
  0xAC, 0x88, 0x25, 0x59, 0x99, 0xE2, 0x20, 0x75, 0xEA, 0xAA, 0x34, 0x84,
  0x22, 0xC0, 0xF2, 0x49, 0x00, 0x55, 0x99, 0xAE, 0xB7, 0x49, 0x00, 0xAD,
  0x7D, 0x6A, 0x50, 0x39, 0x88, 0x46, 0x68, 0xFA, 0x49, 0x00, 0x65, 0x29,
  0x80, 0x69, 0x49, 0x20, 0xFC, 0x31, 0x22, 0x22, 0xC0, 0x66, 0x90, 0xE0,
  0xC0, 0x79, 0xAA, 0xE0, 0x49, 0xBB, 0x78, 0x72, 0x4E, 0x11, 0x69, 0xAA,
  0xE0, 0x77, 0x4E, 0x12, 0x62, 0x44, 0x44, 0x80, 0x79, 0xAA, 0xE2, 0xC0,
  0x49, 0xBB, 0x68, 0x46, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x49, 0xD5, 0xA8,
  0x56, 0xA8, 0x7B, 0x6B, 0x5A, 0x80, 0x6E, 0xDA, 0x76, 0xDE, 0x6E, 0xDF,
  0x20, 0x79, 0xAA, 0xE2, 0x40, 0x6A, 0x48, 0x71, 0x2C, 0x5A, 0xA0, 0x76,
  0xDC, 0xFA, 0x80, 0xAD, 0x7C, 0xAA, 0x00, 0xA9, 0x2C, 0x55, 0x52, 0x24,
  0xC0, 0x69, 0x4C, 0x29, 0x45, 0x30, 0xFF, 0x80, 0x22, 0x21, 0x24, 0xC0,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 8, 3, 0, -7 },
  { 10, 5, 7, 5, 0, -7 },
  { 15, 3, 7, 3, 0, -7 },
  { 18, 1, 2, 1, 1, -6 },
  { 19, 3, 7, 2, 0, -6 },
  { 22, 3, 7, 2, -1, -6 },
  { 25, 2, 3, 3, 1, -7 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 3, 7, 3, 0, -7 },
  { 37, 2, 6, 3, 1, -6 },
  { 39, 3, 7, 3, 0, -7 },
  { 42, 3, 7, 3, 0, -7 },
  { 45, 3, 7, 3, 0, -7 },
  { 48, 3, 6, 3, 0, -6 },
  { 51, 4, 7, 3, 0, -7 },
  { 55, 4, 6, 3, 0, -6 },
  { 58, 3, 7, 3, 0, -7 },
  { 61, 3, 7, 3, 0, -7 },
  { 64, 2, 5, 2, 0, -5 },
  { 66, 2, 6, 2, 0, -5 },
  { 68, 4, 4, 4, 0, -5 },
  { 70, 4, 2, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 3, 7, 2, 0, -7 },
  { 76, 5, 7, 5, 0, -6 },
  { 81, 4, 6, 3, -1, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 4, 7, 3, 0, -7 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 6, 3, 0, -6 },
  { 97, 4, 6, 3, 0, -6 },
  { 100, 4, 7, 4, 0, -7 },
  { 104, 4, 6, 4, 0, -6 },
  { 107, 3, 6, 2, 0, -6 },
  { 110, 3, 8, 2, -1, -6 },
  { 113, 4, 6, 3, 0, -6 },
  { 116, 2, 6, 3, 0, -6 },
  { 118, 6, 6, 6, 0, -6 },
  { 123, 5, 6, 4, 0, -6 },
  { 127, 4, 7, 4, 0, -7 },
  { 131, 4, 6, 3, 0, -6 },
  { 134, 4, 9, 4, 0, -7 },
  { 139, 4, 6, 3, 0, -6 },
  { 142, 4, 7, 3, 0, -7 },
  { 146, 3, 6, 3, 1, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 3, 6, 3, 1, -6 },
  { 155, 5, 6, 6, 1, -6 },
  { 159, 5, 6, 3, -1, -6 },
  { 163, 3, 6, 3, 1, -6 },
  { 166, 3, 6, 3, 0, -6 },
  { 169, 3, 7, 3, 0, -6 },
  { 172, 1, 6, 3, 1, -6 },
  { 173, 4, 7, 3, -1, -6 },
  { 177, 4, 3, 4, 0, -6 },
  { 179, 3, 1, 3, -1, 0 },
  { 180, 1, 2, 2, 1, -7 },
  { 181, 4, 5, 4, 0, -5 },
  { 184, 3, 7, 4, 0, -7 },
  { 187, 3, 5, 3, 0, -5 },
  { 189, 4, 7, 4, 0, -7 },
  { 193, 3, 5, 3, 0, -5 },
  { 195, 4, 9, 2, -1, -7 },
  { 200, 4, 7, 4, 0, -5 },
  { 204, 3, 7, 3, 0, -7 },
  { 207, 2, 7, 2, 0, -7 },
  { 209, 3, 9, 2, -1, -7 },
  { 213, 3, 7, 3, 0, -7 },
  { 216, 2, 7, 2, 0, -7 },
  { 218, 5, 5, 5, 0, -5 },
  { 222, 3, 5, 3, 0, -5 },
  { 224, 3, 5, 3, 0, -5 },
  { 226, 3, 7, 4, 0, -5 },
  { 229, 4, 7, 4, 0, -5 },
  { 233, 3, 5, 2, 0, -5 },
  { 235, 3, 5, 3, 0, -5 },
  { 237, 2, 6, 2, 0, -6 },
  { 239, 3, 5, 3, 0, -5 },
  { 241, 2, 5, 3, 1, -5 },
  { 243, 5, 5, 5, 0, -5 },
  { 247, 3, 5, 3, 0, -5 },
  { 249, 4, 7, 3, -1, -5 },
  { 253, 3, 5, 2, 0, -5 },
  { 255, 3, 7, 3, 0, -6 },
  { 258, 1, 9, 3, 1, -7 },
  { 260, 4, 7, 3, -1, -6 },
  { 264, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC9PT7B_H_
