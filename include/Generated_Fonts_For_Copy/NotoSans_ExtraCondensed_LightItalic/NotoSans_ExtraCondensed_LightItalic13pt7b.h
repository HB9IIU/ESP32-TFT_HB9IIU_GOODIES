#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0x80, 0x29, 0x5E, 0x65, 0x79, 0x94,
  0xA0, 0x11, 0xD4, 0xC6, 0x10, 0xC6, 0xD3, 0x10, 0xEA, 0xAB, 0x36, 0xF4,
  0xD5, 0x55, 0x98, 0x32, 0x94, 0x46, 0x56, 0x52, 0xF0, 0x68, 0x12, 0x44,
  0x48, 0x88, 0x88, 0x40, 0x31, 0x11, 0x11, 0x22, 0x24, 0x80, 0x2B, 0x6A,
  0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x3A, 0x52, 0x98, 0xCA, 0x52, 0x60, 0x74, 0xA4, 0x92, 0x80,
  0x78, 0x42, 0x21, 0x11, 0x10, 0xE0, 0x78, 0x42, 0x26, 0x08, 0x42, 0xE0,
  0x18, 0x8C, 0xA5, 0x4B, 0xC4, 0x20, 0x3A, 0x10, 0xC1, 0x08, 0x42, 0xE0,
  0x3A, 0x10, 0xE5, 0x4A, 0x52, 0x60, 0x78, 0x44, 0x22, 0x11, 0x08, 0xC0,
  0x7A, 0x52, 0xA6, 0x4A, 0x52, 0xE0, 0x7A, 0x52, 0x95, 0x18, 0x44, 0xE0,
  0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x19, 0x30, 0x60, 0x80, 0xF8, 0x3E,
  0xC1, 0x82, 0x6C, 0x00, 0x71, 0x12, 0x44, 0x80, 0x80, 0x1E, 0x45, 0x2A,
  0xDA, 0xB5, 0x6D, 0x54, 0x80, 0xE0, 0x08, 0xC6, 0x52, 0x9D, 0x29, 0x88,
  0x3A, 0x52, 0x97, 0x26, 0x32, 0xE0, 0x3C, 0x84, 0x10, 0x82, 0x08, 0x20,
  0x70, 0x3A, 0x52, 0x94, 0xA6, 0x32, 0xE0, 0x3A, 0x10, 0x87, 0x22, 0x10,
  0xE0, 0x3A, 0x10, 0x87, 0x22, 0x10, 0x80, 0x3C, 0x84, 0x10, 0x8E, 0x28,
  0xA2, 0x78, 0x25, 0x14, 0x51, 0x79, 0x28, 0xA2, 0x88, 0x38, 0x88, 0x42,
  0x10, 0x88, 0xE0, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x30, 0x2D, 0x25,
  0x18, 0x61, 0x89, 0x24, 0x90, 0x29, 0x24, 0xA4, 0xE0, 0x21, 0x23, 0x63,
  0x65, 0x66, 0x6A, 0xAA, 0xB2, 0x92, 0x22, 0x49, 0x92, 0xA5, 0x4B, 0x26,
  0x44, 0x88, 0x3D, 0x14, 0x51, 0x86, 0x18, 0xA2, 0x70, 0x3A, 0x52, 0x97,
  0x22, 0x10, 0x80, 0x3D, 0x14, 0x51, 0x86, 0x18, 0xA2, 0x70, 0x81, 0x00,
  0x3A, 0x52, 0x97, 0x32, 0x52, 0x90, 0x7A, 0x10, 0x82, 0x08, 0x42, 0xE0,
  0xF4, 0x44, 0x48, 0x88, 0x80, 0x25, 0x14, 0x52, 0x49, 0x28, 0xA4, 0x70,
  0x8C, 0xA5, 0x4A, 0x53, 0x18, 0x80, 0x91, 0x91, 0x92, 0xAA, 0xB4, 0xD4,
  0xD4, 0x88, 0x88, 0x24, 0x61, 0x84, 0x10, 0xC3, 0x14, 0x90, 0x99, 0xAC,
  0x48, 0x88, 0x80, 0x3C, 0x20, 0x84, 0x10, 0x82, 0x10, 0xF0, 0x32, 0x44,
  0x44, 0x88, 0x88, 0xC0, 0xA5, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x44,
  0x21, 0x38, 0x31, 0x93, 0x90, 0xF0, 0xC0, 0x3A, 0x53, 0x19, 0x49, 0xC0,
  0x21, 0x10, 0xF4, 0xA5, 0x31, 0x97, 0x00, 0x34, 0x48, 0x88, 0x60, 0x04,
  0x10, 0x8E, 0x49, 0x28, 0xA4, 0x91, 0xC0, 0x35, 0x5E, 0x88, 0x60, 0x0C,
  0x20, 0x86, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0xC0, 0x3A, 0x53, 0x19,
  0x49, 0xC2, 0x27, 0x00, 0x21, 0x10, 0xE4, 0xA5, 0x52, 0x94, 0x80, 0x21,
  0x24, 0xA4, 0x80, 0x08, 0x04, 0x21, 0x08, 0x84, 0x21, 0x09, 0x80, 0x21,
  0x10, 0x95, 0x31, 0x94, 0xA4, 0x80, 0x25, 0x24, 0x94, 0x90, 0x76, 0x95,
  0x4A, 0x99, 0x32, 0xA5, 0x00, 0x72, 0x52, 0xA9, 0x4A, 0x40, 0x32, 0x53,
  0x19, 0x49, 0x80, 0x3C, 0x92, 0x49, 0x45, 0x27, 0x10, 0x42, 0x00, 0x3A,
  0x53, 0x19, 0x49, 0xC2, 0x11, 0x00, 0x74, 0x44, 0x88, 0x80, 0x74, 0x44,
  0x22, 0xE0, 0x29, 0xA4, 0xA4, 0xC0, 0x4A, 0x52, 0xA9, 0x4B, 0xC0, 0x9A,
  0xAC, 0xC8, 0x80, 0xA6, 0x9D, 0xB6, 0xAA, 0x49, 0x00, 0x2C, 0xA3, 0x04,
  0x31, 0x4D, 0x00, 0x24, 0xA2, 0x8C, 0x30, 0x82, 0x08, 0x43, 0x00, 0x72,
  0x24, 0x48, 0xC0, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF8,
  0x30, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 5, 9, 5, 0, -9 },
  { 13, 5, 11, 5, 0, -10 },
  { 20, 6, 9, 7, 1, -9 },
  { 27, 5, 9, 5, 0, -9 },
  { 33, 2, 3, 2, 1, -9 },
  { 34, 4, 11, 3, 0, -9 },
  { 40, 4, 11, 3, -1, -9 },
  { 46, 4, 4, 4, 1, -10 },
  { 48, 5, 6, 5, 0, -8 },
  { 52, 2, 3, 2, -1, -1 },
  { 53, 3, 1, 3, 0, -4 },
  { 54, 1, 1, 2, 0, -1 },
  { 55, 6, 9, 4, -1, -9 },
  { 62, 5, 9, 5, 0, -9 },
  { 68, 3, 9, 5, 1, -9 },
  { 72, 5, 9, 5, 0, -9 },
  { 78, 5, 9, 5, 0, -9 },
  { 84, 5, 9, 5, 0, -9 },
  { 90, 5, 9, 5, 0, -9 },
  { 96, 5, 9, 5, 0, -9 },
  { 102, 5, 9, 5, 0, -9 },
  { 108, 5, 9, 5, 0, -9 },
  { 114, 5, 9, 5, 0, -9 },
  { 120, 2, 7, 2, 0, -7 },
  { 122, 3, 9, 2, -1, -7 },
  { 126, 5, 5, 5, 0, -7 },
  { 130, 5, 3, 5, 0, -6 },
  { 132, 5, 5, 5, 0, -7 },
  { 136, 4, 9, 3, 0, -9 },
  { 141, 7, 10, 7, 0, -9 },
  { 150, 5, 9, 5, -1, -9 },
  { 156, 5, 9, 5, 0, -9 },
  { 162, 6, 9, 5, 0, -9 },
  { 169, 5, 9, 6, 0, -9 },
  { 175, 5, 9, 5, 0, -9 },
  { 181, 5, 9, 4, 0, -9 },
  { 187, 6, 9, 6, 0, -9 },
  { 194, 6, 9, 6, 0, -9 },
  { 201, 5, 9, 3, -1, -9 },
  { 207, 5, 11, 2, -2, -9 },
  { 214, 6, 9, 5, 0, -9 },
  { 221, 3, 9, 4, 0, -9 },
  { 225, 8, 9, 8, 0, -9 },
  { 234, 7, 9, 6, 0, -9 },
  { 242, 6, 9, 6, 0, -9 },
  { 249, 5, 9, 5, 0, -9 },
  { 255, 6, 11, 6, 0, -9 },
  { 264, 5, 9, 5, 0, -9 },
  { 270, 5, 9, 5, 0, -9 },
  { 276, 4, 9, 4, 1, -9 },
  { 281, 6, 9, 6, 0, -9 },
  { 288, 5, 9, 5, 1, -9 },
  { 294, 8, 9, 8, 1, -9 },
  { 303, 6, 9, 4, -1, -9 },
  { 310, 4, 9, 4, 1, -9 },
  { 315, 6, 9, 4, -1, -9 },
  { 322, 4, 11, 4, 0, -9 },
  { 328, 2, 9, 4, 1, -9 },
  { 331, 5, 11, 4, -1, -9 },
  { 338, 5, 4, 5, 0, -9 },
  { 341, 4, 1, 4, -1, 1 },
  { 342, 1, 2, 3, 2, -10 },
  { 343, 5, 7, 5, 0, -7 },
  { 348, 5, 10, 5, 0, -10 },
  { 355, 4, 7, 4, 0, -7 },
  { 359, 6, 10, 5, 0, -10 },
  { 367, 4, 7, 5, 0, -7 },
  { 371, 6, 13, 3, -2, -10 },
  { 381, 5, 10, 5, 0, -7 },
  { 388, 5, 10, 5, 0, -10 },
  { 395, 3, 9, 2, 0, -9 },
  { 399, 5, 12, 2, -2, -9 },
  { 407, 5, 10, 4, 0, -10 },
  { 414, 3, 10, 2, 0, -10 },
  { 418, 7, 7, 8, 0, -7 },
  { 425, 5, 7, 5, 0, -7 },
  { 430, 5, 7, 5, 0, -7 },
  { 435, 6, 10, 5, -1, -7 },
  { 443, 5, 10, 5, 0, -7 },
  { 450, 4, 7, 3, 0, -7 },
  { 454, 4, 7, 4, 0, -7 },
  { 458, 3, 9, 3, 0, -9 },
  { 462, 5, 7, 5, 0, -7 },
  { 467, 4, 7, 4, 1, -7 },
  { 471, 6, 7, 7, 1, -7 },
  { 477, 6, 7, 4, -1, -7 },
  { 483, 6, 10, 4, -1, -7 },
  { 491, 4, 7, 3, 0, -7 },
  { 495, 5, 11, 4, 0, -9 },
  { 502, 1, 13, 5, 2, -10 },
  { 504, 5, 11, 4, -1, -9 },
  { 511, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC13PT7B_H_
