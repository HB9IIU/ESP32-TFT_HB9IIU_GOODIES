#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x38, 0xE6, 0x1C,
  0xC3, 0xB8, 0x67, 0x0C, 0xC1, 0x98, 0x73, 0x0C, 0xE1, 0x98, 0x33, 0x06,
  0x61, 0x8C, 0x30, 0x00, 0x18, 0x30, 0x01, 0x87, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0xE1, 0x80, 0x0C, 0x18, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x11, 0x83, 0x00,
  0x18, 0x30, 0x01, 0x87, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x1C, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x86,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xF6, 0x30,
  0x38, 0xC2, 0x06, 0x18, 0x01, 0xC2, 0x00, 0x38, 0x40, 0x07, 0x18, 0x00,
  0xC3, 0x00, 0x1C, 0x60, 0x03, 0x88, 0x00, 0x39, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x37, 0x00, 0x04, 0x70, 0x00, 0x8E, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x10, 0xE0, 0x02, 0x1C, 0x00, 0xC3, 0x04, 0x18, 0xE0, 0xFB,
  0xF8, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x0C, 0x0F, 0xE0, 0x18,
  0x0C, 0x60, 0x18, 0x18, 0x70, 0x30, 0x18, 0x30, 0x30, 0x38, 0x70, 0x60,
  0x30, 0x70, 0x60, 0x30, 0x60, 0xC0, 0x70, 0x60, 0xC0, 0x60, 0x61, 0x80,
  0x60, 0x61, 0x80, 0x60, 0x63, 0x00, 0x60, 0xE7, 0x00, 0xE0, 0xC6, 0x00,
  0xE0, 0xCE, 0x3E, 0xC1, 0xCC, 0x7E, 0xC1, 0x9C, 0xC7, 0xE3, 0x99, 0xC3,
  0x63, 0x39, 0x83, 0x7E, 0x31, 0x83, 0x3C, 0x73, 0x03, 0x00, 0x63, 0x07,
  0x00, 0xE3, 0x07, 0x00, 0xC7, 0x06, 0x01, 0xC6, 0x06, 0x01, 0x86, 0x06,
  0x03, 0x86, 0x06, 0x03, 0x06, 0x0C, 0x07, 0x06, 0x0C, 0x06, 0x06, 0x0C,
  0x0E, 0x06, 0x18, 0x0C, 0x06, 0x18, 0x1C, 0x06, 0x30, 0x18, 0x07, 0xF0,
  0x38, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1C,
  0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x0C, 0x1C,
  0x03, 0x06, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x98, 0x00,
  0xEE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xEC,
  0x00, 0x73, 0x87, 0x38, 0xE1, 0x8C, 0x18, 0x67, 0x07, 0x39, 0x81, 0xCC,
  0xE0, 0x77, 0x38, 0x0D, 0x8C, 0x03, 0xE3, 0x00, 0xF8, 0xC0, 0x1C, 0x30,
  0x0F, 0x0C, 0x03, 0xC3, 0x81, 0xB0, 0xE0, 0xEE, 0x1F, 0xF3, 0x83, 0xF0,
  0xE0, 0x39, 0xCC, 0xE7, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x00, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x10,
  0xE0, 0x73, 0x03, 0xEC, 0x71, 0xFF, 0xC0, 0xF8, 0x07, 0x00, 0x76, 0x03,
  0x8C, 0x1C, 0x30, 0x20, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x1C, 0x30, 0xE1,
  0xC7, 0x0E, 0x18, 0x70, 0xC3, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x5F,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x71, 0xC0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x0C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x18,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0E, 0x03, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xC1, 0xC0, 0x71, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0xE0, 0x78, 0x1F, 0x07, 0xE1, 0xDC, 0x73, 0x3C, 0x63, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xE0, 0xE0, 0x08, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0x07,
  0x00, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0xC0, 0x78, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x00, 0xCE,
  0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x0C, 0x38,
  0x01, 0x86, 0x00, 0x60, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xC0, 0xC0,
  0x38, 0x18, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0C, 0x03, 0x03,
  0x80, 0x60, 0x60, 0x1C, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x04, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x04, 0x01, 0xE0, 0xC0, 0x78, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x38,
  0x03, 0x3F, 0x80, 0xDF, 0xF0, 0x7C, 0x1E, 0x1E, 0x03, 0x87, 0x80, 0xE1,
  0xC0, 0x18, 0x70, 0x06, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x38, 0x06,
  0x0E, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x0C, 0x0C, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x06, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x18, 0x07, 0x03, 0x01, 0xC0,
  0x70, 0x30, 0x06, 0x0E, 0x00, 0xE7, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x3C, 0xE0, 0x0F, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x18, 0x1C,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0x70,
  0x38, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x3C, 0x38, 0x0E, 0x0E, 0x07, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x1C, 0x30,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x18, 0x01,
  0xC6, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x0E, 0x18, 0x07, 0x87, 0x03, 0xE1,
  0xE1, 0xF8, 0x3F, 0xEC, 0x07, 0xF7, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x83, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0x03, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x70, 0xF0, 0xF0, 0xE0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0xE0, 0x83, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x01, 0xF8, 0x63, 0x83,
  0xFC, 0x31, 0x81, 0x86, 0x18, 0xC1, 0x86, 0x0C, 0xC1, 0x83, 0x06, 0x60,
  0xC1, 0x83, 0x30, 0xE1, 0xC3, 0xB8, 0x60, 0xC1, 0x98, 0x30, 0x60, 0xCC,
  0x38, 0x30, 0x66, 0x18, 0x38, 0x33, 0x0C, 0x18, 0x31, 0x86, 0x0C, 0x19,
  0xC3, 0x0E, 0x0C, 0xC1, 0x87, 0x0C, 0x60, 0xC3, 0x86, 0x30, 0x63, 0xC6,
  0x18, 0x3F, 0x7E, 0x0C, 0x0F, 0x1E, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x40, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E,
  0x70, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x0E, 0x1C,
  0x03, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1C, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xC3, 0xE0, 0x18, 0x0E, 0x01, 0x80, 0x70, 0x38, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00,
  0x60, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x1C, 0x0E, 0x03, 0x80, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0C, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x18, 0x03, 0x81, 0x80, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x0E, 0x06, 0x01, 0xE0, 0x60, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xF8, 0x20, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x02, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x73, 0xF0, 0x03,
  0x01, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x06,
  0x03, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60,
  0x03, 0x83, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x60, 0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0x60, 0x03, 0x83, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E,
  0x00, 0xE0, 0x60, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x0C, 0x07, 0x80, 0x63, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3C, 0x07, 0x01, 0xC0,
  0x08, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0xFE, 0x38, 0x03, 0xF8, 0xE0, 0x10, 0xE3, 0x80, 0x03, 0x0E,
  0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00,
  0x18, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0xC0, 0x78, 0x03, 0x00, 0xF0, 0x1C, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x0E, 0x01,
  0x80, 0x0E, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03,
  0x80, 0x1C, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x07,
  0x00, 0x38, 0x06, 0x00, 0x38, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0C, 0x00, 0x70, 0x1C,
  0x00, 0x60, 0x1C, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x30,
  0x01, 0xC0, 0x70, 0x01, 0x80, 0x70, 0x01, 0x80, 0x70, 0x03, 0x80, 0x60,
  0x03, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x60, 0x1C, 0x01,
  0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x06, 0x38, 0x00,
  0x18, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x37,
  0x80, 0x00, 0xF7, 0x00, 0x07, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xC0,
  0x01, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x01, 0x80, 0x0C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xB8, 0x00,
  0x6E, 0x03, 0x70, 0x01, 0xD8, 0x0E, 0xE0, 0x03, 0x30, 0x1D, 0xC0, 0x0E,
  0xE0, 0x3B, 0x80, 0x19, 0xC0, 0x67, 0x00, 0x73, 0x00, 0xCE, 0x00, 0xC6,
  0x03, 0x9C, 0x03, 0x9C, 0x07, 0x18, 0x06, 0x38, 0x0C, 0x30, 0x1C, 0x70,
  0x18, 0x60, 0x38, 0xC0, 0x30, 0xC0, 0x61, 0x80, 0xE1, 0x81, 0xC7, 0x01,
  0xC3, 0x03, 0x0E, 0x03, 0x06, 0x0E, 0x1C, 0x06, 0x0C, 0x18, 0x30, 0x1C,
  0x18, 0x70, 0x60, 0x38, 0x30, 0xC1, 0xC0, 0x70, 0x63, 0x83, 0x80, 0xC0,
  0xC6, 0x06, 0x01, 0x81, 0x9C, 0x0C, 0x07, 0x03, 0x30, 0x38, 0x0E, 0x07,
  0xE0, 0x70, 0x1C, 0x0F, 0x80, 0xE0, 0x30, 0x1F, 0x01, 0x80, 0x60, 0x3E,
  0x03, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0xF0, 0x01, 0x80, 0x78, 0x00, 0xC0, 0x3C, 0x00, 0xE0, 0x1E,
  0x00, 0x70, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x18, 0x06, 0x60, 0x0C, 0x03,
  0x30, 0x0E, 0x03, 0x98, 0x07, 0x01, 0xCC, 0x03, 0x80, 0xE7, 0x01, 0x80,
  0x63, 0x80, 0xC0, 0x30, 0xC0, 0xE0, 0x38, 0x60, 0x70, 0x1C, 0x30, 0x38,
  0x0E, 0x1C, 0x18, 0x06, 0x0E, 0x1C, 0x03, 0x07, 0x0E, 0x03, 0x81, 0x87,
  0x01, 0xC0, 0xC3, 0x00, 0xC0, 0x61, 0x80, 0x60, 0x39, 0xC0, 0x70, 0x1C,
  0xE0, 0x38, 0x0E, 0x70, 0x1C, 0x03, 0x30, 0x0C, 0x01, 0x98, 0x06, 0x00,
  0xDC, 0x07, 0x00, 0x7E, 0x03, 0x80, 0x3F, 0x01, 0xC0, 0x0F, 0x00, 0xC0,
  0x07, 0x80, 0x60, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xE1, 0xE0, 0x38, 0x0E, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80,
  0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCC, 0x00, 0x1C,
  0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x78, 0x78, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0x3F, 0x00,
  0xC0, 0xF0, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x18, 0x1C, 0x03, 0x03,
  0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x0E, 0x0C,
  0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0x81, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xE1, 0xE0,
  0x38, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00,
  0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0,
  0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x8C,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x01, 0xC0,
  0x78, 0x78, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0x3F, 0x00,
  0xC0, 0xF0, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x03, 0x03,
  0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x0E, 0x0C,
  0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x01, 0xC7, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x60,
  0x3C, 0x02, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x08, 0x01, 0xC0,
  0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1,
  0x80, 0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x30,
  0x01, 0xC1, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x06,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xF0, 0x70, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x38, 0x38, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0x60, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xB8, 0x01, 0xC0, 0x0E,
  0xE0, 0x0F, 0x00, 0x3B, 0x80, 0x3C, 0x01, 0xCE, 0x00, 0xF0, 0x07, 0x38,
  0x06, 0xC0, 0x18, 0xE0, 0x1B, 0x00, 0xE3, 0x80, 0xEC, 0x03, 0x8E, 0x03,
  0x30, 0x1C, 0x38, 0x0C, 0xC0, 0x70, 0xE0, 0x73, 0x01, 0x83, 0x01, 0x8C,
  0x0E, 0x0C, 0x0E, 0x30, 0x38, 0x30, 0x30, 0xC0, 0xC0, 0xC0, 0xC3, 0x07,
  0x03, 0x07, 0x0C, 0x18, 0x0C, 0x18, 0x30, 0xE0, 0x30, 0xE0, 0xC3, 0x80,
  0xC3, 0x03, 0x0C, 0x03, 0x0C, 0x0C, 0x70, 0x0C, 0x70, 0x31, 0x80, 0x31,
  0x81, 0xCE, 0x00, 0xCE, 0x07, 0x38, 0x03, 0x30, 0x1C, 0xC0, 0x0C, 0xC0,
  0x77, 0x00, 0x37, 0x01, 0xD8, 0x00, 0xD8, 0x07, 0xE0, 0x03, 0x60, 0x1B,
  0x80, 0x0F, 0x80, 0x6C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x30, 0xC0, 0x00,
  0x63, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03, 0xB0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x73, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x06,
  0x01, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x00,
  0xE1, 0x80, 0xE0, 0xC0, 0x70, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0x66, 0x00, 0x37, 0x00,
  0x1B, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0xC1, 0xC3, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xE1, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x0C, 0x18, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00,
  0x39, 0xC0, 0x0C, 0x30, 0x07, 0x0E, 0x03, 0x81, 0x80, 0xC0, 0x70, 0x70,
  0x1C, 0x18, 0x03, 0x0E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x06, 0x60, 0x01,
  0xF8, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC7, 0x0C, 0x38, 0x60,
  0xC0, 0x00, 0x20, 0x00, 0x7F, 0x30, 0x3F, 0xCC, 0x1E, 0x1B, 0x0F, 0x03,
  0xC3, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x30, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80,
  0x18, 0x60, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C,
  0x38, 0x07, 0x0E, 0x03, 0xC1, 0xC1, 0xF0, 0x70, 0xD8, 0x0F, 0xE6, 0x03,
  0xF1, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x40, 0x0C, 0xFC, 0x07, 0x7F, 0x81, 0xF0, 0xF0, 0x68, 0x1C,
  0x1C, 0x07, 0x0F, 0x01, 0xC3, 0x80, 0x30, 0xE0, 0x0C, 0x38, 0x07, 0x0C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x18, 0x01, 0x86, 0x00,
  0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x38, 0x78, 0x0E, 0x1E, 0x07, 0x06, 0xC3, 0x83, 0xBF, 0xC0, 0xC7,
  0xE0, 0x00, 0x00, 0x10, 0x01, 0xFC, 0x0F, 0xF0, 0x3C, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x40, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x08, 0x30, 0x03, 0xF9,
  0x80, 0x3F, 0xCC, 0x03, 0xC3, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x30,
  0x18, 0x01, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x03, 0x03, 0xE0, 0x1C, 0x36,
  0x00, 0x7F, 0x30, 0x03, 0xF1, 0x80, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x03,
  0xFE, 0x07, 0x0E, 0x0E, 0x06, 0x0E, 0x07, 0x1C, 0x06, 0x18, 0x06, 0x38,
  0x0E, 0x38, 0x0E, 0x30, 0x1C, 0x70, 0x38, 0x71, 0xF0, 0x7F, 0xE0, 0x7F,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x30, 0x3F, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xF3, 0x00, 0xFF, 0x30,
  0x1E, 0x1B, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xC0, 0x0C, 0x1C, 0x01,
  0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x83, 0x80,
  0x38, 0x38, 0x03, 0x83, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x38,
  0x0F, 0x01, 0x81, 0xF0, 0x1C, 0x36, 0x01, 0xFE, 0x60, 0x0F, 0xCE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x08, 0x07, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC1, 0x00, 0x67, 0xE0, 0x77, 0xF8, 0x3E, 0x1C,
  0x1E, 0x06, 0x0E, 0x03, 0x07, 0x01, 0x87, 0x00, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x0C, 0x38, 0x0E, 0x18, 0x07, 0x0C,
  0x03, 0x8E, 0x01, 0x87, 0x00, 0xC3, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x30,
  0xE0, 0x18, 0x70, 0x0C, 0x30, 0x0E, 0x18, 0x07, 0x0C, 0x03, 0x0E, 0x01,
  0x80, 0x00, 0x80, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x60, 0x60, 0x18, 0x38, 0x0E, 0x1C,
  0x03, 0x8E, 0x00, 0xE3, 0x00, 0x31, 0xC0, 0x0C, 0xE0, 0x07, 0x70, 0x01,
  0xDE, 0x00, 0x6F, 0x80, 0x1E, 0xE0, 0x07, 0x18, 0x03, 0xC6, 0x00, 0xE1,
  0x80, 0x30, 0x70, 0x0C, 0x1C, 0x03, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x00, 0x00, 0x08, 0x02, 0x00, 0x67, 0xE3, 0xF8, 0x19, 0xFE, 0xFF, 0x03,
  0x61, 0xF8, 0x70, 0x78, 0x3E, 0x0E, 0x0E, 0x03, 0x81, 0xC3, 0xC0, 0xE0,
  0x38, 0x70, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0xE1, 0x80, 0x70, 0x18, 0x30,
  0x0C, 0x03, 0x0E, 0x01, 0x80, 0xE1, 0xC0, 0x70, 0x1C, 0x38, 0x0E, 0x03,
  0x06, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x0C, 0x38, 0x0E, 0x03, 0x87, 0x01,
  0xC0, 0x70, 0xE0, 0x38, 0x0C, 0x18, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x70,
  0xE0, 0x38, 0x0E, 0x1C, 0x07, 0x01, 0xC3, 0x00, 0xC0, 0x30, 0x60, 0x18,
  0x06, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x01,
  0x9F, 0x81, 0x9F, 0xE0, 0xD8, 0x70, 0x78, 0x18, 0x38, 0x0C, 0x3C, 0x06,
  0x1C, 0x03, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x61, 0xC0,
  0x30, 0xE0, 0x38, 0x60, 0x1C, 0x30, 0x0E, 0x38, 0x06, 0x1C, 0x03, 0x0E,
  0x03, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x70, 0xC0, 0x38,
  0x60, 0x1C, 0x70, 0x0C, 0x38, 0x06, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x18, 0x70, 0x0C, 0x30, 0x06,
  0x38, 0x03, 0x9C, 0x01, 0x8C, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x33, 0x80,
  0x39, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x06, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE1, 0x80, 0xE0, 0xE0, 0xE0, 0x70, 0xF0,
  0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x0C, 0xFC, 0x01, 0xDF,
  0xE0, 0x1B, 0x0F, 0x01, 0xA0, 0x70, 0x1E, 0x07, 0x01, 0xC0, 0x30, 0x38,
  0x03, 0x03, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC1, 0xE0, 0x38,
  0x1E, 0x03, 0x81, 0xE0, 0x70, 0x1B, 0x0E, 0x01, 0xBF, 0xC0, 0x39, 0xF8,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x30, 0x3F, 0xCC, 0x1E,
  0x1B, 0x0F, 0x07, 0xC3, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03,
  0x8E, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01, 0xC6,
  0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC1, 0x81, 0xF0, 0x70, 0xD8,
  0x1F, 0xE6, 0x03, 0xF3, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x7C,
  0x19, 0xF0, 0x37, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x20, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0x02, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0xC0,
  0xE0, 0xFF, 0xE0, 0x7F, 0x80, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x83, 0xFC, 0xFF, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x38, 0x0F, 0xC1, 0xF0, 0x0E, 0x01, 0xC3,
  0x80, 0x60, 0xE0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xC1, 0xC0,
  0x30, 0x70, 0x1C, 0x18, 0x07, 0x06, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x18,
  0x30, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x1C, 0x18,
  0x07, 0x06, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x07,
  0x83, 0xC3, 0xE0, 0x7F, 0xB0, 0x0F, 0xCC, 0x00, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x01, 0xCC, 0x07, 0x30, 0x38, 0xC0, 0xE3,
  0x03, 0x0C, 0x1C, 0x30, 0x60, 0xC3, 0x83, 0x0C, 0x0C, 0x70, 0x31, 0xC0,
  0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0x60, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x07, 0xE0, 0x38, 0x06,
  0xC0, 0x38, 0x0E, 0xC0, 0x78, 0x0C, 0xC0, 0x78, 0x0C, 0xC0, 0x78, 0x1C,
  0xC0, 0xD8, 0x18, 0xC0, 0xD8, 0x38, 0xC1, 0xD8, 0x30, 0xC1, 0x98, 0x30,
  0xC1, 0x98, 0x70, 0xC3, 0x18, 0x60, 0xC3, 0x18, 0xE0, 0xC7, 0x18, 0xE0,
  0xC6, 0x18, 0xC0, 0xC6, 0x19, 0xC0, 0xCC, 0x19, 0x80, 0xCC, 0x19, 0x80,
  0xDC, 0x1B, 0x80, 0xD8, 0x1B, 0x00, 0xD8, 0x1F, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x18, 0x30,
  0x03, 0x0E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1B, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x38, 0xC0, 0x07, 0x1C, 0x01,
  0xC3, 0x80, 0x30, 0x70, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x1C,
  0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x03,
  0x00, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x38, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0E,
  0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80,
  0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x27, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00,
  0x3E, 0x00, 0xBF, 0xC0, 0x7D, 0xF8, 0xF0, 0x1F, 0xF8, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 35, 11, 1, -35 },
  { 45, 11, 13, 15, 5, -35 },
  { 63, 20, 35, 19, 0, -35 },
  { 151, 19, 40, 18, 0, -37 },
  { 246, 24, 36, 28, 2, -35 },
  { 354, 18, 35, 18, 0, -35 },
  { 433, 5, 13, 8, 5, -35 },
  { 442, 14, 43, 12, 1, -35 },
  { 518, 14, 43, 12, -3, -35 },
  { 594, 14, 14, 17, 5, -37 },
  { 619, 17, 23, 20, 2, -29 },
  { 668, 7, 11, 9, -2, -5 },
  { 678, 11, 3, 13, 1, -15 },
  { 683, 3, 5, 9, 1, -5 },
  { 685, 21, 35, 15, -2, -35 },
  { 777, 17, 35, 18, 1, -35 },
  { 852, 11, 35, 18, 5, -35 },
  { 901, 20, 35, 18, -2, -35 },
  { 989, 19, 35, 18, -1, -35 },
  { 1073, 19, 35, 18, -1, -35 },
  { 1157, 19, 35, 18, -1, -35 },
  { 1241, 18, 35, 18, 1, -35 },
  { 1320, 18, 35, 18, 2, -35 },
  { 1399, 19, 35, 18, 0, -35 },
  { 1483, 18, 35, 18, 0, -35 },
  { 1562, 8, 26, 9, 0, -26 },
  { 1588, 11, 32, 9, -2, -26 },
  { 1632, 17, 21, 20, 2, -28 },
  { 1677, 17, 13, 20, 2, -24 },
  { 1705, 17, 21, 20, 2, -28 },
  { 1750, 14, 35, 13, 1, -35 },
  { 1812, 25, 39, 27, 1, -35 },
  { 1934, 18, 35, 18, -3, -35 },
  { 2013, 20, 35, 20, 0, -35 },
  { 2101, 19, 36, 18, 2, -36 },
  { 2187, 21, 35, 21, 0, -35 },
  { 2279, 19, 35, 17, 0, -35 },
  { 2363, 19, 35, 16, 0, -35 },
  { 2447, 22, 36, 23, 2, -36 },
  { 2546, 24, 35, 23, 0, -35 },
  { 2651, 17, 35, 10, -3, -35 },
  { 2726, 17, 44, 9, -7, -35 },
  { 2820, 22, 35, 18, 0, -35 },
  { 2917, 12, 35, 16, 0, -35 },
  { 2970, 31, 35, 30, 0, -35 },
  { 3106, 25, 35, 24, 0, -35 },
  { 3216, 20, 35, 23, 2, -35 },
  { 3304, 19, 35, 19, 0, -35 },
  { 3388, 20, 43, 23, 2, -35 },
  { 3496, 19, 35, 19, 0, -35 },
  { 3580, 20, 35, 18, -1, -35 },
  { 3668, 16, 35, 16, 3, -35 },
  { 3738, 21, 35, 22, 2, -35 },
  { 3830, 18, 35, 18, 4, -35 },
  { 3909, 30, 35, 31, 4, -35 },
  { 4041, 23, 35, 17, -3, -35 },
  { 4142, 17, 35, 16, 3, -35 },
  { 4217, 21, 35, 16, -2, -35 },
  { 4309, 18, 43, 14, -1, -35 },
  { 4406, 7, 35, 16, 5, -35 },
  { 4437, 18, 43, 14, -3, -35 },
  { 4534, 18, 18, 19, 1, -35 },
  { 4575, 14, 2, 14, -4, 4 },
  { 4579, 6, 7, 11, 7, -37 },
  { 4585, 18, 27, 20, 1, -27 },
  { 4646, 18, 37, 19, 0, -37 },
  { 4730, 15, 27, 14, 1, -27 },
  { 4781, 21, 37, 20, 1, -37 },
  { 4879, 16, 27, 17, 1, -27 },
  { 4933, 22, 49, 10, -6, -37 },
  { 5068, 20, 39, 20, -1, -27 },
  { 5166, 17, 37, 19, 0, -37 },
  { 5245, 10, 36, 9, 0, -36 },
  { 5290, 16, 48, 9, -6, -36 },
  { 5386, 18, 37, 16, 0, -37 },
  { 5470, 11, 37, 8, 0, -37 },
  { 5521, 27, 27, 28, 0, -27 },
  { 5613, 17, 27, 19, 0, -27 },
  { 5671, 17, 27, 19, 1, -27 },
  { 5729, 20, 38, 19, -2, -27 },
  { 5824, 18, 39, 20, 1, -27 },
  { 5912, 15, 27, 13, 0, -27 },
  { 5963, 16, 27, 14, -1, -27 },
  { 6017, 10, 32, 10, 1, -32 },
  { 6057, 18, 26, 19, 1, -26 },
  { 6116, 14, 26, 15, 3, -26 },
  { 6162, 24, 26, 25, 3, -26 },
  { 6240, 19, 26, 15, -2, -26 },
  { 6302, 23, 38, 16, -5, -26 },
  { 6412, 16, 26, 13, -2, -26 },
  { 6464, 18, 43, 16, 1, -35 },
  { 6561, 3, 49, 17, 7, -37 },
  { 6580, 17, 43, 16, -3, -35 },
  { 6672, 17, 5, 20, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC49PT7B_H_
