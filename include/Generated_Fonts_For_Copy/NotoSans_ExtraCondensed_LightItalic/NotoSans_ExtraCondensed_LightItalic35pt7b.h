#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60,
  0xE0, 0x60, 0x31, 0x99, 0x88, 0xCC, 0x66, 0x33, 0x11, 0x18, 0x8C, 0xC6,
  0x00, 0x00, 0x84, 0x03, 0x18, 0x06, 0x30, 0x08, 0x40, 0x31, 0x80, 0x63,
  0x00, 0x84, 0x0F, 0xFF, 0x3F, 0xFC, 0x08, 0x40, 0x10, 0x80, 0x63, 0x00,
  0xC4, 0x01, 0x08, 0x06, 0x30, 0x0C, 0x60, 0xFF, 0xF0, 0x63, 0x00, 0xC6,
  0x01, 0x08, 0x06, 0x30, 0x0C, 0x60, 0x10, 0x80, 0x23, 0x00, 0xC6, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x78, 0x07, 0xFC, 0x32, 0x21, 0x88,
  0x06, 0x20, 0x19, 0x80, 0x64, 0x01, 0x90, 0x06, 0x40, 0x0D, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x02, 0xC0, 0x09, 0x00, 0x46, 0x01, 0x18, 0x04,
  0x60, 0x11, 0x00, 0x4C, 0x32, 0x60, 0xFF, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x1E, 0x06, 0x33, 0x04, 0x23, 0x0C, 0x63, 0x08, 0x43,
  0x18, 0x43, 0x10, 0xC2, 0x30, 0xC2, 0x20, 0x86, 0x60, 0x86, 0x40, 0x84,
  0xCF, 0x84, 0x9B, 0x8D, 0xB1, 0xD9, 0x31, 0xF3, 0x21, 0x02, 0x61, 0x06,
  0x61, 0x04, 0x43, 0x0C, 0x43, 0x08, 0xC3, 0x18, 0xC2, 0x10, 0xC6, 0x30,
  0xC4, 0x20, 0x4C, 0x60, 0x78, 0x03, 0xE0, 0x33, 0x01, 0x88, 0x08, 0x40,
  0xC6, 0x06, 0x30, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0x6C, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x0D, 0x84, 0xCC, 0x4C, 0x66, 0x63, 0x36, 0x0D, 0x30, 0x79,
  0x83, 0x8C, 0x0C, 0x60, 0xE3, 0x0F, 0x1D, 0xCC, 0x7C, 0x60, 0x33, 0x26,
  0x66, 0x44, 0xC0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x03,
  0x19, 0x8E, 0x88, 0xFC, 0x70, 0x68, 0x66, 0x61, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x19, 0x8C, 0x66, 0x33, 0x18, 0x80, 0xFE, 0x7D, 0x80, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xC0,
  0x76, 0x0C, 0x31, 0x83, 0x18, 0x31, 0x03, 0x30, 0x33, 0x03, 0x60, 0x36,
  0x02, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC,
  0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x8C, 0x30, 0xC6, 0x0E, 0xE0, 0x7C, 0x00,
  0x06, 0x1C, 0xFB, 0xAC, 0xD1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x06,
  0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC0, 0x03, 0xF0,
  0x1C, 0xE0, 0x41, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xF0, 0x1C, 0xE0, 0x40, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x38, 0xE0,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1A, 0x00, 0x58, 0x03,
  0x60, 0x09, 0x80, 0x64, 0x03, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x0C, 0x0C,
  0x20, 0x61, 0x81, 0x06, 0x0C, 0x18, 0x60, 0x61, 0x83, 0x2F, 0xFF, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x88, 0x0C, 0x38, 0xE0, 0xFF, 0x00, 0x01, 0xF8, 0x1C, 0x81, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x10, 0x1B, 0xE0,
  0xF1, 0x87, 0x0C, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x30,
  0x31, 0x81, 0x8C, 0x0C, 0x60, 0xC3, 0x0E, 0x0C, 0xE0, 0x3E, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x31, 0x83, 0x06, 0x30, 0x31, 0x81,
  0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x30, 0x63, 0x03, 0xB0, 0x0F, 0x00,
  0xF0, 0x0C, 0xC0, 0xC3, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x63, 0x03, 0x0E, 0x70, 0x3F, 0x00, 0x03, 0xE0, 0x3B,
  0x83, 0x0C, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x07, 0x0C, 0xD8, 0x7C, 0x80, 0x8C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x11, 0xC0,
  0xFC, 0x00, 0x0C, 0x31, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x8C, 0x00, 0x01, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x83,
  0xB8, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00,
  0x71, 0xC0, 0x30, 0x18, 0x18, 0x06, 0x0C, 0x00, 0x82, 0x00, 0x31, 0x80,
  0x0C, 0x41, 0xE3, 0x30, 0xC8, 0xC8, 0x46, 0x36, 0x31, 0x89, 0x88, 0x42,
  0x46, 0x10, 0x91, 0x8C, 0x6C, 0x43, 0x1B, 0x10, 0x84, 0xC4, 0x61, 0x21,
  0x18, 0xC8, 0x46, 0x22, 0x1E, 0xF0, 0x87, 0x38, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x9C, 0x00, 0x7E, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x05, 0x00, 0xD0, 0x09, 0x01, 0x90, 0x19,
  0x03, 0x10, 0x31, 0x03, 0x10, 0x61, 0x06, 0x10, 0xC1, 0x0F, 0xF0, 0xFF,
  0x18, 0x11, 0x81, 0x30, 0x13, 0x01, 0x30, 0x16, 0x01, 0x60, 0x1C, 0x01,
  0xC0, 0x10, 0x07, 0xF0, 0x1F, 0xE0, 0x61, 0xC1, 0x03, 0x0C, 0x0C, 0x30,
  0x30, 0xC0, 0xC3, 0x03, 0x08, 0x18, 0x60, 0x61, 0x83, 0x07, 0xF0, 0x1F,
  0xE0, 0xC1, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC6, 0x03, 0x18,
  0x0C, 0x60, 0x71, 0x81, 0x84, 0x0C, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFC,
  0x0F, 0x30, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x0E, 0x60, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x18, 0x70,
  0x20, 0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x08, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x30, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C, 0x1C, 0x10,
  0x70, 0x7F, 0x80, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x07, 0xF8, 0x1F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xE0,
  0xFF, 0x83, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x03,
  0xCF, 0x07, 0x01, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x7C, 0x60,
  0x7C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0x60, 0x10, 0x60, 0x30, 0x70, 0x30, 0x3C, 0x70, 0x1F, 0xE0, 0x06,
  0x01, 0x83, 0x00, 0x81, 0x80, 0xC0, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18,
  0x30, 0x08, 0x18, 0x0C, 0x08, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0xFF,
  0x81, 0xFF, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x10,
  0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x03, 0x01, 0x81, 0x00, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x00, 0x07, 0xF0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0xFE, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x0B, 0x80, 0xF8, 0x00, 0x06, 0x07, 0x06, 0x06, 0x06, 0x0C,
  0x04, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0xC0, 0x08, 0xC0,
  0x19, 0x80, 0x1B, 0x00, 0x1B, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x39, 0x80,
  0x31, 0x80, 0x31, 0x80, 0x31, 0x80, 0x61, 0x80, 0x60, 0xC0, 0x60, 0xC0,
  0x60, 0xC0, 0x40, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E,
  0x0D, 0x00, 0x78, 0x34, 0x01, 0xE0, 0xD0, 0x0D, 0x83, 0x40, 0x36, 0x09,
  0x01, 0x90, 0x64, 0x06, 0xC1, 0x90, 0x33, 0x06, 0x60, 0xCC, 0x11, 0x82,
  0x30, 0xC6, 0x18, 0x83, 0x18, 0x46, 0x0C, 0x63, 0x18, 0x31, 0x8C, 0x60,
  0x86, 0x61, 0x86, 0x19, 0x8C, 0x18, 0x6C, 0x30, 0x61, 0xB0, 0xC1, 0x87,
  0x83, 0x04, 0x1E, 0x08, 0x30, 0x70, 0x60, 0xC1, 0xC1, 0x80, 0x07, 0x00,
  0xC1, 0xC0, 0x20, 0x70, 0x18, 0x1C, 0x06, 0x0D, 0x01, 0x83, 0x60, 0x60,
  0xD8, 0x30, 0x36, 0x0C, 0x09, 0x83, 0x06, 0x20, 0xC1, 0x88, 0x20, 0x63,
  0x18, 0x18, 0xC6, 0x0C, 0x31, 0x83, 0x0C, 0x60, 0xC1, 0x10, 0x30, 0x4C,
  0x08, 0x1B, 0x06, 0x06, 0xC1, 0x81, 0xB0, 0x60, 0x68, 0x18, 0x0E, 0x04,
  0x03, 0x83, 0x00, 0xE0, 0xC0, 0x38, 0x00, 0x01, 0xF8, 0x07, 0x38, 0x18,
  0x30, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x98, 0x03, 0x30, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x0C, 0x0C,
  0x18, 0x30, 0x39, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x61, 0x81,
  0x07, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x08, 0x18, 0x60, 0x61,
  0x81, 0x86, 0x0C, 0x18, 0xE0, 0xFF, 0x03, 0xF0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x01, 0xF8, 0x07, 0x38, 0x18, 0x30, 0x60, 0x31, 0x80, 0x63,
  0x00, 0xC4, 0x01, 0x98, 0x03, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00,
  0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x33,
  0x00, 0x66, 0x01, 0x8C, 0x03, 0x0C, 0x0C, 0x18, 0x30, 0x39, 0xC0, 0x3F,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x61, 0x81, 0x07, 0x0C, 0x0C, 0x30, 0x30,
  0xC0, 0xC3, 0x03, 0x08, 0x18, 0x60, 0x61, 0x83, 0x86, 0x1C, 0x1F, 0xE0,
  0xFE, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x04, 0x0C, 0x30, 0x30, 0xC0, 0x60, 0x01, 0xFE, 0x0F,
  0xB8, 0x18, 0x10, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x20, 0x30, 0x7B, 0xE0, 0x7F, 0x00, 0x7F, 0xF7, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x02,
  0x18, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01, 0x86, 0x03, 0x08,
  0x06, 0x30, 0x0C, 0x60, 0x10, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03,
  0x18, 0x0C, 0x30, 0x18, 0x60, 0x31, 0x80, 0x63, 0x00, 0x86, 0x03, 0x0C,
  0x06, 0x18, 0x18, 0x38, 0x30, 0x39, 0xC0, 0x3F, 0x00, 0xC0, 0x1E, 0x01,
  0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x18, 0x18, 0xC1, 0x86,
  0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCC,
  0x06, 0x40, 0x36, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0xC0, 0x30, 0x1F, 0x01, 0xC0, 0x6C, 0x07, 0x01, 0xB0, 0x1C,
  0x0C, 0xC0, 0xF0, 0x33, 0x02, 0xC1, 0x8C, 0x1A, 0x06, 0x30, 0x68, 0x18,
  0xC1, 0x20, 0xC3, 0x0C, 0x83, 0x0C, 0x32, 0x18, 0x31, 0x88, 0x60, 0xC6,
  0x21, 0x83, 0x10, 0x8C, 0x0C, 0xC2, 0x30, 0x23, 0x09, 0x80, 0x98, 0x26,
  0x02, 0x61, 0x98, 0x09, 0x06, 0xC0, 0x2C, 0x1B, 0x00, 0xB0, 0x68, 0x02,
  0x81, 0xE0, 0x0E, 0x07, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x00, 0x03,
  0x03, 0x03, 0x02, 0x03, 0x06, 0x03, 0x0C, 0x01, 0x0C, 0x01, 0x18, 0x01,
  0x98, 0x01, 0xB0, 0x01, 0xB0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C,
  0x40, 0x18, 0x40, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0x60, 0x60, 0x36, 0x03, 0x60, 0x66, 0x04, 0x60, 0xC6, 0x18, 0x21, 0x82,
  0x30, 0x33, 0x03, 0x60, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x01,
  0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x84, 0x31, 0x8C, 0x63, 0x08, 0x43, 0x18, 0xC6, 0x30, 0x84,
  0x31, 0x8C, 0x63, 0x18, 0x42, 0x18, 0x03, 0xF8, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0xCC, 0x04, 0x60, 0x61, 0x02, 0x0C, 0x30, 0x63,
  0x01, 0x98, 0x0D, 0x80, 0x6C, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0xC6, 0x62,
  0x31, 0x07, 0x98, 0x7E, 0xC7, 0x14, 0x30, 0x63, 0x03, 0x18, 0x19, 0x80,
  0xCC, 0x0C, 0x60, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63,
  0x03, 0x18, 0x38, 0xC3, 0x83, 0x34, 0x1F, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xE0, 0x7F,
  0x82, 0x86, 0x38, 0x31, 0xC1, 0x8C, 0x0C, 0x60, 0x62, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x0C, 0x40, 0x66, 0x03, 0x30, 0x11, 0x81, 0x8C, 0x0C, 0x70,
  0xC6, 0xCC, 0x37, 0xC0, 0x03, 0xC3, 0xF1, 0xC0, 0x60, 0x30, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x1C, 0x87, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x07, 0x98, 0x1F, 0xB0, 0x71,
  0x40, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x61,
  0x80, 0xC3, 0x01, 0x86, 0x02, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0xE0, 0xC2, 0x80, 0xCD, 0x01, 0xF6, 0x00, 0x03, 0x81, 0xF8, 0x61, 0x9C,
  0x33, 0x06, 0xC0, 0xD8, 0x33, 0x0C, 0xC7, 0x9F, 0xC3, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x60, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x7C, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x03, 0xC0, 0x00, 0x01, 0xE6, 0x07, 0xEC, 0x1C, 0x50, 0x30, 0x60,
  0xC0, 0xC1, 0x81, 0x86, 0x03, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x30, 0xC0,
  0x61, 0x80, 0xC3, 0x03, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0xE0,
  0x33, 0xC0, 0x7D, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x81, 0x86, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0xE0, 0xFF, 0x0E, 0x31,
  0xC1, 0x18, 0x11, 0x83, 0x18, 0x31, 0x03, 0x30, 0x33, 0x02, 0x30, 0x63,
  0x06, 0x20, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0x80,
  0x06, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82,
  0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0xF0, 0x00,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x18, 0x61, 0x82, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0xC0, 0x6C,
  0x02, 0x60, 0x37, 0x01, 0xF8, 0x0E, 0xC0, 0x66, 0x06, 0x30, 0x30, 0x81,
  0x86, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x60, 0x03, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x0D,
  0xE3, 0xC1, 0x7E, 0xFC, 0x38, 0xF1, 0x8E, 0x1C, 0x31, 0x83, 0x06, 0x30,
  0x60, 0xC6, 0x0C, 0x18, 0x81, 0x83, 0x30, 0x20, 0x46, 0x0C, 0x18, 0xC1,
  0x83, 0x18, 0x30, 0x66, 0x04, 0x0C, 0xC1, 0x83, 0x18, 0x30, 0x63, 0x06,
  0x0C, 0x40, 0xC1, 0x98, 0x10, 0x23, 0x06, 0x0C, 0x00, 0x0C, 0xE0, 0xBF,
  0x0E, 0x31, 0xC1, 0x18, 0x31, 0x83, 0x18, 0x31, 0x03, 0x30, 0x33, 0x02,
  0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x0C,
  0xC0, 0x80, 0x07, 0x80, 0xFE, 0x18, 0x63, 0x06, 0x30, 0x22, 0x03, 0x60,
  0x26, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0,
  0xCC, 0x18, 0xC3, 0x86, 0x70, 0x7E, 0x00, 0x03, 0x38, 0x05, 0xF8, 0x0A,
  0x18, 0x38, 0x30, 0x70, 0x60, 0xC0, 0xC1, 0x81, 0x82, 0x03, 0x0C, 0x06,
  0x18, 0x0C, 0x30, 0x30, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C,
  0x0C, 0x1C, 0x30, 0x69, 0xC0, 0xDF, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0x98,
  0x7E, 0xC7, 0x14, 0x30, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x04, 0x60,
  0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x38,
  0xC3, 0x83, 0x3C, 0x1F, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x09, 0xE1, 0x78, 0x28, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x00, 0x07, 0x83, 0xFC,
  0x61, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x19, 0xC3, 0xF0, 0x00,
  0x0C, 0x10, 0x20, 0xC1, 0xEF, 0xCC, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x1A, 0x3C, 0x00, 0x18, 0x31, 0x83,
  0x10, 0x33, 0x03, 0x30, 0x23, 0x06, 0x30, 0x66, 0x06, 0x60, 0x66, 0x0C,
  0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x8E, 0xD8,
  0x79, 0x00, 0xC0, 0xF0, 0x3C, 0x0B, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0x18,
  0xC6, 0x31, 0x0C, 0xC3, 0x30, 0xD8, 0x36, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0C, 0x00, 0xC0, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x58, 0x38, 0x6C, 0x3C,
  0x36, 0x16, 0x33, 0x1B, 0x19, 0x8D, 0x88, 0xC4, 0xCC, 0x66, 0x66, 0x32,
  0x36, 0x1B, 0x1B, 0x0D, 0x8D, 0x06, 0x85, 0x83, 0xC2, 0xC1, 0xC1, 0x40,
  0xE0, 0xE0, 0x70, 0x60, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x61,
  0x81, 0x8C, 0x02, 0x30, 0x09, 0x80, 0x34, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x0D, 0x80, 0x32, 0x01, 0x8C, 0x06, 0x30, 0x30,
  0xC1, 0x83, 0x0E, 0x04, 0x00, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0xC0,
  0x20, 0x60, 0x10, 0x60, 0x08, 0x30, 0x04, 0x30, 0x02, 0x18, 0x01, 0x08,
  0x00, 0x8C, 0x00, 0x44, 0x00, 0x26, 0x00, 0x13, 0x00, 0x0B, 0x00, 0x05,
  0x80, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x4E, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x70, 0x1F, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0xF8, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0xC0, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xF0, 0x07, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x38, 0x0F, 0x00, 0x80,
  0x00, 0x7C, 0x0F, 0x79, 0xE0, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 25, 8, 0, -25 },
  { 26, 9, 9, 10, 3, -25 },
  { 37, 15, 25, 14, 0, -25 },
  { 84, 14, 29, 13, 0, -27 },
  { 135, 16, 25, 20, 2, -25 },
  { 185, 13, 25, 13, 0, -25 },
  { 226, 4, 9, 6, 3, -25 },
  { 231, 10, 31, 9, 1, -25 },
  { 270, 10, 31, 9, -2, -25 },
  { 309, 9, 11, 12, 4, -27 },
  { 322, 13, 17, 15, 1, -21 },
  { 350, 5, 9, 6, -1, -4 },
  { 356, 7, 1, 9, 1, -10 },
  { 357, 3, 3, 6, 0, -3 },
  { 359, 15, 25, 11, -2, -25 },
  { 406, 12, 25, 13, 1, -25 },
  { 444, 7, 25, 13, 4, -25 },
  { 466, 14, 25, 13, -1, -25 },
  { 510, 14, 25, 13, -1, -25 },
  { 554, 14, 25, 13, -1, -25 },
  { 598, 14, 25, 13, -1, -25 },
  { 642, 13, 25, 13, 1, -25 },
  { 683, 13, 25, 13, 1, -25 },
  { 724, 13, 25, 13, 0, -25 },
  { 765, 13, 25, 13, 0, -25 },
  { 806, 6, 19, 6, 0, -19 },
  { 821, 8, 24, 6, -2, -19 },
  { 845, 13, 15, 15, 1, -20 },
  { 870, 13, 9, 15, 1, -17 },
  { 885, 13, 15, 15, 1, -20 },
  { 910, 11, 25, 9, 0, -25 },
  { 945, 18, 28, 19, 1, -25 },
  { 1008, 12, 25, 13, -2, -25 },
  { 1046, 14, 25, 14, 0, -25 },
  { 1090, 14, 25, 13, 1, -25 },
  { 1134, 15, 25, 15, 0, -25 },
  { 1181, 14, 25, 12, 0, -25 },
  { 1225, 14, 25, 12, 0, -25 },
  { 1269, 16, 25, 17, 1, -25 },
  { 1319, 17, 25, 16, 0, -25 },
  { 1373, 12, 25, 7, -2, -25 },
  { 1411, 12, 31, 6, -5, -25 },
  { 1458, 16, 25, 13, 0, -25 },
  { 1508, 9, 25, 11, 0, -25 },
  { 1537, 22, 25, 22, 0, -25 },
  { 1606, 18, 25, 17, 0, -25 },
  { 1663, 15, 25, 16, 1, -25 },
  { 1710, 14, 25, 13, 0, -25 },
  { 1754, 15, 31, 16, 1, -25 },
  { 1813, 14, 25, 14, 0, -25 },
  { 1857, 15, 25, 13, -1, -25 },
  { 1904, 12, 25, 11, 2, -25 },
  { 1942, 15, 25, 16, 1, -25 },
  { 1989, 13, 25, 13, 3, -25 },
  { 2030, 22, 25, 22, 3, -25 },
  { 2099, 16, 25, 12, -2, -25 },
  { 2149, 12, 25, 11, 2, -25 },
  { 2187, 14, 25, 11, -1, -25 },
  { 2231, 13, 31, 10, -1, -25 },
  { 2282, 5, 25, 12, 4, -25 },
  { 2298, 13, 31, 10, -2, -25 },
  { 2349, 13, 13, 14, 1, -25 },
  { 2371, 10, 2, 10, -3, 3 },
  { 2374, 4, 6, 8, 5, -27 },
  { 2377, 13, 19, 14, 1, -19 },
  { 2408, 13, 27, 14, 0, -27 },
  { 2452, 10, 19, 10, 1, -19 },
  { 2476, 15, 27, 14, 1, -27 },
  { 2527, 11, 19, 12, 1, -19 },
  { 2554, 15, 35, 7, -4, -27 },
  { 2620, 15, 27, 14, -1, -19 },
  { 2671, 12, 27, 13, 0, -27 },
  { 2712, 7, 25, 6, 0, -25 },
  { 2734, 12, 33, 6, -5, -25 },
  { 2784, 13, 27, 12, 0, -27 },
  { 2828, 8, 27, 6, 0, -27 },
  { 2855, 19, 19, 20, 0, -19 },
  { 2901, 12, 19, 13, 0, -19 },
  { 2930, 12, 19, 13, 1, -19 },
  { 2959, 15, 27, 14, -2, -19 },
  { 3010, 13, 27, 14, 1, -19 },
  { 3054, 11, 19, 9, 0, -19 },
  { 3081, 11, 19, 10, 0, -19 },
  { 3108, 7, 23, 7, 1, -23 },
  { 3129, 12, 19, 14, 1, -19 },
  { 3158, 10, 19, 11, 2, -19 },
  { 3182, 17, 19, 18, 2, -19 },
  { 3223, 14, 19, 11, -2, -19 },
  { 3257, 17, 27, 11, -4, -19 },
  { 3315, 11, 19, 9, -1, -19 },
  { 3342, 12, 31, 11, 1, -25 },
  { 3389, 2, 35, 12, 5, -27 },
  { 3398, 12, 31, 11, -2, -25 },
  { 3445, 13, 3, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC35PT7B_H_
