#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38,
  0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x86, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x06,
  0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0xE0, 0x01, 0xC0, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x81, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x07, 0x03,
  0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0E, 0x0E,
  0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x30,
  0x00, 0x70, 0x30, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xE3, 0x1C, 0x07, 0x84, 0x08, 0x0E, 0x18, 0x00, 0x38, 0x30, 0x00,
  0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x07,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x1E, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xBC, 0x00, 0x02, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x38, 0x00,
  0x10, 0x70, 0x30, 0x61, 0xC0, 0x7C, 0xDF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x1C, 0x07, 0xF8, 0x03, 0x80, 0xE3, 0x80, 0x38, 0x0C, 0x18, 0x07,
  0x01, 0xC1, 0x80, 0x70, 0x18, 0x18, 0x0E, 0x03, 0x81, 0x80, 0xE0, 0x38,
  0x18, 0x1C, 0x07, 0x01, 0x81, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x03, 0x83,
  0x80, 0x60, 0x38, 0x70, 0x0E, 0x03, 0x87, 0x00, 0xE0, 0x30, 0xE0, 0x0E,
  0x03, 0x0E, 0x00, 0xE0, 0x71, 0xC0, 0x0E, 0x07, 0x1C, 0x38, 0xC0, 0x63,
  0x87, 0xEC, 0x0E, 0x38, 0xFE, 0xC0, 0xE7, 0x1C, 0x7C, 0x1C, 0x73, 0x87,
  0xE1, 0xCE, 0x30, 0x3E, 0x38, 0xE7, 0x03, 0x7F, 0x1C, 0x60, 0x77, 0xE1,
  0xCE, 0x07, 0x1C, 0x38, 0xE0, 0x70, 0x03, 0x8E, 0x07, 0x00, 0x70, 0xC0,
  0x70, 0x06, 0x1C, 0x07, 0x00, 0xE1, 0xC0, 0x60, 0x0C, 0x1C, 0x0E, 0x01,
  0xC1, 0x80, 0xE0, 0x18, 0x18, 0x0E, 0x03, 0x81, 0x80, 0xC0, 0x30, 0x18,
  0x1C, 0x07, 0x01, 0x81, 0xC0, 0x60, 0x18, 0x18, 0x0E, 0x01, 0x83, 0x80,
  0xC0, 0x18, 0x70, 0x1C, 0x01, 0xC7, 0x01, 0x80, 0x1F, 0xE0, 0x38, 0x00,
  0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0xE0, 0x00, 0xF7, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEF, 0x00, 0x07,
  0x1C, 0x1C, 0x38, 0x70, 0x71, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x38, 0x0E,
  0x38, 0xE0, 0x38, 0xE7, 0x00, 0xF7, 0x1C, 0x01, 0xDC, 0x70, 0x07, 0xE1,
  0xC0, 0x1F, 0x87, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC1, 0xC0,
  0x1F, 0x07, 0x00, 0xFC, 0x1E, 0x07, 0x70, 0x7C, 0x79, 0xE0, 0xFF, 0xC3,
  0x81, 0xFE, 0x0E, 0x00, 0xC0, 0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C,
  0x71, 0xC6, 0x38, 0xE3, 0x8C, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x04, 0x0C, 0x03, 0x86, 0x03, 0xE3, 0x02, 0x7D,
  0x9E, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xE6, 0x01,
  0xE3, 0x81, 0xE0, 0xC0, 0x60, 0x70, 0x20, 0x1C, 0x00, 0x08, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xF1, 0xE0, 0x0F, 0x07, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0x78, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00,
  0x71, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0xC1, 0xC0,
  0x1C, 0x0E, 0x01, 0xE0, 0x78, 0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0x0F, 0x00,
  0x7D, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0xF7, 0x0F, 0x38, 0xF3, 0x9F, 0x1C,
  0x70, 0xE1, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x3C, 0x00, 0x60, 0x1E, 0x00,
  0x40, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0x83, 0xE0, 0x0C, 0x03, 0xC0, 0x10, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x40, 0x0F, 0x80,
  0xF0, 0x7E, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xCE, 0x00,
  0x03, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE2, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3C,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x20, 0x07, 0xC0, 0x78, 0x3F, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x82, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x71, 0xF8, 0x03, 0x8F, 0xF0,
  0x0E, 0xFF, 0xE0, 0x3B, 0x03, 0xC0, 0xF8, 0x07, 0x03, 0xC0, 0x1C, 0x1F,
  0x00, 0x70, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x70,
  0x07, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x3E, 0x7C,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xCF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x01,
  0xE3, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x80, 0x78, 0x07, 0x01, 0xE0,
  0x0F, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x3F, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xE1, 0xE0, 0x1E,
  0x07, 0x01, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7,
  0x00, 0x1E, 0x38, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x38, 0x0F,
  0xC1, 0xE0, 0xEE, 0x07, 0xFE, 0xF0, 0x1F, 0xE7, 0x00, 0x7C, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x83, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE0, 0x40, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x30, 0x38, 0x01, 0x80, 0x60, 0x70, 0x1F, 0xE0, 0xE1, 0xC0, 0x7F, 0xC1,
  0x83, 0x81, 0xC3, 0x83, 0x06, 0x07, 0x07, 0x06, 0x1C, 0x0E, 0x0C, 0x0C,
  0x38, 0x38, 0x38, 0x18, 0x60, 0x60, 0x70, 0x71, 0xC1, 0xC0, 0xE0, 0xE3,
  0x83, 0x81, 0x81, 0xC6, 0x06, 0x07, 0x03, 0x0C, 0x1C, 0x0E, 0x06, 0x38,
  0x38, 0x1C, 0x1C, 0x70, 0x60, 0x30, 0x38, 0xE0, 0xC0, 0xE0, 0x61, 0x81,
  0x81, 0xC0, 0xC3, 0x07, 0x03, 0x83, 0x86, 0x0E, 0x0E, 0x06, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x78, 0x30, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x73,
  0x73, 0x81, 0xC0, 0xFC, 0x7E, 0x03, 0x80, 0xF0, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0,
  0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0F,
  0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x70,
  0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x1E, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x07,
  0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0x07, 0xC0, 0x0E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1E,
  0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38,
  0x00, 0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x07, 0xC0, 0x70,
  0x0F, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x0E, 0x00,
  0x78, 0x02, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1C, 0x07, 0xC0,
  0x0E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0E,
  0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00,
  0x70, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C,
  0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x07, 0x00, 0x7C, 0x03, 0x80, 0x7C, 0x01, 0xC0, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x0C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xFC, 0x1C, 0x00, 0x7F, 0x83, 0x80, 0x1F, 0xF0, 0xF0, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x1C,
  0x01, 0xF0, 0x03, 0x80, 0x1F, 0xC3, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x70, 0x0E,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80,
  0x70, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x02, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0B, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38,
  0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xB8, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x0F,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00,
  0x3C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3B, 0x80, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x03, 0xB8,
  0x00, 0x39, 0xC0, 0x39, 0xC0, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0x1C, 0xF0,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x38, 0xE0, 0x07, 0x8E, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x0E,
  0x18, 0x01, 0xC7, 0x00, 0x70, 0xC0, 0x1C, 0x38, 0x07, 0x06, 0x00, 0xE1,
  0xC0, 0x38, 0x30, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0xE0, 0x0E, 0x0E,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x38, 0x38, 0x07, 0x03, 0x83, 0x81, 0xC0,
  0x38, 0x1C, 0x1C, 0x1E, 0x01, 0xC0, 0xE1, 0xC0, 0xE0, 0x0E, 0x07, 0x0E,
  0x07, 0x00, 0xF0, 0x38, 0xE0, 0x38, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x38,
  0x0E, 0x78, 0x1E, 0x01, 0xC0, 0x73, 0x80, 0xE0, 0x0E, 0x03, 0x9C, 0x07,
  0x00, 0xE0, 0x1D, 0xC0, 0x38, 0x07, 0x00, 0xEE, 0x01, 0xC0, 0x38, 0x07,
  0xE0, 0x1C, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x0E, 0x01, 0xF0, 0x07, 0x00,
  0xE0, 0x0F, 0x80, 0x38, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0x80, 0x3E, 0x00,
  0x0E, 0x00, 0xFC, 0x00, 0x38, 0x03, 0xF0, 0x00, 0xE0, 0x0F, 0xC0, 0x07,
  0x00, 0x77, 0x00, 0x1C, 0x01, 0xDC, 0x00, 0x70, 0x07, 0x30, 0x01, 0xC0,
  0x1C, 0xE0, 0x0F, 0x00, 0x73, 0x80, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x0E,
  0x38, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xE1, 0xC0, 0x78, 0x07, 0x87,
  0x01, 0xC0, 0x1C, 0x1C, 0x07, 0x00, 0x70, 0x70, 0x1C, 0x01, 0xC1, 0xC0,
  0x70, 0x07, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x0E, 0x00, 0xE0, 0x38, 0x38,
  0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x03, 0x87, 0x80, 0x38, 0x0E, 0x1C, 0x01,
  0xC0, 0x18, 0x70, 0x07, 0x00, 0x71, 0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x70,
  0x07, 0x3C, 0x03, 0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0x73, 0x80, 0x38, 0x00,
  0xEE, 0x00, 0xE0, 0x03, 0xB8, 0x03, 0x80, 0x0E, 0xC0, 0x1E, 0x00, 0x3F,
  0x00, 0x70, 0x00, 0xFC, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0x00, 0x07, 0xC0,
  0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x87,
  0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x07, 0x80,
  0x0E, 0x03, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x38,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0x03, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xE0,
  0x07, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x1C, 0x01,
  0xE0, 0x38, 0x07, 0x80, 0x70, 0x1E, 0x01, 0xE0, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x83,
  0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x73, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F,
  0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0x03, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xE0,
  0x38, 0x07, 0x80, 0x70, 0x3E, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x03, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC1, 0xE0, 0x07, 0x80, 0x30, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x0F, 0x00, 0x7E,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xF8,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01,
  0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xE0,
  0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x1E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3B, 0x80, 0x03, 0xC0, 0x03, 0xDC, 0x00, 0x1E, 0x00, 0x1C, 0xE0, 0x01,
  0xF0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x0F, 0x38, 0x00, 0x7C, 0x00, 0x71,
  0xC0, 0x07, 0xE0, 0x07, 0x8E, 0x00, 0x36, 0x00, 0x38, 0x70, 0x03, 0xB0,
  0x01, 0xC3, 0x80, 0x1D, 0x80, 0x1E, 0x1C, 0x00, 0xCC, 0x00, 0xE0, 0xE0,
  0x0E, 0x60, 0x0F, 0x07, 0x00, 0x73, 0x00, 0x70, 0x38, 0x07, 0x18, 0x03,
  0x81, 0xC0, 0x38, 0xC0, 0x3C, 0x0E, 0x01, 0xC6, 0x01, 0xC0, 0x70, 0x1C,
  0x70, 0x0E, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x1C, 0x0E, 0x1C, 0x07, 0x00,
  0xE0, 0x70, 0xE0, 0x78, 0x07, 0x03, 0x87, 0x03, 0x80, 0x38, 0x38, 0x38,
  0x1C, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0x0E, 0x0C, 0x0E, 0x0E, 0x00, 0x70,
  0xE0, 0x70, 0xF0, 0x03, 0x87, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x1C, 0x38,
  0x00, 0xE3, 0x80, 0xE3, 0x80, 0x07, 0x18, 0x07, 0x1C, 0x00, 0x79, 0xC0,
  0x39, 0xE0, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x77, 0x00, 0x07, 0x30, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x1F,
  0xC0, 0x01, 0xDC, 0x00, 0xDC, 0x00, 0x0E, 0xC0, 0x06, 0xE0, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF7,
  0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x78, 0x03, 0xC3, 0x80, 0x38,
  0x38, 0x07, 0x83, 0x80, 0x70, 0x38, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x03, 0x81, 0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03,
  0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE3, 0xC7, 0x1C, 0x38, 0xE1, 0x87, 0x0C, 0x00,
  0x3C, 0x00, 0x07, 0xF8, 0xC0, 0x7F, 0xCE, 0x07, 0x87, 0x70, 0x78, 0x1B,
  0x87, 0x80, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF1, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x07, 0xC1, 0xC0, 0x3E,
  0x0F, 0x03, 0x60, 0x3C, 0x73, 0x01, 0xFF, 0x38, 0x07, 0xF1, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0xFF, 0x00, 0xE7, 0xFE, 0x03, 0xB8,
  0x78, 0x0F, 0x80, 0xE0, 0x3E, 0x03, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x1C,
  0x1E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80,
  0x1C, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x1C, 0x06, 0x71, 0xF0,
  0x39, 0xFF, 0x80, 0xE3, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x78, 0x20, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE3,
  0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x38, 0x00, 0xFF, 0x38, 0x01, 0xFF, 0xB8, 0x03, 0xC3, 0xB8, 0x07,
  0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1C,
  0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xF0,
  0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x1F, 0x00, 0xE0, 0x17, 0x00, 0xF0,
  0x36, 0x00, 0x78, 0xE6, 0x00, 0x7F, 0xCE, 0x00, 0x3F, 0x8E, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x0F, 0x07,
  0x01, 0xC3, 0xC0, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00,
  0xE3, 0x80, 0x39, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x07, 0x8F, 0x0F, 0xC3,
  0xFF, 0xC0, 0xFF, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x08, 0x1E, 0x0E, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE7, 0x00, 0x3F, 0xF7, 0x00, 0x78,
  0x77, 0x00, 0xF0, 0x37, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1E, 0x03, 0xC0,
  0x1E, 0x03, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x1C, 0x00,
  0xF0, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x07,
  0xE0, 0x1E, 0x07, 0xC0, 0x0F, 0x1D, 0xC0, 0x0F, 0xF9, 0xC0, 0x07, 0xF1,
  0xC0, 0x00, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x80, 0x1E, 0x00, 0xC0, 0x3C, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0xE0, 0x07, 0x3F, 0xC0, 0x77,
  0xFE, 0x03, 0xB0, 0x78, 0x1F, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x70,
  0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x10, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xBE, 0x00, 0x0F, 0xF8,
  0x00, 0x76, 0xE0, 0x01, 0xF3, 0x80, 0x07, 0xCE, 0x00, 0x1E, 0x3C, 0x00,
  0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0xCF, 0xF0, 0xFF, 0x00, 0xEF, 0xFC, 0xFF, 0xC0,
  0x76, 0x1E, 0xE1, 0xE0, 0x3E, 0x07, 0xE0, 0x70, 0x1E, 0x03, 0xE0, 0x3C,
  0x0E, 0x01, 0xE0, 0x1C, 0x0F, 0x00, 0xF0, 0x0E, 0x07, 0x80, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x00,
  0xE0, 0xE0, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x38, 0x1C, 0x01, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0x1E, 0x0E, 0x00, 0xE0,
  0x0E, 0x07, 0x00, 0x70, 0x07, 0x03, 0x80, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x01, 0xC1, 0xC0, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x1C, 0x1C, 0x01,
  0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x03, 0x83, 0xC0, 0x1C, 0x03, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0x0C, 0x7F, 0x80, 0xEF, 0xFC, 0x07, 0x60, 0xF0, 0x3E, 0x03,
  0x81, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x38, 0x38,
  0x03, 0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x78, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x78, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xE1, 0xE0, 0x70, 0x1C, 0x1E,
  0x03, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x1C, 0xE0,
  0x03, 0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00,
  0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0F, 0x03, 0xC0, 0xF1, 0xF0, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x18, 0xFF,
  0x00, 0x1C, 0xFF, 0xC0, 0x0E, 0xE1, 0xE0, 0x07, 0xE0, 0x70, 0x03, 0xE0,
  0x3C, 0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x78,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E,
  0x00, 0x3C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x3C, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x3C,
  0x03, 0x80, 0x1C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1E,
  0x00, 0x77, 0x1F, 0x00, 0x3B, 0xFF, 0x00, 0x38, 0xFE, 0x00, 0x1C, 0x08,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF9, 0xC0,
  0x7F, 0xEE, 0x07, 0x87, 0x70, 0x78, 0x1B, 0x87, 0x80, 0x78, 0x38, 0x03,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x0F, 0x07,
  0x00, 0x78, 0x38, 0x07, 0xC1, 0xC0, 0x3E, 0x0F, 0x03, 0xE0, 0x3C, 0x77,
  0x01, 0xFF, 0x38, 0x07, 0xF1, 0xC0, 0x04, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x63, 0xE0,
  0x3B, 0xF8, 0x0E, 0xE2, 0x03, 0xF0, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x81, 0xE0, 0x60, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x08, 0x03, 0xC1, 0xE1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x1F, 0xF9, 0xFF, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x10, 0x3F, 0x81, 0xFC, 0x01, 0x00, 0x07, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0,
  0xE0, 0x3E, 0x0E, 0x06, 0xC0, 0xF1, 0xEC, 0x0F, 0xFD, 0xC0, 0x7F, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C,
  0xE0, 0x07, 0x38, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x1C, 0x18,
  0x0F, 0x06, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x70, 0x18, 0x1C, 0x06, 0x0E,
  0x01, 0x83, 0x80, 0x61, 0xE0, 0x18, 0x70, 0x06, 0x1C, 0x01, 0x8E, 0x00,
  0x63, 0x80, 0x19, 0xC0, 0x06, 0x70, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1B,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x3B, 0x80, 0x3C, 0x01, 0xDC, 0x03, 0xE0, 0x1C,
  0xE0, 0x1F, 0x00, 0xE7, 0x00, 0xF8, 0x0E, 0x38, 0x0F, 0xC0, 0x71, 0xC0,
  0x6E, 0x03, 0x8E, 0x07, 0x70, 0x38, 0x70, 0x3B, 0x81, 0xC3, 0x81, 0x9C,
  0x1C, 0x18, 0x1C, 0xE0, 0xE0, 0xC0, 0xC7, 0x07, 0x06, 0x0E, 0x38, 0x70,
  0x30, 0x71, 0xC3, 0x83, 0x83, 0x0E, 0x18, 0x1C, 0x38, 0x71, 0xC0, 0xE1,
  0x83, 0x0E, 0x07, 0x1C, 0x18, 0xE0, 0x38, 0xE0, 0xC7, 0x01, 0xC6, 0x06,
  0x30, 0x0E, 0x70, 0x33, 0x80, 0x73, 0x81, 0x9C, 0x03, 0xB8, 0x0D, 0xC0,
  0x1D, 0xC0, 0x6E, 0x00, 0xEC, 0x03, 0x60, 0x07, 0xE0, 0x1F, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x03,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x1E,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x03, 0x80,
  0xF0, 0x03, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x18, 0x1C,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x40, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 42, 13, 1, -42 },
  { 64, 14, 15, 18, 6, -42 },
  { 91, 24, 42, 23, 0, -42 },
  { 217, 23, 48, 22, 0, -45 },
  { 355, 28, 44, 33, 3, -43 },
  { 509, 22, 44, 22, -1, -43 },
  { 630, 6, 15, 10, 6, -42 },
  { 642, 17, 51, 15, 1, -42 },
  { 751, 17, 51, 15, -4, -42 },
  { 860, 17, 18, 20, 6, -45 },
  { 899, 21, 28, 24, 2, -35 },
  { 973, 8, 14, 11, -2, -6 },
  { 987, 13, 2, 15, 1, -17 },
  { 991, 4, 5, 11, 1, -5 },
  { 994, 26, 42, 18, -3, -42 },
  { 1131, 21, 44, 22, 1, -43 },
  { 1247, 13, 42, 22, 6, -42 },
  { 1316, 24, 43, 22, -2, -43 },
  { 1445, 23, 44, 22, -1, -43 },
  { 1572, 23, 43, 22, -1, -43 },
  { 1696, 23, 43, 22, -1, -42 },
  { 1820, 22, 44, 22, 1, -43 },
  { 1941, 22, 42, 22, 2, -42 },
  { 2057, 23, 44, 22, -1, -43 },
  { 2184, 21, 44, 22, 0, -43 },
  { 2300, 10, 32, 11, 0, -32 },
  { 2340, 14, 40, 11, -3, -32 },
  { 2410, 21, 26, 24, 2, -34 },
  { 2479, 21, 16, 24, 2, -29 },
  { 2521, 21, 26, 24, 2, -34 },
  { 2590, 17, 43, 16, 1, -43 },
  { 2682, 31, 47, 32, 1, -42 },
  { 2865, 22, 42, 22, -4, -42 },
  { 2981, 24, 42, 24, 0, -42 },
  { 3107, 24, 44, 21, 2, -43 },
  { 3239, 25, 42, 26, 0, -42 },
  { 3371, 23, 42, 21, 0, -42 },
  { 3492, 23, 42, 19, 0, -42 },
  { 3613, 27, 44, 28, 2, -43 },
  { 3762, 28, 42, 27, 0, -42 },
  { 3909, 20, 42, 13, -3, -42 },
  { 4014, 21, 53, 11, -9, -42 },
  { 4154, 27, 42, 22, 0, -42 },
  { 4296, 15, 42, 19, 0, -42 },
  { 4375, 37, 42, 36, 0, -42 },
  { 4570, 30, 42, 29, 0, -42 },
  { 4728, 25, 44, 28, 2, -43 },
  { 4866, 23, 42, 22, 0, -42 },
  { 4987, 25, 53, 28, 2, -43 },
  { 5153, 23, 42, 23, 0, -42 },
  { 5274, 25, 44, 21, -2, -43 },
  { 5412, 19, 42, 19, 4, -42 },
  { 5512, 26, 43, 26, 2, -42 },
  { 5652, 22, 42, 22, 5, -42 },
  { 5768, 37, 42, 37, 4, -42 },
  { 5963, 27, 42, 20, -3, -42 },
  { 6105, 20, 42, 19, 4, -42 },
  { 6210, 24, 42, 19, -2, -42 },
  { 6336, 21, 51, 16, -1, -42 },
  { 6470, 9, 42, 19, 6, -42 },
  { 6518, 22, 51, 16, -4, -42 },
  { 6659, 22, 21, 23, 1, -42 },
  { 6717, 17, 3, 17, -5, 5 },
  { 6724, 6, 9, 13, 9, -45 },
  { 6731, 21, 33, 24, 2, -32 },
  { 6818, 22, 46, 23, 0, -45 },
  { 6945, 17, 33, 17, 2, -32 },
  { 7016, 24, 46, 24, 2, -45 },
  { 7154, 18, 33, 21, 2, -32 },
  { 7229, 27, 59, 12, -8, -45 },
  { 7429, 24, 46, 24, -1, -32 },
  { 7567, 21, 45, 23, 0, -45 },
  { 7686, 12, 43, 10, 0, -43 },
  { 7751, 21, 57, 10, -8, -43 },
  { 7901, 22, 45, 19, 0, -45 },
  { 8025, 13, 45, 10, 0, -45 },
  { 8099, 33, 32, 34, 0, -32 },
  { 8231, 21, 32, 23, 0, -32 },
  { 8315, 19, 33, 23, 2, -32 },
  { 8394, 25, 46, 23, -3, -32 },
  { 8538, 21, 46, 24, 2, -32 },
  { 8659, 18, 32, 15, 0, -32 },
  { 8731, 19, 33, 17, -1, -32 },
  { 8810, 13, 40, 12, 1, -39 },
  { 8875, 20, 32, 23, 2, -31 },
  { 8955, 18, 31, 18, 3, -31 },
  { 9025, 29, 31, 30, 3, -31 },
  { 9138, 24, 31, 19, -3, -31 },
  { 9231, 28, 45, 19, -6, -31 },
  { 9389, 19, 31, 15, -2, -31 },
  { 9463, 20, 51, 19, 2, -42 },
  { 9591, 3, 59, 21, 9, -45 },
  { 9614, 21, 51, 19, -4, -42 },
  { 9748, 21, 6, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC59PT7B_H_
