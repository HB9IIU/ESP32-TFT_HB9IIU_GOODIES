#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x18, 0x67, 0x1C, 0xE3, 0x98, 0x73, 0x0C, 0x61, 0x9C,
  0x33, 0x0E, 0x61, 0x8C, 0x31, 0x86, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x10, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x81, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0xC1, 0x80, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x79, 0x18, 0x18, 0x40, 0x0E, 0x30, 0x03,
  0x0C, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xE6,
  0x00, 0x1D, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xB8, 0x00, 0x26, 0x00, 0x19, 0xC0, 0x06, 0x30, 0x01, 0x0C, 0x00,
  0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x20, 0x8E, 0x0E, 0x27,
  0x03, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x38, 0x3F, 0x00, 0xC1, 0xC6,
  0x06, 0x06, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x18,
  0x18, 0x18, 0x60, 0x60, 0xC3, 0x01, 0x83, 0x0C, 0x06, 0x0C, 0x60, 0x38,
  0x31, 0x80, 0xC0, 0xCC, 0x03, 0x06, 0x31, 0xEC, 0x19, 0x8F, 0xF0, 0xE6,
  0x63, 0xC3, 0x33, 0x8F, 0x9C, 0xCC, 0x37, 0xE6, 0x70, 0xDF, 0x19, 0x83,
  0x00, 0xC6, 0x0C, 0x03, 0x18, 0x30, 0x18, 0xC0, 0xC0, 0x63, 0x07, 0x03,
  0x0C, 0x18, 0x0C, 0x30, 0x60, 0x60, 0xC1, 0x81, 0x83, 0x0E, 0x0C, 0x0C,
  0x30, 0x30, 0x31, 0xC1, 0x80, 0xC6, 0x06, 0x03, 0xF0, 0x30, 0x07, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x63, 0x80, 0x70, 0xC0,
  0x30, 0x60, 0x18, 0x30, 0x0C, 0x38, 0x0E, 0x1C, 0x07, 0x0C, 0x03, 0x8E,
  0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x30, 0xE7, 0x18, 0x63, 0x0E, 0x33,
  0x07, 0x39, 0x81, 0x99, 0xC0, 0xDC, 0xC0, 0x7C, 0x60, 0x1E, 0x30, 0x0E,
  0x18, 0x07, 0x0C, 0x07, 0x86, 0x07, 0xC3, 0x87, 0x70, 0xFF, 0x38, 0x3F,
  0x0C, 0x00, 0x37, 0x76, 0x66, 0x6C, 0xCC, 0xC8, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x86,
  0x0E, 0x20, 0x3D, 0x18, 0x7F, 0xE0, 0xE0, 0x0F, 0x00, 0xC8, 0x1C, 0x61,
  0xC3, 0x84, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E,
  0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0x8E, 0x03, 0x06, 0x07, 0x07,
  0x0E, 0x07, 0x0C, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x60, 0x0E,
  0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18,
  0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xE0,
  0xE0, 0xC0, 0x61, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x01, 0xC0, 0xE0, 0x78,
  0x76, 0x3B, 0x9C, 0xEE, 0x31, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0x07, 0x00, 0x40, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0x38, 0x38, 0x08, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x08, 0x0F, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x01, 0xB8, 0x00, 0xEE, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x30, 0x60, 0x0C, 0x38,
  0x06, 0x0E, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C,
  0x07, 0x06, 0x01, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x78, 0x00, 0xFF,
  0x80, 0x39, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x0C, 0x0F,
  0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x78,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x9F, 0x80,
  0xDF, 0xE0, 0xF8, 0x38, 0x78, 0x1C, 0x38, 0x06, 0x1C, 0x03, 0x0C, 0x01,
  0x8E, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x0C, 0x38, 0x06, 0x1C, 0x07, 0x0E, 0x03, 0x03, 0x03, 0x81, 0xC3, 0x80,
  0x7F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xE0, 0xE0, 0xE0,
  0x70, 0x60, 0x18, 0x70, 0x0C, 0x38, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x87,
  0x01, 0xC3, 0x80, 0xC0, 0xC0, 0xE0, 0x70, 0xE0, 0x18, 0xE0, 0x0F, 0xE0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xB8, 0x07, 0x0E, 0x07, 0x07, 0x07, 0x01,
  0xC3, 0x00, 0xE3, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x01, 0xC7, 0x01, 0xC1, 0xC1, 0xC0, 0xFF, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01,
  0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x30,
  0x1E, 0x18, 0x0F, 0x0E, 0x0F, 0x83, 0xFD, 0x80, 0xFC, 0xC0, 0x10, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0x02, 0x07, 0x07, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xF0, 0xE0, 0xE0, 0x00, 0x80, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x86, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C,
  0x07, 0x83, 0x18, 0x1F, 0xC3, 0x18, 0x38, 0xC7, 0x18, 0x71, 0x86, 0x30,
  0x61, 0x86, 0x30, 0xC1, 0x86, 0x30, 0xC1, 0x86, 0x61, 0xC3, 0x06, 0x61,
  0x83, 0x06, 0x61, 0x83, 0x0C, 0x61, 0x87, 0x0C, 0x63, 0x86, 0x0C, 0xC3,
  0x06, 0x08, 0xC3, 0x0E, 0x18, 0xC3, 0x0E, 0x18, 0xC3, 0x1E, 0x30, 0xC1,
  0x96, 0x60, 0xC1, 0xF3, 0xC0, 0xC0, 0xE1, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x08, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x6E, 0x00, 0x77, 0x00, 0x33, 0x80, 0x19, 0xC0, 0x1C, 0xE0, 0x0C,
  0x70, 0x0E, 0x38, 0x06, 0x1C, 0x03, 0x0E, 0x03, 0x87, 0x01, 0x83, 0x81,
  0xC1, 0xC0, 0xC0, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x30, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x73, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x01, 0xFE,
  0x00, 0x3F, 0xF0, 0x06, 0x1F, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x06, 0x01,
  0xC0, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x07,
  0x03, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x07, 0x80, 0x7F, 0xC0,
  0x0F, 0xFC, 0x03, 0x83, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x81, 0x80, 0x70,
  0x30, 0x06, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x30, 0x07, 0x06, 0x00, 0xE1,
  0xC0, 0x18, 0x38, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x3E, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1E, 0x08,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x82, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x06, 0x3E, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x06, 0x01, 0xC0, 0xC0,
  0x38, 0x38, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x30, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x0C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x38,
  0x38, 0x07, 0x06, 0x01, 0xC0, 0xC0, 0xF0, 0x18, 0x7C, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x20, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0xC0, 0x78, 0x1C, 0x07, 0x80, 0x20, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x1F, 0xC7, 0x00, 0xFE, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00,
  0x60, 0x38, 0x03, 0x01, 0xE0, 0x38, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x06, 0x03,
  0x80, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x60,
  0x38, 0x01, 0x80, 0xC0, 0x06, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x70,
  0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x07,
  0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00,
  0x70, 0x38, 0x01, 0x80, 0xE0, 0x06, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x38, 0x0C, 0x03,
  0x80, 0x60, 0x38, 0x07, 0x01, 0x80, 0x38, 0x1C, 0x01, 0x81, 0xC0, 0x0C,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00,
  0x0C, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x33, 0x80, 0x01, 0xB8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x98, 0x00, 0x38, 0xC0, 0x01,
  0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x06, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x01, 0xB0, 0x00, 0xD8, 0x0D, 0x80, 0x07, 0xC0, 0xEC, 0x00,
  0x6E, 0x07, 0x60, 0x03, 0x60, 0x33, 0x00, 0x3B, 0x01, 0x98, 0x01, 0x98,
  0x0C, 0xC0, 0x1D, 0xC0, 0xE6, 0x00, 0xCE, 0x07, 0x30, 0x0E, 0x60, 0x31,
  0x80, 0x63, 0x01, 0x8C, 0x07, 0x18, 0x0C, 0x60, 0x31, 0xC0, 0xE3, 0x03,
  0x8E, 0x06, 0x18, 0x18, 0x60, 0x30, 0xC1, 0xC3, 0x01, 0x86, 0x0C, 0x38,
  0x1C, 0x30, 0x61, 0xC0, 0xE1, 0xC6, 0x0C, 0x06, 0x0E, 0x30, 0x60, 0x30,
  0x73, 0x83, 0x01, 0x83, 0x98, 0x38, 0x1C, 0x1D, 0xC1, 0xC0, 0xE0, 0x6C,
  0x0C, 0x06, 0x03, 0xE0, 0x60, 0x30, 0x1E, 0x03, 0x01, 0x80, 0xF0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x06, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x38, 0x1F, 0x00, 0x70, 0x3E, 0x00, 0xC0, 0x6C,
  0x01, 0x80, 0xD8, 0x07, 0x03, 0xB0, 0x0E, 0x07, 0x60, 0x1C, 0x0C, 0xE0,
  0x30, 0x18, 0xC0, 0x60, 0x31, 0x81, 0xC0, 0xE3, 0x03, 0x81, 0xC6, 0x06,
  0x03, 0x0C, 0x0C, 0x06, 0x1C, 0x18, 0x0C, 0x18, 0x70, 0x38, 0x30, 0xE0,
  0x70, 0x61, 0x80, 0xC0, 0xC3, 0x01, 0x81, 0xC6, 0x07, 0x03, 0x9C, 0x0E,
  0x03, 0x38, 0x18, 0x06, 0x60, 0x30, 0x0C, 0xC0, 0x60, 0x19, 0x81, 0xC0,
  0x3F, 0x03, 0x80, 0x7C, 0x06, 0x00, 0x78, 0x0C, 0x00, 0xF0, 0x18, 0x01,
  0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x0F, 0x0F, 0x01, 0xC0, 0xE0, 0x70, 0x0C, 0x1C, 0x01, 0xC3, 0x00, 0x38,
  0xE0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x98, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x07, 0x30,
  0x00, 0xE6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60,
  0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x18, 0xF8, 0x0E, 0x0E, 0x03,
  0x81, 0xC0, 0xC0, 0x70, 0x30, 0x0C, 0x1C, 0x03, 0x07, 0x01, 0xC1, 0xC0,
  0x70, 0x60, 0x1C, 0x18, 0x07, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xC0, 0x30,
  0x30, 0x1C, 0x0C, 0x1E, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0x0F,
  0x01, 0xC0, 0xE0, 0x70, 0x0C, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07,
  0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x98, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x01, 0xD8, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xE6,
  0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x0E,
  0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x18, 0xF8, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0xC0, 0x70, 0x30, 0x1C, 0x1C,
  0x03, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x60, 0x1C, 0x18, 0x07, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0xC0, 0x70, 0x30, 0x3C, 0x0C, 0x7E, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x61, 0x80, 0x18, 0x70, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE0,
  0xC0, 0x30, 0x30, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x18,
  0x18, 0x06, 0x06, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x1C, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xFC, 0x07, 0x83, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC1, 0x00, 0x70, 0x30, 0x1E, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x18, 0x01,
  0x81, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x38, 0x38,
  0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x30,
  0x38, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00,
  0x30, 0x38, 0x01, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x03,
  0x00, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x06,
  0x03, 0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x38,
  0x0C, 0x01, 0xC0, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x03,
  0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0xE6, 0x00, 0x73, 0x00,
  0x31, 0x80, 0x38, 0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0E, 0x18, 0x06, 0x0C,
  0x07, 0x06, 0x03, 0x03, 0x03, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0x60, 0xE0,
  0x30, 0x60, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x01, 0x9C,
  0x00, 0xCE, 0x00, 0x66, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x1B, 0x00, 0x38, 0x01, 0xD8, 0x01, 0xC0, 0x0C, 0xC0, 0x0E, 0x00, 0xE6,
  0x00, 0xF0, 0x07, 0x30, 0x07, 0x80, 0x31, 0x80, 0x7C, 0x03, 0x8C, 0x03,
  0x60, 0x18, 0x60, 0x1B, 0x01, 0xC3, 0x01, 0xD8, 0x0E, 0x18, 0x0C, 0xC0,
  0x60, 0xC0, 0x66, 0x07, 0x06, 0x06, 0x30, 0x30, 0x30, 0x31, 0x83, 0x81,
  0x83, 0x8C, 0x1C, 0x0C, 0x18, 0x60, 0xC0, 0x60, 0xC3, 0x0E, 0x03, 0x0C,
  0x18, 0x60, 0x18, 0x60, 0xC7, 0x00, 0xC7, 0x06, 0x38, 0x06, 0x30, 0x71,
  0x80, 0x31, 0x83, 0x9C, 0x01, 0x98, 0x1C, 0xC0, 0x1C, 0xC0, 0xEE, 0x00,
  0xEE, 0x06, 0x70, 0x07, 0x60, 0x33, 0x00, 0x3B, 0x01, 0xB8, 0x01, 0xF8,
  0x0D, 0x80, 0x0F, 0x80, 0x6C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01,
  0x83, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x71, 0x80, 0x01, 0xCE,
  0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x36, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x07,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x38, 0x70, 0x30, 0x30, 0x70, 0x30, 0x60, 0x30, 0xE0,
  0x30, 0xC0, 0x31, 0xC0, 0x31, 0x80, 0x33, 0x80, 0x3B, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xC3, 0x0C,
  0x30, 0xE3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC3,
  0x0E, 0x38, 0x61, 0x86, 0x18, 0x61, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x19,
  0xC0, 0x0C, 0x60, 0x0C, 0x38, 0x0E, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x83,
  0x00, 0xC3, 0x80, 0x61, 0x80, 0x39, 0xC0, 0x0C, 0xC0, 0x07, 0xC0, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x18, 0xE3, 0x18, 0x60, 0x00, 0xF0,
  0x01, 0xFC, 0xC1, 0xE7, 0x61, 0xC1, 0xF0, 0xE0, 0x70, 0xE0, 0x38, 0x60,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x01, 0xC6,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x06, 0x1C, 0x07, 0x0E, 0x03, 0x83, 0x02, 0xC1, 0xC3, 0xE0, 0xFF,
  0x60, 0x3F, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC7, 0x00, 0xCF, 0xE0, 0x6C, 0x70, 0x3C, 0x1C, 0x3C, 0x0E,
  0x1E, 0x03, 0x0E, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x71, 0xC0,
  0x38, 0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x03, 0x8C,
  0x01, 0x86, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xF0, 0x70,
  0x78, 0x38, 0x67, 0xF8, 0x31, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x78,
  0x83, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x04, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x03, 0xC6, 0x01, 0xFC, 0xC0, 0x79, 0xF8, 0x1C, 0x1F,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x18, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x18,
  0x18, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x60,
  0x60, 0x0C, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0x81,
  0xC0, 0x70, 0x38, 0x1E, 0x03, 0x02, 0xC0, 0x70, 0xF8, 0x0F, 0xF6, 0x00,
  0xFC, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1E, 0x70, 0x70, 0x60, 0xC0,
  0xE3, 0x81, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x1C, 0xE0, 0x71, 0xC1, 0xC3,
  0x1F, 0x07, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x08, 0x1F, 0xF0,
  0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xCC, 0x07, 0x9D, 0x81, 0xC1,
  0xF0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01,
  0xC1, 0x80, 0x30, 0x70, 0x06, 0x0E, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x06,
  0x06, 0x00, 0xC1, 0xC0, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xE0, 0x30, 0x3C, 0x07, 0x0F, 0x80, 0xFF, 0x60,
  0x0F, 0xCC, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x80, 0x70, 0x18, 0x3C, 0x03,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x3C, 0x06, 0x7F, 0x06, 0xE7, 0x07, 0x83, 0x07, 0x03, 0x0E,
  0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x1C, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0xE0,
  0x38, 0xE0, 0x30, 0x01, 0xC0, 0xF0, 0x38, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x20, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x70, 0x38, 0x70, 0x1C, 0x30, 0x0C,
  0x38, 0x06, 0x38, 0x03, 0x38, 0x03, 0x98, 0x01, 0xDC, 0x00, 0xDE, 0x00,
  0x7F, 0x00, 0x3D, 0x80, 0x3C, 0xC0, 0x1C, 0x70, 0x0C, 0x38, 0x06, 0x0C,
  0x03, 0x06, 0x03, 0x83, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x70,
  0x18, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x00,
  0x00, 0x3C, 0x1E, 0x03, 0x3F, 0x3F, 0x81, 0xB3, 0xD8, 0xE0, 0xF0, 0xF8,
  0x30, 0xF0, 0x38, 0x18, 0x70, 0x18, 0x0C, 0x38, 0x1C, 0x06, 0x18, 0x0E,
  0x03, 0x0C, 0x07, 0x03, 0x8E, 0x03, 0x01, 0xC7, 0x01, 0x80, 0xC3, 0x01,
  0xC0, 0x61, 0x80, 0xE0, 0x70, 0xC0, 0x60, 0x38, 0xE0, 0x30, 0x18, 0x70,
  0x18, 0x0C, 0x30, 0x1C, 0x06, 0x18, 0x0E, 0x07, 0x0C, 0x06, 0x03, 0x8E,
  0x03, 0x01, 0x86, 0x01, 0x80, 0xC3, 0x01, 0xC0, 0x61, 0x80, 0xC0, 0x71,
  0xC0, 0x60, 0x38, 0xE0, 0x30, 0x18, 0x00, 0x00, 0x3C, 0x06, 0x7F, 0x06,
  0xE7, 0x07, 0x83, 0x0F, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C,
  0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x38,
  0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x70, 0x18, 0x70,
  0x18, 0x60, 0x18, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0x00, 0xF0, 0x07,
  0xF8, 0x1E, 0x70, 0x70, 0x70, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x9C, 0x03,
  0x30, 0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x80, 0x36, 0x00, 0xEC, 0x01, 0xD8,
  0x03, 0xF0, 0x06, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xCE, 0x03,
  0x0C, 0x0E, 0x1C, 0x38, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x33,
  0xF8, 0x06, 0xC7, 0x00, 0xF0, 0x70, 0x1C, 0x0E, 0x07, 0x80, 0xC0, 0xE0,
  0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x00,
  0x70, 0x60, 0x0E, 0x0C, 0x01, 0x83, 0x80, 0x30, 0x70, 0x0E, 0x0C, 0x01,
  0xC1, 0x80, 0x30, 0x30, 0x0E, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x3C, 0x1C,
  0x07, 0x87, 0x81, 0xDF, 0xE0, 0x39, 0xF8, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFC, 0xC1, 0xE7, 0x61, 0xC1, 0xF0, 0xE0, 0x70, 0xE0, 0x38, 0x60,
  0x1C, 0x70, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xC6,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0xC1, 0xC3, 0xE0, 0xFF,
  0x60, 0x3F, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x19, 0xE0, 0x6F, 0x81, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0xFC, 0x1C, 0x38, 0x70, 0x20, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x30, 0x38, 0x7F, 0xE0, 0x7F, 0x80, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x83, 0xFC, 0xFE, 0x0C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xFC, 0x1F, 0x00,
  0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x70, 0x1C, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0xE0, 0x38,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xE1, 0xB0, 0x7F, 0x70, 0x7E, 0x60,
  0xC0, 0x3E, 0x01, 0xB0, 0x0D, 0x80, 0xEC, 0x06, 0x60, 0x73, 0x03, 0x18,
  0x38, 0xC1, 0x86, 0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x70, 0x63, 0x03, 0x38,
  0x19, 0x80, 0xDC, 0x06, 0xC0, 0x36, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x38, 0x1F, 0x01, 0xC0, 0x6C, 0x07, 0x01, 0xB0,
  0x3C, 0x0E, 0xC0, 0xF0, 0x33, 0x03, 0xC0, 0xCC, 0x1B, 0x06, 0x30, 0x6C,
  0x18, 0xC3, 0x30, 0xE3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x31, 0x8C, 0x60,
  0xC6, 0x31, 0x83, 0x30, 0xCE, 0x0C, 0xC3, 0x30, 0x37, 0x0C, 0xC0, 0xD8,
  0x37, 0x03, 0x60, 0xD8, 0x0F, 0x03, 0x60, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x03, 0x01, 0xC0,
  0xC0, 0xE0, 0x38, 0x30, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x19,
  0xC0, 0x06, 0x60, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x70, 0x03,
  0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0E, 0x06, 0x03,
  0x83, 0x80, 0x60, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0E, 0x03, 0x80,
  0x38, 0x0C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0,
  0x00, 0x63, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x18, 0x00,
  0x7F, 0x01, 0xFF, 0xC3, 0x81, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 33, 10, 1, -33 },
  { 39, 11, 12, 14, 4, -33 },
  { 56, 19, 33, 18, 0, -33 },
  { 135, 18, 38, 17, 0, -35 },
  { 221, 22, 34, 26, 2, -33 },
  { 315, 17, 33, 17, 0, -33 },
  { 386, 4, 12, 8, 5, -33 },
  { 392, 13, 40, 11, 1, -33 },
  { 457, 13, 40, 12, -3, -33 },
  { 522, 13, 14, 16, 5, -35 },
  { 545, 16, 21, 19, 2, -27 },
  { 587, 7, 11, 8, -2, -5 },
  { 597, 10, 3, 12, 1, -14 },
  { 601, 3, 4, 8, 1, -4 },
  { 603, 20, 33, 14, -2, -33 },
  { 686, 16, 33, 17, 1, -33 },
  { 752, 10, 33, 17, 5, -33 },
  { 794, 19, 33, 17, -2, -33 },
  { 873, 18, 33, 17, -1, -33 },
  { 948, 18, 33, 17, -1, -33 },
  { 1023, 18, 33, 17, -1, -33 },
  { 1098, 17, 33, 17, 1, -33 },
  { 1169, 17, 33, 17, 2, -33 },
  { 1240, 17, 33, 17, 0, -33 },
  { 1311, 17, 33, 17, 0, -33 },
  { 1382, 8, 25, 8, 0, -25 },
  { 1407, 10, 31, 8, -2, -25 },
  { 1446, 16, 20, 19, 2, -26 },
  { 1486, 16, 12, 19, 2, -22 },
  { 1510, 16, 20, 19, 2, -26 },
  { 1550, 13, 33, 12, 1, -33 },
  { 1604, 24, 37, 25, 1, -33 },
  { 1715, 17, 33, 17, -3, -33 },
  { 1786, 19, 33, 18, 0, -33 },
  { 1865, 18, 33, 17, 2, -33 },
  { 1940, 19, 33, 20, 0, -33 },
  { 2019, 18, 33, 16, 0, -33 },
  { 2094, 18, 33, 15, 0, -33 },
  { 2169, 21, 33, 22, 2, -33 },
  { 2256, 22, 33, 21, 0, -33 },
  { 2347, 15, 33, 10, -2, -33 },
  { 2409, 16, 41, 8, -7, -33 },
  { 2491, 21, 33, 17, 0, -33 },
  { 2578, 11, 33, 15, 0, -33 },
  { 2624, 29, 33, 28, 0, -33 },
  { 2744, 23, 33, 22, 0, -33 },
  { 2839, 19, 33, 22, 2, -33 },
  { 2918, 18, 33, 17, 0, -33 },
  { 2993, 19, 41, 22, 2, -33 },
  { 3091, 18, 33, 18, 0, -33 },
  { 3166, 19, 33, 17, -1, -33 },
  { 3245, 15, 33, 15, 3, -33 },
  { 3307, 21, 33, 21, 1, -33 },
  { 3394, 17, 33, 17, 4, -33 },
  { 3465, 29, 33, 29, 3, -33 },
  { 3585, 22, 33, 16, -3, -33 },
  { 3676, 16, 33, 15, 3, -33 },
  { 3742, 20, 33, 15, -2, -33 },
  { 3825, 17, 40, 13, -1, -33 },
  { 3910, 6, 33, 15, 5, -33 },
  { 3935, 17, 40, 13, -3, -33 },
  { 4020, 17, 17, 18, 1, -33 },
  { 4057, 13, 2, 13, -4, 4 },
  { 4061, 5, 7, 10, 7, -35 },
  { 4066, 17, 25, 18, 1, -25 },
  { 4120, 17, 35, 18, 0, -35 },
  { 4195, 14, 25, 13, 1, -25 },
  { 4239, 19, 35, 18, 1, -35 },
  { 4323, 15, 25, 16, 1, -25 },
  { 4370, 21, 46, 10, -6, -35 },
  { 4491, 19, 36, 18, -1, -25 },
  { 4577, 16, 35, 18, 0, -35 },
  { 4647, 10, 33, 8, 0, -33 },
  { 4689, 16, 44, 8, -6, -33 },
  { 4777, 17, 35, 15, 0, -35 },
  { 4852, 10, 35, 8, 0, -35 },
  { 4896, 25, 25, 27, 0, -25 },
  { 4975, 16, 25, 18, 0, -25 },
  { 5025, 15, 25, 18, 1, -25 },
  { 5072, 19, 36, 18, -2, -25 },
  { 5158, 17, 36, 18, 1, -25 },
  { 5235, 14, 25, 12, 0, -25 },
  { 5279, 15, 25, 14, -1, -25 },
  { 5326, 10, 30, 10, 1, -30 },
  { 5364, 16, 24, 18, 1, -24 },
  { 5412, 13, 24, 14, 3, -24 },
  { 5451, 22, 24, 23, 3, -24 },
  { 5517, 18, 24, 14, -2, -24 },
  { 5571, 22, 35, 15, -5, -24 },
  { 5668, 15, 24, 12, -2, -24 },
  { 5713, 17, 40, 15, 1, -33 },
  { 5798, 2, 46, 16, 7, -35 },
  { 5810, 16, 40, 15, -3, -33 },
  { 5890, 16, 5, 19, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC46PT7B_H_
