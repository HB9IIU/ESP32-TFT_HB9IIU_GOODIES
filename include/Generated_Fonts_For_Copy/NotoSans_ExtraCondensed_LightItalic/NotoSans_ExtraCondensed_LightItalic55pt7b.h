#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00,
  0x1C, 0x38, 0xE1, 0xCE, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x38, 0xC1, 0xCE,
  0x0C, 0x70, 0x63, 0x87, 0x18, 0x38, 0xC1, 0x86, 0x0C, 0x70, 0x60, 0x00,
  0x0E, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x70, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x60, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3E,
  0xDF, 0x03, 0xC4, 0x10, 0x38, 0x20, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x07, 0x18,
  0x00, 0x38, 0xC0, 0x00, 0xE4, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0x78,
  0x00, 0x19, 0xC0, 0x00, 0x87, 0x00, 0x0C, 0x38, 0x00, 0x61, 0xC0, 0x03,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC1,
  0x03, 0x1E, 0x0E, 0x19, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xC0, 0xFF, 0x00,
  0x60, 0x70, 0xC0, 0x38, 0x18, 0x30, 0x0C, 0x0E, 0x0C, 0x07, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x30, 0x18, 0x0C, 0x1C, 0x06,
  0x07, 0x06, 0x03, 0x81, 0xC3, 0x80, 0xE0, 0x70, 0xC0, 0x38, 0x18, 0x70,
  0x0C, 0x06, 0x18, 0x03, 0x03, 0x8E, 0x00, 0xC0, 0xE7, 0x0F, 0x30, 0x31,
  0xC7, 0xEC, 0x1C, 0xE3, 0x9F, 0x06, 0x39, 0xC7, 0xC3, 0x9C, 0xE0, 0xF0,
  0xC6, 0x38, 0x3F, 0xF3, 0x8C, 0x0D, 0xF8, 0xC7, 0x03, 0x38, 0x71, 0x81,
  0xC0, 0x18, 0x60, 0x70, 0x0E, 0x38, 0x1C, 0x03, 0x0E, 0x06, 0x01, 0xC3,
  0x01, 0x80, 0x60, 0xC0, 0x60, 0x38, 0x30, 0x38, 0x0C, 0x1C, 0x0C, 0x07,
  0x07, 0x03, 0x01, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x60, 0x30, 0x1C, 0x38,
  0x1C, 0x07, 0x0E, 0x06, 0x00, 0xC7, 0x03, 0x80, 0x3F, 0x80, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x70, 0x01, 0x83,
  0x80, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xDC, 0x00, 0x1C, 0xE0, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xE0,
  0xE3, 0x8E, 0x07, 0x1C, 0x70, 0x39, 0xC7, 0x00, 0xEE, 0x38, 0x07, 0x61,
  0xC0, 0x3F, 0x0C, 0x00, 0xF0, 0x60, 0x07, 0x87, 0x00, 0x38, 0x1C, 0x03,
  0xE0, 0xE0, 0x3F, 0x07, 0x03, 0xB8, 0x3C, 0x3D, 0xC0, 0xFF, 0xC7, 0x03,
  0xF8, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x71,
  0xC6, 0x18, 0x63, 0x80, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x04,
  0x18, 0x1E, 0x30, 0x3E, 0x61, 0x8F, 0xFF, 0x07, 0xFE, 0x0F, 0x00, 0x3E,
  0x00, 0xE6, 0x03, 0x8E, 0x0E, 0x0C, 0x18, 0x1C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x70, 0xE0, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x38, 0x07, 0x07,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0xE0,
  0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1C, 0x1C, 0x03,
  0x83, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x07, 0x00, 0xF3, 0xC0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xF1,
  0xEC, 0x7B, 0x9E, 0x77, 0x0E, 0x41, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3C, 0x1E, 0x00,
  0x40, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xC0,
  0xE0, 0x08, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x08, 0x01, 0xE0, 0x70, 0x3E, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xDC,
  0x00, 0x06, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x07, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x60, 0x03, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x40, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x20, 0x07, 0x80, 0xE0, 0x7C, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0xFC,
  0x03, 0x9F, 0xF0, 0x3B, 0x8F, 0x03, 0x60, 0x78, 0x7C, 0x03, 0x87, 0x80,
  0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x03, 0x87, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3C, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0x80, 0xE0, 0x0E,
  0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x78, 0x00,
  0xE3, 0xC0, 0x03, 0xDE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0x38, 0x00, 0x78, 0x70, 0x03, 0x81, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0x07, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0x80, 0x07,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x78, 0x07, 0x00, 0xF0, 0x78, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x1E, 0x1E, 0x03, 0xC0, 0xE0, 0x38, 0x06, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1E, 0x1E, 0x03,
  0xE0, 0xE0, 0x6E, 0x0F, 0xFD, 0xC0, 0x7F, 0x9C, 0x03, 0xF1, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x08, 0x3E, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0C,
  0x0E, 0x08, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x60, 0x06, 0x03, 0x06, 0x03, 0xFC, 0x30, 0xC0,
  0x7F, 0x83, 0x0C, 0x0E, 0x18, 0x31, 0xC1, 0xC3, 0x83, 0x18, 0x18, 0x38,
  0x31, 0x83, 0x83, 0x03, 0x38, 0x30, 0x30, 0x73, 0x07, 0x07, 0x07, 0x30,
  0x70, 0x70, 0x63, 0x06, 0x06, 0x06, 0x70, 0xE0, 0x60, 0x67, 0x0E, 0x0E,
  0x0E, 0x60, 0xC0, 0xE0, 0xC6, 0x0C, 0x0C, 0x0C, 0x60, 0xC1, 0xC1, 0xC6,
  0x0C, 0x1C, 0x18, 0xE0, 0xC1, 0xC1, 0x8E, 0x0C, 0x3C, 0x30, 0xE0, 0xC6,
  0xC7, 0x0E, 0x0F, 0xEE, 0xE0, 0xE0, 0x7C, 0x7C, 0x0E, 0x03, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x10, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xB0, 0x00, 0x3B, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x00,
  0x07, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x00, 0x1C, 0x30,
  0x01, 0xC3, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00, 0x38, 0x30, 0x07, 0x03,
  0x00, 0x70, 0x30, 0x0E, 0x03, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x38, 0x07, 0x03, 0x80, 0x70, 0x70,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77,
  0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0E,
  0x1F, 0x80, 0x38, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x01, 0xC0,
  0x3C, 0x07, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x07, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1E, 0x02, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x70, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x03, 0x8F, 0xE0, 0x07, 0x03, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x01,
  0xC0, 0x3C, 0x03, 0x81, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xC7, 0x80, 0x3F, 0xC3,
  0x80, 0x1F, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x18, 0x03, 0xC0, 0x1C, 0x00, 0xF8,
  0x1E, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xBE, 0x00,
  0x01, 0xDF, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0x70, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xB8, 0x00, 0x3B, 0x80, 0x77, 0x00, 0x07, 0x70, 0x0E, 0xE0, 0x01, 0xCE,
  0x01, 0xDC, 0x00, 0x39, 0x80, 0x3B, 0x80, 0x0E, 0x70, 0x0E, 0x30, 0x01,
  0xCE, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x38, 0xC0, 0x0E, 0x38, 0x07, 0x18,
  0x01, 0xCE, 0x00, 0xC3, 0x00, 0x71, 0xC0, 0x38, 0x60, 0x0E, 0x38, 0x07,
  0x0C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x1C, 0x38,
  0x03, 0x07, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0xE0, 0xE0, 0x1C, 0x1C, 0x1C,
  0x1C, 0x03, 0x83, 0x87, 0x03, 0x00, 0x70, 0x70, 0xE0, 0xE0, 0x1C, 0x0E,
  0x18, 0x1C, 0x03, 0x81, 0xC7, 0x03, 0x80, 0x70, 0x38, 0xC0, 0x70, 0x0E,
  0x07, 0x38, 0x1C, 0x01, 0x80, 0xE6, 0x03, 0x80, 0x70, 0x1D, 0xC0, 0x70,
  0x0E, 0x03, 0xB8, 0x0E, 0x01, 0xC0, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0xC0,
  0x70, 0x06, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x06, 0x00, 0xF0,
  0x00, 0xE0, 0x0F, 0x80, 0x0E, 0x01, 0xF8, 0x00, 0xE0, 0x1F, 0x80, 0x0E,
  0x01, 0xF8, 0x01, 0xC0, 0x1D, 0x80, 0x1C, 0x01, 0x98, 0x01, 0xC0, 0x39,
  0xC0, 0x1C, 0x03, 0x9C, 0x01, 0xC0, 0x39, 0xC0, 0x38, 0x03, 0x9C, 0x03,
  0x80, 0x70, 0xC0, 0x38, 0x07, 0x0E, 0x03, 0x80, 0x70, 0xE0, 0x30, 0x07,
  0x0E, 0x07, 0x00, 0x60, 0xE0, 0x70, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0x60,
  0x70, 0x0E, 0x07, 0x06, 0x00, 0xE0, 0x70, 0xE0, 0x0C, 0x07, 0x0E, 0x01,
  0xC0, 0x70, 0xE0, 0x1C, 0x03, 0x0E, 0x01, 0xC0, 0x31, 0xC0, 0x1C, 0x03,
  0x9C, 0x03, 0x80, 0x39, 0xC0, 0x38, 0x03, 0x9C, 0x03, 0x80, 0x39, 0xC0,
  0x38, 0x01, 0xB8, 0x03, 0x80, 0x1B, 0x80, 0x70, 0x01, 0xF8, 0x07, 0x00,
  0x1F, 0x80, 0x70, 0x01, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0x60, 0x00, 0xF0,
  0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x01, 0xC0, 0x78,
  0x03, 0x80, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xBC,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0xC0, 0x0E,
  0x03, 0x80, 0x38, 0x07, 0x80, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0E, 0x3F, 0x00, 0x38, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03,
  0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81,
  0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x81,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x01, 0xC0, 0x78, 0x03, 0x80,
  0xE0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xBC, 0x00, 0x0F,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0xC0, 0x0E, 0x03, 0x80,
  0x38, 0x07, 0x80, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0E, 0x3F, 0x00,
  0x38, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xE0, 0x0E,
  0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1C, 0x07,
  0x00, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3C, 0x07, 0x01, 0xE0, 0x08, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x80, 0x1E, 0x03, 0xC1, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xC7, 0x00,
  0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xDC, 0x00, 0x0D, 0xC0,
  0x00, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0x00, 0x39, 0xC0,
  0x07, 0x80, 0x0E, 0x38, 0x00, 0xF0, 0x01, 0xC7, 0x00, 0x3E, 0x00, 0x38,
  0xC0, 0x07, 0xC0, 0x0E, 0x18, 0x00, 0xF8, 0x01, 0xC3, 0x00, 0x3F, 0x00,
  0x70, 0x60, 0x06, 0xE0, 0x0E, 0x0C, 0x01, 0xDC, 0x01, 0xC1, 0x80, 0x3B,
  0x80, 0x70, 0x70, 0x06, 0x70, 0x0E, 0x0E, 0x01, 0xCE, 0x03, 0x81, 0xC0,
  0x39, 0xC0, 0x70, 0x38, 0x06, 0x38, 0x0E, 0x07, 0x01, 0xC7, 0x03, 0x80,
  0xE0, 0x30, 0xE0, 0x70, 0x1C, 0x0E, 0x18, 0x1C, 0x03, 0x81, 0xC3, 0x03,
  0x80, 0x70, 0x30, 0x60, 0x70, 0x0E, 0x0E, 0x0C, 0x1C, 0x01, 0xC1, 0x81,
  0x83, 0x80, 0x38, 0x70, 0x30, 0xE0, 0x07, 0x0E, 0x06, 0x1C, 0x00, 0xE1,
  0x80, 0xC3, 0x80, 0x1C, 0x70, 0x18, 0xE0, 0x03, 0x8C, 0x03, 0x1C, 0x00,
  0x73, 0x80, 0x63, 0x00, 0x0E, 0x70, 0x0C, 0xE0, 0x01, 0xCC, 0x01, 0x9C,
  0x00, 0x3B, 0x80, 0x77, 0x00, 0x07, 0x70, 0x0E, 0xE0, 0x00, 0xEC, 0x01,
  0xD8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x0C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x06, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x1E, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xDC, 0x00, 0xF7,
  0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0,
  0x70, 0x70, 0x1C, 0x0C, 0x0E, 0x03, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0xE0, 0x03,
  0xB8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60,
  0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x00, 0x18, 0x1C, 0x01, 0xC0, 0xE0,
  0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC7, 0x1C, 0x38, 0x61, 0xC3, 0x0C, 0x00,
  0x1C, 0x00, 0x07, 0xF1, 0xC0, 0x7F, 0xCC, 0x07, 0x87, 0x60, 0x78, 0x1F,
  0x03, 0x80, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x0C,
  0x01, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0xF8, 0x1C, 0x0D, 0x80, 0xF0, 0xCC,
  0x03, 0xFE, 0xE0, 0x0F, 0xC7, 0x00, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x87, 0x80, 0x39, 0xFC, 0x03, 0xBF, 0xE0, 0x3F,
  0x0F, 0x03, 0x60, 0x70, 0x7C, 0x07, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07,
  0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x18, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03,
  0xC3, 0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x70, 0x6C, 0x0E, 0x06, 0xE1,
  0xE0, 0xE7, 0xFC, 0x0E, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0x82, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x78, 0x60, 0x7F, 0xE0, 0x3F, 0xC0, 0x04, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC3,
  0x80, 0x1F, 0xC7, 0x00, 0x7F, 0xCC, 0x01, 0xE1, 0xF8, 0x07, 0x81, 0xF0,
  0x0E, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x70,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x18, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x07, 0x81, 0xC0, 0x0E,
  0x03, 0x80, 0x1C, 0x03, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x03, 0xC0,
  0x1C, 0x0D, 0x80, 0x3C, 0x33, 0x00, 0x3F, 0xCE, 0x00, 0x3F, 0x1C, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x0E,
  0x07, 0x81, 0x81, 0xC0, 0x70, 0xE0, 0x1C, 0x78, 0x06, 0x1C, 0x03, 0x87,
  0x00, 0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x1E, 0x1C, 0x1F, 0x07, 0xFF,
  0x81, 0xFF, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x40, 0xF0, 0x60, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x09, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x9C, 0x01,
  0xFF, 0x30, 0x07, 0x87, 0x60, 0x1E, 0x07, 0xC0, 0x38, 0x07, 0x80, 0xE0,
  0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0C,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0x70, 0x36, 0x00, 0xF0,
  0xDC, 0x00, 0xFF, 0xB8, 0x00, 0xFC, 0x70, 0x00, 0x40, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x40, 0x1C, 0x00,
  0xF1, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x87, 0x80, 0x39, 0xFC, 0x03, 0xBF, 0xE0, 0x37,
  0x0E, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x06, 0x07,
  0x00, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0,
  0xE0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x38,
  0x18, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x07,
  0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x06, 0x07, 0x00,
  0xE0, 0x60, 0x0E, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x02, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x03, 0x03, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x00,
  0x70, 0xE0, 0x07, 0x1E, 0x00, 0x61, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xCF, 0x00, 0x1D, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x70,
  0x01, 0xE3, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x07, 0x01, 0xE0, 0x0E, 0x7F, 0x1F, 0xE0, 0x33, 0xFE, 0xFF, 0xC0,
  0xD8, 0x7B, 0x0F, 0x03, 0xC0, 0xF8, 0x1C, 0x1E, 0x03, 0xC0, 0x70, 0x78,
  0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x1C, 0x3C, 0x03,
  0x80, 0x70, 0xE0, 0x0C, 0x01, 0xC3, 0x80, 0x70, 0x0E, 0x0E, 0x01, 0xC0,
  0x38, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x03, 0x87, 0x00, 0x60, 0x0C,
  0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x01, 0xC1, 0x80, 0x38, 0x07, 0x0E,
  0x00, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0x60, 0xE0, 0x1C, 0x03, 0x83, 0x80,
  0x70, 0x0E, 0x0C, 0x01, 0xC0, 0x38, 0x70, 0x06, 0x00, 0xE1, 0xC0, 0x38,
  0x07, 0x07, 0x00, 0xE0, 0x1C, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x01,
  0xC3, 0x80, 0x70, 0x06, 0x00, 0x00, 0x07, 0x00, 0x39, 0xFC, 0x03, 0x3F,
  0xE0, 0x37, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x07, 0x07, 0x80, 0x60, 0x70,
  0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xC0, 0xE0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1,
  0xC0, 0x38, 0x18, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38,
  0x38, 0x07, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x06,
  0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x01, 0xE1, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0x80,
  0x30, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x0E,
  0x38, 0x01, 0xC3, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0xF0,
  0x1C, 0x3C, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x03, 0x9F, 0xC0, 0x0E, 0xFF, 0x80, 0x37, 0x0F, 0x00, 0xD8, 0x1C,
  0x07, 0xC0, 0x70, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x0C, 0x07,
  0x00, 0x30, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x01, 0xF0, 0x38,
  0x07, 0xE3, 0xE0, 0x19, 0xFF, 0x00, 0xE3, 0xF0, 0x03, 0x82, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0xF1, 0xC0, 0x7F, 0xCC, 0x07, 0x87, 0x60, 0x78, 0x1F, 0x03, 0x80,
  0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x06, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x0C, 0x01, 0xE0,
  0x70, 0x0F, 0x03, 0x80, 0xF8, 0x1C, 0x0D, 0x80, 0xF0, 0xDC, 0x03, 0xFE,
  0xE0, 0x0F, 0xC7, 0x00, 0x10, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x81, 0xCF, 0x80, 0xCF, 0xC0, 0x6E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x1E, 0x06, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x08, 0x03, 0x83, 0x83, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x03, 0xFF, 0x3F, 0xF0, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFE, 0x07, 0xE0, 0x10, 0x00,
  0x07, 0x00, 0x70, 0x70, 0x06, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x18, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x03, 0x83, 0x80, 0x30, 0x38, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x1E, 0x0E, 0x01, 0xE0,
  0xE0, 0x3E, 0x0F, 0x06, 0xC0, 0x78, 0xEC, 0x07, 0xFD, 0xC0, 0x3F, 0x9C,
  0x00, 0x40, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE1, 0xC0, 0xE3,
  0x80, 0xE3, 0x80, 0xE7, 0x00, 0xE7, 0x00, 0xE6, 0x00, 0xEE, 0x00, 0xEE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x1B, 0x80, 0x78, 0x07, 0x70,
  0x0F, 0x00, 0xEE, 0x01, 0xE0, 0x39, 0xC0, 0x7C, 0x07, 0x38, 0x0D, 0x80,
  0xC7, 0x03, 0xB0, 0x38, 0xE0, 0x66, 0x07, 0x1C, 0x0C, 0xC0, 0xC3, 0x83,
  0x98, 0x38, 0x70, 0x63, 0x07, 0x0E, 0x1C, 0x61, 0xC1, 0xC3, 0x0C, 0x38,
  0x38, 0x61, 0x86, 0x07, 0x1C, 0x31, 0xC0, 0xE3, 0x06, 0x38, 0x1C, 0xE0,
  0xCE, 0x03, 0x98, 0x19, 0xC0, 0x73, 0x03, 0x30, 0x0E, 0xE0, 0x6E, 0x01,
  0xD8, 0x0D, 0xC0, 0x3F, 0x01, 0xB0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0E,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03,
  0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x0E, 0x00, 0x1C, 0x60,
  0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x30, 0x00, 0x71, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x38, 0x0C, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x20, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03, 0xF3, 0xF8, 0xFC,
  0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 39, 12, 1, -39 },
  { 60, 13, 14, 16, 5, -39 },
  { 83, 23, 39, 22, 0, -39 },
  { 196, 21, 45, 20, 0, -42 },
  { 315, 26, 41, 31, 3, -40 },
  { 449, 21, 41, 21, -1, -40 },
  { 557, 6, 14, 9, 5, -39 },
  { 568, 16, 48, 14, 1, -39 },
  { 664, 16, 48, 14, -4, -39 },
  { 760, 15, 17, 19, 6, -42 },
  { 792, 19, 25, 23, 2, -32 },
  { 852, 8, 13, 10, -2, -6 },
  { 865, 12, 2, 14, 1, -16 },
  { 868, 4, 5, 10, 1, -5 },
  { 871, 24, 39, 17, -3, -39 },
  { 988, 19, 41, 20, 1, -40 },
  { 1086, 11, 39, 20, 6, -39 },
  { 1140, 22, 40, 20, -2, -40 },
  { 1250, 21, 41, 20, -1, -40 },
  { 1358, 22, 40, 20, -1, -40 },
  { 1468, 22, 40, 20, -1, -39 },
  { 1578, 20, 41, 20, 1, -40 },
  { 1681, 20, 39, 20, 2, -39 },
  { 1779, 22, 41, 20, -1, -40 },
  { 1892, 20, 41, 20, 0, -40 },
  { 1995, 10, 29, 10, 0, -29 },
  { 2032, 13, 36, 10, -3, -29 },
  { 2091, 19, 23, 23, 2, -31 },
  { 2146, 19, 15, 23, 2, -27 },
  { 2182, 19, 23, 23, 2, -31 },
  { 2237, 16, 40, 15, 1, -40 },
  { 2317, 28, 45, 30, 1, -40 },
  { 2475, 20, 39, 20, -4, -39 },
  { 2573, 22, 39, 22, 0, -39 },
  { 2681, 22, 41, 20, 2, -40 },
  { 2794, 23, 39, 24, 0, -39 },
  { 2907, 22, 39, 19, 0, -39 },
  { 3015, 22, 39, 18, 0, -39 },
  { 3123, 25, 41, 26, 2, -40 },
  { 3252, 26, 39, 25, 0, -39 },
  { 3379, 19, 39, 12, -3, -39 },
  { 3472, 19, 49, 10, -8, -39 },
  { 3589, 25, 39, 21, 0, -39 },
  { 3711, 14, 39, 18, 0, -39 },
  { 3780, 35, 39, 34, 0, -39 },
  { 3951, 28, 39, 27, 0, -39 },
  { 4088, 23, 41, 26, 2, -40 },
  { 4206, 22, 39, 21, 0, -39 },
  { 4314, 23, 49, 26, 2, -40 },
  { 4455, 22, 39, 21, 0, -39 },
  { 4563, 22, 41, 20, -1, -40 },
  { 4676, 18, 39, 18, 4, -39 },
  { 4764, 24, 40, 25, 2, -39 },
  { 4884, 20, 39, 21, 5, -39 },
  { 4982, 35, 39, 34, 4, -39 },
  { 5153, 25, 39, 19, -3, -39 },
  { 5275, 18, 39, 18, 4, -39 },
  { 5363, 23, 39, 18, -2, -39 },
  { 5476, 20, 48, 15, -1, -39 },
  { 5596, 8, 39, 18, 6, -39 },
  { 5635, 20, 48, 15, -3, -39 },
  { 5755, 21, 20, 22, 1, -39 },
  { 5808, 15, 2, 16, -4, 5 },
  { 5812, 6, 9, 12, 8, -42 },
  { 5819, 21, 31, 22, 1, -30 },
  { 5901, 20, 43, 22, 0, -42 },
  { 6009, 16, 31, 16, 2, -30 },
  { 6071, 23, 43, 22, 1, -42 },
  { 6195, 18, 31, 19, 1, -30 },
  { 6265, 25, 55, 11, -7, -42 },
  { 6437, 23, 43, 22, -1, -30 },
  { 6561, 20, 42, 21, 0, -42 },
  { 6666, 12, 40, 10, 0, -40 },
  { 6726, 19, 53, 10, -7, -40 },
  { 6852, 20, 42, 18, 0, -42 },
  { 6957, 12, 42, 9, 0, -42 },
  { 7020, 30, 30, 32, 0, -30 },
  { 7133, 20, 30, 21, 0, -30 },
  { 7208, 19, 31, 21, 1, -30 },
  { 7282, 22, 43, 22, -2, -30 },
  { 7401, 21, 43, 22, 1, -30 },
  { 7514, 17, 30, 14, 0, -30 },
  { 7578, 18, 31, 16, -1, -30 },
  { 7648, 12, 37, 12, 1, -36 },
  { 7704, 20, 30, 21, 1, -29 },
  { 7779, 16, 29, 17, 3, -29 },
  { 7837, 27, 29, 28, 3, -29 },
  { 7935, 21, 29, 17, -2, -29 },
  { 8012, 26, 42, 17, -6, -29 },
  { 8149, 18, 29, 14, -2, -29 },
  { 8215, 19, 48, 18, 2, -39 },
  { 8329, 3, 55, 20, 8, -42 },
  { 8350, 19, 48, 17, -3, -39 },
  { 8464, 20, 5, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC55PT7B_H_
