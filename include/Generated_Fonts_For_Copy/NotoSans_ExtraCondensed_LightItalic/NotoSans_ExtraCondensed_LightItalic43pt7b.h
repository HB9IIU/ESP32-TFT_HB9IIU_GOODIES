#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x00,
  0x38, 0xCC, 0x33, 0x1C, 0xC7, 0x71, 0x98, 0x66, 0x19, 0x86, 0x63, 0x30,
  0xCC, 0x30, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x86, 0x07, 0xFF,
  0xF1, 0xFF, 0xFC, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x03, 0xFF, 0xF8, 0xFF,
  0xFE, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x02, 0x08, 0x01, 0x86, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0xE0, 0x1F,
  0xFC, 0x1C, 0x8C, 0x1C, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01,
  0x88, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x3B, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x13, 0x00, 0x08, 0xC0, 0x04,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x0C, 0x00, 0x86, 0x00, 0x46, 0x0C,
  0x67, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x07, 0x80, 0x60, 0x7C, 0x02, 0x06, 0x30,
  0x30, 0x61, 0x81, 0x03, 0x0C, 0x18, 0x18, 0x60, 0x81, 0x83, 0x0C, 0x0C,
  0x18, 0xC0, 0x60, 0xC6, 0x03, 0x0C, 0x60, 0x30, 0x63, 0x01, 0x83, 0x30,
  0x0C, 0x19, 0x8E, 0x61, 0x98, 0xFB, 0x0C, 0xCC, 0xD8, 0x4C, 0xC3, 0xC6,
  0x66, 0x1B, 0xE6, 0x60, 0xDE, 0x33, 0x06, 0x03, 0x18, 0x20, 0x18, 0x83,
  0x01, 0x8C, 0x18, 0x0C, 0x60, 0xC0, 0xC3, 0x06, 0x06, 0x18, 0x60, 0x60,
  0xC3, 0x03, 0x06, 0x18, 0x30, 0x31, 0x81, 0x81, 0x8C, 0x18, 0x0C, 0xC0,
  0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x0E, 0x70, 0x18, 0x60, 0x30,
  0xC0, 0xE1, 0x81, 0x83, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xC0,
  0x3B, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x33,
  0x0C, 0xC7, 0x1B, 0x86, 0x36, 0x0C, 0xDC, 0x1D, 0xB0, 0x1F, 0x60, 0x3C,
  0xC0, 0x79, 0x80, 0xE3, 0x01, 0xC6, 0x07, 0x8E, 0x1F, 0x9F, 0xF3, 0x1F,
  0xC6, 0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x62, 0x30, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x43, 0x0E, 0x60, 0xE8, 0xC7,
  0xF8, 0x70, 0x1A, 0x06, 0x63, 0x8C, 0x20, 0xC0, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0E, 0x18, 0x70, 0xC3, 0x86, 0x0C, 0x30, 0x61, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0E, 0x70, 0x38,
  0x60, 0x60, 0xE1, 0x81, 0xC3, 0x03, 0x8C, 0x07, 0x18, 0x0E, 0x70, 0x1C,
  0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60,
  0x1C, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x0C,
  0x60, 0x38, 0xC0, 0x61, 0x81, 0xC3, 0x03, 0x06, 0x0E, 0x0E, 0x38, 0x0F,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0x83, 0x83, 0xC3, 0xE3, 0xB7, 0x3B, 0x19,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xE1, 0xC0, 0x40, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0xC1, 0xC0, 0x40, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x01, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x08, 0x0F, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x0C,
  0x18, 0x0C, 0x1C, 0x0E, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x83,
  0x01, 0x83, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC8,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x08, 0x0F, 0x07, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x33, 0xE0, 0x77, 0xF0, 0x6C, 0x38, 0x78, 0x38, 0x70,
  0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0,
  0x38, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xE0, 0xE0, 0x60,
  0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0xFC, 0x03, 0xFE, 0x07, 0x07, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x0E, 0x0E, 0x06, 0x0C, 0x07,
  0x38, 0x03, 0x70, 0x03, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x1C, 0x70, 0x30,
  0x30, 0x70, 0x38, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xE0, 0x30, 0xE0, 0x70, 0x7F, 0xE0, 0x3F,
  0xC0, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x06, 0x06, 0x0E, 0x06, 0x0C,
  0x06, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x38, 0x06, 0x38,
  0x06, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x18, 0x1E, 0x1C, 0x3E, 0x1F,
  0xEC, 0x0F, 0xCC, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0x06, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0E, 0x1C, 0x38, 0x00,
  0x01, 0x80, 0x70, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F,
  0xC1, 0xFE, 0x18, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x06, 0x03, 0x80, 0x18,
  0x0C, 0x00, 0x20, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60,
  0x7E, 0x31, 0x83, 0xB0, 0xCC, 0x18, 0xC3, 0x30, 0xC3, 0x0C, 0xC3, 0x0C,
  0x36, 0x18, 0x20, 0xD8, 0x61, 0x86, 0x61, 0x86, 0x19, 0x8C, 0x18, 0x64,
  0x30, 0xC1, 0xB0, 0xC3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x70, 0x8C, 0x31,
  0xC6, 0x30, 0xCF, 0x30, 0xC3, 0xE7, 0xC3, 0x07, 0x1E, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x10, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x1B, 0x00,
  0x33, 0x00, 0x33, 0x00, 0x73, 0x00, 0x63, 0x00, 0x63, 0x00, 0xC3, 0x00,
  0xC3, 0x01, 0xC3, 0x01, 0x83, 0x01, 0x83, 0x03, 0x03, 0x03, 0x03, 0x07,
  0xFF, 0x07, 0xFF, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0,
  0x07, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x30, 0xF0, 0x0C, 0x0E, 0x03, 0x01,
  0x81, 0xC0, 0x70, 0x70, 0x1C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60,
  0xE0, 0x38, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x07, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x18, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x60, 0x18, 0x38, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x06,
  0x01, 0xC1, 0x80, 0xE0, 0x60, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0xF0, 0x40, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x02,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x31, 0xF0,
  0x0C, 0x0E, 0x03, 0x01, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x18, 0x07, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x38, 0x03, 0x0C, 0x01, 0xC3, 0x00,
  0x70, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38,
  0x60, 0x0E, 0x38, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x70,
  0x0C, 0x1C, 0x07, 0x06, 0x03, 0x81, 0x81, 0xC0, 0x61, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0x03, 0x83, 0xC0,
  0x20, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x01, 0xFC, 0xC0, 0x3F, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x0E, 0x18, 0x01, 0x83, 0x80, 0x30, 0x30, 0x06, 0x07, 0x01, 0xC0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0x80, 0x38, 0x1C, 0x01, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x07, 0x03, 0x80, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x30,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x70, 0x06, 0x03,
  0x00, 0x30, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x09, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x70, 0x1C, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x30,
  0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x30, 0x60, 0x06, 0x1C, 0x00, 0xC7, 0x00,
  0x38, 0xC0, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00,
  0xFE, 0x00, 0x1E, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03,
  0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x80, 0x70, 0x30, 0x0E,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x30, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xB0, 0x01, 0xB0, 0x36, 0x00, 0x76,
  0x06, 0xC0, 0x0D, 0xC0, 0xD8, 0x01, 0xB0, 0x3B, 0x00, 0x66, 0x06, 0x60,
  0x0C, 0xC0, 0xCC, 0x03, 0x38, 0x19, 0x80, 0x67, 0x03, 0x30, 0x18, 0xC0,
  0xE7, 0x03, 0x18, 0x18, 0xE0, 0xE3, 0x03, 0x0C, 0x18, 0xE0, 0x61, 0x87,
  0x18, 0x1C, 0x30, 0xC3, 0x03, 0x06, 0x38, 0x60, 0x60, 0xC6, 0x0C, 0x0C,
  0x19, 0xC3, 0x81, 0x83, 0x30, 0x60, 0x70, 0x66, 0x0C, 0x0C, 0x0D, 0x81,
  0x81, 0x81, 0xB0, 0x70, 0x30, 0x3C, 0x0E, 0x06, 0x07, 0x81, 0x81, 0xC0,
  0xE0, 0x30, 0x30, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x0F, 0x00, 0x70,
  0x3C, 0x01, 0x80, 0xF0, 0x06, 0x03, 0xC0, 0x18, 0x1F, 0x00, 0xE0, 0x6C,
  0x03, 0x01, 0xB8, 0x0C, 0x06, 0x60, 0x30, 0x19, 0x80, 0xC0, 0xE6, 0x07,
  0x03, 0x18, 0x18, 0x0C, 0x60, 0x60, 0x30, 0xC1, 0x80, 0xC3, 0x0E, 0x07,
  0x0C, 0x38, 0x18, 0x30, 0xC0, 0x60, 0xC3, 0x01, 0x83, 0x8C, 0x0E, 0x06,
  0x70, 0x38, 0x19, 0x80, 0xC0, 0x66, 0x03, 0x01, 0x98, 0x0C, 0x06, 0x60,
  0x70, 0x1F, 0x81, 0x80, 0x3C, 0x06, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0x60,
  0x0F, 0x03, 0x80, 0x3C, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C,
  0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x37, 0x00, 0x0D, 0xC0, 0x07, 0x60, 0x01, 0xD8, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x98, 0x00, 0xCE, 0x00, 0x71,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x06, 0x01, 0xC1, 0xC0, 0x60, 0x30,
  0x70, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xC7,
  0xC0, 0x60, 0xE0, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x06, 0x0C, 0x03, 0x06,
  0x03, 0x83, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x60, 0xC0, 0x70, 0x60, 0x30,
  0x30, 0x38, 0x38, 0x38, 0x1F, 0xF8, 0x0F, 0xF0, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x07, 0x00, 0xC1,
  0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80,
  0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x0D, 0xC0, 0x07,
  0x60, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x98,
  0x00, 0xCE, 0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x06, 0x01,
  0xC1, 0xC0, 0x60, 0x30, 0x70, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xC7, 0xC0, 0x60, 0xE0, 0x30,
  0x38, 0x38, 0x1C, 0x1C, 0x06, 0x0C, 0x07, 0x06, 0x03, 0x83, 0x01, 0xC3,
  0x80, 0xC1, 0xC0, 0x60, 0xC0, 0x70, 0x60, 0x30, 0x30, 0x38, 0x38, 0xF8,
  0x1F, 0xF0, 0x0F, 0xE0, 0x06, 0x38, 0x03, 0x0C, 0x03, 0x86, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x60, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x87, 0x01, 0xC3, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x3C, 0x18, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0xC0,
  0x70, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x70, 0xE0,
  0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0x83, 0x80,
  0x30, 0x70, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x0E, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x0C,
  0x1C, 0x03, 0x03, 0x80, 0x60, 0x30, 0x1C, 0x07, 0x07, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x00, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0,
  0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0,
  0x60, 0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC3,
  0x80, 0xC3, 0x00, 0xC7, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xCC,
  0x00, 0xDC, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x6C, 0x01, 0xC0, 0x1D,
  0x80, 0x38, 0x03, 0x30, 0x07, 0x00, 0x66, 0x01, 0xE0, 0x18, 0xC0, 0x3C,
  0x03, 0x18, 0x0D, 0x80, 0xE3, 0x01, 0xB0, 0x18, 0x60, 0x36, 0x03, 0x0C,
  0x0C, 0xC0, 0xC3, 0x81, 0x98, 0x18, 0x70, 0x73, 0x07, 0x0E, 0x0C, 0x60,
  0xC1, 0xC1, 0x8C, 0x18, 0x38, 0x61, 0x86, 0x07, 0x0C, 0x30, 0xC0, 0xE1,
  0x86, 0x38, 0x1C, 0x61, 0x86, 0x03, 0x8C, 0x30, 0xC0, 0x73, 0x06, 0x30,
  0x0E, 0x60, 0xC6, 0x01, 0xCC, 0x19, 0xC0, 0x33, 0x03, 0x30, 0x06, 0x60,
  0x66, 0x00, 0xD8, 0x0D, 0xC0, 0x1B, 0x01, 0xB0, 0x03, 0x60, 0x3E, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x38, 0x06, 0x03, 0x80, 0x30, 0x18, 0x01, 0xC1,
  0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80, 0x01, 0x8C, 0x00,
  0x1C, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xE0, 0x06, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x03, 0x80, 0x30, 0x00,
  0x60, 0x0E, 0xC0, 0x39, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x0C, 0x0E, 0x18,
  0x18, 0x38, 0x70, 0x70, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x9C, 0x03, 0x30,
  0x06, 0xE0, 0x0D, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x70, 0x03, 0x30, 0x06, 0x30, 0x0E,
  0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0E, 0x60,
  0x06, 0x60, 0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0x1C, 0x63, 0x0C,
  0x20, 0x01, 0xF3, 0x07, 0xF3, 0x0E, 0x1F, 0x0C, 0x0E, 0x1C, 0x0E, 0x18,
  0x0E, 0x38, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60,
  0x1C, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xC0, 0x38, 0xC0,
  0x30, 0xE0, 0x70, 0xE0, 0xF0, 0x61, 0xB0, 0x7F, 0x30, 0x3E, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x7C, 0x06, 0xFE, 0x0F,
  0x86, 0x0F, 0x07, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x18, 0x70, 0x38, 0x78,
  0x70, 0xCF, 0xE0, 0xCF, 0xC0, 0x01, 0xF8, 0x3F, 0x83, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x08, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1F, 0x30, 0x1F, 0xDC, 0x0E, 0x1E,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x38, 0x38, 0x0E, 0x0C, 0x03, 0x07,
  0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x83, 0x80,
  0x60, 0xE0, 0x18, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xE0, 0x70,
  0x38, 0x3C, 0x06, 0x1B, 0x01, 0xFC, 0x80, 0x3E, 0x60, 0x00, 0x01, 0xF0,
  0x3F, 0xC3, 0x86, 0x18, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x07, 0x70,
  0x33, 0x07, 0x1B, 0xF0, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x04, 0x3F, 0xE0, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x38, 0x80, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0xC0, 0x7F, 0xB0,
  0x38, 0x7C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xE0, 0xE0, 0x38, 0x30,
  0x0C, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x1C, 0x18, 0x06,
  0x0E, 0x01, 0x83, 0x80, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF0, 0x18, 0x6C, 0x07, 0xF6, 0x00, 0xF9, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x08, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x19, 0xF0, 0x37, 0xF0, 0x78, 0x61, 0xE0,
  0xC3, 0x81, 0x87, 0x03, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x38, 0xC0, 0x61,
  0x80, 0xC3, 0x01, 0x8E, 0x07, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x63, 0x81, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x70,
  0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x70,
  0x0C, 0x60, 0x1C, 0xC0, 0x19, 0xC0, 0x1B, 0x80, 0x1B, 0x80, 0x1F, 0x80,
  0x3D, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0xE0,
  0x60, 0xE0, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x60, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x00,
  0x06, 0x7C, 0x7C, 0x06, 0xFE, 0xFE, 0x0D, 0x0F, 0x87, 0x0E, 0x07, 0x07,
  0x0E, 0x06, 0x07, 0x0C, 0x06, 0x07, 0x0C, 0x0E, 0x06, 0x1C, 0x0E, 0x06,
  0x18, 0x0C, 0x06, 0x18, 0x0C, 0x0E, 0x18, 0x0C, 0x0E, 0x18, 0x1C, 0x0C,
  0x38, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x1C, 0x30, 0x18, 0x18,
  0x70, 0x38, 0x18, 0x70, 0x30, 0x18, 0x60, 0x30, 0x18, 0x60, 0x30, 0x38,
  0x60, 0x70, 0x30, 0xE0, 0x60, 0x30, 0xC0, 0x60, 0x30, 0x06, 0x7C, 0x0D,
  0xFC, 0x36, 0x38, 0x78, 0x30, 0xE0, 0x61, 0x80, 0xC3, 0x01, 0x8E, 0x03,
  0x18, 0x0E, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x63, 0x81, 0xC6, 0x03, 0x8C,
  0x06, 0x18, 0x0C, 0x70, 0x18, 0xE0, 0x71, 0x80, 0xC3, 0x01, 0x86, 0x03,
  0x1C, 0x06, 0x30, 0x1C, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE1, 0xC3, 0x03,
  0x18, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x00,
  0xD8, 0x03, 0x60, 0x1F, 0x80, 0x6E, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00,
  0xCE, 0x07, 0x38, 0x18, 0x60, 0xC1, 0xFF, 0x03, 0xF0, 0x00, 0x01, 0x9F,
  0x00, 0x6F, 0xE0, 0x3E, 0x18, 0x0D, 0x07, 0x03, 0x80, 0xC0, 0xE0, 0x30,
  0x30, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0x80, 0x70, 0x60, 0x1C, 0x18,
  0x06, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0C, 0x03,
  0x07, 0x01, 0xC1, 0xC0, 0x60, 0x70, 0x38, 0x1E, 0x1C, 0x0E, 0xFE, 0x03,
  0x3F, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xF3, 0x07, 0xFB, 0x0E, 0x1F, 0x0C, 0x0E, 0x1C, 0x0E, 0x18,
  0x0E, 0x38, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60,
  0x1C, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0xC0,
  0x70, 0xE0, 0x70, 0xE0, 0xF0, 0x61, 0xF0, 0x7F, 0x60, 0x3E, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x78, 0x37, 0x83, 0x60,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xF0, 0xE0, 0x83, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x81, 0xC3, 0xFF, 0x07,
  0xF0, 0x00, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC1, 0xFD, 0xFE, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3E, 0x0F, 0x00, 0x0C, 0x06,
  0x18, 0x0C, 0x70, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C,
  0x0E, 0x30, 0x1C, 0x60, 0x30, 0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x06,
  0x18, 0x0C, 0x30, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0x03, 0x86, 0x07, 0x0E,
  0x1E, 0x0F, 0xEC, 0x1F, 0x98, 0x00, 0xE0, 0x1B, 0x01, 0xD8, 0x0C, 0xC0,
  0xE6, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x18, 0x61, 0xC3, 0x0C, 0x18, 0xE0,
  0xC6, 0x06, 0x30, 0x33, 0x01, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x00, 0x60, 0x30, 0x1D, 0x80,
  0xC0, 0x66, 0x07, 0x03, 0x98, 0x1C, 0x0C, 0x60, 0xD0, 0x31, 0x83, 0xC1,
  0x86, 0x0B, 0x06, 0x18, 0x6C, 0x38, 0x61, 0xB0, 0xC1, 0x8C, 0xC3, 0x06,
  0x33, 0x18, 0x19, 0x8C, 0x60, 0x66, 0x31, 0x81, 0x98, 0xCC, 0x0E, 0xC3,
  0x30, 0x3B, 0x0D, 0x80, 0xEC, 0x36, 0x03, 0xE0, 0xD8, 0x0D, 0x83, 0xC0,
  0x3C, 0x0F, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x00,
  0x07, 0x03, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x1C,
  0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1D, 0x80, 0x0C, 0xC0, 0x0C, 0x60,
  0x0E, 0x30, 0x06, 0x18, 0x07, 0x0E, 0x03, 0x03, 0x03, 0x01, 0x83, 0x80,
  0xC0, 0x01, 0x80, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x38, 0x01, 0x83, 0x00,
  0x18, 0x70, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x9C, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x01, 0xB0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0xC2, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0x01, 0x7F, 0xC3, 0xC1,
  0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 31, 9, 1, -31 },
  { 36, 10, 11, 13, 4, -31 },
  { 50, 18, 31, 17, 0, -31 },
  { 120, 17, 36, 16, 0, -33 },
  { 197, 21, 31, 24, 2, -31 },
  { 279, 15, 31, 16, 0, -31 },
  { 338, 5, 11, 7, 4, -31 },
  { 345, 12, 38, 11, 1, -31 },
  { 402, 12, 38, 11, -3, -31 },
  { 459, 11, 13, 15, 5, -33 },
  { 477, 16, 20, 18, 1, -25 },
  { 517, 7, 10, 8, -2, -4 },
  { 526, 9, 2, 11, 1, -13 },
  { 529, 3, 4, 8, 1, -4 },
  { 531, 19, 31, 13, -2, -31 },
  { 605, 15, 31, 16, 1, -31 },
  { 664, 9, 31, 16, 5, -31 },
  { 699, 17, 31, 16, -1, -31 },
  { 765, 17, 31, 16, -1, -31 },
  { 831, 17, 31, 16, -1, -31 },
  { 897, 17, 31, 16, -1, -31 },
  { 963, 16, 31, 16, 1, -31 },
  { 1025, 17, 31, 16, 1, -31 },
  { 1091, 16, 31, 16, 0, -31 },
  { 1153, 16, 31, 16, 0, -31 },
  { 1215, 7, 23, 8, 0, -23 },
  { 1236, 10, 29, 8, -2, -23 },
  { 1273, 16, 18, 18, 1, -24 },
  { 1309, 16, 11, 18, 1, -21 },
  { 1331, 16, 18, 18, 1, -24 },
  { 1367, 12, 31, 11, 1, -31 },
  { 1414, 22, 35, 24, 1, -31 },
  { 1511, 16, 31, 16, -3, -31 },
  { 1573, 18, 31, 17, 0, -31 },
  { 1643, 17, 31, 16, 2, -31 },
  { 1709, 18, 31, 19, 0, -31 },
  { 1779, 17, 31, 15, 0, -31 },
  { 1845, 17, 31, 14, 0, -31 },
  { 1911, 19, 31, 20, 2, -31 },
  { 1985, 21, 31, 20, 0, -31 },
  { 2067, 14, 31, 9, -2, -31 },
  { 2122, 15, 39, 8, -6, -31 },
  { 2196, 19, 31, 16, 0, -31 },
  { 2270, 11, 31, 14, 0, -31 },
  { 2313, 27, 31, 27, 0, -31 },
  { 2418, 22, 31, 21, 0, -31 },
  { 2504, 18, 31, 20, 1, -31 },
  { 2574, 17, 31, 16, 0, -31 },
  { 2640, 18, 38, 20, 1, -31 },
  { 2726, 17, 31, 17, 0, -31 },
  { 2792, 18, 31, 15, -1, -31 },
  { 2862, 14, 31, 14, 3, -31 },
  { 2917, 19, 31, 19, 1, -31 },
  { 2991, 16, 31, 16, 4, -31 },
  { 3053, 27, 31, 27, 3, -31 },
  { 3158, 21, 31, 14, -3, -31 },
  { 3240, 15, 31, 14, 3, -31 },
  { 3299, 18, 31, 14, -2, -31 },
  { 3369, 16, 38, 12, -1, -31 },
  { 3445, 7, 31, 14, 4, -31 },
  { 3473, 16, 38, 12, -3, -31 },
  { 3549, 16, 16, 17, 1, -31 },
  { 3581, 12, 2, 12, -3, 4 },
  { 3584, 5, 7, 10, 6, -33 },
  { 3589, 16, 23, 17, 1, -23 },
  { 3635, 16, 33, 17, 0, -33 },
  { 3701, 13, 23, 13, 1, -23 },
  { 3739, 18, 33, 17, 1, -33 },
  { 3814, 13, 23, 15, 1, -23 },
  { 3852, 19, 43, 9, -5, -33 },
  { 3955, 18, 33, 17, -1, -23 },
  { 4030, 15, 33, 17, 0, -33 },
  { 4092, 9, 31, 7, 0, -31 },
  { 4127, 15, 41, 8, -6, -31 },
  { 4204, 16, 33, 14, 0, -33 },
  { 4270, 9, 33, 7, 0, -33 },
  { 4308, 24, 23, 25, 0, -23 },
  { 4377, 15, 23, 17, 0, -23 },
  { 4421, 14, 23, 16, 1, -23 },
  { 4462, 18, 33, 17, -2, -23 },
  { 4537, 16, 33, 17, 1, -23 },
  { 4603, 13, 23, 11, 0, -23 },
  { 4641, 14, 23, 13, -1, -23 },
  { 4682, 9, 28, 9, 1, -28 },
  { 4714, 15, 23, 17, 1, -23 },
  { 4758, 13, 23, 13, 2, -23 },
  { 4796, 22, 23, 22, 2, -23 },
  { 4860, 17, 23, 14, -2, -23 },
  { 4909, 20, 33, 14, -4, -23 },
  { 4992, 13, 23, 11, -1, -23 },
  { 5030, 15, 38, 14, 1, -31 },
  { 5102, 3, 43, 15, 6, -33 },
  { 5119, 15, 38, 14, -3, -31 },
  { 5191, 16, 4, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC43PT7B_H_
