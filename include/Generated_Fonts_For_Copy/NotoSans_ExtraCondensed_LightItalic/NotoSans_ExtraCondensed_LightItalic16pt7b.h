#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x44, 0x00, 0x80, 0xB6, 0xD0, 0x16, 0x28, 0x53,
  0xF2, 0x85, 0x13, 0x78, 0x51, 0x22, 0x80, 0x08, 0x73, 0x14, 0x50, 0xC1,
  0x0A, 0x28, 0xAB, 0x10, 0x40, 0x20, 0xA6, 0x55, 0x2A, 0x96, 0xF6, 0xD5,
  0x2A, 0x95, 0x2C, 0x60, 0x10, 0xA2, 0x8A, 0x28, 0xC6, 0x15, 0x9A, 0x69,
  0xBA, 0xF0, 0x18, 0x88, 0x84, 0x21, 0x10, 0x84, 0x21, 0x04, 0x20, 0x11,
  0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x2A, 0x5A, 0x20, 0x21, 0x09, 0xF2,
  0x10, 0x80, 0x29, 0x40, 0xF0, 0x80, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x00, 0x08, 0xD2, 0x51, 0x45, 0x14, 0x62, 0x8A, 0x29,
  0x18, 0x74, 0xA4, 0x94, 0x92, 0x00, 0x0C, 0x24, 0x08, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x41, 0x07, 0xC0, 0x18, 0x90, 0x41, 0x04, 0x63, 0x02, 0x08,
  0x21, 0x38, 0x04, 0x30, 0xC6, 0x28, 0xA4, 0xA2, 0x91, 0xE1, 0x04, 0x3C,
  0x84, 0x10, 0x70, 0x20, 0x82, 0x08, 0x4E, 0x00, 0x0C, 0x42, 0x10, 0x41,
  0xE4, 0xA2, 0x8A, 0x28, 0x9C, 0xFC, 0x21, 0x04, 0x10, 0x82, 0x10, 0x42,
  0x08, 0x00, 0x18, 0x94, 0x51, 0x24, 0xE3, 0x12, 0x8A, 0x28, 0xBC, 0x18,
  0x94, 0x51, 0x45, 0x14, 0x8E, 0x08, 0x21, 0x38, 0x24, 0x00, 0x00, 0x80,
  0x11, 0x00, 0x00, 0x02, 0x44, 0x80, 0x09, 0xB1, 0x06, 0x0C, 0x20, 0xF8,
  0x01, 0xF0, 0x83, 0x04, 0x13, 0x62, 0x00, 0x32, 0x42, 0x11, 0x10, 0x88,
  0x40, 0x01, 0x00, 0x06, 0x0C, 0x88, 0x24, 0x14, 0xEA, 0xA5, 0x55, 0x4A,
  0xA5, 0x4F, 0x20, 0x10, 0x07, 0x80, 0x0C, 0x31, 0x45, 0x14, 0x93, 0xD1,
  0x45, 0x18, 0x40, 0x3C, 0x44, 0x89, 0x24, 0x8F, 0x11, 0x22, 0x89, 0x13,
  0xC0, 0x18, 0x94, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x3C, 0x44,
  0x89, 0x14, 0x28, 0x51, 0x22, 0x89, 0x13, 0xC0, 0x3C, 0x82, 0x08, 0x41,
  0xE4, 0x10, 0x82, 0x0F, 0x00, 0x3C, 0x82, 0x08, 0x41, 0xE4, 0x10, 0x82,
  0x08, 0x00, 0x0C, 0x65, 0x02, 0x08, 0x10, 0x27, 0x42, 0x89, 0x12, 0x23,
  0xC0, 0x21, 0x22, 0x22, 0x22, 0x42, 0x7C, 0x44, 0x44, 0x84, 0x84, 0x88,
  0x3C, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x0E, 0x00, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x60, 0x22, 0x48, 0xA1, 0x85, 0x0E, 0x14,
  0x28, 0x91, 0x12, 0x20, 0x22, 0x22, 0x44, 0x44, 0x88, 0xF0, 0x30, 0xCC,
  0x33, 0x14, 0xC6, 0x52, 0x94, 0xA5, 0x29, 0x52, 0x95, 0x26, 0x49, 0x90,
  0x31, 0x31, 0x31, 0x32, 0x52, 0x4A, 0x4A, 0x4C, 0x8C, 0x8C, 0x84, 0x18,
  0x94, 0x51, 0x86, 0x18, 0x61, 0x8A, 0x29, 0x3C, 0x3C, 0x92, 0x49, 0x45,
  0xE4, 0x10, 0x82, 0x08, 0x00, 0x18, 0x94, 0x51, 0x86, 0x18, 0x61, 0x8A,
  0x29, 0x3C, 0x20, 0x81, 0x00, 0x3C, 0x92, 0x49, 0x45, 0xE5, 0x14, 0x92,
  0x28, 0x80, 0x18, 0x94, 0x10, 0x40, 0x81, 0x04, 0x08, 0x21, 0x3C, 0xF9,
  0x08, 0x44, 0x21, 0x08, 0x44, 0x20, 0x46, 0x89, 0x14, 0x28, 0x51, 0x22,
  0x44, 0x89, 0x23, 0x80, 0x86, 0x18, 0xA2, 0x92, 0x4A, 0x28, 0xA3, 0x0C,
  0x00, 0x84, 0x63, 0x18, 0xCA, 0x52, 0x95, 0x29, 0x4A, 0x52, 0x98, 0xC6,
  0x31, 0x08, 0x40, 0x13, 0x12, 0x14, 0x18, 0x18, 0x18, 0x18, 0x28, 0x48,
  0x48, 0x88, 0x8E, 0x25, 0x14, 0x61, 0x04, 0x10, 0x42, 0x08, 0x00, 0x1E,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x83, 0xE0, 0x39, 0x08, 0x44,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x70, 0xAA, 0xA9, 0x54, 0x1C, 0x20, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x23, 0x80, 0x10, 0xA2, 0x91, 0xC4,
  0xF0, 0xD0, 0x1C, 0x94, 0x51, 0x46, 0x28, 0xA2, 0x78, 0x20, 0x82, 0x0E,
  0x25, 0x14, 0x51, 0x45, 0x2C, 0xBC, 0x19, 0x10, 0x84, 0x42, 0x10, 0x70,
  0x02, 0x04, 0x08, 0xE2, 0x48, 0x91, 0x22, 0x89, 0x12, 0x23, 0xC0, 0x19,
  0x52, 0x97, 0x42, 0x10, 0x70, 0x06, 0x10, 0x20, 0xE0, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x60, 0x1C, 0x94, 0x51, 0x46, 0x28,
  0xA2, 0x78, 0x41, 0x04, 0xE0, 0x20, 0x82, 0x0E, 0x25, 0x14, 0x52, 0x4A,
  0x28, 0xA4, 0x24, 0x12, 0x92, 0x52, 0x40, 0x08, 0x40, 0x10, 0x88, 0x42,
  0x10, 0x88, 0x42, 0x11, 0x18, 0x20, 0x82, 0x09, 0x29, 0x45, 0x18, 0x52,
  0x49, 0x24, 0x24, 0x92, 0x92, 0x52, 0x40, 0x3B, 0x12, 0x51, 0x29, 0x14,
  0x92, 0x4A, 0x25, 0x12, 0x91, 0x00, 0x38, 0x94, 0x51, 0x49, 0x28, 0xA2,
  0x90, 0x18, 0x94, 0x51, 0x46, 0x28, 0xA2, 0x70, 0x1C, 0x24, 0x89, 0x12,
  0x24, 0x49, 0x32, 0x78, 0x81, 0x04, 0x08, 0x00, 0x1C, 0x94, 0x51, 0x46,
  0x28, 0xA2, 0x78, 0x21, 0x04, 0x10, 0x3B, 0x10, 0x84, 0x22, 0x10, 0x80,
  0x32, 0x50, 0x82, 0x10, 0x42, 0xE0, 0x22, 0x34, 0x44, 0x44, 0x88, 0xC0,
  0x24, 0x94, 0x52, 0x49, 0x28, 0xA6, 0x70, 0x8C, 0xA5, 0x4A, 0x53, 0x18,
  0x80, 0x91, 0x92, 0x92, 0xB2, 0xB4, 0xD4, 0xD4, 0x88, 0x98, 0x22, 0x48,
  0x60, 0xC1, 0x06, 0x0C, 0x24, 0xC8, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x3C, 0x20, 0x84, 0x10, 0x82,
  0x10, 0xF0, 0x0C, 0x41, 0x04, 0x20, 0x8C, 0x08, 0x21, 0x04, 0x10, 0x40,
  0x80, 0xFF, 0xFF, 0x18, 0x20, 0x82, 0x10, 0x40, 0xC4, 0x10, 0x82, 0x08,
  0x62, 0x00, 0x45, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 3, 4, 5, 2, -11 },
  { 9, 7, 11, 6, 0, -11 },
  { 19, 6, 13, 6, 0, -12 },
  { 29, 7, 12, 9, 1, -12 },
  { 40, 6, 12, 6, 0, -12 },
  { 49, 1, 4, 3, 2, -11 },
  { 50, 5, 14, 4, 0, -11 },
  { 59, 4, 14, 4, -1, -11 },
  { 66, 4, 5, 5, 2, -12 },
  { 69, 5, 7, 7, 1, -9 },
  { 74, 3, 4, 3, -1, -2 },
  { 76, 4, 1, 4, 0, -5 },
  { 77, 1, 1, 3, 0, -1 },
  { 78, 7, 11, 5, -1, -11 },
  { 88, 6, 12, 6, 0, -12 },
  { 97, 3, 11, 6, 2, -11 },
  { 102, 7, 12, 6, -1, -12 },
  { 113, 6, 12, 6, 0, -12 },
  { 122, 6, 12, 6, 0, -12 },
  { 131, 6, 11, 6, 0, -11 },
  { 140, 6, 12, 6, 0, -12 },
  { 149, 6, 11, 6, 1, -11 },
  { 158, 6, 12, 6, 0, -12 },
  { 167, 6, 12, 6, 0, -12 },
  { 176, 3, 9, 3, 0, -9 },
  { 180, 4, 11, 3, -1, -9 },
  { 186, 5, 7, 7, 1, -9 },
  { 191, 5, 4, 7, 1, -8 },
  { 194, 5, 7, 7, 1, -9 },
  { 199, 5, 12, 4, 0, -12 },
  { 207, 9, 13, 9, 0, -12 },
  { 222, 6, 11, 6, -1, -11 },
  { 231, 7, 11, 6, 0, -11 },
  { 241, 6, 12, 6, 1, -12 },
  { 250, 7, 11, 7, 0, -11 },
  { 260, 6, 11, 6, 0, -11 },
  { 269, 6, 11, 5, 0, -11 },
  { 278, 7, 12, 8, 1, -12 },
  { 289, 8, 11, 7, 0, -11 },
  { 300, 6, 11, 3, -1, -11 },
  { 309, 5, 14, 3, -2, -11 },
  { 318, 7, 11, 6, 0, -11 },
  { 328, 4, 11, 5, 0, -11 },
  { 334, 10, 11, 10, 0, -11 },
  { 348, 8, 11, 8, 0, -11 },
  { 359, 6, 12, 8, 1, -12 },
  { 368, 6, 11, 6, 0, -11 },
  { 377, 6, 15, 8, 1, -12 },
  { 389, 6, 11, 6, 0, -11 },
  { 398, 6, 12, 6, 0, -12 },
  { 407, 5, 11, 5, 1, -11 },
  { 414, 7, 11, 7, 1, -11 },
  { 424, 6, 11, 6, 1, -11 },
  { 433, 10, 11, 10, 1, -11 },
  { 447, 8, 11, 5, -1, -11 },
  { 458, 6, 11, 5, 1, -11 },
  { 467, 7, 11, 5, -1, -11 },
  { 477, 5, 14, 4, 0, -11 },
  { 486, 2, 11, 5, 2, -11 },
  { 489, 6, 14, 4, -1, -11 },
  { 500, 6, 5, 6, 0, -11 },
  { 504, 4, 1, 5, -1, 1 },
  { 505, 2, 2, 4, 2, -12 },
  { 506, 6, 9, 6, 0, -9 },
  { 513, 6, 12, 6, 0, -12 },
  { 522, 5, 9, 5, 0, -9 },
  { 528, 7, 12, 6, 0, -12 },
  { 539, 5, 9, 6, 0, -9 },
  { 545, 7, 16, 3, -2, -12 },
  { 559, 6, 13, 6, 0, -9 },
  { 569, 6, 12, 6, 0, -12 },
  { 578, 3, 12, 3, 0, -12 },
  { 583, 5, 16, 3, -2, -12 },
  { 593, 6, 12, 5, 0, -12 },
  { 602, 3, 12, 3, 0, -12 },
  { 607, 9, 9, 9, 0, -9 },
  { 618, 6, 9, 6, 0, -9 },
  { 625, 6, 9, 6, 0, -9 },
  { 632, 7, 13, 6, -1, -9 },
  { 644, 6, 13, 6, 0, -9 },
  { 654, 5, 9, 4, 0, -9 },
  { 660, 5, 9, 5, 0, -9 },
  { 666, 4, 11, 3, 0, -11 },
  { 672, 6, 9, 6, 0, -9 },
  { 679, 5, 9, 5, 1, -9 },
  { 685, 8, 9, 8, 1, -9 },
  { 694, 7, 9, 5, -1, -9 },
  { 702, 8, 13, 5, -2, -9 },
  { 715, 6, 9, 4, -1, -9 },
  { 722, 6, 14, 5, 0, -11 },
  { 733, 1, 16, 6, 2, -12 },
  { 735, 6, 14, 5, -1, -11 },
  { 746, 5, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC16PT7B_H_
