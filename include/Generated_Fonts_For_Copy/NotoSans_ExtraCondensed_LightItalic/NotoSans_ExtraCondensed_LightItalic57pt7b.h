#ifndef _NOTOSANS_EXTRACONDENSED_LIGHTITALIC57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0x8E, 0x1C, 0x60, 0xE3, 0x07, 0x38, 0x31, 0xC1, 0x8C, 0x0C,
  0x60, 0xE3, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1,
  0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x83, 0x80, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x70, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x79, 0x8E, 0x03, 0xC6, 0x08, 0x0E, 0x18, 0x00, 0x70,
  0x60, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0xC2, 0x00, 0x07, 0x18, 0x00, 0x1E, 0x60, 0x00, 0x39, 0x80, 0x00,
  0x76, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xBC, 0x00, 0x06, 0x78, 0x00, 0x18, 0xE0,
  0x00, 0x63, 0x80, 0x01, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x00,
  0xC1, 0x80, 0x03, 0x0E, 0x00, 0x08, 0x38, 0x00, 0x61, 0xE0, 0x81, 0x8F,
  0x03, 0xC6, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0x80, 0xFE, 0x00, 0x60, 0x38, 0xC0, 0x1C,
  0x06, 0x1C, 0x03, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x70, 0x18, 0x0E, 0x0E,
  0x07, 0x01, 0x81, 0xC0, 0xC0, 0x70, 0x38, 0x38, 0x0E, 0x07, 0x06, 0x01,
  0x80, 0xC1, 0xC0, 0x30, 0x18, 0x30, 0x0E, 0x03, 0x0E, 0x01, 0xC0, 0xE1,
  0x80, 0x38, 0x1C, 0x70, 0x06, 0x03, 0x0C, 0x00, 0xC0, 0x63, 0x87, 0x98,
  0x1C, 0x61, 0xFB, 0x03, 0x1C, 0x77, 0xE0, 0xE3, 0x1C, 0x7C, 0x1C, 0xE7,
  0x0F, 0x87, 0x18, 0xC0, 0xF9, 0xC7, 0x38, 0x1B, 0xF0, 0xC7, 0x03, 0x7C,
  0x38, 0xC0, 0xE0, 0x06, 0x38, 0x1C, 0x01, 0xC7, 0x03, 0x80, 0x30, 0xC0,
  0x70, 0x0E, 0x18, 0x0C, 0x01, 0x87, 0x01, 0x80, 0x70, 0xE0, 0x70, 0x0C,
  0x1C, 0x0E, 0x03, 0x83, 0x81, 0x80, 0x60, 0x60, 0x70, 0x1C, 0x0C, 0x0E,
  0x03, 0x01, 0x81, 0x80, 0xE0, 0x30, 0x70, 0x38, 0x07, 0x0C, 0x07, 0x00,
  0xE3, 0x81, 0xC0, 0x0F, 0xE0, 0x38, 0x01, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1C, 0xE0,
  0x01, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xE0, 0xE1, 0xCE, 0x07, 0x0C, 0x70,
  0x1C, 0xE7, 0x80, 0xE7, 0x38, 0x07, 0x71, 0xC0, 0x1F, 0x8E, 0x00, 0xF8,
  0x70, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0xE0, 0x1F, 0x07, 0x00,
  0xF8, 0x38, 0x0E, 0xE1, 0xF1, 0xE7, 0x07, 0xFE, 0x38, 0x1F, 0xE0, 0xE0,
  0x10, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x61, 0x8E, 0x38,
  0xE3, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x61, 0xC0, 0xF9, 0x80, 0x7D, 0x8F, 0x0F, 0xFF, 0x03, 0xFC,
  0x03, 0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x38, 0x60, 0x78, 0x70, 0x30, 0x30,
  0x20, 0x38, 0x00, 0x20, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0x0F, 0x0E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0E,
  0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x78, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x38, 0x07,
  0x07, 0x00, 0x79, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3E, 0x0F, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E,
  0xE1, 0xC4, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0x81, 0xE0, 0x04, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0x70, 0x1E, 0x00,
  0x80, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x02, 0x00, 0x78, 0x0E, 0x07, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x28, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x30, 0x00, 0x19, 0xC0,
  0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x80, 0x03,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0x60, 0x18, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x0C, 0x01,
  0xC0, 0x70, 0x07, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0x83, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x02, 0x00, 0x78, 0x0E, 0x07, 0xC0,
  0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xEE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x7E, 0x01, 0xCF, 0xF8, 0x0E, 0xF7, 0xE0, 0x7E,
  0x0F, 0x03, 0xE0, 0x38, 0x3E, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00,
  0x3C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87,
  0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x0E,
  0x00, 0xF1, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0x81, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78, 0x00, 0xE1,
  0xE0, 0x01, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3D, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0x80,
  0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0F, 0x00,
  0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x87, 0x00, 0x3C, 0x38, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0x01, 0xF0, 0x3E,
  0x3B, 0x80, 0xFF, 0x9C, 0x03, 0xF8, 0xE0, 0x02, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x02, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xFF, 0x03, 0xEF, 0xC1, 0x81, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xF0, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00,
  0x18, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x60, 0x30, 0x60,
  0x1F, 0xE1, 0x87, 0x01, 0xFE, 0x0C, 0x30, 0x1C, 0x70, 0x63, 0x81, 0xC3,
  0x83, 0x1C, 0x1C, 0x18, 0x18, 0xC0, 0xC0, 0xC0, 0xCE, 0x0E, 0x0E, 0x0E,
  0x70, 0x60, 0x70, 0x73, 0x03, 0x03, 0x03, 0x98, 0x38, 0x18, 0x19, 0xC1,
  0x81, 0xC0, 0xCE, 0x0C, 0x0E, 0x0E, 0x70, 0xE0, 0x60, 0x73, 0x07, 0x03,
  0x03, 0x18, 0x38, 0x38, 0x38, 0xC1, 0xC1, 0xC1, 0x86, 0x0E, 0x1E, 0x0C,
  0x30, 0x70, 0xF0, 0xE3, 0x83, 0x8D, 0x86, 0x1C, 0x1C, 0x6C, 0x60, 0xE0,
  0x7E, 0x7F, 0x07, 0x03, 0xE1, 0xE0, 0x38, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x20, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0,
  0x00, 0x38, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0x03, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x38, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x03, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x0E, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xF0, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0,
  0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x07, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x78,
  0x0E, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x20,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xC7, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xE0,
  0xFC, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x80,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x70, 0x3E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0,
  0x06, 0x00, 0xF0, 0x00, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0xFE, 0x1C, 0x00, 0xFF, 0x0F,
  0x00, 0x3F, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x3C,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0xCF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00,
  0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xE0,
  0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x1D, 0xE0, 0x00, 0x0E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF9, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x07, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7E, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x1D, 0x80, 0x00, 0xEE,
  0x01, 0xD8, 0x00, 0x0F, 0xC0, 0x1D, 0x80, 0x01, 0xDC, 0x01, 0x98, 0x00,
  0x1D, 0xC0, 0x39, 0xC0, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x39,
  0xC0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x0E, 0x38,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x0E, 0x38, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x70, 0xE0,
  0x0E, 0x1C, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x1C, 0x1C, 0x1C,
  0x0E, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0x1C, 0x0C, 0x38, 0x1C, 0x03, 0x80,
  0xC3, 0x81, 0xC0, 0x38, 0x0C, 0x30, 0x1C, 0x03, 0x80, 0xC7, 0x01, 0xC0,
  0x38, 0x0C, 0x60, 0x38, 0x03, 0x80, 0xEE, 0x03, 0x80, 0x70, 0x0E, 0xE0,
  0x38, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0x00,
  0xF8, 0x07, 0x00, 0x70, 0x0F, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x38, 0x07, 0xC0, 0x01,
  0xC0, 0x3E, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x07, 0x00,
  0x7C, 0x00, 0x38, 0x07, 0x60, 0x03, 0xC0, 0x3B, 0x80, 0x1C, 0x01, 0xDC,
  0x00, 0xE0, 0x0E, 0xE0, 0x07, 0x00, 0x67, 0x00, 0x38, 0x07, 0x18, 0x03,
  0x80, 0x38, 0xE0, 0x1C, 0x01, 0xC7, 0x00, 0xE0, 0x0E, 0x38, 0x07, 0x00,
  0xE1, 0xC0, 0x38, 0x07, 0x0E, 0x03, 0x80, 0x38, 0x30, 0x1C, 0x01, 0xC1,
  0xC0, 0xE0, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38, 0x07, 0x03, 0x83,
  0x80, 0x38, 0x1C, 0x1C, 0x01, 0xC0, 0x60, 0xE0, 0x0E, 0x03, 0x87, 0x00,
  0xE0, 0x1C, 0x70, 0x07, 0x00, 0xE3, 0x80, 0x38, 0x07, 0x1C, 0x01, 0xC0,
  0x38, 0xE0, 0x1C, 0x00, 0xC7, 0x00, 0xE0, 0x07, 0x70, 0x07, 0x00, 0x3B,
  0x80, 0x38, 0x01, 0xDC, 0x01, 0xC0, 0x0E, 0xE0, 0x1C, 0x00, 0x37, 0x00,
  0xE0, 0x01, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x7C, 0x01, 0xC0,
  0x03, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x0F, 0x07, 0x00,
  0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x38, 0x3E, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x1C, 0x01, 0xC0,
  0x70, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x0E,
  0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xE0, 0x38, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x07,
  0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x38, 0x3E, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x1C,
  0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0xC1,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01,
  0xC0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0x80, 0x60, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x10, 0x03, 0xE0,
  0x3E, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x70,
  0x01, 0xF0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01,
  0xEE, 0x00, 0x0E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x77, 0x00, 0x07, 0x00, 0x0E, 0x70,
  0x00, 0xF0, 0x00, 0xE7, 0x00, 0x0F, 0x00, 0x0E, 0x70, 0x01, 0xF0, 0x01,
  0xC7, 0x00, 0x1F, 0x00, 0x1C, 0x70, 0x01, 0xF0, 0x03, 0x87, 0x00, 0x3F,
  0x00, 0x38, 0x70, 0x03, 0x70, 0x03, 0x87, 0x00, 0x77, 0x00, 0x70, 0x70,
  0x07, 0x70, 0x07, 0x07, 0x00, 0x67, 0x00, 0xF0, 0x70, 0x0E, 0x70, 0x0E,
  0x07, 0x00, 0xE6, 0x00, 0xE0, 0x70, 0x1C, 0x60, 0x1C, 0x07, 0x01, 0xC6,
  0x01, 0xC0, 0x70, 0x18, 0x60, 0x3C, 0x07, 0x03, 0x86, 0x03, 0x80, 0x60,
  0x38, 0x60, 0x38, 0x06, 0x03, 0x06, 0x07, 0x00, 0x60, 0x70, 0x60, 0x70,
  0x0E, 0x06, 0x06, 0x0F, 0x00, 0xE0, 0xE0, 0x60, 0xE0, 0x0E, 0x0E, 0x0E,
  0x0E, 0x00, 0xE0, 0xC0, 0xE1, 0xC0, 0x0E, 0x1C, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0xE3, 0xC0, 0x0E, 0x38, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0xE3, 0x80,
  0x0E, 0x30, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x0E,
  0xF0, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x00, 0xEC,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xEE,
  0x00, 0x3D, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C,
  0x01, 0xC3, 0x80, 0x78, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x1C, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x38, 0x00, 0x67, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x03,
  0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xE1, 0xC1, 0xC3,
  0x83, 0x07, 0x06, 0x0E, 0x00, 0x3C, 0x08, 0x0F, 0xF1, 0x80, 0xFF, 0xCC,
  0x0F, 0x86, 0xE0, 0x70, 0x1F, 0x07, 0x00, 0xF8, 0x78, 0x07, 0x83, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0xF0,
  0x38, 0x0F, 0x81, 0xE0, 0xDC, 0x07, 0x8E, 0xE0, 0x3F, 0xE6, 0x00, 0xFE,
  0x30, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x38, 0x01, 0xC7, 0xF0, 0x0E, 0xFF, 0xC0, 0x76, 0x0E, 0x03, 0xE0,
  0x78, 0x1E, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83,
  0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x3C, 0x3C, 0x01, 0xC1, 0xF0, 0x1E, 0x0F, 0x81,
  0xE0, 0x6E, 0x1E, 0x07, 0x3F, 0xE0, 0x38, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xC1, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x60, 0x7F, 0xE0,
  0x3F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x3F, 0xCE, 0x00, 0xFF, 0xDC, 0x03,
  0xE1, 0xB8, 0x07, 0x01, 0xF0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x3C, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0,
  0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x78, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x0F, 0x80, 0x78, 0x37, 0x00, 0x78,
  0xEE, 0x00, 0xFF, 0x98, 0x00, 0xFE, 0x30, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0xC0, 0x38,
  0xE0, 0x1E, 0x38, 0x0F, 0x0E, 0x0F, 0x87, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x10, 0x3C, 0x1C, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x10,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0x00, 0x1F, 0xC6, 0x00, 0x7F, 0xE6, 0x00, 0xF8,
  0x6E, 0x00, 0xE0, 0x3E, 0x01, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x3C, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x01,
  0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0x1C, 0x07, 0xC0, 0x1E, 0x0F,
  0xC0, 0x1F, 0x1D, 0xC0, 0x0F, 0xF9, 0x80, 0x07, 0xF3, 0x80, 0x00, 0x83,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x80, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC7,
  0x80, 0x39, 0xFE, 0x03, 0xBF, 0xF0, 0x3F, 0x0F, 0x03, 0xE0, 0x70, 0x3C,
  0x07, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0,
  0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C,
  0x38, 0x01, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03,
  0x87, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x06, 0x00,
  0x70, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03,
  0x81, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0x8E, 0x00, 0x18, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x77,
  0x80, 0x03, 0xFC, 0x00, 0x3B, 0x70, 0x01, 0xF3, 0x80, 0x0F, 0x9C, 0x00,
  0x78, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x07, 0x3F, 0xC7, 0xF8, 0x0E,
  0xFF, 0x9F, 0xF8, 0x1F, 0x87, 0xF0, 0xF0, 0x34, 0x07, 0xC0, 0xE0, 0x78,
  0x0F, 0x01, 0xC1, 0xE0, 0x1E, 0x03, 0x83, 0xC0, 0x38, 0x07, 0x07, 0x00,
  0x70, 0x0E, 0x0E, 0x01, 0xC0, 0x1C, 0x3C, 0x03, 0x80, 0x38, 0x70, 0x07,
  0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x70,
  0x07, 0x0E, 0x00, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x38, 0x38, 0x03, 0x80,
  0x70, 0x70, 0x06, 0x00, 0xE0, 0xE0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03,
  0x87, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0x1C, 0x1C, 0x03, 0x80, 0x38,
  0x38, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xC1, 0xC0, 0x1C, 0x03, 0x83,
  0x80, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x1C, 0x38,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x80, 0x39, 0xFE, 0x03, 0xBF, 0xF0,
  0x3F, 0x0F, 0x03, 0x60, 0x70, 0x3C, 0x07, 0x07, 0x80, 0x70, 0x78, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F, 0x03, 0xC3, 0x80, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1D, 0xC0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0xC0,
  0xE0, 0x78, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x71, 0xFC, 0x00, 0x73, 0xFE, 0x00, 0x76, 0x0E, 0x00, 0x7C,
  0x0F, 0x00, 0x78, 0x07, 0x00, 0xF8, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xF0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0x03, 0x80,
  0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1E, 0x07, 0x80,
  0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x78, 0x0F, 0x00, 0x70, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0xC3,
  0xC0, 0x0C, 0xFF, 0x80, 0x1C, 0x7F, 0x00, 0x1C, 0x10, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x08, 0x0F, 0xF1, 0x80, 0xFF, 0xCC, 0x0F, 0x06, 0xE0, 0x70, 0x1F, 0x07,
  0x00, 0xF8, 0x78, 0x07, 0x83, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F,
  0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01,
  0xE0, 0xE0, 0x1F, 0x07, 0x00, 0xF0, 0x38, 0x0F, 0x81, 0xC0, 0xFC, 0x0F,
  0x8E, 0xE0, 0x3F, 0xEE, 0x00, 0xFE, 0x70, 0x00, 0x83, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x81, 0xCF, 0xC0, 0xEF,
  0xE0, 0x6F, 0x10, 0x36, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x0E, 0x03, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC2, 0x00, 0xE0, 0xE0, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x28, 0x00,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x01, 0xFF,
  0x3F, 0xF0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF1, 0x07, 0xE0, 0x7E, 0x00, 0x80, 0x07, 0x00, 0x78,
  0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x0E, 0x01, 0xE0,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x0F, 0x80, 0xF1, 0xDC, 0x07, 0xFC,
  0xC0, 0x1F, 0xC6, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07,
  0x03, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x31, 0xC0, 0x18, 0xE0, 0x0C,
  0x70, 0x06, 0x70, 0x03, 0x38, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x6C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x60,
  0x07, 0x00, 0x76, 0x00, 0xF0, 0x07, 0x60, 0x0F, 0x00, 0xE6, 0x01, 0xF0,
  0x0E, 0x60, 0x1F, 0x01, 0xCE, 0x01, 0xB0, 0x1C, 0xE0, 0x3B, 0x01, 0xCE,
  0x03, 0x30, 0x38, 0xE0, 0x73, 0x03, 0x8E, 0x07, 0x70, 0x70, 0xE0, 0x67,
  0x07, 0x0E, 0x0E, 0x70, 0x70, 0xE0, 0xC7, 0x0E, 0x0E, 0x1C, 0x70, 0xE0,
  0xE1, 0xC7, 0x0C, 0x0E, 0x18, 0x71, 0xC0, 0xE3, 0x87, 0x1C, 0x0E, 0x30,
  0x73, 0x80, 0xE7, 0x07, 0x38, 0x0E, 0x70, 0x73, 0x00, 0xE6, 0x07, 0x70,
  0x0E, 0xE0, 0x77, 0x00, 0xEC, 0x07, 0x60, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x06, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x0C,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7,
  0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xD8, 0x00,
  0x03, 0xB0, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01,
  0xC3, 0x80, 0x07, 0x83, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1E, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x17, 0xFE, 0x01, 0xFF, 0xF0, 0x7C, 0x07, 0xFF, 0x80,
  0x3F, 0xE8, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 41, 12, 1, -41 },
  { 63, 13, 15, 17, 6, -41 },
  { 88, 24, 41, 23, 0, -41 },
  { 211, 22, 46, 21, 0, -43 },
  { 338, 27, 42, 32, 3, -41 },
  { 480, 21, 42, 21, -1, -41 },
  { 591, 6, 15, 9, 6, -41 },
  { 603, 17, 50, 14, 1, -41 },
  { 710, 16, 50, 14, -4, -41 },
  { 810, 16, 17, 19, 6, -43 },
  { 844, 20, 26, 24, 2, -33 },
  { 909, 8, 13, 10, -2, -6 },
  { 922, 13, 3, 15, 1, -17 },
  { 927, 4, 5, 10, 1, -5 },
  { 930, 25, 41, 18, -3, -41 },
  { 1059, 20, 42, 21, 1, -41 },
  { 1164, 12, 41, 21, 6, -41 },
  { 1226, 23, 41, 21, -2, -41 },
  { 1344, 22, 42, 21, -1, -41 },
  { 1460, 22, 41, 21, -1, -41 },
  { 1573, 22, 42, 21, -1, -41 },
  { 1689, 21, 42, 21, 1, -41 },
  { 1800, 21, 41, 21, 2, -41 },
  { 1908, 23, 42, 21, -1, -41 },
  { 2029, 21, 42, 21, 0, -41 },
  { 2140, 10, 31, 10, 0, -31 },
  { 2179, 13, 38, 10, -3, -31 },
  { 2241, 20, 24, 24, 2, -32 },
  { 2301, 20, 15, 24, 2, -28 },
  { 2339, 20, 24, 24, 2, -32 },
  { 2399, 17, 41, 15, 1, -41 },
  { 2487, 29, 46, 31, 1, -41 },
  { 2654, 21, 41, 21, -4, -41 },
  { 2762, 23, 41, 23, 0, -41 },
  { 2880, 23, 42, 21, 2, -41 },
  { 3001, 24, 41, 25, 0, -41 },
  { 3124, 23, 41, 20, 0, -41 },
  { 3242, 23, 41, 19, 0, -41 },
  { 3360, 26, 42, 27, 2, -41 },
  { 3497, 27, 41, 26, 0, -41 },
  { 3636, 19, 41, 12, -3, -41 },
  { 3734, 20, 51, 10, -8, -41 },
  { 3862, 26, 41, 21, 0, -41 },
  { 3996, 14, 41, 18, 0, -41 },
  { 4068, 36, 41, 35, 0, -41 },
  { 4253, 29, 41, 28, 0, -41 },
  { 4402, 24, 42, 27, 2, -41 },
  { 4528, 22, 41, 22, 0, -41 },
  { 4641, 24, 51, 27, 2, -41 },
  { 4794, 22, 41, 22, 0, -41 },
  { 4907, 23, 42, 20, -1, -41 },
  { 5028, 19, 41, 18, 4, -41 },
  { 5126, 25, 42, 26, 2, -41 },
  { 5258, 21, 41, 21, 5, -41 },
  { 5366, 36, 41, 36, 4, -41 },
  { 5551, 26, 41, 19, -3, -41 },
  { 5685, 19, 41, 18, 4, -41 },
  { 5783, 24, 41, 18, -2, -41 },
  { 5906, 21, 50, 16, -1, -41 },
  { 6038, 8, 41, 19, 6, -41 },
  { 6079, 21, 50, 16, -4, -41 },
  { 6211, 21, 21, 23, 1, -41 },
  { 6267, 17, 2, 16, -5, 5 },
  { 6272, 7, 9, 13, 8, -44 },
  { 6280, 21, 32, 23, 2, -31 },
  { 6364, 21, 44, 23, 0, -43 },
  { 6480, 16, 32, 17, 2, -31 },
  { 6544, 23, 44, 23, 2, -43 },
  { 6671, 18, 32, 20, 1, -31 },
  { 6743, 25, 58, 12, -7, -44 },
  { 6925, 24, 45, 23, -1, -31 },
  { 7060, 20, 43, 22, 0, -43 },
  { 7168, 12, 41, 10, 0, -41 },
  { 7230, 19, 55, 10, -7, -41 },
  { 7361, 21, 43, 19, 0, -43 },
  { 7474, 12, 43, 10, 0, -43 },
  { 7539, 31, 31, 33, 0, -31 },
  { 7660, 20, 31, 22, 0, -31 },
  { 7738, 18, 32, 22, 2, -31 },
  { 7810, 24, 44, 23, -3, -31 },
  { 7942, 21, 44, 23, 2, -31 },
  { 8058, 17, 31, 15, 0, -31 },
  { 8124, 18, 32, 17, -1, -31 },
  { 8196, 12, 38, 12, 1, -37 },
  { 8253, 21, 31, 22, 1, -30 },
  { 8335, 17, 30, 17, 3, -30 },
  { 8399, 28, 30, 29, 3, -30 },
  { 8504, 23, 30, 18, -3, -30 },
  { 8591, 27, 44, 18, -6, -30 },
  { 8740, 18, 30, 15, -2, -30 },
  { 8808, 20, 50, 18, 2, -41 },
  { 8933, 2, 57, 20, 9, -43 },
  { 8948, 20, 50, 18, -4, -41 },
  { 9073, 20, 6, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_LightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHTITALIC57PT7B_H_
