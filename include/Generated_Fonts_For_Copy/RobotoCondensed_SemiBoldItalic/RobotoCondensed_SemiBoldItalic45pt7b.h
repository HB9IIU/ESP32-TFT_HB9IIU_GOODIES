#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC45PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x3C, 0x79, 0xE7,
  0x8F, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8E, 0x3C, 0x71, 0xE7,
  0x8F, 0x3C, 0x71, 0xE3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00,
  0x71, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x70, 0x00, 0x71, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x3C, 0x78, 0x00, 0x70, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x07,
  0x8E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x7C, 0xFC,
  0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x87, 0x8F, 0x06, 0x78, 0x78, 0x7B,
  0xC3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF0, 0xF3, 0xC7, 0x87, 0x3C, 0x3C, 0x7B,
  0xC1, 0xF7, 0xDE, 0x07, 0xFD, 0xE0, 0x1F, 0xDE, 0x00, 0x7C, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x3E, 0x00, 0x7B, 0xF8, 0x07, 0xBF,
  0xE0, 0x7B, 0xEF, 0x83, 0xDE, 0x3C, 0x3C, 0xE1, 0xE3, 0xCF, 0x0F, 0x1C,
  0x78, 0x79, 0xE3, 0xC3, 0xDE, 0x1E, 0x1E, 0xE0, 0xF1, 0xE3, 0x03, 0xDF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x8F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x1F, 0x00,
  0x7C, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF3, 0xFF, 0xC7,
  0x9F, 0x9F, 0x3E, 0x7E, 0x7E, 0xFB, 0xF0, 0xFB, 0xEF, 0xC3, 0xFF, 0x3F,
  0x07, 0xFC, 0xFC, 0x1F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0x01, 0xF8, 0x7E,
  0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0x00, 0x08, 0x00,
  0x60, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x08, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x40, 0xE0, 0x9F, 0x3C, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0xF0,
  0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x7C, 0x1E, 0x03, 0x03, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x01, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFC, 0x7D, 0xFB, 0xF7, 0xEF, 0xCF, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF9, 0xF8, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xF0,
  0x3F, 0x7E, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0xFE, 0x3F, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xDF, 0x7E, 0xE3, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x3E,
  0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7C, 0x1F,
  0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE7, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x1E, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81,
  0xF8, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x81, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF9, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F,
  0xBF, 0x07, 0xE7, 0xC3, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F,
  0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0xFC,
  0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x1F, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x8F,
  0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0xDF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x7E,
  0x7C, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xEF, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x00,
  0x0F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0F,
  0x03, 0xF0, 0x38, 0x3C, 0x0F, 0xF0, 0x70, 0xF0, 0x3F, 0xF8, 0xF1, 0xE0,
  0xFF, 0xE1, 0xE3, 0x83, 0xE3, 0xC3, 0xCF, 0x0F, 0x87, 0x87, 0x9E, 0x1E,
  0x0F, 0x0F, 0x78, 0x7C, 0x1C, 0x1E, 0xF0, 0xF0, 0x78, 0x3D, 0xE1, 0xE0,
  0xF0, 0x73, 0xC7, 0xC1, 0xE0, 0xEF, 0x0F, 0x83, 0xC1, 0xDE, 0x1E, 0x0F,
  0x03, 0xBC, 0x3C, 0x1E, 0x0F, 0x78, 0x78, 0x3C, 0x1C, 0xF0, 0xF0, 0xF8,
  0x39, 0xE1, 0xE1, 0xE0, 0xE3, 0xC3, 0xC7, 0xC3, 0xC7, 0x87, 0xFF, 0xCF,
  0x0F, 0x0F, 0xFF, 0xFE, 0x1E, 0x0F, 0xE7, 0xF0, 0x3C, 0x0F, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF8, 0x00,
  0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x83,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x7E, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F,
  0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E,
  0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F,
  0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x07, 0xFE, 0x7C, 0x1F, 0xFD, 0xF8, 0x3F, 0xFB, 0xF0,
  0x7F, 0xF7, 0xE0, 0xFF, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F,
  0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xE3,
  0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7C, 0x03, 0xF8, 0x0F, 0x80,
  0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x3E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFC,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFB, 0xC0,
  0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xBE, 0x03, 0xEF,
  0x83, 0xEF, 0x81, 0xFB, 0xE0, 0xF3, 0xE0, 0x7E, 0xF8, 0x7D, 0xF8, 0x1F,
  0xBE, 0x1F, 0x7E, 0x07, 0xC7, 0x8F, 0x9F, 0x81, 0xF1, 0xE3, 0xE7, 0xC0,
  0x7C, 0x79, 0xF1, 0xF0, 0x3F, 0x1E, 0x7C, 0xFC, 0x0F, 0xC7, 0x9E, 0x3F,
  0x03, 0xF1, 0xEF, 0x8F, 0xC0, 0xFC, 0x7F, 0xC3, 0xF0, 0x3E, 0x1F, 0xF0,
  0xF8, 0x0F, 0x83, 0xF8, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x7E,
  0x0F, 0xF0, 0x0F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xE0, 0x7E, 0x0F, 0xFC,
  0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xC0,
  0xFD, 0xE1, 0xF8, 0x1F, 0x3C, 0x3F, 0x07, 0xE7, 0xC7, 0xE0, 0xFC, 0x78,
  0xFC, 0x1F, 0x8F, 0x1F, 0x03, 0xF1, 0xE3, 0xE0, 0x7E, 0x3E, 0xFC, 0x0F,
  0x83, 0xDF, 0x83, 0xF0, 0x7B, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC0, 0xFF,
  0x81, 0xF8, 0x1F, 0xF0, 0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0xC1, 0xF8,
  0x07, 0xF8, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F,
  0x87, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x3F,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xF8, 0x7E,
  0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F,
  0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x3F,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF8, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC1,
  0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0,
  0x7F, 0xF8, 0x1F, 0x80, 0xFB, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0x07,
  0xEF, 0xC1, 0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7E,
  0x7E, 0x1F, 0xE0, 0xF8, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8, 0x7F, 0x87, 0xE3,
  0xF1, 0xFF, 0x0F, 0x87, 0xE3, 0xFE, 0x1F, 0x0F, 0xC7, 0xBC, 0x7E, 0x1F,
  0x9F, 0x78, 0xF8, 0x3F, 0x3E, 0xF1, 0xF0, 0x7E, 0x79, 0xE7, 0xE0, 0xFD,
  0xF3, 0xCF, 0x81, 0xFB, 0xE7, 0x9F, 0x03, 0xF7, 0x8F, 0x7E, 0x03, 0xFF,
  0x1E, 0xF8, 0x07, 0xFE, 0x3D, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE3, 0xE0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0xF9, 0xF8, 0x01,
  0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87,
  0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x83,
  0xDE, 0x1F, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0x1E, 0x7C, 0x3D, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x78,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7C, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0xFB, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFD, 0xFF, 0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8,
  0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xC7,
  0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x3F, 0x01, 0xFE, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0,
  0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E,
  0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xDF, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E,
  0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x41, 0xF8, 0x38, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x01, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0xBE, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x03, 0xF1,
  0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F,
  0xC3, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xE0,
  0x7E, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0xFB, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0,
  0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC,
  0x0F, 0x8F, 0xC1, 0xF8, 0x03, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xE0, 0xFE, 0x0F,
  0x87, 0xF0, 0x3E, 0x3F, 0x81, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xBF,
  0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFD,
  0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x7E,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0x0F, 0x9F, 0x83, 0xF0, 0x1F, 0x7F, 0x8F, 0xF0, 0x3F,
  0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0,
  0xFF, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x03,
  0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0xFC, 0x1F, 0x81, 0xF1, 0xF8, 0x3F,
  0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x1F, 0x8F, 0x81, 0xF0,
  0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x7E, 0x0F, 0xC0, 0xF8, 0xFC, 0x1F, 0x83,
  0xF1, 0xF8, 0x3F, 0x07, 0xE3, 0xE0, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0x3E, 0x3F, 0x07, 0xE0, 0x7C, 0x7E, 0x0F, 0xC1, 0xF8,
  0x0F, 0x9F, 0x80, 0xFB, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0,
  0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E,
  0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7,
  0xC0, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7E, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xE7, 0xC0,
  0x0F, 0xBF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xF7, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x7F, 0x9F, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x9E, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xE3, 0xFF, 0x87, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC,
  0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0xFC, 0x0F, 0x9F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0x9F, 0x87,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xF8,
  0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F,
  0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC1, 0xF8, 0x7C, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xDF, 0x01, 0xF9, 0xF0, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xC0,
  0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8,
  0x7E, 0xF8, 0x7E, 0x1F, 0x3E, 0x3F, 0x87, 0xCF, 0x8F, 0xE3, 0xE3, 0xE3,
  0xF8, 0xF8, 0xF9, 0xFE, 0x3E, 0x3E, 0x7F, 0x9F, 0x0F, 0xBF, 0xE7, 0xC3,
  0xEF, 0x79, 0xF0, 0xFB, 0xDE, 0xF8, 0x3F, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF,
  0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC1,
  0xF0, 0xFC, 0x0F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xBE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x03, 0xF1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E,
  0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0xF0, 0x07,
  0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x03, 0xCF, 0xF8, 0x1E, 0xFF, 0xE1, 0xE7, 0xFF, 0x8F, 0x7C,
  0x7F, 0xFB, 0xE1, 0xFF, 0x9E, 0x07, 0xFC, 0xF0, 0x1F, 0xC0, 0x00, 0x7C,
  0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 32, 11, 1, -32 },
  { 45, 13, 12, 14, 3, -34 },
  { 65, 23, 32, 23, 1, -32 },
  { 157, 20, 41, 22, 1, -37 },
  { 260, 21, 32, 28, 4, -32 },
  { 344, 22, 32, 25, 1, -32 },
  { 432, 6, 12, 7, 3, -34 },
  { 441, 14, 46, 14, 2, -36 },
  { 522, 14, 46, 14, -2, -36 },
  { 603, 19, 19, 20, 2, -32 },
  { 649, 19, 23, 21, 1, -26 },
  { 704, 9, 13, 10, -3, -5 },
  { 719, 11, 5, 15, 2, -16 },
  { 726, 7, 6, 12, 1, -6 },
  { 732, 20, 35, 15, -3, -32 },
  { 820, 19, 32, 22, 2, -32 },
  { 896, 13, 32, 22, 5, -32 },
  { 948, 21, 32, 22, 0, -32 },
  { 1032, 20, 32, 22, 1, -32 },
  { 1112, 21, 32, 22, 0, -32 },
  { 1196, 20, 32, 22, 2, -32 },
  { 1276, 18, 32, 22, 2, -32 },
  { 1348, 21, 32, 22, 2, -32 },
  { 1432, 20, 32, 22, 1, -32 },
  { 1512, 18, 32, 22, 3, -32 },
  { 1584, 10, 24, 12, 1, -24 },
  { 1614, 12, 32, 11, -2, -24 },
  { 1662, 18, 21, 19, 1, -24 },
  { 1710, 18, 15, 22, 2, -22 },
  { 1744, 18, 21, 20, 1, -24 },
  { 1792, 17, 32, 19, 3, -32 },
  { 1860, 31, 41, 33, 1, -31 },
  { 2019, 25, 32, 26, -2, -32 },
  { 2119, 24, 32, 24, 0, -32 },
  { 2215, 23, 32, 25, 2, -32 },
  { 2307, 24, 32, 25, 0, -32 },
  { 2403, 23, 32, 21, 0, -32 },
  { 2495, 23, 32, 21, 0, -32 },
  { 2587, 23, 32, 26, 2, -32 },
  { 2679, 27, 32, 27, 0, -32 },
  { 2787, 11, 32, 12, 1, -32 },
  { 2831, 22, 32, 21, 0, -32 },
  { 2919, 27, 32, 24, 0, -32 },
  { 3027, 18, 32, 21, 0, -32 },
  { 3099, 34, 32, 33, 0, -32 },
  { 3235, 27, 32, 27, 0, -32 },
  { 3343, 23, 32, 26, 2, -32 },
  { 3435, 25, 32, 25, 0, -32 },
  { 3535, 23, 38, 26, 2, -32 },
  { 3645, 24, 32, 24, 0, -32 },
  { 3741, 23, 32, 23, 1, -32 },
  { 3833, 22, 32, 23, 4, -32 },
  { 3921, 24, 32, 25, 2, -32 },
  { 4017, 24, 32, 25, 4, -32 },
  { 4113, 31, 32, 33, 4, -32 },
  { 4237, 27, 32, 24, -1, -32 },
  { 4345, 23, 32, 24, 4, -32 },
  { 4437, 26, 32, 23, -1, -32 },
  { 4541, 15, 44, 11, -1, -37 },
  { 4624, 10, 35, 17, 4, -32 },
  { 4668, 15, 44, 11, -3, -37 },
  { 4751, 14, 16, 17, 2, -32 },
  { 4779, 18, 5, 17, -3, 0 },
  { 4791, 10, 7, 14, 4, -34 },
  { 4800, 18, 24, 21, 1, -24 },
  { 4854, 20, 34, 22, 0, -34 },
  { 4939, 18, 24, 20, 1, -24 },
  { 4993, 22, 34, 22, 1, -34 },
  { 5087, 19, 24, 21, 1, -24 },
  { 5144, 15, 34, 14, 2, -34 },
  { 5208, 21, 33, 22, 0, -24 },
  { 5295, 20, 34, 21, 0, -34 },
  { 5380, 11, 33, 11, 0, -33 },
  { 5426, 16, 42, 10, -5, -33 },
  { 5510, 22, 34, 21, 0, -34 },
  { 5604, 12, 34, 11, 0, -34 },
  { 5655, 31, 24, 33, 0, -24 },
  { 5748, 20, 24, 21, 0, -24 },
  { 5808, 19, 24, 22, 1, -24 },
  { 5865, 22, 33, 22, -2, -24 },
  { 5956, 20, 33, 22, 1, -24 },
  { 6039, 15, 24, 14, 0, -24 },
  { 6084, 19, 24, 20, 0, -24 },
  { 6141, 12, 30, 13, 2, -30 },
  { 6186, 20, 24, 21, 1, -24 },
  { 6246, 18, 24, 19, 2, -24 },
  { 6300, 26, 24, 28, 3, -24 },
  { 6378, 21, 24, 20, -1, -24 },
  { 6441, 22, 33, 19, -1, -24 },
  { 6532, 21, 24, 20, -1, -24 },
  { 6595, 14, 43, 13, 1, -35 },
  { 6671, 9, 38, 11, 1, -32 },
  { 6714, 14, 43, 13, -2, -35 },
  { 6790, 21, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC45PT7B_H_
