#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC6PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x30, 0x6B, 0xE0, 0x0D, 0x1C, 0x00, 0xED, 0x6B, 0xF0, 0x40,
  0x1A, 0xA0, 0x15, 0xA0, 0xE8, 0x49, 0x20, 0xC0, 0x00, 0x80, 0x5A, 0x76,
  0xE0, 0xF0, 0xE5, 0x60, 0x6C, 0xE0, 0x2B, 0xA0, 0x48, 0xE0, 0x5A, 0xE0,
  0x69, 0x40, 0x6E, 0xE0, 0xF5, 0xA0, 0x20, 0x30, 0x70, 0x78, 0xEA, 0x00,
  0xE9, 0x00, 0x7B, 0xFF, 0xC0, 0x6F, 0xD0, 0x7E, 0xF0, 0x72, 0x70, 0x76,
  0xE0, 0x7E, 0x60, 0x7A, 0x40, 0x72, 0xF0, 0x5E, 0xAA, 0x6A, 0x24, 0xE0,
  0x6C, 0xCA, 0x6B, 0x5D, 0xFD, 0x5E, 0xAA, 0x76, 0xF0, 0x77, 0x40, 0x76,
  0xF2, 0x77, 0x50, 0x68, 0xF0, 0x69, 0x20, 0xB6, 0xF0, 0xA6, 0x44, 0xDE,
  0xEC, 0x64, 0x4A, 0x64, 0x44, 0x69, 0x70, 0x6A, 0xA0, 0x95, 0x5A, 0xA0,
  0x60, 0xC0, 0x00, 0xFB, 0x00, 0x53, 0xDC, 0xF3, 0x00, 0x27, 0xDC, 0xFF,
  0x00, 0x5A, 0x80, 0xF7, 0x60, 0x53, 0xDC, 0x2A, 0x15, 0x40, 0x53, 0x6C,
  0x5A, 0x80, 0xFB, 0xD0, 0xF7, 0x00, 0xF7, 0x00, 0xF7, 0x40, 0xF7, 0x20,
  0xE8, 0xCB, 0x00, 0x2A, 0xB7, 0x00, 0xA9, 0x00, 0xDE, 0xA0, 0xCB, 0x00,
  0xB9, 0x40, 0x6B, 0x00, 0x56, 0xA0, 0x78, 0x18, 0xA0, 0xE0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 2, 4, 4, 1, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 1, 0, -5 },
  { 12, 2, 6, 2, 0, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 3, 2, 3, 0, -4 },
  { 17, 3, 4, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 2, 0, -1 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 2, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 2, 3, 3, 0, -3 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 3, 3, 3, 0, -3 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 4, 5, 4, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 4, 4, 3, 0, -4 },
  { 74, 2, 4, 3, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 3, 5, 4, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 4, 4, 3, 0, -4 },
  { 95, 4, 4, 4, 1, -4 },
  { 97, 4, 4, 3, 0, -4 },
  { 99, 4, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 2, 6, 2, 0, -5 },
  { 105, 2, 4, 2, 0, -4 },
  { 106, 2, 6, 2, 0, -5 },
  { 108, 2, 2, 2, 0, -4 },
  { 109, 2, 1, 2, 0, 0 },
  { 110, 1, 1, 2, 1, -5 },
  { 111, 3, 3, 3, 0, -3 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 3, 3, 3, 0, -3 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 3, 3, 3, 0, -3 },
  { 121, 2, 5, 2, 0, -5 },
  { 123, 3, 4, 3, 0, -3 },
  { 125, 3, 5, 3, 0, -5 },
  { 127, 2, 4, 1, 0, -4 },
  { 128, 2, 5, 1, -1, -4 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 2, 5, 1, 0, -5 },
  { 134, 4, 3, 4, 0, -3 },
  { 136, 3, 3, 3, 0, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 4, 3, 0, -3 },
  { 142, 3, 4, 3, 0, -3 },
  { 144, 2, 3, 2, 0, -3 },
  { 145, 3, 3, 3, 0, -3 },
  { 147, 2, 4, 2, 0, -4 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 4, 3, 4, 0, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 4, 3, 0, -3 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 2, 6, 2, 0, -5 },
  { 162, 1, 5, 1, 0, -4 },
  { 163, 2, 6, 2, 0, -5 },
  { 165, 3, 1, 3, 0, -2 },
};

const GFXfont RobotoCondensed_SemiBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC6PT7B_H_
