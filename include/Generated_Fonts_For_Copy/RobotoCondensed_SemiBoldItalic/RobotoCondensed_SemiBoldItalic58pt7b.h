#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC58PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E,
  0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x78,
  0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0x78, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC3,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFC, 0x7C, 0x04, 0x1F, 0x0F, 0x80, 0xE3, 0xE1, 0xF0,
  0x3E, 0xF8, 0x1E, 0x0F, 0x9F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x7C, 0x7C,
  0x1F, 0x1F, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x7C, 0xF8, 0x1F, 0x1F, 0x3E,
  0x03, 0xFF, 0xEF, 0x80, 0x7F, 0xF9, 0xF0, 0x07, 0xFE, 0x7C, 0x00, 0x7F,
  0x9F, 0x00, 0x01, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x1F,
  0x3F, 0xF0, 0x03, 0xEF, 0xFF, 0x00, 0xF9, 0xFF, 0xE0, 0x3E, 0x7E, 0x3E,
  0x07, 0xCF, 0x87, 0xC1, 0xF3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F,
  0x83, 0xE3, 0xE1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC1, 0xF7,
  0xC0, 0xF8, 0x7C, 0x70, 0x1F, 0x8F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xF0, 0xFF, 0xFC, 0x3F,
  0x1F, 0xFF, 0xC3, 0xF3, 0xFD, 0xFE, 0x3F, 0x3F, 0x8F, 0xE7, 0xF7, 0xF8,
  0xFF, 0x7E, 0x7F, 0x07, 0xF7, 0xEF, 0xF0, 0x7F, 0xFE, 0xFF, 0x03, 0xFF,
  0xCF, 0xF0, 0x3F, 0xFC, 0xFF, 0x01, 0xFF, 0x8F, 0xF0, 0x1F, 0xF8, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x9F, 0xE0,
  0x3F, 0xE1, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x30, 0x1E, 0x06, 0x7E, 0x3E, 0x3E, 0x7F, 0xBE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xEF, 0x00, 0x0F,
  0xCF, 0x80, 0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x03, 0xC0,
  0x10, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF,
  0xE0, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xBF, 0x9E, 0x1F, 0xC8, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xE1, 0xFC,
  0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xC1, 0xFE, 0x00, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x7F, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xDF,
  0xF0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF1, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x87,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x03, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3,
  0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0x81, 0xFC,
  0xFF, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0, 0x3F, 0xCF, 0xF0,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xEF, 0xE0, 0x3F, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0x7F, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0xE0, 0x1E, 0x07, 0xE0, 0x3F,
  0xF0, 0x1F, 0x07, 0xC0, 0x7F, 0xFC, 0x1F, 0x0F, 0xC0, 0xFF, 0xFE, 0x0F,
  0x0F, 0x81, 0xFF, 0xFC, 0x0F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x1F, 0x03,
  0xF0, 0x7C, 0x0F, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x3E, 0x07, 0xC0, 0xFC,
  0x0F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x3E,
  0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x7C, 0x1F, 0x81,
  0xF0, 0x1E, 0x7C, 0x1F, 0x81, 0xF0, 0x1E, 0x7C, 0x1F, 0x01, 0xF0, 0x1E,
  0x7C, 0x1F, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x03, 0xE0, 0x3C, 0xF8, 0x3F,
  0x03, 0xE0, 0x3C, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0xF8, 0x3F, 0x07, 0xE0,
  0x78, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x0F, 0xE0, 0xF0, 0xF8,
  0x1F, 0x9F, 0xE1, 0xF0, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xFB,
  0xFF, 0xC0, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x78, 0x07, 0xE0, 0xFF, 0x00,
  0x7C, 0x01, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0x87, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0x81, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0x9F, 0xE0,
  0x7F, 0xFE, 0x7F, 0x01, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0xC7, 0xF0, 0x1F,
  0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xEF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x03, 0xFB, 0xE0, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x03, 0xF7, 0xF0,
  0x3F, 0xBF, 0x00, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB,
  0xF0, 0x1F, 0xBF, 0x81, 0xFC, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0x03,
  0xF3, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0xFE, 0x07, 0xF1, 0xF0, 0x7E, 0x7F,
  0x81, 0xFC, 0x7C, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0x0F, 0xC7, 0xF0, 0x3F,
  0xC7, 0xE3, 0xF1, 0xFC, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x03, 0xF8, 0x7E,
  0x7E, 0x3F, 0xC0, 0xFE, 0x1F, 0xBF, 0x0F, 0xF0, 0x3F, 0x87, 0xEF, 0xC3,
  0xF8, 0x0F, 0xE0, 0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0x81,
  0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x1F,
  0xFC, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xE0, 0x1F, 0xE0,
  0x7F, 0xF8, 0x07, 0xF0, 0x1F, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x9F, 0x03,
  0xFC, 0x0F, 0xE7, 0xE0, 0xFE, 0x03, 0xF9, 0xF8, 0x3F, 0x81, 0xFE, 0x3E,
  0x0F, 0xE0, 0x7F, 0x8F, 0x87, 0xF8, 0x1F, 0xE3, 0xF1, 0xFE, 0x07, 0xF0,
  0xFC, 0x7F, 0x81, 0xFC, 0x1F, 0x1F, 0xC0, 0x7F, 0x07, 0xE7, 0xF0, 0x3F,
  0xC1, 0xF9, 0xFC, 0x0F, 0xF0, 0x3E, 0xFF, 0x03, 0xF8, 0x0F, 0xBF, 0xC0,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFE,
  0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0,
  0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFE,
  0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xE0, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x37, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0x81, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x01,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF,
  0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0,
  0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xFF, 0x07,
  0xF0, 0x7E, 0x0F, 0xFF, 0x0F, 0xE0, 0x7E, 0x0F, 0xFF, 0x0F, 0xE0, 0x7E,
  0x1F, 0xFF, 0x0F, 0xE0, 0x7E, 0x1F, 0xBF, 0x1F, 0xC0, 0x7E, 0x1F, 0xBF,
  0x1F, 0xC0, 0x7E, 0x3F, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x3F, 0x3F, 0x80,
  0x7E, 0x3F, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x3F, 0x3F, 0x80, 0x7E, 0x7E,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x3F, 0x7F,
  0x00, 0x7E, 0xFC, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07,
  0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0,
  0xFC, 0xF8, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xC7,
  0xE0, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F,
  0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0x07, 0xF3, 0xFC,
  0x0F, 0xEF, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF3, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFE, 0x07, 0xF1, 0xFC,
  0x01, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x7F, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x3F, 0xC7, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xBF, 0xFE, 0x0F, 0xE7, 0xFF, 0x03, 0xF8,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x08, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x03, 0xFF,
  0x9F, 0xC0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xF8,
  0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFD, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x30, 0x7F, 0x80, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xF8, 0x7E, 0x00, 0xFF, 0xE7, 0xE0, 0x3F, 0xFE, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x41, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x30, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x9F,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF1,
  0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x78, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x01, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x07, 0xFC, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xE0,
  0x0F, 0xE7, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0xE7, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x3F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF1, 0xFE, 0x03,
  0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF9, 0xFE, 0x01, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xFC, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x8F,
  0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9,
  0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0xC1, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x9F, 0xFC, 0x03,
  0xF8, 0xFF, 0x80, 0x3F, 0x81, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0xC3, 0xF0, 0x3F, 0xF9, 0xFC, 0x1F, 0xFF, 0x7F, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC,
  0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xEF, 0xE0, 0x00, 0x83, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x7C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0xF0, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0x00, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE3, 0xFC, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x06, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F,
  0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07,
  0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xDF,
  0x80, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xC0, 0xFE,
  0x7E, 0x07, 0xF0, 0x3F, 0x9F, 0x83, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0x07,
  0xF1, 0xF8, 0x3F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF0, 0xFE, 0x1F, 0x87, 0xFC,
  0x3F, 0x87, 0xE3, 0xFF, 0x0F, 0xC1, 0xF8, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F,
  0xF9, 0xF8, 0x1F, 0x9F, 0xFE, 0x7E, 0x07, 0xE7, 0xDF, 0xBF, 0x81, 0xFB,
  0xF3, 0xEF, 0xC0, 0x7E, 0xF8, 0xFB, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3E, 0x0F, 0xFC, 0x03, 0xE1, 0xFF, 0xE0,
  0x3E, 0x3F, 0xFF, 0x07, 0xE3, 0xFF, 0xF0, 0x7E, 0x7F, 0x3F, 0xCF, 0xC7,
  0xE1, 0xFF, 0xFC, 0x7C, 0x0F, 0xFF, 0x87, 0xC0, 0x7F, 0xF8, 0xFC, 0x03,
  0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 42, 14, 1, -41 },
  { 75, 16, 15, 18, 4, -44 },
  { 105, 29, 41, 30, 1, -41 },
  { 254, 26, 54, 28, 2, -48 },
  { 430, 27, 43, 36, 5, -42 },
  { 576, 28, 43, 32, 1, -42 },
  { 727, 8, 15, 9, 4, -44 },
  { 742, 17, 59, 18, 3, -46 },
  { 868, 18, 59, 18, -3, -46 },
  { 1001, 24, 25, 25, 3, -41 },
  { 1076, 24, 30, 27, 2, -34 },
  { 1166, 11, 17, 13, -3, -7 },
  { 1190, 14, 6, 19, 2, -21 },
  { 1201, 9, 9, 16, 1, -8 },
  { 1212, 25, 45, 19, -3, -41 },
  { 1353, 24, 43, 28, 3, -42 },
  { 1482, 17, 41, 28, 6, -41 },
  { 1570, 27, 42, 28, 0, -42 },
  { 1712, 26, 43, 28, 1, -42 },
  { 1852, 26, 41, 28, 1, -41 },
  { 1986, 26, 42, 28, 2, -41 },
  { 2123, 23, 42, 28, 3, -41 },
  { 2244, 27, 41, 28, 3, -41 },
  { 2383, 25, 43, 28, 2, -42 },
  { 2518, 23, 42, 28, 4, -42 },
  { 2639, 13, 33, 15, 1, -32 },
  { 2693, 16, 42, 14, -3, -32 },
  { 2777, 23, 27, 25, 1, -31 },
  { 2855, 24, 18, 28, 2, -28 },
  { 2909, 23, 27, 26, 1, -31 },
  { 2987, 21, 43, 25, 4, -42 },
  { 3100, 40, 53, 43, 1, -40 },
  { 3365, 32, 41, 33, -2, -41 },
  { 3529, 29, 41, 31, 1, -41 },
  { 3678, 30, 43, 32, 2, -42 },
  { 3840, 30, 41, 32, 1, -41 },
  { 3994, 29, 41, 28, 1, -41 },
  { 4143, 29, 41, 27, 1, -41 },
  { 4292, 30, 43, 33, 2, -42 },
  { 4454, 34, 41, 35, 1, -41 },
  { 4629, 14, 41, 15, 1, -41 },
  { 4701, 28, 42, 28, 0, -41 },
  { 4848, 34, 41, 31, 1, -41 },
  { 5023, 23, 41, 27, 1, -41 },
  { 5141, 42, 41, 43, 1, -41 },
  { 5357, 34, 41, 35, 1, -41 },
  { 5532, 31, 43, 34, 2, -42 },
  { 5699, 31, 41, 32, 1, -41 },
  { 5858, 31, 49, 34, 2, -42 },
  { 6048, 30, 41, 31, 1, -41 },
  { 6202, 29, 43, 30, 1, -42 },
  { 6358, 28, 41, 30, 5, -41 },
  { 6502, 31, 42, 32, 2, -41 },
  { 6665, 31, 41, 32, 5, -41 },
  { 6824, 40, 41, 42, 5, -41 },
  { 7029, 36, 41, 31, -2, -41 },
  { 7214, 29, 41, 30, 5, -41 },
  { 7363, 33, 41, 30, -1, -41 },
  { 7533, 19, 57, 15, -1, -48 },
  { 7669, 13, 45, 21, 5, -41 },
  { 7743, 19, 57, 15, -3, -48 },
  { 7879, 19, 21, 22, 2, -41 },
  { 7929, 22, 6, 23, -3, 0 },
  { 7946, 12, 9, 18, 6, -44 },
  { 7960, 23, 33, 27, 1, -32 },
  { 8055, 26, 45, 28, 0, -44 },
  { 8202, 24, 33, 26, 1, -32 },
  { 8301, 28, 45, 28, 1, -44 },
  { 8459, 24, 33, 27, 1, -32 },
  { 8558, 20, 45, 18, 2, -45 },
  { 8671, 28, 44, 28, 0, -32 },
  { 8825, 25, 44, 28, 0, -44 },
  { 8963, 15, 43, 14, 0, -43 },
  { 9044, 20, 55, 14, -6, -43 },
  { 9182, 28, 44, 27, 0, -44 },
  { 9336, 15, 44, 14, 0, -44 },
  { 9419, 39, 32, 42, 0, -32 },
  { 9575, 25, 32, 28, 0, -32 },
  { 9675, 25, 33, 28, 1, -32 },
  { 9779, 28, 44, 28, -2, -32 },
  { 9933, 26, 44, 28, 1, -32 },
  { 10076, 19, 32, 18, 0, -32 },
  { 10152, 24, 33, 26, 0, -32 },
  { 10251, 16, 39, 17, 2, -38 },
  { 10329, 25, 32, 28, 2, -31 },
  { 10429, 23, 31, 25, 3, -31 },
  { 10519, 34, 31, 36, 3, -31 },
  { 10651, 28, 31, 25, -2, -31 },
  { 10760, 29, 43, 25, -2, -31 },
  { 10916, 26, 31, 25, -1, -31 },
  { 11017, 18, 55, 17, 1, -45 },
  { 11141, 12, 49, 14, 1, -41 },
  { 11215, 18, 55, 17, -2, -45 },
  { 11339, 28, 13, 32, 2, -24 },
};

const GFXfont RobotoCondensed_SemiBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC58PT7B_H_
