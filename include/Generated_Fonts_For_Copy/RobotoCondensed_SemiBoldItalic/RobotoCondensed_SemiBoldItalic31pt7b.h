#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC31PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7,
  0x8E, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x8F, 0x1C, 0x00, 0x73, 0xB9, 0xDC,
  0xCE, 0xE6, 0x73, 0x3B, 0x99, 0xCC, 0x01, 0xCE, 0x03, 0x98, 0x06, 0x70,
  0x1C, 0xE0, 0x39, 0x80, 0x67, 0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0C,
  0xE0, 0x39, 0x80, 0x67, 0x00, 0xCE, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC,
  0x39, 0x80, 0x63, 0x00, 0xCE, 0x03, 0x98, 0x07, 0x30, 0x0C, 0xE0, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xE7,
  0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xE7, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x3C, 0x01, 0xF8, 0x0F, 0x70, 0x39, 0xC7, 0xC7, 0x3B, 0x1C, 0xCC,
  0x77, 0x3B, 0xB8, 0xFF, 0xC1, 0xE6, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x70,
  0x3F, 0xE1, 0xDD, 0xCE, 0xE3, 0x33, 0x8D, 0xCE, 0x3E, 0x39, 0xD0, 0xEF,
  0x01, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xF3, 0xC1,
  0xC7, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x78, 0x1F, 0xE0, 0x1F, 0x80, 0x3C,
  0x01, 0xFC, 0xF7, 0xF9, 0xEF, 0x7B, 0xBC, 0xF7, 0x78, 0xFE, 0xF1, 0xF9,
  0xE1, 0xE3, 0xC7, 0xC7, 0xFF, 0xC7, 0xFF, 0x83, 0xE7, 0x80, 0x77, 0x77,
  0x6E, 0xEE, 0x00, 0x40, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0x80, 0x20, 0x08, 0x06, 0x03, 0x80, 0xE0, 0x70,
  0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x0F,
  0x07, 0x07, 0x07, 0x03, 0x01, 0x00, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0xE7, 0x7F, 0xFF, 0x3F, 0xE0, 0xE0, 0x1F, 0x03, 0xB8, 0x73, 0x8E, 0x1C,
  0x01, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x71, 0xCF, 0x3C, 0xE7, 0xBC, 0x60, 0x7F,
  0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x03, 0xE0,
  0x7F, 0x87, 0xFE, 0x3C, 0xF3, 0xC3, 0x9E, 0x1C, 0xE0, 0xEF, 0x07, 0x78,
  0x3B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x07, 0xF8, 0x3F, 0xC1, 0xDE, 0x1E,
  0xF0, 0xF3, 0x87, 0x1E, 0x78, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x00, 0x83,
  0xC7, 0xEF, 0xF7, 0xFB, 0x3E, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0x01,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE1, 0xE3, 0xC7, 0x83, 0x8F, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x3C, 0x78, 0xE0, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xE0, 0xF3, 0xC3,
  0xCF, 0xBE, 0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xFE, 0x07, 0x78,
  0x39, 0xE1, 0xE7, 0x87, 0x1C, 0x38, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x9E, 0x1F, 0xF8, 0x3F, 0xC0,
  0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0x3C, 0xF0, 0xF7, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0xF3, 0x87, 0x9E, 0x78, 0xFF, 0xC3, 0xFC,
  0x0F, 0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x87, 0xDE, 0x3C, 0x38, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x1C, 0xF8,
  0x7F, 0xC1, 0xFC, 0x0F, 0xF8, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x9E, 0x1F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x07,
  0x81, 0xFE, 0x3F, 0xE3, 0xCF, 0x78, 0xF7, 0x8F, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xE7, 0xFE, 0x1F, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x1F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0x3C, 0xF3, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x3C, 0xE0, 0x0F, 0x0F, 0x0F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0x40, 0x00, 0x10, 0x07, 0x01, 0xE0,
  0x7E, 0x1F, 0xE7, 0xF0, 0xFC, 0x0F, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x80, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF7, 0xFF, 0x00, 0x20,
  0x03, 0x80, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x07,
  0xF1, 0xFE, 0x7F, 0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0xDE, 0xF1, 0xEF, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xF8, 0xF8, 0x0F, 0x01, 0xC0, 0xF0, 0x07, 0x07, 0x00, 0x18, 0x70,
  0xF0, 0xC7, 0x0F, 0xE7, 0x38, 0xFF, 0x1B, 0x8E, 0x38, 0xDC, 0x71, 0x86,
  0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC7, 0x1F, 0x9C, 0x30, 0xDC, 0xE3,
  0x86, 0xC7, 0x1C, 0x36, 0x38, 0xE3, 0xB1, 0xCF, 0x19, 0x8F, 0xF9, 0x8C,
  0x3E, 0xFC, 0x61, 0xE7, 0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xDC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80,
  0xF1, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF,
  0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x00, 0xEF, 0x80, 0x7F, 0x80, 0x3C, 0x0F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0x3E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x3C, 0x7C, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x1E, 0x3E, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x9F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0xFE, 0x78, 0xFE, 0xF0, 0xFE, 0xF0, 0x1E, 0xF0, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x81,
  0xE1, 0xE0, 0x3C, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x70, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xE1,
  0xE7, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC1, 0xE0,
  0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x9E,
  0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x7C,
  0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xE7, 0xFF, 0x7F,
  0xF8, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0E, 0xE0, 0xFE,
  0x1D, 0xC3, 0xFC, 0x7B, 0x87, 0x78, 0xF7, 0x1E, 0xE1, 0xEE, 0x3B, 0xC3,
  0xDC, 0xF7, 0x87, 0xB9, 0xCF, 0x0F, 0x3B, 0x9E, 0x3C, 0x7E, 0x38, 0x78,
  0xFC, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x87, 0x8F,
  0x0F, 0x1E, 0x1C, 0x3C, 0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F,
  0x0F, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x1E,
  0x1F, 0xC7, 0x87, 0x9C, 0xF0, 0xF3, 0x9E, 0x1E, 0x73, 0xC3, 0xCF, 0x78,
  0x78, 0xEF, 0x0F, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x3F, 0x0F, 0x07, 0xE1,
  0xE0, 0xFC, 0x3C, 0x1F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBF, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x7C, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xC3, 0xC3, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x0F, 0x9E, 0x07, 0x8F, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xBF, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0,
  0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x7C, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x0F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x3C, 0x1F, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3C, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x78,
  0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF9,
  0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0xF7, 0xE3, 0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xCF,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x1F, 0x3E, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x03,
  0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x38,
  0x78, 0x1C, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xFC, 0x3C,
  0x3D, 0xE3, 0xE1, 0xEF, 0x1F, 0x0F, 0x78, 0xF8, 0xF3, 0xCF, 0xC7, 0x9E,
  0x7E, 0x3C, 0xF3, 0xF3, 0xC7, 0xBF, 0x9E, 0x3D, 0xDC, 0xF1, 0xEE, 0xEF,
  0x0F, 0xF7, 0x78, 0x7F, 0x3B, 0xC3, 0xF9, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xC0,
  0x78, 0x1E, 0x00, 0x0F, 0x03, 0xE1, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC3,
  0xC0, 0x78, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF8,
  0x1E, 0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0x3E, 0x00, 0xF0, 0x3F, 0xE0, 0x7B,
  0xC1, 0xF7, 0x83, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x3B,
  0xC0, 0x77, 0x80, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xC0, 0x0F, 0xC3, 0xF0, 0xF8, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x3E, 0x0F, 0x80, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70,
  0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87,
  0x0F, 0x07, 0xE0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x07, 0x01, 0xE0, 0xF8,
  0x3E, 0x1F, 0x87, 0x63, 0x98, 0xE7, 0x71, 0xDC, 0x7E, 0x1C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0x8F, 0x1C, 0x03, 0xE0, 0x7F, 0x87, 0xFE,
  0x7C, 0xF3, 0xC7, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0x3F, 0xF3, 0xF7, 0x9E,
  0x3C, 0xE1, 0xEF, 0x0F, 0x7C, 0xF9, 0xFF, 0xCF, 0xFC, 0x1C, 0xF0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0x07,
  0xFE, 0x1F, 0xF8, 0xF9, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0x83, 0xDE, 0x0F, 0x78, 0x39, 0xE1, 0xE7, 0x87, 0x9F, 0x3C, 0xFF, 0xF3,
  0xDF, 0x8F, 0x3C, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0xCF, 0x78, 0x77,
  0x07, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0E, 0xF1, 0xEF,
  0x3E, 0x7F, 0xC7, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xCF, 0x1F, 0xDC, 0x3F, 0xF8, 0xF9,
  0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0x87, 0x9F, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0x78, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0x77, 0x07, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x4F, 0x9C, 0x7F,
  0xE3, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xC1, 0xE0, 0x3C,
  0x1F, 0xE3, 0xFC, 0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0x9E, 0x1F, 0xBC, 0x7F, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x9E, 0x1F, 0xFC, 0x1F, 0xF8, 0x1E, 0xF0, 0x01, 0xE1, 0x07, 0x83,
  0x1F, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFF, 0x3F, 0xF9, 0xF3,
  0xCF, 0x0E, 0x78, 0x73, 0xC7, 0x9C, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x1C, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xC0, 0x0E, 0x0F,
  0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x83, 0xF0, 0x7C, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x8F, 0x8F, 0x3E, 0x1C, 0xF8, 0x79, 0xE0, 0xF7, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF3, 0xC1, 0xE7,
  0x83, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x0F,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x1C, 0xF1, 0xE0, 0xFF,
  0xDF, 0x8F, 0xFF, 0xFE, 0x7C, 0xFD, 0xF3, 0xC7, 0xC7, 0x9E, 0x3C, 0x3C,
  0xF1, 0xE1, 0xE7, 0x0F, 0x0F, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0x9E, 0x1E,
  0x3C, 0xF0, 0xE1, 0xE7, 0x8F, 0x0F, 0x38, 0x78, 0x7B, 0xC3, 0xC3, 0xDE,
  0x1E, 0x1C, 0xF0, 0xF1, 0xE0, 0x1C, 0xF0, 0xFF, 0xCF, 0xFE, 0x7C, 0xF3,
  0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0x38, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF0, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0xF9, 0xE7, 0x87, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x0F, 0x7C, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F,
  0x00, 0x0E, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xF9, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xE1, 0xE3,
  0xC3, 0xC7, 0xCF, 0x1F, 0xFE, 0x3D, 0xF8, 0x79, 0xE0, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x38, 0xFE,
  0xE3, 0xFF, 0x9F, 0x3E, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0xFE, 0x1F,
  0xF8, 0x3D, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x1D, 0xC7, 0xF3, 0xFC, 0xFF, 0x3E, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0xC7, 0x9E, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xEF, 0x0F, 0x78, 0xF1, 0xFF,
  0x87, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x07, 0x8F, 0xEF, 0xF7, 0xF8, 0xF0,
  0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x3E,
  0x1F, 0x07, 0x80, 0x3C, 0x39, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC,
  0x3D, 0xE1, 0xCE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x1E,
  0x7D, 0xF3, 0xFF, 0x8F, 0xFC, 0x3D, 0xE0, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x78, 0x77, 0x87, 0x70, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0xE1, 0xC3, 0xF8,
  0x70, 0xEE, 0x3C, 0x7B, 0x8F, 0x1E, 0xE3, 0xC7, 0x39, 0xFB, 0xCE, 0x7E,
  0xF3, 0xBB, 0xB8, 0xEE, 0xFE, 0x3B, 0xBF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x3C, 0x78, 0x38, 0xF0, 0x7B, 0xC0, 0xFF, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xEE,
  0x07, 0x9C, 0x0F, 0x3C, 0x3C, 0x78, 0xF8, 0xF0, 0x1E, 0x1E, 0x3C, 0x7C,
  0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x00, 0x81, 0xC1, 0xE1,
  0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x87, 0xC3,
  0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x0E, 0x07, 0x00, 0x80, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E,
  0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E,
  0x1C, 0x30, 0x60, 0xC0, 0x0C, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x0F, 0x0F, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x1E, 0x0E,
  0x06, 0x00, 0x1E, 0x0E, 0x7E, 0x1D, 0xFE, 0x73, 0xDE, 0xEE, 0x3F, 0xDC,
  0x3F, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 22, 8, 1, -22 },
  { 21, 9, 8, 10, 2, -23 },
  { 30, 15, 22, 16, 1, -22 },
  { 72, 14, 28, 15, 1, -25 },
  { 121, 14, 22, 19, 3, -22 },
  { 160, 15, 22, 17, 1, -22 },
  { 202, 4, 8, 5, 2, -23 },
  { 206, 10, 32, 10, 1, -25 },
  { 246, 9, 32, 10, -1, -25 },
  { 282, 12, 13, 13, 2, -22 },
  { 302, 13, 16, 14, 1, -19 },
  { 328, 6, 9, 7, -2, -4 },
  { 335, 8, 3, 10, 1, -11 },
  { 338, 4, 4, 9, 1, -4 },
  { 340, 14, 24, 10, -2, -22 },
  { 382, 13, 22, 15, 1, -22 },
  { 418, 9, 22, 15, 3, -22 },
  { 443, 15, 22, 15, 0, -22 },
  { 485, 14, 22, 15, 1, -22 },
  { 524, 14, 22, 15, 0, -22 },
  { 563, 14, 22, 15, 1, -22 },
  { 602, 13, 22, 15, 1, -22 },
  { 638, 15, 22, 15, 1, -22 },
  { 680, 14, 22, 15, 1, -22 },
  { 719, 12, 22, 15, 2, -22 },
  { 752, 6, 17, 8, 1, -17 },
  { 765, 8, 22, 7, -1, -17 },
  { 787, 12, 15, 13, 1, -17 },
  { 810, 13, 10, 15, 1, -15 },
  { 827, 12, 15, 14, 1, -17 },
  { 850, 12, 22, 13, 2, -22 },
  { 883, 21, 29, 23, 1, -22 },
  { 960, 17, 22, 18, -1, -22 },
  { 1007, 16, 22, 17, 0, -22 },
  { 1051, 16, 22, 17, 1, -22 },
  { 1095, 16, 22, 17, 0, -22 },
  { 1139, 16, 22, 15, 0, -22 },
  { 1183, 16, 22, 14, 0, -22 },
  { 1227, 16, 22, 18, 1, -22 },
  { 1271, 19, 22, 19, 0, -22 },
  { 1324, 8, 22, 8, 0, -22 },
  { 1346, 15, 22, 15, 0, -22 },
  { 1388, 19, 22, 17, 0, -22 },
  { 1441, 13, 22, 14, 0, -22 },
  { 1477, 23, 22, 23, 0, -22 },
  { 1541, 19, 22, 18, 0, -22 },
  { 1594, 16, 22, 18, 1, -22 },
  { 1638, 17, 22, 17, 0, -22 },
  { 1685, 16, 26, 18, 1, -22 },
  { 1737, 16, 22, 16, 0, -22 },
  { 1781, 15, 22, 16, 1, -22 },
  { 1823, 16, 22, 16, 2, -22 },
  { 1867, 17, 22, 17, 1, -22 },
  { 1914, 17, 22, 17, 2, -22 },
  { 1961, 21, 22, 23, 3, -22 },
  { 2019, 19, 22, 17, -1, -22 },
  { 2072, 15, 22, 16, 3, -22 },
  { 2114, 17, 22, 16, 0, -22 },
  { 2161, 10, 31, 8, 0, -26 },
  { 2200, 7, 24, 11, 3, -22 },
  { 2221, 11, 31, 8, -2, -26 },
  { 2264, 10, 11, 12, 1, -22 },
  { 2278, 12, 3, 12, -2, 0 },
  { 2283, 6, 5, 10, 3, -24 },
  { 2287, 13, 17, 14, 0, -17 },
  { 2315, 14, 23, 15, 0, -23 },
  { 2356, 12, 17, 14, 1, -17 },
  { 2382, 15, 23, 15, 1, -23 },
  { 2426, 12, 17, 14, 1, -17 },
  { 2452, 11, 23, 10, 1, -23 },
  { 2484, 15, 23, 15, 0, -17 },
  { 2528, 13, 23, 15, 0, -23 },
  { 2566, 8, 23, 7, 0, -23 },
  { 2589, 11, 29, 7, -3, -23 },
  { 2629, 15, 23, 14, 0, -23 },
  { 2673, 8, 23, 7, 0, -23 },
  { 2696, 21, 17, 22, 0, -17 },
  { 2741, 13, 17, 15, 0, -17 },
  { 2769, 13, 17, 15, 1, -17 },
  { 2797, 15, 23, 15, -1, -17 },
  { 2841, 14, 23, 15, 1, -17 },
  { 2882, 10, 17, 10, 0, -17 },
  { 2904, 13, 17, 14, 0, -17 },
  { 2932, 9, 20, 9, 1, -20 },
  { 2955, 13, 17, 15, 1, -17 },
  { 2983, 12, 17, 13, 2, -17 },
  { 3009, 18, 17, 19, 2, -17 },
  { 3048, 15, 17, 14, -1, -17 },
  { 3080, 15, 23, 13, -1, -17 },
  { 3124, 13, 17, 14, 0, -17 },
  { 3152, 9, 29, 9, 1, -24 },
  { 3185, 7, 26, 8, 0, -22 },
  { 3208, 9, 30, 9, -1, -24 },
  { 3242, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC31PT7B_H_
