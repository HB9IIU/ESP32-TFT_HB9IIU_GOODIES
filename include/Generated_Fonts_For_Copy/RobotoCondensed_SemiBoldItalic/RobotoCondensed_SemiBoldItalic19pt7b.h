#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC19PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x18, 0xCC, 0x60, 0x00, 0xCE, 0x30, 0x6D, 0xA4,
  0x96, 0xD8, 0x06, 0x81, 0x20, 0xD8, 0x36, 0x3F, 0xCF, 0xF1, 0xB0, 0x48,
  0x7F, 0xBF, 0xC3, 0x40, 0x90, 0x6C, 0x1A, 0x00, 0x04, 0x04, 0x1E, 0x3F,
  0x77, 0x63, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0xC6, 0xCE, 0xFC, 0x78,
  0x20, 0x20, 0x70, 0x6C, 0x26, 0xD3, 0x4F, 0x67, 0x60, 0x20, 0x30, 0x37,
  0x16, 0x9A, 0x79, 0x20, 0xF0, 0x70, 0x0E, 0x07, 0xC1, 0xB0, 0xCC, 0x33,
  0x07, 0x81, 0xC0, 0xF3, 0x6D, 0x99, 0xEE, 0x79, 0x8C, 0x7F, 0x8F, 0x60,
  0x6D, 0x6C, 0x08, 0x71, 0x8C, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x41, 0x82, 0x00, 0x10, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC6, 0x18, 0x63, 0x0C, 0x63, 0x88, 0x00, 0x08, 0x08, 0xDB, 0xFF,
  0x18, 0x38, 0x6C, 0x44, 0x18, 0x18, 0x18, 0x18, 0xFE, 0xFE, 0x30, 0x30,
  0x30, 0x30, 0x36, 0x66, 0xC0, 0xFF, 0x7D, 0x80, 0x03, 0x03, 0x06, 0x06,
  0x04, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x1E,
  0x3E, 0x77, 0x63, 0x63, 0xE7, 0xC7, 0xC7, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC,
  0x78, 0x0C, 0xEF, 0xB6, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x1C, 0x71, 0x80,
  0x0E, 0x1F, 0x8C, 0xEE, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E,
  0x0E, 0x0F, 0xF7, 0xF8, 0x0E, 0x1F, 0x8C, 0xE6, 0x70, 0x38, 0x18, 0x7C,
  0x3C, 0x07, 0x01, 0xB8, 0xCC, 0xE7, 0xE1, 0xE0, 0x03, 0x83, 0xC1, 0xC1,
  0xE0, 0xB0, 0xD8, 0xDC, 0x6E, 0x66, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0, 0x70,
  0x3F, 0x3F, 0x30, 0x60, 0x60, 0x7C, 0x7E, 0x06, 0x06, 0x06, 0xC6, 0xCE,
  0xFC, 0x78, 0x0E, 0x3C, 0xE3, 0x86, 0x1F, 0xBF, 0xF3, 0xC7, 0x8F, 0x1E,
  0x77, 0xCF, 0x00, 0x7F, 0xBF, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x00, 0x1E, 0x3E, 0x77, 0x63, 0x67,
  0x66, 0x3E, 0x7C, 0xEE, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x1C, 0x3E, 0x66,
  0x67, 0xE7, 0xE7, 0xE7, 0x7E, 0x3E, 0x06, 0x0C, 0x1C, 0x78, 0x60, 0x31,
  0x8C, 0x00, 0x00, 0x00, 0x67, 0x18, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x01,
  0x8C, 0xC6, 0x60, 0x01, 0x07, 0x1E, 0x78, 0x60, 0xF8, 0x3C, 0x0E, 0x04,
  0x7E, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x20, 0x38, 0x3C, 0x0F, 0x07, 0x1F,
  0x7C, 0x60, 0x80, 0x3C, 0xFD, 0x9F, 0x30, 0x61, 0xC7, 0x1C, 0x30, 0x60,
  0x03, 0x06, 0x0C, 0x00, 0x03, 0xE0, 0x7B, 0x86, 0x06, 0x20, 0x13, 0x3C,
  0x93, 0xE5, 0x9B, 0x29, 0x99, 0x4C, 0xCE, 0x64, 0xF3, 0x67, 0x9F, 0x64,
  0xEE, 0x20, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x1B, 0x83, 0x30, 0xE6, 0x18, 0xC7, 0xF8, 0xFF, 0x38,
  0x66, 0x0D, 0xC1, 0xC0, 0x3F, 0x0F, 0xE3, 0x9C, 0xC7, 0x31, 0xCC, 0x67,
  0xF9, 0xFC, 0x71, 0x98, 0x66, 0x19, 0x8E, 0xFF, 0x3F, 0x80, 0x1F, 0x0F,
  0xE7, 0x19, 0x86, 0x61, 0xB8, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0xCC, 0x33,
  0x9C, 0x7E, 0x0F, 0x00, 0x3F, 0x0F, 0xE3, 0x9C, 0xC7, 0x30, 0xCC, 0x37,
  0x1D, 0xC7, 0x71, 0xD8, 0x66, 0x39, 0x8C, 0xFF, 0x3F, 0x00, 0x3F, 0xCF,
  0xF3, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0xF1, 0xFC, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE3, 0x80, 0xC0, 0x30, 0x0C, 0x07,
  0xF1, 0xFC, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x0F,
  0xE7, 0x19, 0x87, 0x60, 0x38, 0x0E, 0x03, 0x1E, 0xCF, 0xB0, 0xEC, 0x3B,
  0x8C, 0x7F, 0x0F, 0x80, 0x38, 0x63, 0x86, 0x38, 0x63, 0x06, 0x30, 0xE3,
  0x0E, 0x7F, 0xC7, 0xFC, 0x70, 0xC6, 0x0C, 0x61, 0xC6, 0x1C, 0xE1, 0x8E,
  0x18, 0x19, 0xCE, 0x63, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x70, 0x01, 0x80,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0xB9, 0xDC, 0xC7,
  0xE1, 0xC0, 0x38, 0xE3, 0x9C, 0x39, 0xC3, 0x38, 0x37, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x70, 0x67, 0x06, 0x30, 0xE3, 0x8E, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xFF,
  0xFE, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE7,
  0xCD, 0x9F, 0x36, 0x65, 0xB9, 0x96, 0xE6, 0x73, 0x19, 0xCC, 0xE7, 0x33,
  0x98, 0xC0, 0x38, 0x63, 0x86, 0x3C, 0x63, 0xC6, 0x3C, 0xE3, 0x4E, 0x76,
  0xC7, 0x6C, 0x76, 0xC6, 0x2C, 0x63, 0xC6, 0x3C, 0xE3, 0x8E, 0x18, 0x1F,
  0x0F, 0xE7, 0x19, 0x87, 0x61, 0xF8, 0x7E, 0x1B, 0x06, 0xC1, 0xB0, 0x6C,
  0x3B, 0x9C, 0x7E, 0x0F, 0x00, 0x3F, 0x8F, 0xF3, 0x8C, 0xC3, 0x30, 0xCC,
  0x37, 0x1D, 0xFE, 0x7F, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x1F,
  0x0F, 0xE7, 0x19, 0x87, 0x61, 0xF8, 0x7E, 0x1B, 0x06, 0xC1, 0xB0, 0x6C,
  0x3B, 0x9C, 0x7E, 0x0F, 0x80, 0x70, 0x08, 0x3F, 0x0F, 0xE3, 0x9C, 0xC3,
  0x30, 0xCC, 0x77, 0x19, 0xFE, 0x7E, 0x19, 0xC6, 0x71, 0x8C, 0xE3, 0x38,
  0xE0, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x30, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0xEE, 0x39, 0x8C, 0x7F, 0x0F, 0x80, 0x7F, 0xDF, 0xF0, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x00, 0x71, 0xDC, 0x76, 0x19, 0x86, 0x61, 0xB8, 0x6E, 0x3B, 0x8E, 0xC3,
  0x30, 0xCC, 0x33, 0x9C, 0xFE, 0x1F, 0x00, 0xC1, 0xB0, 0xEC, 0x3B, 0x0C,
  0xC7, 0x39, 0x8E, 0xE3, 0xB0, 0x6C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x00, 0xC6, 0x3E, 0x31, 0xB3, 0x8D, 0x9C, 0xEC, 0xE6, 0x6F, 0x33, 0x6B,
  0x9B, 0x58, 0xF2, 0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0x80,
  0x1C, 0x71, 0xCE, 0x0C, 0xE0, 0xDC, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0xF0,
  0x0F, 0x01, 0xF8, 0x1B, 0x83, 0x98, 0x71, 0xC7, 0x1C, 0xC3, 0xE1, 0xB9,
  0xDC, 0xC6, 0xE3, 0x61, 0xE0, 0xF0, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03,
  0x00, 0x3F, 0xCF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18,
  0x0E, 0x07, 0x01, 0x80, 0xFF, 0x3F, 0xC0, 0x1C, 0xF3, 0x8C, 0x30, 0xC3,
  0x1C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x38, 0xC3, 0x8E, 0x00, 0xCC, 0xCC,
  0xCE, 0xE6, 0x66, 0x66, 0x77, 0x30, 0x1C, 0x70, 0xC7, 0x1C, 0x61, 0x86,
  0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x73, 0xCE, 0x00, 0x18, 0xE3, 0x9A,
  0x6B, 0x3C, 0xC0, 0xFF, 0xFC, 0xE6, 0x30, 0x1E, 0x3F, 0x73, 0x03, 0x3F,
  0x77, 0xE6, 0xE6, 0xFE, 0x76, 0x38, 0x38, 0x30, 0x30, 0x3E, 0x3F, 0x73,
  0x63, 0x63, 0x63, 0x63, 0xE7, 0xFE, 0xDC, 0x1E, 0x3F, 0x73, 0x63, 0x60,
  0x60, 0x66, 0x66, 0x7E, 0x3C, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x1D, 0x8F,
  0xE7, 0x31, 0x8C, 0x63, 0x38, 0xCE, 0x71, 0x9C, 0x7E, 0x0F, 0x80, 0x1E,
  0x3F, 0x73, 0x63, 0x7F, 0x7F, 0x60, 0x62, 0x7E, 0x3C, 0x1C, 0xF3, 0x1C,
  0xFB, 0xE6, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x00, 0x1D, 0x9F, 0xDC, 0xEC,
  0x66, 0x33, 0x1B, 0x8C, 0xCE, 0x7F, 0x1F, 0x01, 0x81, 0xCF, 0xC3, 0xC0,
  0x38, 0x38, 0x30, 0x30, 0x3E, 0x7F, 0x73, 0x63, 0x63, 0x63, 0x67, 0xE7,
  0xE6, 0xC6, 0x11, 0xCE, 0x03, 0x19, 0xCE, 0x63, 0x18, 0xCE, 0x70, 0x04,
  0x1C, 0x30, 0x00, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C,
  0x18, 0xF1, 0xC0, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x39, 0xB9, 0xF8, 0xD8,
  0x7C, 0x3E, 0x1B, 0x1D, 0xCE, 0x66, 0x30, 0x19, 0xCC, 0x63, 0x19, 0xCE,
  0x63, 0x18, 0xCE, 0x70, 0x3E, 0x71, 0xFF, 0xDC, 0xEE, 0xC6, 0x36, 0x33,
  0xB1, 0x9D, 0x9C, 0xDC, 0xC6, 0xE6, 0x36, 0x31, 0x80, 0x3E, 0x7F, 0x73,
  0x63, 0x63, 0x63, 0x67, 0xE7, 0xE6, 0xC6, 0x1E, 0x1F, 0x9C, 0xCC, 0x66,
  0x33, 0x19, 0x8C, 0xCE, 0x7E, 0x1E, 0x00, 0x1F, 0x0F, 0xCE, 0x66, 0x33,
  0x19, 0x8C, 0xC6, 0xE7, 0x7F, 0x37, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x1D,
  0x9F, 0xDC, 0xCC, 0x66, 0x33, 0x1B, 0x9C, 0xCE, 0x7E, 0x1F, 0x01, 0x80,
  0xC0, 0xE0, 0x70, 0x3C, 0xF7, 0x9C, 0x61, 0x86, 0x38, 0xE3, 0x00, 0x1E,
  0x3F, 0x73, 0x70, 0x3C, 0x1E, 0x06, 0xC6, 0x7E, 0x3C, 0x33, 0x9D, 0xFF,
  0xB1, 0x9C, 0xE6, 0x31, 0xC6, 0x00, 0x67, 0xE7, 0xE6, 0xC6, 0xC6, 0xC6,
  0xCE, 0xCE, 0xFC, 0xFC, 0xC6, 0xC6, 0xEE, 0xEC, 0x7C, 0x78, 0x78, 0x70,
  0x70, 0x70, 0xC4, 0x79, 0xDF, 0x3B, 0x6F, 0x6D, 0xF9, 0xEF, 0x3D, 0xE7,
  0x38, 0xE7, 0x1C, 0xE0, 0x39, 0x86, 0xE1, 0xB0, 0x78, 0x0E, 0x07, 0x81,
  0xE0, 0xD8, 0x77, 0x18, 0xC0, 0x31, 0x8E, 0x63, 0xB8, 0xEC, 0x3F, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x00, 0x3F,
  0x7F, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xFE, 0xFE, 0x04, 0x31, 0x86,
  0x18, 0xE3, 0x0C, 0x63, 0x86, 0x1C, 0x61, 0x86, 0x18, 0x30, 0xC0, 0x11,
  0x33, 0x33, 0x22, 0x26, 0x66, 0x64, 0x44, 0xC0, 0x10, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x0C, 0x71, 0x8C, 0x30, 0xC3, 0x1C, 0xE1, 0x00, 0x71, 0xFC,
  0xB7, 0xD9, 0xC0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 6, 1, -14 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 8, 18, 9, 1, -16 },
  { 50, 9, 14, 12, 2, -14 },
  { 66, 10, 14, 11, 0, -14 },
  { 84, 3, 5, 3, 1, -14 },
  { 86, 6, 19, 6, 1, -15 },
  { 101, 6, 19, 6, -1, -15 },
  { 116, 8, 8, 8, 1, -14 },
  { 124, 8, 10, 9, 1, -11 },
  { 134, 4, 5, 4, -1, -2 },
  { 137, 4, 2, 6, 1, -7 },
  { 138, 3, 3, 5, 0, -3 },
  { 140, 8, 15, 6, -1, -14 },
  { 155, 8, 14, 9, 1, -14 },
  { 169, 6, 14, 9, 2, -14 },
  { 180, 9, 14, 9, 0, -14 },
  { 196, 9, 14, 9, 0, -14 },
  { 212, 9, 14, 9, 0, -14 },
  { 228, 8, 14, 9, 1, -14 },
  { 242, 7, 14, 9, 1, -14 },
  { 255, 9, 14, 9, 1, -14 },
  { 271, 8, 14, 9, 1, -14 },
  { 285, 8, 14, 9, 1, -14 },
  { 299, 5, 11, 5, 0, -11 },
  { 306, 5, 14, 5, -1, -11 },
  { 315, 8, 9, 8, 0, -10 },
  { 324, 8, 6, 9, 1, -9 },
  { 330, 8, 9, 8, 0, -10 },
  { 339, 7, 14, 8, 1, -14 },
  { 352, 13, 17, 14, 0, -13 },
  { 380, 11, 14, 11, -1, -14 },
  { 400, 10, 14, 10, 0, -14 },
  { 418, 10, 14, 11, 1, -14 },
  { 436, 10, 14, 10, 0, -14 },
  { 454, 10, 14, 9, 0, -14 },
  { 472, 10, 14, 9, 0, -14 },
  { 490, 10, 14, 11, 1, -14 },
  { 508, 12, 14, 11, 0, -14 },
  { 529, 5, 14, 5, 0, -14 },
  { 538, 9, 14, 9, 0, -14 },
  { 554, 12, 14, 10, 0, -14 },
  { 575, 8, 14, 9, 0, -14 },
  { 589, 14, 14, 14, 0, -14 },
  { 614, 12, 14, 11, 0, -14 },
  { 635, 10, 14, 11, 1, -14 },
  { 653, 10, 14, 10, 0, -14 },
  { 671, 10, 16, 11, 1, -14 },
  { 691, 10, 14, 10, 0, -14 },
  { 709, 10, 14, 10, 0, -14 },
  { 727, 10, 14, 10, 1, -14 },
  { 745, 10, 14, 10, 1, -14 },
  { 763, 10, 14, 11, 2, -14 },
  { 781, 13, 14, 14, 2, -14 },
  { 804, 12, 14, 10, -1, -14 },
  { 825, 9, 14, 10, 2, -14 },
  { 841, 10, 14, 10, 0, -14 },
  { 859, 6, 19, 5, 0, -16 },
  { 874, 4, 15, 7, 2, -14 },
  { 882, 6, 19, 5, -1, -16 },
  { 897, 6, 7, 7, 1, -14 },
  { 903, 7, 2, 7, -1, 0 },
  { 905, 4, 3, 6, 2, -14 },
  { 907, 8, 10, 9, 0, -10 },
  { 917, 8, 14, 9, 0, -14 },
  { 931, 8, 10, 8, 0, -10 },
  { 941, 10, 14, 9, 0, -14 },
  { 959, 8, 10, 9, 0, -10 },
  { 969, 6, 14, 6, 1, -14 },
  { 980, 9, 14, 9, 0, -10 },
  { 996, 8, 14, 9, 0, -14 },
  { 1010, 5, 14, 5, 0, -14 },
  { 1019, 7, 18, 4, -2, -14 },
  { 1035, 9, 14, 9, 0, -14 },
  { 1051, 5, 14, 5, 0, -14 },
  { 1060, 13, 10, 14, 0, -10 },
  { 1077, 8, 10, 9, 0, -10 },
  { 1087, 9, 10, 9, 0, -10 },
  { 1099, 9, 14, 9, -1, -10 },
  { 1115, 9, 14, 9, 0, -10 },
  { 1131, 6, 10, 6, 0, -10 },
  { 1139, 8, 10, 8, 0, -10 },
  { 1149, 5, 13, 6, 1, -13 },
  { 1158, 8, 10, 9, 1, -10 },
  { 1168, 8, 10, 8, 1, -10 },
  { 1178, 11, 10, 12, 1, -10 },
  { 1192, 10, 10, 8, -1, -10 },
  { 1205, 10, 14, 8, -1, -10 },
  { 1223, 8, 10, 8, 0, -10 },
  { 1233, 6, 18, 6, 0, -15 },
  { 1247, 4, 17, 5, 0, -14 },
  { 1256, 6, 18, 6, -1, -15 },
  { 1270, 9, 4, 10, 1, -8 },
};

const GFXfont RobotoCondensed_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC19PT7B_H_
