#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC17PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0x63, 0x11, 0x8C, 0x60, 0x11, 0x80, 0x5A, 0xF5, 0xA0,
  0x05, 0x06, 0x82, 0xC1, 0x43, 0xF8, 0xB0, 0x58, 0xFE, 0x24, 0x16, 0x1A,
  0x09, 0x00, 0x08, 0x10, 0xF3, 0xF6, 0x6C, 0xD8, 0x38, 0x1C, 0x1B, 0x36,
  0x6F, 0xCF, 0x08, 0x10, 0x30, 0x58, 0x4B, 0x5A, 0x5C, 0x7C, 0x1F, 0x1D,
  0x2D, 0x69, 0x4D, 0x06, 0x1E, 0x0F, 0x0C, 0x86, 0xC3, 0xE0, 0xC0, 0xE6,
  0xDE, 0xEF, 0x73, 0x1F, 0xC7, 0x60, 0x5F, 0x08, 0xCC, 0xC6, 0x23, 0x18,
  0xC6, 0x31, 0x0C, 0x63, 0x08, 0x40, 0x10, 0x41, 0x82, 0x08, 0x30, 0xC2,
  0x18, 0x61, 0x86, 0x30, 0xC6, 0x10, 0x80, 0x18, 0x23, 0x5B, 0xE3, 0x09,
  0x12, 0x00, 0x18, 0x30, 0xC7, 0xFF, 0xC6, 0x0C, 0x18, 0x60, 0x2D, 0xAC,
  0xFF, 0xEC, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x3C, 0xFD, 0x9E, 0x3C, 0x78, 0xF1, 0xE6, 0xCD, 0x9B,
  0xE3, 0x80, 0x1B, 0xFC, 0x63, 0x18, 0xCE, 0x63, 0x18, 0xC0, 0x1E, 0x3F,
  0x33, 0x63, 0x07, 0x06, 0x0C, 0x18, 0x38, 0x70, 0xFE, 0xFE, 0x1E, 0x3F,
  0x73, 0x03, 0x07, 0x1E, 0x1C, 0x06, 0x06, 0xC6, 0x7C, 0x38, 0x07, 0x07,
  0x0E, 0x1E, 0x16, 0x36, 0x66, 0xFF, 0xFE, 0x0C, 0x0C, 0x0C, 0x3E, 0xFD,
  0x83, 0x07, 0x9F, 0x83, 0x06, 0xCD, 0x9B, 0xF3, 0x80, 0x0C, 0x79, 0xC3,
  0x0D, 0xDF, 0xB3, 0x67, 0xCD, 0x9B, 0xF3, 0xC0, 0x7F, 0xFE, 0x06, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x1E, 0x3F, 0x33, 0x33,
  0x33, 0x3E, 0x3C, 0x66, 0x66, 0x66, 0x7E, 0x38, 0x3C, 0xF9, 0x9E, 0x3C,
  0x79, 0xDF, 0x3E, 0x0C, 0x31, 0xC3, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x60,
  0x38, 0xC0, 0x00, 0x00, 0x06, 0x23, 0x19, 0x80, 0x02, 0x1C, 0xF3, 0x8E,
  0x0F, 0x07, 0x02, 0x7F, 0xF8, 0x07, 0xEF, 0xC0, 0x20, 0xE0, 0xF0, 0x70,
  0xEF, 0x98, 0x40, 0x39, 0xFC, 0xC3, 0x1C, 0xE3, 0x18, 0x00, 0x06, 0x18,
  0x07, 0xC0, 0xC6, 0x18, 0x23, 0x01, 0x23, 0x96, 0x69, 0x4D, 0x94, 0x99,
  0xD9, 0x3D, 0x92, 0xDB, 0x6C, 0xDC, 0x40, 0x04, 0x00, 0x72, 0x01, 0xE0,
  0x03, 0x01, 0xC0, 0x70, 0x36, 0x0D, 0x86, 0x61, 0x98, 0xFE, 0x3F, 0x8C,
  0x66, 0x19, 0x87, 0x3F, 0x1F, 0xCC, 0x66, 0x37, 0x3B, 0xF9, 0xF8, 0xC6,
  0x63, 0x31, 0xBF, 0x9F, 0x80, 0x1E, 0x3F, 0x63, 0x63, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC6, 0xC6, 0xFE, 0x78, 0x3E, 0x1F, 0x8C, 0xE6, 0x37, 0x1B, 0x0D,
  0x8E, 0xC6, 0x63, 0x33, 0xBF, 0x9F, 0x80, 0x3F, 0x9F, 0xCC, 0x06, 0x07,
  0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x30, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0x8C,
  0x06, 0x07, 0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x00, 0x1E,
  0x3F, 0x63, 0x63, 0xC0, 0xCF, 0xCF, 0xC3, 0xC7, 0xC6, 0xFE, 0x7C, 0x30,
  0xCC, 0x33, 0x0C, 0xC3, 0x71, 0xDF, 0xE7, 0xF9, 0x86, 0x61, 0x98, 0x6E,
  0x3B, 0x0C, 0x31, 0x8C, 0x63, 0x39, 0x8C, 0x63, 0x39, 0x80, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0xC6, 0xCE, 0x7C, 0x78, 0x31, 0xCC,
  0xE3, 0x30, 0xD8, 0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0x66, 0x19, 0x8E, 0x73,
  0x0C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xFF, 0xF0,
  0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xE6, 0x8F, 0x36, 0xD9, 0xB7, 0xCD,
  0xAC, 0x6F, 0x63, 0x73, 0x3B, 0x99, 0x88, 0xC0, 0x38, 0xCE, 0x33, 0x8C,
  0xE3, 0x7D, 0xDB, 0x66, 0x59, 0x96, 0x67, 0x99, 0xEE, 0x33, 0x0C, 0x1E,
  0x1F, 0x98, 0xCC, 0x6C, 0x3E, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x3F, 0x8F,
  0x00, 0x3F, 0x1F, 0xCC, 0x66, 0x37, 0x1B, 0x1D, 0xFC, 0xFC, 0x60, 0x30,
  0x38, 0x18, 0x00, 0x1E, 0x1F, 0x98, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0x86,
  0xC3, 0x63, 0x3F, 0x8F, 0x80, 0xE0, 0x20, 0x3F, 0x1F, 0xCC, 0x66, 0x37,
  0x3B, 0xF9, 0xF8, 0xCC, 0x66, 0x33, 0x39, 0xD8, 0x60, 0x1E, 0x1F, 0x8C,
  0xE6, 0x33, 0x01, 0xE0, 0x38, 0x0E, 0xE3, 0x33, 0x9F, 0x87, 0x80, 0x7F,
  0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x63, 0xB1, 0x98, 0xCC, 0x6E, 0x36, 0x1B, 0x1D, 0x8C, 0xC6, 0x63,
  0x3F, 0x0F, 0x00, 0xE1, 0xB1, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB8, 0xD8,
  0x6C, 0x1C, 0x0E, 0x06, 0x00, 0xCC, 0x79, 0x8F, 0x33, 0x6E, 0x6D, 0xCD,
  0xEB, 0x3D, 0x67, 0xAC, 0xE7, 0x1C, 0xE3, 0x1C, 0x63, 0x00, 0x31, 0xCC,
  0x63, 0xB0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0xF8, 0x36, 0x1D, 0x8E, 0x73,
  0x0C, 0x63, 0xB1, 0x99, 0xCC, 0xC2, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x00, 0x3F, 0x9F, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70,
  0x30, 0x30, 0x3F, 0xDF, 0xC0, 0x39, 0xCC, 0x63, 0x19, 0x8C, 0x63, 0x18,
  0xCE, 0x63, 0x1C, 0xE0, 0xE6, 0x66, 0x66, 0x67, 0x33, 0x33, 0x30, 0x1C,
  0xE1, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC6, 0x38, 0xE0,
  0x31, 0x9E, 0xBD, 0xEC, 0xFD, 0xF8, 0xCD, 0x80, 0x1C, 0x7D, 0x98, 0x33,
  0xEC, 0xF3, 0x7E, 0x7C, 0x30, 0x30, 0x30, 0x30, 0x7E, 0x7E, 0x67, 0x63,
  0x66, 0x66, 0xE6, 0xFE, 0xDC, 0x1C, 0x7D, 0x9B, 0x06, 0x1C, 0x19, 0xBE,
  0x38, 0x03, 0x81, 0x80, 0xC0, 0x63, 0xB3, 0xF9, 0x9C, 0xCC, 0xE6, 0x73,
  0x39, 0x8F, 0xC7, 0x40, 0x1C, 0x7D, 0x9B, 0xF7, 0xFC, 0x18, 0x3F, 0x3C,
  0x19, 0xDC, 0xCF, 0xF9, 0x8C, 0xC6, 0x31, 0x8C, 0x00, 0x3B, 0x7F, 0x63,
  0x66, 0x66, 0xE6, 0xE6, 0x7E, 0x7E, 0x0C, 0xFC, 0x78, 0x30, 0x60, 0xC1,
  0x87, 0xEF, 0xD9, 0xB3, 0x66, 0xCF, 0x1E, 0x3C, 0xC0, 0x33, 0x03, 0x76,
  0x66, 0x66, 0xCC, 0x0C, 0x30, 0x03, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x0C,
  0x33, 0xCE, 0x00, 0x30, 0x30, 0x30, 0x30, 0x77, 0x6E, 0x6C, 0x78, 0x78,
  0x7C, 0xEC, 0xCC, 0xCE, 0x33, 0x33, 0x36, 0x66, 0x66, 0x6C, 0xC0, 0x2E,
  0xE7, 0xFE, 0x66, 0x76, 0x66, 0x66, 0x66, 0x66, 0xE6, 0x6C, 0xE6, 0xCC,
  0x60, 0x6E, 0xFD, 0x9B, 0x36, 0x6C, 0xF1, 0xE3, 0xCC, 0x1C, 0x3E, 0x66,
  0x63, 0x67, 0xE6, 0x66, 0x7C, 0x38, 0x37, 0x1F, 0x8C, 0xE6, 0x73, 0x31,
  0x99, 0xCC, 0xFE, 0x6E, 0x30, 0x18, 0x0C, 0x00, 0x3B, 0x7F, 0x67, 0x66,
  0x66, 0xE6, 0xE6, 0x7E, 0x7C, 0x0C, 0x0C, 0x0C, 0x6D, 0xF7, 0x18, 0x61,
  0x8E, 0x30, 0xC0, 0x3C, 0xFD, 0x9B, 0x83, 0xC1, 0xB3, 0x7E, 0x78, 0x66,
  0xFF, 0x6C, 0xCC, 0xCE, 0xE0, 0x73, 0x63, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x7E, 0x7C, 0xCD, 0x9B, 0x36, 0xCD, 0x8E, 0x1C, 0x38, 0x60, 0xCC, 0xF3,
  0x6D, 0xDB, 0x76, 0xFF, 0x3F, 0xCE, 0x63, 0x98, 0xC6, 0x00, 0x33, 0x0D,
  0x87, 0x83, 0xC1, 0xC0, 0xE0, 0xD8, 0xEC, 0x66, 0x00, 0x33, 0x99, 0x8D,
  0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x00, 0x7E,
  0xFC, 0x30, 0xE3, 0x86, 0x18, 0x7E, 0xFC, 0x08, 0x61, 0x8C, 0x30, 0xC3,
  0x18, 0xC1, 0x86, 0x18, 0x61, 0x86, 0x08, 0x33, 0x22, 0x22, 0x66, 0x64,
  0x44, 0x4C, 0x10, 0x61, 0x86, 0x18, 0x61, 0x87, 0x1C, 0xC3, 0x0C, 0x31,
  0x86, 0x10, 0x63, 0xF2, 0xDE, 0x8C,
};

const GFXglyph RobotoCondensed_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 5, 1, -13 },
  { 12, 9, 12, 9, 0, -12 },
  { 26, 7, 16, 8, 1, -14 },
  { 40, 8, 12, 11, 1, -12 },
  { 52, 9, 12, 9, 0, -12 },
  { 66, 2, 4, 3, 1, -13 },
  { 67, 5, 17, 5, 1, -13 },
  { 78, 6, 17, 5, -1, -13 },
  { 91, 7, 7, 7, 1, -12 },
  { 98, 7, 9, 8, 1, -10 },
  { 106, 3, 5, 4, -1, -2 },
  { 108, 4, 2, 6, 1, -6 },
  { 109, 3, 2, 5, 0, -2 },
  { 110, 8, 13, 6, -1, -12 },
  { 123, 7, 12, 8, 1, -12 },
  { 134, 5, 12, 8, 2, -12 },
  { 142, 8, 12, 8, 0, -12 },
  { 154, 8, 12, 8, 0, -12 },
  { 166, 8, 12, 8, 0, -12 },
  { 178, 7, 12, 8, 1, -12 },
  { 189, 7, 12, 8, 1, -12 },
  { 200, 8, 12, 8, 1, -12 },
  { 212, 8, 12, 8, 0, -12 },
  { 224, 7, 12, 8, 1, -12 },
  { 235, 4, 9, 4, 0, -9 },
  { 240, 5, 12, 4, -1, -9 },
  { 248, 7, 8, 7, 0, -9 },
  { 255, 7, 5, 8, 1, -8 },
  { 260, 7, 8, 8, 0, -9 },
  { 267, 6, 12, 7, 1, -12 },
  { 276, 12, 16, 13, 0, -12 },
  { 300, 10, 12, 10, -1, -12 },
  { 315, 9, 12, 9, 0, -12 },
  { 329, 8, 12, 9, 1, -12 },
  { 341, 9, 12, 9, 0, -12 },
  { 355, 9, 12, 8, 0, -12 },
  { 369, 9, 12, 8, 0, -12 },
  { 383, 8, 12, 10, 1, -12 },
  { 395, 10, 12, 10, 0, -12 },
  { 410, 5, 12, 4, 0, -12 },
  { 418, 8, 12, 8, 0, -12 },
  { 430, 10, 12, 9, 0, -12 },
  { 445, 7, 12, 8, 0, -12 },
  { 456, 13, 12, 13, 0, -12 },
  { 476, 10, 12, 10, 0, -12 },
  { 491, 9, 12, 10, 1, -12 },
  { 505, 9, 12, 9, 0, -12 },
  { 519, 9, 14, 10, 1, -12 },
  { 535, 9, 12, 9, 0, -12 },
  { 549, 9, 12, 9, 0, -12 },
  { 563, 9, 12, 9, 1, -12 },
  { 577, 9, 12, 9, 1, -12 },
  { 591, 9, 12, 9, 1, -12 },
  { 605, 11, 12, 12, 2, -12 },
  { 622, 10, 12, 9, 0, -12 },
  { 637, 9, 12, 9, 1, -12 },
  { 651, 9, 12, 9, 0, -12 },
  { 665, 5, 17, 4, 0, -14 },
  { 676, 4, 13, 6, 1, -12 },
  { 683, 6, 17, 4, -1, -14 },
  { 696, 5, 6, 6, 1, -12 },
  { 700, 7, 2, 7, -1, 0 },
  { 702, 3, 3, 5, 2, -13 },
  { 704, 7, 9, 8, 0, -9 },
  { 712, 8, 13, 8, 0, -13 },
  { 725, 7, 9, 8, 0, -9 },
  { 733, 9, 13, 8, 0, -13 },
  { 748, 7, 9, 8, 0, -9 },
  { 756, 5, 13, 5, 1, -13 },
  { 765, 8, 12, 8, 0, -9 },
  { 777, 7, 13, 8, 0, -13 },
  { 789, 4, 12, 4, 0, -12 },
  { 795, 6, 15, 4, -2, -12 },
  { 807, 8, 13, 8, 0, -13 },
  { 820, 4, 13, 4, 0, -13 },
  { 827, 12, 9, 12, 0, -9 },
  { 841, 7, 9, 8, 0, -9 },
  { 849, 8, 9, 8, 0, -9 },
  { 858, 9, 12, 8, -1, -9 },
  { 872, 8, 12, 8, 0, -9 },
  { 884, 6, 9, 5, 0, -9 },
  { 891, 7, 9, 8, 0, -9 },
  { 899, 4, 11, 5, 1, -11 },
  { 905, 8, 9, 8, 0, -9 },
  { 914, 7, 9, 7, 1, -9 },
  { 922, 10, 9, 11, 1, -9 },
  { 934, 9, 9, 7, -1, -9 },
  { 945, 9, 12, 7, -1, -9 },
  { 959, 7, 9, 7, 0, -9 },
  { 967, 6, 16, 5, 0, -13 },
  { 979, 4, 14, 4, 0, -12 },
  { 986, 6, 16, 5, -1, -13 },
  { 998, 8, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC17PT7B_H_
