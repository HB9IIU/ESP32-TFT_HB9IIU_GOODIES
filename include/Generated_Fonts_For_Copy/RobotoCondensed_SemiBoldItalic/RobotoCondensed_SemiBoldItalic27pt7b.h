#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC27PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0x70, 0x00,
  0x38, 0xE3, 0x8E, 0x00, 0x66, 0xCD, 0x9F, 0x7C, 0xD9, 0xB3, 0x00, 0x03,
  0x38, 0x19, 0x80, 0xCC, 0x0E, 0xE0, 0x66, 0x03, 0x30, 0xFF, 0xE7, 0xFF,
  0x0C, 0xC0, 0xEE, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x80, 0xCC, 0x0E,
  0xE0, 0x66, 0x03, 0x30, 0x39, 0x80, 0x01, 0x80, 0x18, 0x01, 0x80, 0x7C,
  0x1F, 0xE1, 0xFE, 0x3C, 0xF3, 0x8F, 0x38, 0xF3, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0xE1, 0xCE, 0x1C, 0xF3, 0xCF, 0xFC,
  0x7F, 0x83, 0xE0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x3C, 0x03, 0xF0, 0x19,
  0x84, 0xCC, 0x6E, 0x66, 0x73, 0x71, 0x9B, 0x0F, 0xB0, 0x3B, 0x80, 0x18,
  0x01, 0xB8, 0x1B, 0xE1, 0xF9, 0x8D, 0x8C, 0xCC, 0x6E, 0x63, 0x63, 0x38,
  0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0x9C, 0x1C, 0x70,
  0x71, 0xC1, 0xEE, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x73, 0xF9, 0x9E, 0xEE,
  0x73, 0xF9, 0xC7, 0xE7, 0x1F, 0x1C, 0x38, 0x7F, 0xF0, 0xFF, 0xC1, 0xF7,
  0x80, 0x6F, 0xFF, 0xB0, 0x01, 0x01, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x04, 0x00, 0x08,
  0x0C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x70, 0xE0,
  0xC0, 0x80, 0x03, 0x00, 0x30, 0x07, 0x04, 0x62, 0x76, 0xE7, 0xFF, 0x0F,
  0x81, 0xF0, 0x3B, 0x03, 0x38, 0x71, 0x82, 0x10, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x71, 0x8E, 0x39, 0xC7, 0x18, 0x7F, 0xFB,
  0xF0, 0xEE, 0xEE, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x00, 0x07,
  0x81, 0xFE, 0x1F, 0xE3, 0x8E, 0x38, 0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70,
  0xE7, 0x0E, 0xF0, 0xEF, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCF, 0x3C, 0x7F,
  0x87, 0xF0, 0x3E, 0x00, 0x03, 0x0F, 0x7E, 0xFE, 0xEE, 0x0E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x38, 0xE3, 0xC7, 0x9C, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x78,
  0xE3, 0xC7, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x01, 0xC0, 0x0E, 0x78, 0x71, 0xC3, 0x8E, 0x3C, 0x7F, 0xC1, 0xFC, 0x07,
  0xC0, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0x81, 0xDC, 0x1C, 0xE0, 0xE7, 0x0E, 0x78, 0xE3, 0xC7, 0xFF, 0x7F, 0xFB,
  0xFF, 0xC0, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF3, 0xC0, 0x38, 0x03, 0x80, 0x3F, 0x87, 0xFC, 0x7F, 0xC1, 0x1E, 0x01,
  0xE0, 0x0E, 0x01, 0xEE, 0x1E, 0xE1, 0xCF, 0x3C, 0x7F, 0x87, 0xF8, 0x1E,
  0x00, 0x01, 0xC0, 0xF8, 0x3F, 0x0F, 0x03, 0xC0, 0x70, 0x1F, 0xE3, 0xFE,
  0x7F, 0xCE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC3, 0xFC, 0x73, 0x9E, 0x7F,
  0x87, 0xF0, 0x78, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x07,
  0x81, 0xFE, 0x1F, 0xE3, 0xCE, 0x38, 0xF3, 0x8F, 0x38, 0xE3, 0x8E, 0x1F,
  0xC1, 0xF8, 0x7F, 0x87, 0x1C, 0xF1, 0xCE, 0x1C, 0xE1, 0xCF, 0x3C, 0xFF,
  0x87, 0xF8, 0x3E, 0x00, 0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xFC, 0xFF, 0xFD, 0xFF, 0x3F, 0x80, 0xE0, 0x70, 0x7C,
  0x7E, 0x3F, 0x0F, 0x00, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x01, 0xCE,
  0x73, 0x80, 0x0C, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x87, 0x0E, 0x1C, 0x70, 0xE3, 0x82, 0x00, 0x00, 0x40, 0x70, 0x7C,
  0x7F, 0x7F, 0x3F, 0x0E, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF0, 0x1C, 0x01,
  0x00, 0x3F, 0xEF, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF7, 0xFE,
  0xFF, 0xC0, 0x20, 0x1E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0x7C, 0x7F,
  0xFE, 0x3E, 0x0E, 0x02, 0x00, 0x1F, 0x1F, 0xE7, 0xFB, 0xCF, 0xE3, 0xC0,
  0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x78, 0x70,
  0x38, 0x06, 0x1C, 0x01, 0x8E, 0x00, 0x33, 0x0F, 0x0D, 0xC7, 0xF3, 0x63,
  0x9C, 0xD8, 0xC6, 0x3E, 0x71, 0x8F, 0x18, 0xE3, 0xC6, 0x38, 0xF3, 0x8C,
  0x6C, 0xE3, 0x1B, 0x39, 0xC6, 0xCE, 0xF3, 0x31, 0xEF, 0x8C, 0x79, 0xC3,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x86, 0x00, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xEE, 0x03, 0xDC, 0x07, 0x38, 0x1E, 0x70, 0x38, 0xF0, 0x70,
  0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E, 0x78, 0x1C, 0xE0, 0x3F,
  0xC0, 0x78, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x0F, 0x1C, 0x1C, 0x70,
  0x73, 0xC3, 0xCF, 0x0E, 0x3F, 0xF8, 0xFF, 0x83, 0xFF, 0x0E, 0x1E, 0x78,
  0x39, 0xE1, 0xE7, 0x07, 0x9C, 0x3C, 0x7F, 0xF1, 0xFF, 0x8F, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x3D, 0xE0, 0xF7, 0x83,
  0xDC, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7B, 0xC1,
  0xCF, 0x07, 0x1C, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x07,
  0x3C, 0x1C, 0xE0, 0xF3, 0x83, 0xCE, 0x0F, 0x78, 0x39, 0xE1, 0xE7, 0x07,
  0x9C, 0x3C, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38,
  0x1D, 0xE0, 0x77, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xEF, 0x1F, 0xBC,
  0x7E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x9E, 0x3C, 0x7F, 0xF0, 0xFF, 0x81,
  0xF8, 0x00, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x3C,
  0x70, 0x38, 0xF0, 0x38, 0x0E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C,
  0x78, 0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC0, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x78, 0xF3, 0xC7, 0x9E, 0x78, 0x7F,
  0xC3, 0xFC, 0x07, 0x80, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1C, 0x78,
  0x1C, 0x78, 0x1C, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7D, 0xE0, 0x79, 0xE0, 0x70, 0xE0, 0x70, 0xF0,
  0x70, 0xF0, 0x70, 0x78, 0xF0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE1, 0xF8, 0x7E,
  0x3F, 0x87, 0xE3, 0xB8, 0xEE, 0x3B, 0x8F, 0xE3, 0xB9, 0xDE, 0x3B, 0x9D,
  0xC3, 0xBB, 0x9C, 0x79, 0xB9, 0xC7, 0x9B, 0x3C, 0x71, 0xF3, 0xC7, 0x1E,
  0x38, 0x71, 0xE3, 0x87, 0x1E, 0x38, 0xF1, 0xC7, 0x80, 0x1E, 0x07, 0x1E,
  0x07, 0x1F, 0x07, 0x1F, 0x0F, 0x1F, 0x0F, 0x1F, 0x8E, 0x3F, 0x8E, 0x3F,
  0x8E, 0x3D, 0x9E, 0x39, 0xDE, 0x39, 0xDE, 0x38, 0xDC, 0x78, 0xDC, 0x78,
  0xFC, 0x70, 0xFC, 0x70, 0x7C, 0x70, 0x7C, 0x70, 0x78, 0xF0, 0x38, 0x03,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x3D, 0xE0, 0x77, 0x81, 0xDC,
  0x07, 0x70, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC1, 0xEF,
  0x07, 0x9C, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E,
  0x3C, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x3D, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70,
  0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0x1C,
  0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x00,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x0F, 0x1C, 0x1C, 0x70, 0x73, 0xC1,
  0xCF, 0x0F, 0x3C, 0x78, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x79, 0xE1, 0xE3,
  0x87, 0x8E, 0x1C, 0x3C, 0x70, 0xF1, 0xC1, 0xCF, 0x07, 0x80, 0x07, 0xC0,
  0xFF, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x0E, 0x70, 0x7B, 0x83, 0x9E, 0x3C,
  0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x3C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xF7, 0x83,
  0x9E, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0xBC, 0x1C, 0xF0, 0x73, 0xC1,
  0xCF, 0x0F, 0x3C, 0x38, 0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x00, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x8E, 0x1E, 0x1C, 0x3C, 0x38,
  0x70, 0x79, 0xE0, 0xF3, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xF0, 0xE1,
  0xFE, 0x1C, 0x3B, 0xC7, 0x87, 0x38, 0xF1, 0xE7, 0x1E, 0x38, 0xE7, 0xC7,
  0x1C, 0xF9, 0xE3, 0x9B, 0x38, 0x77, 0x67, 0x0E, 0xED, 0xE1, 0xD9, 0xB8,
  0x3F, 0x37, 0x07, 0xE6, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x87, 0x87,
  0x83, 0xC7, 0x80, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7B, 0x80, 0x79, 0xC0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x00, 0xF0, 0x3D, 0xC1, 0xE7, 0x07, 0x1E, 0x3C, 0x78, 0xE0, 0xE7, 0x83,
  0x9C, 0x0E, 0xE0, 0x3B, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0x0F, 0x87, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0x81, 0xF0, 0xF8, 0x78, 0x00, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x78,
  0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x07, 0x87, 0xC3,
  0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0xF8,
  0x7C, 0x3C, 0x00, 0x06, 0x07, 0x03, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE6,
  0x63, 0x71, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x00, 0xF3, 0x9C, 0x70, 0x07,
  0x83, 0xF8, 0xFF, 0x9C, 0x70, 0x0E, 0x01, 0xC3, 0xF9, 0xFF, 0x79, 0xEE,
  0x3F, 0xC7, 0x78, 0xE7, 0xFC, 0xFF, 0x8F, 0x70, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xF3, 0xCF, 0x38,
  0x73, 0x87, 0x78, 0x77, 0x87, 0x70, 0xF7, 0x0F, 0x70, 0xE7, 0x1E, 0xFF,
  0xEE, 0xFC, 0xE7, 0x80, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0xEF, 0x1F, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x8F, 0x71, 0xCF, 0xF8, 0xFE, 0x0F,
  0x80, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x7B,
  0xC7, 0xFC, 0x7F, 0xE3, 0x8F, 0x3C, 0x39, 0xC3, 0xCE, 0x1E, 0x70, 0xE3,
  0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x1E, 0x3F, 0xF0, 0xFF, 0x07, 0xB8, 0x00,
  0x0F, 0x07, 0xF8, 0xFF, 0x38, 0xE7, 0x0F, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF,
  0xDC, 0x03, 0x80, 0x78, 0xCF, 0xF8, 0xFF, 0x0F, 0x80, 0x07, 0x87, 0xC7,
  0xE3, 0xC1, 0xC1, 0xE1, 0xFD, 0xFE, 0xFE, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0x0F, 0x38, 0xFF,
  0xCF, 0xFC, 0x71, 0xE7, 0x87, 0x38, 0x39, 0xC3, 0xCE, 0x1E, 0x70, 0xE3,
  0x87, 0x1C, 0x38, 0xE3, 0xC7, 0xFE, 0x1F, 0xF0, 0x77, 0x00, 0x38, 0x43,
  0xC7, 0xFC, 0x3F, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0xF3, 0x8F,
  0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0x1E, 0xF1, 0xEF, 0x1C,
  0xE1, 0xC0, 0x0C, 0x3C, 0x78, 0x60, 0x00, 0x07, 0x1E, 0x3C, 0x70, 0xE1,
  0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x00, 0x01, 0x80, 0xF0,
  0x3C, 0x06, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC3, 0xF0, 0xF8, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF1, 0xE7, 0x9E, 0x39, 0xE1, 0xDE, 0x0E, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0x70, 0x73, 0x83, 0x9E, 0x3C,
  0x71, 0xE3, 0x8E, 0x1E, 0x00, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E,
  0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x00,
  0x3D, 0xC7, 0x8F, 0xFB, 0xF3, 0xFF, 0xFC, 0xE3, 0xC7, 0x38, 0xF1, 0xCE,
  0x3C, 0x77, 0x8E, 0x1D, 0xE3, 0x87, 0x70, 0xE3, 0xDC, 0x38, 0xF7, 0x1E,
  0x39, 0xC7, 0x8E, 0xF1, 0xC3, 0xBC, 0x70, 0xEE, 0x1C, 0x78, 0x39, 0xC3,
  0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0xF3, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xE7,
  0x0E, 0x71, 0xE7, 0x1E, 0xF1, 0xEF, 0x1C, 0xE1, 0xC0, 0x0F, 0x87, 0xF9,
  0xFF, 0x38, 0xFF, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x87,
  0x71, 0xEF, 0xF8, 0xFE, 0x0F, 0x80, 0x1D, 0xE0, 0xFF, 0x87, 0xFE, 0x3C,
  0xF1, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x87, 0x38, 0x79, 0xC3, 0xCE, 0x1C,
  0x71, 0xE7, 0xFF, 0x3F, 0xF1, 0xCF, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x00, 0x1E, 0x73, 0xFE, 0x7F, 0xE7, 0x1E, 0xF0, 0xEE, 0x1E,
  0xE1, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0xC7, 0xF8,
  0x7B, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x3F, 0x9F, 0xCF,
  0xE7, 0xD3, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x83, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0x73, 0x80, 0x70, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7B, 0x87, 0x78, 0xE7, 0xFC, 0xFF, 0x07, 0x80, 0x1C,
  0x78, 0xF7, 0xFF, 0xFF, 0xCE, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x3C,
  0x7C, 0x78, 0x70, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0x1E,
  0xF1, 0xEF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0xCF, 0xF8,
  0x7B, 0x80, 0xF0, 0xEE, 0x3D, 0xC7, 0x39, 0xE7, 0x38, 0xE7, 0x1D, 0xE3,
  0xB8, 0x77, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0xE3,
  0x8F, 0xC7, 0x1F, 0x9E, 0x77, 0x3C, 0xEE, 0xF9, 0xDD, 0xF7, 0x3B, 0x6E,
  0x7E, 0xDC, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1C,
  0x38, 0x38, 0x70, 0x00, 0x1C, 0x78, 0xE3, 0x87, 0xBC, 0x1D, 0xC0, 0xFE,
  0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0x70, 0x7B, 0x83,
  0x9C, 0x3C, 0xF3, 0xC3, 0x80, 0x3C, 0x38, 0xE3, 0xC7, 0x1C, 0x39, 0xE1,
  0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF,
  0x80, 0x03, 0x07, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0xF0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x30, 0x10, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x8C,
  0x30, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x00, 0x08, 0x0C, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x1E,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0x3C,
  0x3B, 0xF1, 0xDF, 0xCD, 0xCF, 0xEE, 0x3E, 0x00, 0xE0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 19, 7, 1, -19 },
  { 16, 7, 7, 8, 2, -20 },
  { 23, 13, 19, 14, 1, -19 },
  { 54, 12, 25, 13, 1, -22 },
  { 92, 13, 19, 17, 2, -19 },
  { 123, 14, 19, 15, 0, -19 },
  { 157, 3, 7, 4, 2, -20 },
  { 160, 9, 27, 8, 1, -21 },
  { 191, 8, 27, 8, -1, -21 },
  { 218, 12, 12, 12, 1, -19 },
  { 236, 11, 14, 13, 1, -15 },
  { 256, 6, 8, 6, -2, -3 },
  { 262, 7, 3, 9, 1, -10 },
  { 265, 4, 4, 7, 1, -4 },
  { 267, 12, 21, 9, -2, -19 },
  { 299, 12, 19, 13, 1, -19 },
  { 328, 8, 19, 13, 3, -19 },
  { 347, 13, 19, 13, 0, -19 },
  { 378, 13, 19, 13, 0, -19 },
  { 409, 13, 19, 13, 0, -19 },
  { 440, 12, 19, 13, 1, -19 },
  { 469, 11, 19, 13, 1, -19 },
  { 496, 13, 19, 13, 1, -19 },
  { 527, 12, 19, 13, 1, -19 },
  { 556, 10, 19, 13, 2, -19 },
  { 580, 5, 15, 7, 1, -15 },
  { 590, 7, 20, 6, -1, -15 },
  { 608, 10, 13, 12, 1, -15 },
  { 625, 11, 9, 13, 1, -13 },
  { 638, 10, 12, 12, 1, -14 },
  { 653, 10, 19, 12, 2, -19 },
  { 677, 18, 25, 20, 1, -19 },
  { 734, 15, 19, 16, -1, -19 },
  { 770, 14, 19, 15, 0, -19 },
  { 804, 14, 19, 15, 1, -19 },
  { 838, 14, 19, 15, 0, -19 },
  { 872, 14, 19, 13, 0, -19 },
  { 906, 14, 19, 13, 0, -19 },
  { 940, 14, 19, 15, 1, -19 },
  { 974, 16, 19, 16, 0, -19 },
  { 1012, 7, 19, 7, 0, -19 },
  { 1029, 13, 19, 13, 0, -19 },
  { 1060, 16, 19, 14, 0, -19 },
  { 1098, 11, 19, 13, 0, -19 },
  { 1125, 20, 19, 20, 0, -19 },
  { 1173, 16, 19, 16, 0, -19 },
  { 1211, 14, 19, 16, 1, -19 },
  { 1245, 15, 19, 15, 0, -19 },
  { 1281, 14, 22, 16, 1, -19 },
  { 1320, 14, 19, 14, 0, -19 },
  { 1354, 13, 19, 14, 1, -19 },
  { 1385, 13, 19, 14, 2, -19 },
  { 1416, 14, 19, 15, 1, -19 },
  { 1450, 15, 19, 15, 2, -19 },
  { 1486, 19, 19, 20, 2, -19 },
  { 1532, 17, 19, 15, -1, -19 },
  { 1573, 14, 19, 14, 2, -19 },
  { 1607, 15, 19, 14, 0, -19 },
  { 1643, 9, 26, 7, 0, -22 },
  { 1673, 6, 21, 10, 2, -19 },
  { 1689, 9, 26, 7, -2, -22 },
  { 1719, 9, 10, 10, 1, -19 },
  { 1731, 11, 3, 11, -2, 0 },
  { 1736, 5, 4, 9, 3, -20 },
  { 1739, 11, 15, 12, 0, -15 },
  { 1760, 12, 21, 13, 0, -21 },
  { 1792, 11, 15, 12, 1, -15 },
  { 1813, 13, 21, 13, 1, -21 },
  { 1848, 11, 15, 12, 1, -15 },
  { 1869, 9, 21, 9, 1, -21 },
  { 1893, 13, 20, 13, 0, -15 },
  { 1926, 12, 21, 13, 0, -21 },
  { 1958, 7, 21, 6, 0, -21 },
  { 1977, 10, 26, 6, -3, -21 },
  { 2010, 13, 21, 12, 0, -21 },
  { 2045, 7, 21, 6, 0, -21 },
  { 2064, 18, 15, 20, 0, -15 },
  { 2098, 12, 15, 13, 0, -15 },
  { 2121, 11, 15, 13, 1, -15 },
  { 2142, 13, 20, 13, -1, -15 },
  { 2175, 12, 20, 13, 1, -15 },
  { 2205, 9, 15, 9, 0, -15 },
  { 2222, 11, 15, 12, 0, -15 },
  { 2243, 7, 18, 8, 1, -18 },
  { 2259, 12, 15, 13, 1, -15 },
  { 2282, 11, 15, 12, 1, -15 },
  { 2303, 15, 15, 17, 2, -15 },
  { 2332, 13, 15, 12, -1, -15 },
  { 2357, 13, 20, 12, -1, -15 },
  { 2390, 12, 15, 12, 0, -15 },
  { 2413, 8, 26, 8, 1, -21 },
  { 2439, 6, 23, 7, 0, -19 },
  { 2457, 8, 26, 8, -1, -21 },
  { 2483, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC27PT7B_H_
