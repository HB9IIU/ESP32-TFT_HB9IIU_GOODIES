#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC70PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x1F, 0x87, 0xE7, 0xF0,
  0xFC, 0xFE, 0x1F, 0x9F, 0x87, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x3F,
  0x1F, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF,
  0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x60, 0xFC, 0x0F, 0x80, 0x78, 0x7E, 0x07, 0xC0, 0x7F, 0x3F,
  0x03, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0x3F, 0x0F,
  0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0xCF, 0xC0,
  0x1F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xE7, 0xE0, 0x03, 0xFF, 0xE7, 0xE0,
  0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x7F, 0xF0, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7E,
  0x7F, 0xFE, 0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x3F, 0x3F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x83, 0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x07, 0xE7,
  0xE0, 0x1F, 0x83, 0xF0, 0xE0, 0x0F, 0xC3, 0xF8, 0x30, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0xF8, 0x1F,
  0xC3, 0xFF, 0xFF, 0x07, 0xF1, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0xCF, 0xF8,
  0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xCF, 0xF8, 0x7F, 0xCF, 0xE7, 0xFC, 0x1F,
  0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0x1F, 0xE0,
  0x1F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xF8, 0x7F,
  0x80, 0x1F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD,
  0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E,
  0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x30, 0x0F, 0xC0, 0x37, 0xC0, 0xFC, 0x1F, 0x7F, 0x0F, 0x87, 0xFF,
  0xFE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0xC1, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xE0, 0x0F, 0x80, 0x0C,
  0x00, 0x70, 0x00, 0x40, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x03, 0xC0, 0x02, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0x07, 0xF9, 0xFF, 0x3F,
  0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFE, 0x3F, 0x81, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7,
  0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFB, 0xFC,
  0xFC, 0x3F, 0xCF, 0x07, 0xFC, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F,
  0xEF, 0xF8, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFF,
  0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xE0,
  0x1F, 0xF0, 0x00, 0x40, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0x80, 0x1F, 0xE7, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xE7, 0xFF, 0x03,
  0xFE, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xF8,
  0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x1F, 0xF9, 0xFF, 0x87,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0xE1,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF,
  0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0x80,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xE0,
  0x7E, 0x01, 0xFF, 0xFF, 0x81, 0xF0, 0x7E, 0x01, 0xFE, 0x0F, 0xC0, 0xF8,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3E,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0x87, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xE3, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF1, 0xF8, 0x1F, 0xC0, 0x3F, 0x00,
  0xF8, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x3F, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x8F, 0xC0, 0xFE, 0x03, 0xF0,
  0x07, 0xC7, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x00, 0xFC,
  0x03, 0xE3, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF1, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xC0, 0x7C, 0x1F, 0x80, 0xFF, 0x3F,
  0xF0, 0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xFC, 0xFE, 0x03, 0xE0, 0x1F, 0xFE,
  0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0xFC, 0x03, 0xFF,
  0x1F, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFC,
  0x7F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F,
  0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xCF, 0xF8,
  0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xFC, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xDF, 0xF0, 0x0F, 0xF3,
  0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x7F,
  0xCF, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFC, 0x07, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0xC0, 0x3F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF8,
  0x07, 0xF8, 0xFE, 0x0F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F,
  0xC0, 0x3F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xF1, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFE, 0x7F,
  0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFB,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xEF, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x07, 0xFD, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x7F, 0x00,
  0xFF, 0x80, 0x7F, 0xDF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF3, 0xF0, 0x1F, 0xF0,
  0x07, 0xFC, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x3F, 0x81, 0xFF, 0x00, 0xFF,
  0x87, 0xE0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xF0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0x8F, 0xF8, 0x07,
  0xFC, 0x0F, 0xE3, 0xFC, 0x01, 0xFF, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xDF, 0xF0, 0x0F, 0xF8, 0x03, 0xF7,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xF0, 0x0F,
  0xF8, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F,
  0xF0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0x1F,
  0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x3F,
  0xE0, 0x7F, 0x83, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFB, 0xF8, 0x3F,
  0xC0, 0x7F, 0x83, 0xFB, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFB, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF3, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF3, 0xF8, 0xFF,
  0x80, 0x7F, 0x8F, 0xF3, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xE3, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xE3, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE3, 0xF9, 0xFE,
  0x00, 0x7F, 0x9F, 0xC3, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xC3, 0xF9, 0xFE,
  0x00, 0x7F, 0xBF, 0x83, 0xFB, 0xFC, 0x00, 0x7F, 0xBF, 0x83, 0xFB, 0xFC,
  0x00, 0x7F, 0xBF, 0x83, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFD,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F,
  0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF3, 0xFE, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x80, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xE7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x0F, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0x7F, 0xFF, 0x81, 0xFE, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0xF8, 0x0F, 0xF0,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF,
  0xF9, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xF0, 0x00, 0xFF,
  0xC7, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7,
  0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x04,
  0x07, 0xFC, 0x00, 0xE0, 0x7F, 0xE0, 0x3F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF,
  0x1F, 0xE0, 0x1F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x04, 0x00, 0x3F, 0xF0, 0x07, 0x80,
  0x3F, 0xF0, 0x07, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x87, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF,
  0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87,
  0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x07, 0xFC,
  0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xE7, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFD, 0xFF, 0xF0, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xF1, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC7,
  0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xCF,
  0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x8F, 0xFC,
  0x00, 0x3F, 0xDF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFB, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xFC,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x07,
  0xFF, 0xC7, 0xF8, 0x1F, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xBF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8,
  0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0,
  0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xE0, 0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0xFD, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03,
  0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xF8,
  0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0xFF,
  0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xC0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFE, 0x07,
  0xF8, 0x7F, 0x03, 0xFF, 0x03, 0xFC, 0x3F, 0x83, 0xFF, 0x83, 0xFC, 0x1F,
  0xC1, 0xFF, 0xC1, 0xFE, 0x0F, 0xE1, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0xFF,
  0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0xFC, 0x3F,
  0x80, 0xFE, 0x3F, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0xBF, 0x9F, 0xE0, 0x3F,
  0x9F, 0xDF, 0xDF, 0xE0, 0x1F, 0xCF, 0xCF, 0xEF, 0xF0, 0x0F, 0xEF, 0xE7,
  0xF7, 0xF0, 0x07, 0xF7, 0xF3, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0x9F, 0xF0,
  0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xC0,
  0x0F, 0xC3, 0xFF, 0xF0, 0x07, 0xE1, 0xFF, 0xFC, 0x07, 0xF1, 0xFF, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xF8, 0xFF, 0xBF, 0xFF, 0xFC, 0x7F, 0x07,
  0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x1F, 0xC0,
  0x3F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 51, 17, 1, -50 },
  { 116, 19, 18, 22, 5, -53 },
  { 159, 35, 50, 36, 2, -50 },
  { 378, 31, 66, 34, 2, -58 },
  { 634, 33, 52, 43, 6, -51 },
  { 849, 34, 52, 39, 1, -51 },
  { 1070, 9, 18, 11, 5, -53 },
  { 1091, 22, 72, 22, 3, -56 },
  { 1289, 22, 71, 22, -3, -55 },
  { 1485, 28, 30, 30, 4, -50 },
  { 1590, 29, 36, 33, 2, -41 },
  { 1721, 14, 20, 16, -4, -8 },
  { 1756, 17, 7, 23, 3, -25 },
  { 1771, 11, 10, 19, 1, -9 },
  { 1785, 31, 54, 23, -4, -50 },
  { 1995, 30, 52, 34, 3, -51 },
  { 2190, 20, 50, 34, 8, -50 },
  { 2315, 33, 51, 34, 0, -51 },
  { 2526, 32, 52, 34, 1, -51 },
  { 2734, 32, 50, 34, 1, -50 },
  { 2934, 32, 51, 34, 2, -50 },
  { 3138, 28, 51, 34, 3, -50 },
  { 3317, 33, 50, 34, 3, -50 },
  { 3524, 31, 52, 34, 2, -51 },
  { 3726, 27, 51, 34, 5, -51 },
  { 3899, 16, 39, 18, 1, -38 },
  { 3977, 19, 50, 17, -3, -38 },
  { 4096, 27, 33, 30, 2, -38 },
  { 4208, 29, 22, 34, 3, -33 },
  { 4288, 28, 32, 31, 1, -37 },
  { 4400, 26, 52, 30, 5, -51 },
  { 4569, 49, 64, 52, 1, -49 },
  { 4961, 39, 50, 40, -3, -50 },
  { 5205, 36, 50, 38, 1, -50 },
  { 5430, 36, 52, 39, 3, -51 },
  { 5664, 36, 50, 38, 1, -50 },
  { 5889, 35, 50, 33, 1, -50 },
  { 6108, 35, 50, 32, 1, -50 },
  { 6327, 36, 52, 40, 3, -51 },
  { 6561, 42, 50, 42, 1, -50 },
  { 6824, 18, 50, 18, 1, -50 },
  { 6937, 34, 51, 33, 0, -50 },
  { 7154, 41, 50, 37, 1, -50 },
  { 7411, 27, 50, 32, 1, -50 },
  { 7580, 51, 50, 51, 1, -50 },
  { 7899, 42, 50, 42, 1, -50 },
  { 8162, 36, 52, 41, 3, -51 },
  { 8396, 37, 50, 38, 1, -50 },
  { 8628, 36, 60, 41, 3, -51 },
  { 8898, 36, 50, 37, 1, -50 },
  { 9123, 36, 52, 36, 1, -51 },
  { 9357, 35, 50, 37, 5, -50 },
  { 9576, 38, 51, 39, 2, -50 },
  { 9819, 37, 50, 39, 6, -50 },
  { 10051, 48, 50, 51, 6, -50 },
  { 10351, 43, 50, 38, -2, -50 },
  { 10620, 35, 50, 37, 6, -50 },
  { 10839, 39, 50, 36, -1, -50 },
  { 11083, 23, 69, 18, -1, -58 },
  { 11282, 16, 54, 26, 6, -50 },
  { 11390, 23, 69, 18, -4, -58 },
  { 11589, 23, 25, 26, 2, -50 },
  { 11661, 27, 7, 27, -4, 0 },
  { 11685, 14, 10, 22, 7, -52 },
  { 11703, 29, 39, 32, 1, -38 },
  { 11845, 31, 54, 34, 0, -53 },
  { 12055, 28, 39, 31, 2, -38 },
  { 12192, 33, 54, 34, 2, -53 },
  { 12415, 28, 39, 32, 2, -38 },
  { 12552, 25, 54, 22, 2, -54 },
  { 12721, 33, 52, 34, 0, -38 },
  { 12936, 30, 53, 33, 0, -53 },
  { 13135, 17, 52, 17, 1, -52 },
  { 13246, 24, 66, 16, -7, -52 },
  { 13444, 34, 53, 32, 0, -53 },
  { 13670, 17, 53, 17, 1, -53 },
  { 13783, 48, 38, 51, 0, -38 },
  { 14011, 30, 38, 33, 0, -38 },
  { 14154, 29, 39, 34, 2, -38 },
  { 14296, 33, 52, 34, -2, -38 },
  { 14511, 31, 52, 34, 2, -38 },
  { 14713, 23, 38, 22, 0, -38 },
  { 14823, 28, 39, 31, 1, -38 },
  { 14960, 20, 47, 21, 2, -46 },
  { 15078, 31, 38, 33, 2, -37 },
  { 15226, 28, 37, 30, 4, -37 },
  { 15356, 41, 37, 43, 4, -37 },
  { 15546, 34, 37, 30, -2, -37 },
  { 15704, 34, 51, 30, -2, -37 },
  { 15921, 31, 37, 30, -1, -37 },
  { 16065, 21, 67, 20, 2, -55 },
  { 16241, 15, 59, 17, 1, -50 },
  { 16352, 22, 67, 20, -3, -55 },
  { 16537, 33, 15, 38, 3, -28 },
};

const GFXfont RobotoCondensed_SemiBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC70PT7B_H_
