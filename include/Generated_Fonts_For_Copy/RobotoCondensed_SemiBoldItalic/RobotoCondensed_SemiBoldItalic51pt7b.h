#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC51PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x00,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F,
  0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x0F,
  0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0xEF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x7C, 0x08, 0x7C, 0x3C, 0x1E, 0x78,
  0x3C, 0x1E, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x7C, 0xF8, 0x78,
  0x7C, 0xF0, 0x78, 0x79, 0xE0, 0x78, 0xFB, 0xE0, 0x7F, 0xF3, 0xC0, 0x3F,
  0xF7, 0x80, 0x1F, 0xEF, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x7B, 0xFC, 0x00, 0xF7, 0xFE, 0x01,
  0xEF, 0xFF, 0x03, 0xEF, 0x8F, 0x03, 0xCF, 0x0F, 0x07, 0x9F, 0x0F, 0x0F,
  0x9E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x7C,
  0x1E, 0x1F, 0x38, 0x1F, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xCF, 0xC0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x87, 0xE1, 0xFF, 0xC3, 0xF1, 0xFF, 0xF1, 0xF1, 0xFF,
  0xF8, 0xF9, 0xFC, 0xFE, 0xFC, 0xFC, 0x3F, 0x7E, 0x7E, 0x1F, 0xFE, 0x7F,
  0x07, 0xFF, 0x3F, 0x83, 0xFF, 0x9F, 0xC0, 0xFF, 0x8F, 0xE0, 0x7F, 0x87,
  0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x81, 0xFF, 0x8F, 0xE0, 0x0C, 0x00,
  0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF,
  0x80, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x40,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0x81, 0xE0, 0xCF, 0x8F, 0x1E, 0xFF, 0x77,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3E, 0x01, 0xF0, 0xF0,
  0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0x80, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC,
  0x1E, 0x01, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF, 0x00,
  0x3C, 0x7E, 0xFE, 0xFE, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xCF, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xFB, 0xF8, 0x0F,
  0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xF3,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFD, 0xFB, 0x87, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF9, 0xFE,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0x3F, 0x83,
  0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC1, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xBF, 0x80, 0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3E, 0x1F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0x1F, 0xE0, 0x18, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC1, 0xFC,
  0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF9, 0xF0, 0x1F, 0xBF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xFE, 0x7F, 0x9F, 0xC1, 0xFC, 0xFE, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x07,
  0xF1, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xFC,
  0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03,
  0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xFC, 0xFE,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F,
  0x9F, 0xC7, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xDF, 0x80, 0xFD, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xEF, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x1F, 0x00, 0xF0,
  0xF8, 0x0F, 0xF8, 0x1E, 0x1E, 0x03, 0xFF, 0xC3, 0xC7, 0xC0, 0xFF, 0xF8,
  0x78, 0xF0, 0x3F, 0x1F, 0x0F, 0x3E, 0x0F, 0x83, 0xC1, 0xE7, 0xC1, 0xF0,
  0x78, 0x3C, 0xF0, 0x7C, 0x1F, 0x07, 0xBE, 0x0F, 0x83, 0xE0, 0xF7, 0xC3,
  0xE0, 0x78, 0x1E, 0xF0, 0x7C, 0x0F, 0x03, 0xDE, 0x0F, 0x83, 0xE0, 0x73,
  0xC3, 0xE0, 0x7C, 0x1E, 0xF8, 0x7C, 0x0F, 0x03, 0xDF, 0x0F, 0x81, 0xE0,
  0x7B, 0xE1, 0xF0, 0x7C, 0x0E, 0x78, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC1,
  0xE0, 0x79, 0xE0, 0xF8, 0x7C, 0x1E, 0x3C, 0x1F, 0x1F, 0x83, 0xC7, 0x83,
  0xFF, 0xF9, 0xF0, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0x07, 0xF9, 0xFF, 0x03,
  0xE0, 0x7E, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x40, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F,
  0xC0, 0x7F, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0,
  0x7E, 0x03, 0xF8, 0x1F, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0xE7, 0xE0, 0x7F,
  0xF9, 0xF8, 0x1F, 0xFE, 0x7E, 0x07, 0xFF, 0xBF, 0x81, 0xFF, 0xCF, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7,
  0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xE0, 0x7F,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x7F,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0x3F, 0x01, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x7F, 0x80, 0x01, 0xFD,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFC,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0,
  0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x7C, 0x03, 0xEF, 0xC0, 0xFD, 0xF0,
  0x1F, 0xFF, 0x03, 0xF3, 0xE0, 0x7D, 0xF8, 0x0F, 0xCF, 0x83, 0xF7, 0xE0,
  0x3F, 0x3E, 0x0F, 0x9F, 0x80, 0xFC, 0xF8, 0x7E, 0x7E, 0x07, 0xF3, 0xE1,
  0xF3, 0xF8, 0x1F, 0x8F, 0x8F, 0xCF, 0xE0, 0x7E, 0x3E, 0x3E, 0x3F, 0x01,
  0xF8, 0xF8, 0xF8, 0xFC, 0x07, 0xE3, 0xE7, 0xC3, 0xF0, 0x3F, 0x87, 0x9F,
  0x1F, 0xC0, 0xFE, 0x1F, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0xE1, 0xF8, 0x0F,
  0xC1, 0xFF, 0x87, 0xE0, 0x3F, 0x07, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xF0,
  0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x00,
  0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07,
  0xE0, 0x3F, 0xF8, 0x1F, 0xC0, 0x7E, 0xF8, 0x3F, 0x81, 0xFD, 0xF0, 0x7F,
  0x03, 0xFB, 0xE0, 0xFC, 0x07, 0xF3, 0xC1, 0xF8, 0x0F, 0xC7, 0xC3, 0xF0,
  0x1F, 0x8F, 0x8F, 0xE0, 0x3F, 0x1F, 0x1F, 0xC0, 0xFE, 0x1F, 0x3F, 0x81,
  0xFC, 0x3E, 0x7E, 0x03, 0xF8, 0x7C, 0xFC, 0x07, 0xE0, 0x79, 0xF8, 0x0F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE,
  0x03, 0xFF, 0x01, 0xF8, 0x07, 0xFE, 0x03, 0xF0, 0x0F, 0xFC, 0x07, 0xE0,
  0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00,
  0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07,
  0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0x01,
  0xFB, 0xF0, 0x1F, 0xC0, 0x7F, 0x7E, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F,
  0x01, 0xF9, 0xF8, 0x1F, 0xE0, 0x7F, 0x3F, 0x03, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7F, 0x81, 0xF8, 0xFC, 0x1F, 0xF0, 0x7F, 0x1F, 0x83, 0xFE, 0x0F, 0xC3,
  0xF0, 0x7F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF8, 0x7F, 0x0F, 0xC3, 0xFF, 0x0F,
  0xC1, 0xF8, 0x7F, 0xE1, 0xF8, 0x3F, 0x1F, 0xFC, 0x7F, 0x07, 0xE3, 0xEF,
  0x8F, 0xC0, 0xFC, 0xFD, 0xF1, 0xF8, 0x1F, 0x9F, 0x3E, 0x3F, 0x03, 0xF3,
  0xE7, 0xCF, 0xC0, 0x7E, 0xFC, 0xF9, 0xF8, 0x0F, 0xDF, 0x1F, 0x3F, 0x01,
  0xFB, 0xE3, 0xEF, 0xC0, 0x3F, 0xFC, 0x7D, 0xF8, 0x07, 0xFF, 0x07, 0xBF,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF9,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F,
  0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x03, 0xE3, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x07,
  0xBE, 0x0F, 0x9E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1F, 0x3E,
  0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F,
  0xC7, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xF0, 0xFC,
  0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0x7F, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0x7E, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x81,
  0xFC, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xCF, 0xF8, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0xFE,
  0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x3F, 0xEF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x7E, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0x07, 0xF0, 0x18,
  0x3F, 0xC7, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xBF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFB, 0xF0, 0x03, 0xE7, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x20, 0x0F, 0xE0, 0x30, 0x0F, 0xE0,
  0x7C, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x09, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xF0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x0F, 0xF0, 0x1F, 0x8F, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7,
  0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xF9, 0xF8, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0xFB,
  0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE7, 0xFF, 0x7F, 0x83, 0xF0, 0x7F, 0x83,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F,
  0x81, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x07, 0xE1, 0xF8,
  0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x07, 0xF1,
  0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x03, 0xF8, 0xFC, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x3F, 0x7F, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xCF, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0xFE,
  0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x9F,
  0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xFD, 0xFC, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xFE, 0x7F, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF1, 0xF8, 0x01, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xDF, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x07, 0xFC,
  0xFC, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF,
  0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xF3, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE7, 0x87, 0xEF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xE4, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF1, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC,
  0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0xC3, 0xF9, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x87,
  0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xF0, 0x3E, 0x07, 0xEF, 0xC1, 0xF8,
  0x1F, 0xBF, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0xFE, 0x0F,
  0xCF, 0xC3, 0xF8, 0x7E, 0x3F, 0x1F, 0xE1, 0xF8, 0xFC, 0x7F, 0xC7, 0xC3,
  0xF1, 0xFF, 0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F, 0x3F, 0xF3, 0xE0, 0x7D,
  0xF7, 0xDF, 0x81, 0xF7, 0xDF, 0x7E, 0x07, 0xDE, 0x7D, 0xF0, 0x1F, 0xF9,
  0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x01, 0xF7, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xBF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x01,
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x70,
  0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0x1F, 0xF8, 0x1F,
  0x3F, 0xF8, 0x1F, 0x7F, 0xFC, 0x3E, 0x7F, 0xFF, 0x7E, 0x7C, 0x3F, 0xFE,
  0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 36, 13, 1, -36 },
  { 60, 15, 13, 16, 3, -38 },
  { 85, 26, 36, 26, 1, -36 },
  { 202, 22, 46, 25, 2, -41 },
  { 329, 24, 36, 32, 4, -36 },
  { 437, 25, 37, 28, 1, -36 },
  { 553, 7, 13, 8, 3, -38 },
  { 565, 16, 51, 16, 2, -40 },
  { 667, 16, 51, 16, -2, -40 },
  { 769, 21, 22, 22, 3, -36 },
  { 827, 21, 26, 24, 2, -30 },
  { 896, 10, 15, 12, -3, -6 },
  { 915, 13, 5, 17, 2, -18 },
  { 924, 8, 7, 14, 1, -7 },
  { 931, 23, 39, 17, -3, -36 },
  { 1044, 22, 36, 25, 2, -36 },
  { 1143, 14, 36, 25, 6, -36 },
  { 1206, 24, 36, 25, 0, -36 },
  { 1314, 23, 36, 25, 1, -36 },
  { 1418, 23, 36, 25, 1, -36 },
  { 1522, 23, 36, 25, 2, -36 },
  { 1626, 21, 36, 25, 2, -36 },
  { 1721, 24, 36, 25, 2, -36 },
  { 1829, 23, 36, 25, 1, -36 },
  { 1933, 21, 36, 25, 3, -36 },
  { 2028, 11, 28, 13, 1, -28 },
  { 2067, 14, 37, 12, -2, -28 },
  { 2132, 20, 24, 22, 1, -28 },
  { 2192, 21, 15, 25, 2, -24 },
  { 2232, 20, 23, 23, 1, -27 },
  { 2290, 18, 36, 22, 4, -36 },
  { 2371, 35, 46, 38, 1, -35 },
  { 2573, 28, 36, 29, -2, -36 },
  { 2699, 27, 36, 28, 0, -36 },
  { 2821, 26, 36, 28, 2, -36 },
  { 2938, 27, 36, 28, 0, -36 },
  { 3060, 27, 36, 24, 0, -36 },
  { 3182, 26, 36, 24, 0, -36 },
  { 3299, 26, 36, 29, 2, -36 },
  { 3416, 31, 36, 30, 0, -36 },
  { 3556, 13, 36, 13, 1, -36 },
  { 3615, 25, 36, 24, 0, -36 },
  { 3728, 31, 36, 27, 0, -36 },
  { 3868, 21, 36, 24, 0, -36 },
  { 3963, 38, 36, 37, 0, -36 },
  { 4134, 31, 36, 30, 0, -36 },
  { 4274, 27, 36, 30, 2, -36 },
  { 4396, 28, 36, 28, 0, -36 },
  { 4522, 27, 42, 30, 2, -36 },
  { 4664, 27, 36, 27, 0, -36 },
  { 4786, 26, 36, 26, 1, -36 },
  { 4903, 25, 36, 27, 4, -36 },
  { 5016, 27, 36, 28, 2, -36 },
  { 5138, 27, 36, 28, 4, -36 },
  { 5260, 35, 36, 37, 5, -36 },
  { 5418, 31, 36, 28, -1, -36 },
  { 5558, 26, 36, 27, 4, -36 },
  { 5675, 29, 36, 26, -1, -36 },
  { 5806, 17, 50, 13, -1, -42 },
  { 5913, 12, 39, 19, 4, -36 },
  { 5972, 17, 50, 13, -3, -42 },
  { 6079, 16, 18, 19, 2, -36 },
  { 6115, 20, 5, 20, -3, 0 },
  { 6128, 10, 8, 16, 5, -39 },
  { 6138, 21, 27, 23, 1, -27 },
  { 6209, 23, 38, 24, 0, -38 },
  { 6319, 21, 27, 23, 1, -27 },
  { 6390, 25, 38, 25, 1, -38 },
  { 6509, 21, 27, 24, 1, -27 },
  { 6580, 17, 39, 16, 2, -39 },
  { 6663, 24, 37, 25, 0, -27 },
  { 6774, 22, 38, 24, 0, -38 },
  { 6879, 13, 38, 12, 0, -38 },
  { 6941, 18, 48, 12, -5, -38 },
  { 7049, 25, 38, 23, 0, -38 },
  { 7168, 13, 38, 12, 0, -38 },
  { 7230, 35, 27, 37, 0, -27 },
  { 7349, 22, 27, 24, 0, -27 },
  { 7424, 22, 27, 25, 1, -27 },
  { 7499, 25, 37, 24, -2, -27 },
  { 7615, 23, 37, 25, 1, -27 },
  { 7722, 17, 27, 16, 0, -27 },
  { 7780, 21, 27, 22, 0, -27 },
  { 7851, 14, 34, 15, 2, -34 },
  { 7911, 22, 27, 24, 2, -27 },
  { 7986, 20, 27, 22, 3, -27 },
  { 8054, 30, 27, 32, 3, -27 },
  { 8156, 25, 27, 22, -2, -27 },
  { 8241, 25, 37, 22, -2, -27 },
  { 8357, 23, 27, 22, -1, -27 },
  { 8435, 16, 49, 15, 1, -40 },
  { 8533, 11, 43, 12, 1, -36 },
  { 8593, 16, 49, 15, -2, -40 },
  { 8691, 24, 11, 28, 2, -20 },
};

const GFXfont RobotoCondensed_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC51PT7B_H_
