#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC43PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xF0,
  0xFC, 0x3E, 0x07, 0x00, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x79, 0xE7,
  0x1E, 0x71, 0xEF, 0x1C, 0xF1, 0xCE, 0x1C, 0xE3, 0xC0, 0x00, 0x1C, 0x78,
  0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00,
  0x3C, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x79,
  0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xE3, 0xC0,
  0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x00, 0x0F,
  0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x81,
  0xF3, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0x9E, 0x08, 0xF1, 0xE0, 0xCF, 0x0E, 0x1E, 0xF1,
  0xE3, 0xCF, 0x1E, 0x38, 0xE1, 0xE7, 0x8F, 0x1E, 0xF0, 0xF3, 0xCE, 0x07,
  0xFD, 0xE0, 0x7F, 0xBC, 0x01, 0xE7, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0xF8, 0x03, 0xDF, 0xC0, 0x7B, 0xFE, 0x07, 0x3C,
  0xF0, 0xF7, 0x8F, 0x1E, 0x78, 0xF3, 0xC7, 0x0F, 0x38, 0x70, 0xF7, 0x87,
  0x0F, 0xF0, 0x70, 0xE2, 0x07, 0x9E, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0xF9, 0xFF,
  0xC7, 0xDF, 0xBF, 0x3C, 0xF9, 0xFB, 0xEF, 0xC7, 0xFF, 0x7E, 0x3F, 0xFB,
  0xE0, 0xFF, 0x9F, 0x07, 0xFC, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0xDF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFD, 0xF0, 0x3F, 0x8F, 0xC0,
  0x7D, 0xE7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0xCE, 0x00, 0x00, 0x10, 0x01,
  0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x08, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x38, 0x77, 0xCE,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x0F, 0x70, 0x07, 0x9E, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0x38, 0x3C, 0x00,
  0x04, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF0, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFE, 0x0F, 0xDF, 0x87, 0xC3, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x03,
  0xF7, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x3E, 0x3E, 0x0F, 0x87, 0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xEF, 0x3E, 0xC3, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xF7, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0,
  0xF9, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x87, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xF7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF7, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xF8, 0x06, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0xFC,
  0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xBE, 0x07, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3E, 0xF8, 0x1F, 0x3E, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F,
  0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0x7C, 0x7E, 0x1F,
  0x87, 0xC3, 0xE0, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xE3, 0xE1, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9,
  0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC, 0x1F, 0x8F, 0x87, 0xE1,
  0xFD, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0,
  0xF9, 0xF8, 0x7C, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xF0, 0x7D, 0xF8, 0x7E, 0x7E, 0x7F,
  0x3F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0xFB, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF0, 0x01, 0xE0, 0x3E,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x10, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x38, 0x78, 0x0F, 0x81, 0xC3, 0x81, 0xFE, 0x0E, 0x3C, 0x1F,
  0xFC, 0x71, 0xC1, 0xFB, 0xC3, 0x9E, 0x1F, 0x1E, 0x1C, 0xF0, 0xF0, 0xF0,
  0xE7, 0x0F, 0x07, 0x87, 0x78, 0x78, 0x38, 0x3B, 0xC7, 0xC3, 0xC1, 0xDC,
  0x3C, 0x1E, 0x0F, 0xE1, 0xE0, 0xF0, 0x7F, 0x0F, 0x07, 0x07, 0xF8, 0x78,
  0x78, 0x3B, 0xC7, 0xC3, 0xC1, 0xDE, 0x3C, 0x1E, 0x1E, 0xF1, 0xF1, 0xF0,
  0xE7, 0x0F, 0x8F, 0x0F, 0x38, 0x3F, 0xFC, 0xF1, 0xE1, 0xFF, 0xFF, 0x0F,
  0x0F, 0xE7, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0x00, 0x01, 0xFE, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xF0,
  0x7C, 0x07, 0xC0, 0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC1, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xFC, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xCF, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xF8, 0x3F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F,
  0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F,
  0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xFE, 0xFC, 0x1F, 0xFB, 0xF0, 0xFF, 0xEF,
  0xC3, 0xFF, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0,
  0x7F, 0x00, 0x7C, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03,
  0xF3, 0xF0, 0x00, 0xF9, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x3F,
  0x9F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F,
  0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xBC, 0x1F, 0x7C, 0x1F, 0xBC, 0x1F,
  0x7C, 0x1F, 0x3C, 0x1E, 0xFC, 0x1F, 0x3C, 0x3E, 0xF8, 0x1F, 0x3C, 0x3C,
  0xF8, 0x1F, 0x3C, 0x7C, 0xF8, 0x1F, 0x3C, 0x78, 0xF8, 0x3F, 0x3E, 0xF9,
  0xF8, 0x3F, 0x1E, 0xF1, 0xF8, 0x3E, 0x1E, 0xF1, 0xF0, 0x3E, 0x1F, 0xF1,
  0xF0, 0x3E, 0x1F, 0xE1, 0xF0, 0x7E, 0x1F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC3,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xFC, 0x0F, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0,
  0x0F, 0x81, 0xFE, 0x03, 0xE0, 0x7F, 0x80, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F,
  0xF8, 0x1F, 0x83, 0xFF, 0x07, 0xE0, 0xFB, 0xC1, 0xF0, 0x3E, 0xF0, 0x7C,
  0x0F, 0xBE, 0x1F, 0x07, 0xE7, 0x8F, 0xC1, 0xF9, 0xE3, 0xF0, 0x7E, 0x78,
  0xFC, 0x1F, 0x1F, 0x3E, 0x07, 0xC3, 0xCF, 0x81, 0xF0, 0xF7, 0xE0, 0xFC,
  0x3D, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x03, 0xE0, 0x7F, 0xC0,
  0xF8, 0x1F, 0xF0, 0x7E, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x07, 0xE0, 0x3F,
  0xC1, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF8,
  0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00,
  0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFB,
  0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0,
  0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF8, 0x3F,
  0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0,
  0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xF8,
  0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07,
  0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x80,
  0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xEF,
  0x81, 0xF8, 0x3F, 0x7C, 0x1F, 0xC1, 0xFB, 0xE0, 0xFE, 0x0F, 0x9F, 0x07,
  0xF0, 0x7C, 0xF8, 0x7F, 0x87, 0xE7, 0xC3, 0xFC, 0x3E, 0x3E, 0x1F, 0xE1,
  0xF1, 0xF1, 0xFF, 0x1F, 0x8F, 0x8F, 0x78, 0xF8, 0x7C, 0x7B, 0xC7, 0xC3,
  0xE7, 0xDE, 0x7E, 0x1F, 0x3C, 0xF3, 0xE0, 0xF9, 0xE7, 0x9F, 0x07, 0xDF,
  0x3D, 0xF8, 0x3E, 0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC3, 0xE0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0,
  0x3F, 0x0F, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80,
  0x7C, 0xFC, 0x01, 0xE7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x83, 0xCE, 0x0F, 0x38, 0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C,
  0x3D, 0xF0, 0xF7, 0x83, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x81, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xF9,
  0xF7, 0xE0, 0xFB, 0xF0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F,
  0x7F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFD, 0xF0, 0x7C, 0xF8, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE1, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0xF9,
  0xF8, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3E, 0x7F, 0x87,
  0xC7, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFB,
  0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7E, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x1F, 0x03, 0xFC, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3F,
  0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0x78,
  0x03, 0xF7, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xC3, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x03, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x81, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x3F, 0xDF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF8, 0x7F, 0x3F, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7E,
  0x0F, 0xC7, 0xE0, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFE, 0xF8, 0x07, 0xDF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x60, 0x3F, 0x07, 0x8F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF3, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF9,
  0xF8, 0x3F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x03, 0x80, 0xF8, 0x1F, 0x83,
  0xF0, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0xC3, 0xE1, 0xFC, 0x1F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0x80, 0x7E, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x0F, 0x9F, 0x07,
  0xC0, 0x7F, 0xFC, 0x7F, 0x83, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xC3, 0xF8, 0xFC, 0x7C, 0x1F, 0x83, 0xE3, 0xE0,
  0xFC, 0x1F, 0x1F, 0x07, 0xC0, 0xF9, 0xF8, 0x3E, 0x07, 0xCF, 0x81, 0xF0,
  0x7E, 0x7C, 0x0F, 0x83, 0xF3, 0xE0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0xF8,
  0xF8, 0x3E, 0x07, 0xCF, 0xC1, 0xF0, 0x3E, 0x7C, 0x0F, 0x83, 0xF3, 0xE0,
  0x7C, 0x1F, 0x9F, 0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x07, 0xC7, 0xC1, 0xF0,
  0x3E, 0x7E, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x1F, 0x80, 0x0F, 0x9F, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF8, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3E, 0x3E, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07,
  0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3E, 0xFC, 0x1F, 0x9F, 0x07, 0xC7, 0xF7, 0xF1, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x3E,
  0x3E, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0xDF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xEF, 0xF0, 0x7C, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xE1, 0xFF, 0x7C, 0x7F, 0xEF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7C, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C,
  0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x87, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xEF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xBC, 0x3F, 0xF0,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0x91, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F,
  0xC7, 0xC3, 0xF1, 0xF0, 0x7C, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0xF8, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0x87, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0x03, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x87, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x07,
  0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x07, 0x9F, 0x03, 0xDF, 0x01, 0xEF, 0x80,
  0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x3C, 0x1F, 0x7C, 0x3E,
  0x0F, 0xBE, 0x1F, 0x07, 0xDF, 0x0F, 0x87, 0xCF, 0x8F, 0xC3, 0xE7, 0xC7,
  0xE1, 0xF3, 0xE7, 0xF1, 0xF1, 0xF3, 0xF8, 0xF8, 0xF9, 0xFC, 0x78, 0x7D,
  0xEE, 0x7C, 0x3E, 0xF7, 0xBE, 0x1F, 0xFB, 0xDE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x7C, 0x1F,
  0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3E, 0x07,
  0xE1, 0xF0, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0xFC,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x7E, 0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0E,
  0x00, 0x10, 0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0x01, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFF, 0x1E, 0xFF, 0xFF, 0xEF,
  0x8F, 0xFE, 0xF0, 0x7F, 0xCF, 0x03, 0xF8, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 31, 11, 1, -31 },
  { 40, 12, 11, 13, 3, -32 },
  { 57, 22, 31, 22, 1, -31 },
  { 143, 19, 39, 21, 1, -35 },
  { 236, 20, 31, 27, 4, -31 },
  { 314, 21, 31, 24, 1, -31 },
  { 396, 6, 11, 7, 3, -32 },
  { 405, 13, 44, 13, 2, -34 },
  { 477, 13, 44, 13, -2, -34 },
  { 549, 18, 18, 19, 2, -31 },
  { 590, 18, 22, 20, 1, -25 },
  { 640, 8, 12, 10, -2, -5 },
  { 652, 10, 5, 14, 2, -16 },
  { 659, 6, 6, 12, 1, -6 },
  { 664, 20, 34, 14, -3, -31 },
  { 749, 18, 31, 21, 2, -31 },
  { 819, 12, 31, 21, 5, -31 },
  { 866, 20, 31, 21, 0, -31 },
  { 944, 19, 31, 21, 1, -31 },
  { 1018, 20, 31, 21, 0, -31 },
  { 1096, 20, 31, 21, 1, -31 },
  { 1174, 17, 31, 21, 2, -31 },
  { 1240, 20, 31, 21, 2, -31 },
  { 1318, 19, 31, 21, 1, -31 },
  { 1392, 17, 31, 21, 3, -31 },
  { 1458, 9, 24, 11, 1, -24 },
  { 1485, 12, 31, 10, -2, -24 },
  { 1532, 17, 20, 19, 1, -23 },
  { 1575, 17, 14, 21, 2, -21 },
  { 1605, 17, 20, 19, 1, -23 },
  { 1648, 16, 31, 18, 3, -31 },
  { 1710, 29, 40, 32, 1, -30 },
  { 1855, 24, 31, 25, -2, -31 },
  { 1948, 23, 31, 23, 0, -31 },
  { 2038, 22, 31, 24, 2, -31 },
  { 2124, 23, 31, 24, 0, -31 },
  { 2214, 22, 31, 21, 0, -31 },
  { 2300, 22, 31, 20, 0, -31 },
  { 2386, 22, 31, 24, 2, -31 },
  { 2472, 26, 31, 26, 0, -31 },
  { 2573, 10, 31, 11, 1, -31 },
  { 2612, 21, 31, 20, 0, -31 },
  { 2694, 26, 31, 23, 0, -31 },
  { 2795, 17, 31, 20, 0, -31 },
  { 2861, 32, 31, 32, 0, -31 },
  { 2985, 26, 31, 26, 0, -31 },
  { 3086, 22, 31, 25, 2, -31 },
  { 3172, 24, 31, 24, 0, -31 },
  { 3265, 22, 36, 25, 2, -31 },
  { 3364, 23, 31, 23, 0, -31 },
  { 3454, 21, 31, 22, 1, -31 },
  { 3536, 21, 31, 22, 3, -31 },
  { 3618, 24, 31, 24, 1, -31 },
  { 3711, 23, 31, 24, 3, -31 },
  { 3801, 29, 31, 31, 4, -31 },
  { 3914, 26, 31, 23, -1, -31 },
  { 4015, 21, 31, 22, 4, -31 },
  { 4097, 24, 31, 22, -1, -31 },
  { 4190, 15, 42, 11, -1, -35 },
  { 4269, 9, 34, 16, 4, -31 },
  { 4308, 14, 42, 11, -2, -35 },
  { 4382, 14, 15, 16, 1, -31 },
  { 4409, 17, 4, 17, -3, 0 },
  { 4418, 9, 6, 14, 4, -32 },
  { 4425, 17, 23, 20, 1, -23 },
  { 4474, 19, 32, 21, 0, -32 },
  { 4550, 17, 23, 19, 1, -23 },
  { 4599, 21, 32, 21, 1, -32 },
  { 4683, 18, 23, 20, 1, -23 },
  { 4735, 15, 32, 14, 1, -32 },
  { 4795, 20, 32, 21, 0, -23 },
  { 4875, 19, 32, 20, 0, -32 },
  { 4951, 11, 32, 10, 0, -32 },
  { 4995, 16, 41, 10, -5, -32 },
  { 5077, 21, 32, 20, 0, -32 },
  { 5161, 11, 32, 10, 0, -32 },
  { 5205, 29, 23, 31, 0, -23 },
  { 5289, 19, 23, 20, 0, -23 },
  { 5344, 18, 23, 21, 1, -23 },
  { 5396, 20, 32, 21, -1, -23 },
  { 5476, 19, 32, 21, 1, -23 },
  { 5552, 14, 23, 14, 0, -23 },
  { 5593, 18, 23, 19, 0, -23 },
  { 5645, 12, 28, 13, 1, -28 },
  { 5687, 19, 23, 20, 1, -23 },
  { 5742, 17, 23, 19, 2, -23 },
  { 5791, 25, 23, 27, 3, -23 },
  { 5863, 21, 23, 19, -1, -23 },
  { 5924, 21, 32, 18, -1, -23 },
  { 6008, 20, 23, 19, -1, -23 },
  { 6066, 13, 42, 13, 1, -34 },
  { 6135, 9, 37, 10, 1, -31 },
  { 6177, 14, 42, 13, -2, -34 },
  { 6251, 20, 9, 24, 2, -17 },
};

const GFXfont RobotoCondensed_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC43PT7B_H_
