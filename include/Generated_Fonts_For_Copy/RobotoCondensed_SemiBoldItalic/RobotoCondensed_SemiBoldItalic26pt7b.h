#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC26PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0x60, 0x00,
  0x30, 0xE3, 0x8C, 0x00, 0x66, 0xDF, 0xBF, 0x6C, 0xD9, 0xB3, 0x00, 0x03,
  0x30, 0x19, 0x81, 0xD8, 0x0C, 0xC0, 0x66, 0x07, 0x60, 0xFF, 0xE7, 0xFE,
  0x0D, 0xC0, 0xCC, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x80, 0xCC, 0x0C,
  0xC0, 0x66, 0x03, 0x30, 0x3B, 0x00, 0x01, 0x80, 0x30, 0x04, 0x03, 0xC1,
  0xFC, 0x3F, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0xE1, 0xDC, 0x3B, 0x8F, 0x7F, 0xC7, 0xF0, 0x7C,
  0x06, 0x00, 0xC0, 0x3C, 0x07, 0xE0, 0x66, 0x2E, 0x67, 0xE6, 0x6C, 0x6C,
  0xEF, 0xC7, 0xD8, 0x3B, 0x00, 0x70, 0x06, 0xE0, 0xDF, 0x1B, 0x31, 0xB3,
  0x33, 0x36, 0x33, 0x63, 0x30, 0x3E, 0x01, 0xC0, 0x03, 0xC0, 0x3F, 0x03,
  0xF8, 0x38, 0xC1, 0xC6, 0x0E, 0x70, 0x77, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xCE, 0xFF, 0x77, 0x3B, 0xB8, 0xF9, 0xC7, 0xCE, 0x1C, 0x7F, 0xE1,
  0xFF, 0x87, 0x9C, 0x6F, 0xFD, 0xB0, 0x01, 0x03, 0x07, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x10, 0x08, 0x0C, 0x0C,
  0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xC0, 0x80,
  0x07, 0x00, 0xE0, 0x18, 0x33, 0x37, 0xFE, 0x7F, 0x83, 0x80, 0xF8, 0x33,
  0x0E, 0x70, 0x84, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE1, 0xFF,
  0xFF, 0xF7, 0xFE, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xDC,
  0xE7, 0x73, 0x00, 0x7F, 0xFF, 0xC0, 0x5F, 0xF0, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0xE1,
  0xDC, 0x3B, 0x87, 0x70, 0xFE, 0x1F, 0xC7, 0xF0, 0xEE, 0x1D, 0xC3, 0xB8,
  0x77, 0x9C, 0x7F, 0x8F, 0xE0, 0xF8, 0x00, 0x02, 0x3D, 0xFF, 0xFE, 0xE3,
  0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xC0,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x00, 0x70, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7, 0x38,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0xF0, 0xE7, 0x1E, 0x7F, 0xC3, 0xF8, 0x1F, 0x00, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x1D, 0xE1,
  0xDE, 0x39, 0xC7, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0x80, 0x38, 0x03, 0x80,
  0x37, 0x07, 0xF8, 0x7F, 0xC1, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x01, 0xC0, 0xF8, 0x3F,
  0x0F, 0x03, 0xC0, 0x70, 0x1D, 0xE3, 0xFE, 0x7F, 0xCE, 0x3B, 0xC7, 0x78,
  0xFE, 0x1D, 0xC3, 0xB8, 0x73, 0x9E, 0x7F, 0x8F, 0xE0, 0x78, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x00, 0x07, 0x83, 0xF8, 0x7F, 0x9C, 0x73, 0x8E, 0x71,
  0xCE, 0x39, 0xCF, 0x3F, 0xC3, 0xF1, 0xFE, 0x39, 0xEE, 0x1D, 0xC3, 0xB8,
  0x77, 0x1E, 0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xE7, 0xF9, 0xCF,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFF, 0xF9, 0xFE, 0x3B, 0x81,
  0xC0, 0x70, 0x78, 0xFC, 0x3E, 0x0F, 0x00, 0x33, 0xDE, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x8E, 0x73, 0x80, 0x0C, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x87, 0x0E, 0x38, 0x71, 0xC1, 0x00, 0x00, 0x40,
  0x70, 0x78, 0xFE, 0xFE, 0x3C, 0x0F, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x70,
  0x04, 0x7F, 0xEF, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF7, 0xFE,
  0xFF, 0x80, 0x20, 0x1C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0x7C, 0x7E,
  0xFE, 0x3E, 0x0E, 0x02, 0x00, 0x1E, 0x3F, 0x9F, 0xFE, 0x7E, 0x38, 0x1C,
  0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x03, 0x00, 0x00, 0x00, 0x40, 0x70,
  0x78, 0x18, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61,
  0x80, 0x19, 0xC7, 0x8C, 0xC7, 0xE6, 0xE7, 0x33, 0x67, 0x39, 0xF3, 0x1C,
  0xF1, 0x8C, 0x79, 0xC6, 0x3C, 0xE3, 0x1E, 0x73, 0x8F, 0x39, 0x8D, 0x9D,
  0xC6, 0xCF, 0xFE, 0x63, 0x9E, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x82, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0,
  0xE3, 0x87, 0x8E, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xCE, 0x07, 0x78, 0x1D,
  0xC0, 0x7F, 0x01, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0x0E, 0x1C,
  0x3C, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x1E,
  0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x7F, 0xF3, 0xFF, 0x8F,
  0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xBC, 0x1D,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x3B, 0xC3, 0xCE, 0x1C, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x78, 0x79, 0xE1, 0xC7, 0x07, 0x1C,
  0x38, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7F,
  0xE3, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x8F, 0xFC, 0x7F, 0xE7, 0xFF, 0x07, 0x78, 0x3B, 0xC1,
  0xCE, 0x1E, 0x7F, 0xF1, 0xFF, 0x07, 0xE0, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70,
  0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0x1E, 0x3C, 0x70,
  0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x70,
  0xE3, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x78,
  0xE3, 0xC7, 0x1E, 0x78, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x1E, 0x1E, 0x1E,
  0x3E, 0x1C, 0x3C, 0x1C, 0x78, 0x1C, 0xF0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7D, 0xC0, 0x79, 0xC0, 0x79,
  0xE0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x7F, 0xDF, 0xFB,
  0xFF, 0x00, 0x1F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCE, 0xC3, 0xF1, 0xD8, 0x7E, 0x3B, 0x1D, 0xC7,
  0x73, 0xB8, 0xEE, 0x6F, 0x3D, 0xDD, 0xE7, 0xBB, 0x38, 0xE7, 0xE7, 0x1C,
  0x78, 0xE3, 0x8F, 0x3C, 0x71, 0xE7, 0x9E, 0x38, 0xE3, 0xC7, 0x1C, 0x00,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1F, 0x0E, 0x1F, 0x0E, 0x3F, 0x0E,
  0x3F, 0x1E, 0x3F, 0x9E, 0x3B, 0x9C, 0x39, 0x9C, 0x39, 0xDC, 0x79, 0xDC,
  0x78, 0xFC, 0x78, 0xFC, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x39, 0xE0,
  0xE7, 0x03, 0xDC, 0x0F, 0x70, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xE0,
  0x7B, 0x81, 0xCF, 0x07, 0x1C, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0xC1,
  0xCF, 0x0F, 0x38, 0x3C, 0xFF, 0xE3, 0xFF, 0x1F, 0xF0, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xE0, 0x7B, 0x81, 0xCF, 0x07,
  0x1C, 0x38, 0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x0F, 0x1C, 0x3C, 0x70, 0xF3,
  0xC3, 0xCF, 0x0E, 0x38, 0x78, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x79, 0xC1,
  0xE7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0xCF, 0x0F, 0x00, 0x07,
  0xC0, 0xFF, 0x0F, 0xFC, 0x78, 0xE3, 0x87, 0x3C, 0x3D, 0xE0, 0x07, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0E, 0x70, 0x73, 0x83, 0x9C,
  0x3C, 0xFF, 0xC3, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0xCE, 0x0E, 0x78, 0x39, 0xE0, 0xE7,
  0x87, 0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0x73,
  0x83, 0xCE, 0x0E, 0x3C, 0x78, 0x7F, 0xC1, 0xFF, 0x01, 0xF0, 0x00, 0xF0,
  0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0x70, 0xF1, 0xC3, 0xC7, 0x0E, 0x1C,
  0x78, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x1E, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0xE1, 0xFC,
  0x78, 0xFF, 0x1E, 0x3B, 0xC7, 0x8E, 0xF3, 0xE7, 0xBC, 0xF9, 0xCF, 0x3E,
  0x71, 0xDF, 0x9C, 0x77, 0xEE, 0x1D, 0xBB, 0x87, 0xEE, 0xE1, 0xFB, 0xF0,
  0x7C, 0xFC, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x1C, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C,
  0x07, 0x3C, 0x07, 0x78, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x3C, 0x70,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x7B, 0x83, 0x9C, 0x3C, 0xE1,
  0xC7, 0x1E, 0x3C, 0xE0, 0xEF, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x00, 0x0F,
  0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xF8, 0xF0, 0xF0,
  0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0x71, 0xC7, 0x1C, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0xF8, 0xF0, 0xF0, 0x0E, 0x0E, 0x1E, 0x1E, 0x3F, 0x37, 0x73,
  0x63, 0xE3, 0x7F, 0xCF, 0xFB, 0xFF, 0x00, 0xE3, 0x9C, 0x70, 0x0F, 0x83,
  0xF8, 0xFF, 0x9C, 0x70, 0x0E, 0x3F, 0xCF, 0xFB, 0xCE, 0x71, 0xDE, 0x3B,
  0xCF, 0x3F, 0xE7, 0xFC, 0x7B, 0x80, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0xF7, 0x8F,
  0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xEF, 0xFC, 0xEF, 0xCE, 0x70,
  0x1F, 0x0F, 0xE7, 0xFD, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0xEE, 0x3B, 0xFE, 0x7F, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x1E, 0xE3, 0xFE, 0x7F, 0xE7, 0x1E, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0x8F, 0xF8, 0xFF, 0x87, 0xB8,
  0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0xF1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x38,
  0x0E, 0x13, 0xFE, 0x7F, 0x8F, 0x80, 0x07, 0x87, 0xC7, 0xE3, 0x83, 0xC1,
  0xE1, 0xF9, 0xFC, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xF3, 0x8F, 0x78,
  0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0xFC, 0x7F,
  0xC1, 0xDC, 0x01, 0xC4, 0x3C, 0xFF, 0x8F, 0xF0, 0x3E, 0x00, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0xF1, 0xFF, 0x3F, 0xE7, 0x1C,
  0xE3, 0xBC, 0x77, 0x0E, 0xE1, 0xDC, 0x7B, 0x8E, 0x71, 0xDE, 0x3B, 0x87,
  0x70, 0xE0, 0x00, 0x38, 0x78, 0x60, 0x00, 0x0F, 0x1E, 0x38, 0x70, 0xE1,
  0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x00, 0x01, 0x01, 0xC0, 0xE0,
  0x70, 0x00, 0x00, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE3, 0xF1, 0xF0, 0xF0,
  0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF3,
  0xC7, 0x3C, 0x39, 0xE1, 0xDE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFE, 0x0E, 0x70, 0x73, 0x87, 0x9E, 0x38, 0x71, 0xC3, 0x80, 0x1E, 0x3C,
  0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38,
  0x70, 0xE3, 0xC7, 0x00, 0x3B, 0xCF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xE3,
  0xCF, 0x38, 0xE3, 0xDE, 0x38, 0xF7, 0x8E, 0x39, 0xC3, 0x8E, 0x71, 0xE3,
  0x9C, 0x70, 0xE7, 0x1C, 0x7B, 0xC7, 0x1E, 0xE1, 0xC7, 0x38, 0x71, 0xC0,
  0x3B, 0xC7, 0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0xF1, 0xDC, 0x3B, 0x87, 0x71,
  0xEE, 0x39, 0xC7, 0x78, 0xEE, 0x1D, 0xC3, 0x80, 0x0F, 0x07, 0xF1, 0xFF,
  0x38, 0xEF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x3B, 0x8F, 0x7F,
  0xC7, 0xF0, 0x7C, 0x00, 0x1D, 0xE0, 0xFF, 0x87, 0xFC, 0x38, 0xF1, 0xC7,
  0x9E, 0x3C, 0xE1, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x3C, 0xFF, 0xC7,
  0x7E, 0x39, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x1E,
  0xE7, 0xFD, 0xFF, 0xB8, 0xFE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0xDC,
  0x7B, 0x8E, 0x7F, 0xCF, 0xF8, 0xF7, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x3B, 0x9F, 0xCF, 0xC7, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0x73,
  0x80, 0x78, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x3B, 0x87, 0x3F, 0xC7, 0xF8,
  0x3C, 0x00, 0x1C, 0x78, 0xE7, 0xFF, 0xE7, 0x1E, 0x38, 0x70, 0xE1, 0xC3,
  0x8F, 0x1E, 0x3E, 0x3C, 0x78, 0x70, 0xEE, 0x1D, 0xC7, 0xB8, 0xF7, 0x1D,
  0xE3, 0xB8, 0x77, 0x0E, 0xE3, 0xDC, 0x7B, 0x8E, 0x7F, 0xCF, 0xF8, 0xF7,
  0x00, 0xF1, 0xEE, 0x39, 0xCF, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0xC3, 0xB8,
  0x7E, 0x0F, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x00, 0xE3, 0x1F, 0xCE,
  0x3B, 0x9C, 0x77, 0x79, 0xCE, 0xF3, 0x9D, 0xF7, 0x3F, 0xFC, 0x7D, 0xF8,
  0xFB, 0xE1, 0xF7, 0xC3, 0xC7, 0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x00,
  0x1C, 0x78, 0xE7, 0x87, 0x38, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x70, 0x73, 0x87, 0x9C, 0x38, 0xF0, 0x3C,
  0x78, 0xE3, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x81, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x7F, 0xCF, 0xF9,
  0xFF, 0x00, 0x02, 0x07, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0xF0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60,
  0x70, 0x30, 0x10, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C,
  0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x80, 0x08, 0x1C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x38, 0x37, 0xE3,
  0x7E, 0x7E, 0x7E, 0xE3, 0xEC, 0x1C,
};

const GFXglyph RobotoCondensed_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 19, 6, 1, -19 },
  { 16, 7, 7, 8, 2, -20 },
  { 23, 13, 19, 13, 1, -19 },
  { 54, 11, 24, 13, 1, -22 },
  { 87, 12, 19, 16, 2, -19 },
  { 116, 13, 19, 14, 0, -19 },
  { 147, 3, 7, 4, 2, -20 },
  { 150, 8, 27, 8, 1, -21 },
  { 177, 8, 27, 8, -1, -21 },
  { 204, 11, 11, 11, 1, -19 },
  { 220, 11, 13, 12, 1, -15 },
  { 238, 5, 7, 6, -1, -3 },
  { 243, 6, 3, 8, 1, -10 },
  { 246, 3, 4, 7, 1, -4 },
  { 248, 12, 21, 9, -2, -19 },
  { 280, 11, 19, 13, 1, -19 },
  { 307, 7, 19, 13, 3, -19 },
  { 324, 12, 19, 13, 0, -19 },
  { 353, 12, 19, 13, 0, -19 },
  { 382, 12, 19, 13, 0, -19 },
  { 411, 12, 19, 13, 1, -19 },
  { 440, 11, 19, 13, 1, -19 },
  { 467, 12, 19, 13, 1, -19 },
  { 496, 11, 19, 13, 1, -19 },
  { 523, 10, 19, 13, 2, -19 },
  { 547, 5, 15, 7, 1, -15 },
  { 557, 7, 19, 6, -1, -15 },
  { 574, 10, 12, 11, 1, -14 },
  { 589, 11, 9, 13, 1, -13 },
  { 602, 10, 12, 11, 1, -14 },
  { 617, 9, 19, 11, 2, -19 },
  { 639, 17, 24, 19, 1, -18 },
  { 690, 14, 19, 15, -1, -19 },
  { 724, 14, 19, 14, 0, -19 },
  { 758, 13, 19, 14, 1, -19 },
  { 789, 14, 19, 14, 0, -19 },
  { 823, 14, 19, 12, 0, -19 },
  { 857, 13, 19, 12, 0, -19 },
  { 888, 13, 19, 15, 1, -19 },
  { 919, 16, 19, 16, 0, -19 },
  { 957, 7, 19, 7, 0, -19 },
  { 974, 13, 19, 12, 0, -19 },
  { 1005, 16, 19, 14, 0, -19 },
  { 1043, 11, 19, 12, 0, -19 },
  { 1070, 19, 19, 19, 0, -19 },
  { 1116, 16, 19, 15, 0, -19 },
  { 1154, 14, 19, 15, 1, -19 },
  { 1188, 14, 19, 14, 0, -19 },
  { 1222, 14, 22, 15, 1, -19 },
  { 1261, 14, 19, 14, 0, -19 },
  { 1295, 13, 19, 14, 1, -19 },
  { 1326, 13, 19, 14, 2, -19 },
  { 1357, 14, 19, 14, 1, -19 },
  { 1391, 14, 19, 14, 2, -19 },
  { 1425, 18, 19, 19, 2, -19 },
  { 1468, 16, 19, 14, -1, -19 },
  { 1506, 13, 19, 14, 2, -19 },
  { 1537, 14, 19, 13, 0, -19 },
  { 1571, 8, 25, 7, 0, -21 },
  { 1596, 6, 21, 10, 2, -19 },
  { 1612, 8, 25, 7, -1, -21 },
  { 1637, 8, 9, 10, 1, -19 },
  { 1646, 11, 3, 10, -2, 0 },
  { 1651, 5, 4, 8, 3, -20 },
  { 1654, 11, 14, 12, 0, -14 },
  { 1674, 12, 20, 12, 0, -20 },
  { 1704, 10, 14, 12, 1, -14 },
  { 1722, 12, 20, 13, 1, -20 },
  { 1752, 10, 14, 12, 1, -14 },
  { 1770, 9, 20, 8, 1, -20 },
  { 1793, 12, 19, 13, 0, -14 },
  { 1822, 11, 20, 12, 0, -20 },
  { 1850, 7, 20, 6, 0, -20 },
  { 1868, 9, 25, 6, -3, -20 },
  { 1897, 13, 20, 12, 0, -20 },
  { 1930, 7, 20, 6, 0, -20 },
  { 1948, 18, 14, 19, 0, -14 },
  { 1980, 11, 14, 12, 0, -14 },
  { 2000, 11, 14, 13, 1, -14 },
  { 2020, 13, 19, 12, -1, -14 },
  { 2051, 11, 19, 13, 1, -14 },
  { 2078, 9, 14, 8, 0, -14 },
  { 2094, 11, 14, 11, 0, -14 },
  { 2114, 7, 17, 8, 1, -17 },
  { 2129, 11, 14, 12, 1, -14 },
  { 2149, 11, 14, 11, 1, -14 },
  { 2169, 15, 14, 16, 2, -14 },
  { 2196, 13, 14, 11, -1, -14 },
  { 2219, 13, 19, 11, -1, -14 },
  { 2250, 11, 14, 11, 0, -14 },
  { 2270, 8, 25, 8, 1, -20 },
  { 2295, 6, 22, 6, 0, -19 },
  { 2312, 8, 25, 8, -1, -20 },
  { 2337, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC26PT7B_H_
