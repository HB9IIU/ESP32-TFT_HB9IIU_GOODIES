#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC18PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x18, 0x8C, 0x60, 0x19, 0xC4, 0x00, 0x6A, 0xD7,
  0xBD, 0x00, 0x04, 0x86, 0xC3, 0x41, 0x23, 0xF8, 0xD0, 0x48, 0x2C, 0x7F,
  0x12, 0x0B, 0x0D, 0x86, 0x80, 0x0C, 0x0C, 0x1C, 0x3E, 0x66, 0x67, 0x60,
  0x70, 0x3C, 0x0C, 0x0E, 0xCE, 0xCC, 0xFC, 0x78, 0x20, 0x20, 0x70, 0xD0,
  0x92, 0x96, 0xBC, 0xE8, 0x18, 0x3E, 0x2B, 0x79, 0xDB, 0x9B, 0x0E, 0x0E,
  0x0F, 0x8C, 0xC6, 0x63, 0x60, 0xE0, 0xE0, 0xFB, 0x6D, 0xF3, 0xB9, 0xCF,
  0xE3, 0xF8, 0x69, 0x6C, 0x08, 0xCC, 0x66, 0x31, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x08, 0x61, 0x00, 0x10, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x31,
  0x86, 0x18, 0xC3, 0x18, 0xE2, 0x00, 0x18, 0x33, 0x6F, 0xF3, 0x8F, 0x13,
  0x24, 0x18, 0x30, 0x61, 0xCF, 0xFF, 0xCC, 0x18, 0x30, 0x60, 0x26, 0x66,
  0xC0, 0xFF, 0x5D, 0x80, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x1C, 0x7D, 0x9B, 0x3E, 0x78, 0xF1,
  0xE3, 0xC7, 0x9F, 0x37, 0xE7, 0x80, 0x0B, 0xFF, 0x73, 0x18, 0xC6, 0x33,
  0x98, 0xC6, 0x00, 0x1E, 0x3F, 0x33, 0x73, 0x03, 0x07, 0x06, 0x0C, 0x18,
  0x38, 0x70, 0xFF, 0xFE, 0x1E, 0x3F, 0x33, 0x03, 0x03, 0x1E, 0x1E, 0x06,
  0x07, 0xE7, 0xE6, 0x7E, 0x3C, 0x03, 0x07, 0x0F, 0x0F, 0x1F, 0x36, 0x36,
  0x66, 0xFF, 0xFF, 0x0E, 0x0C, 0x0C, 0x3F, 0x3F, 0x60, 0x60, 0x7C, 0xFC,
  0x0E, 0x06, 0x06, 0xCE, 0xCC, 0xFC, 0x78, 0x0E, 0x78, 0xC3, 0x07, 0xDF,
  0xF1, 0xE3, 0xC7, 0x8F, 0x37, 0xE7, 0x80, 0x7F, 0x7F, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x0E, 0x3F, 0x33, 0x33,
  0x33, 0x3E, 0x3E, 0x66, 0x67, 0x67, 0x66, 0x7E, 0x3C, 0x1C, 0xFD, 0x9B,
  0x3E, 0x78, 0xF9, 0xBF, 0x7E, 0x18, 0x73, 0xC6, 0x00, 0x03, 0x30, 0x00,
  0x04, 0xE6, 0x10, 0xC6, 0x00, 0x00, 0x00, 0x31, 0x98, 0xCC, 0x00, 0x02,
  0x0C, 0x7B, 0xC6, 0x1E, 0x0F, 0x06, 0x04, 0x7F, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x20, 0x30, 0x3C, 0x0F, 0x06, 0x1E, 0x78, 0x60, 0x80, 0x3C, 0xFB,
  0xB8, 0x70, 0xC3, 0x8E, 0x18, 0x20, 0x00, 0x03, 0x06, 0x00, 0x03, 0xC0,
  0x73, 0x86, 0x04, 0x60, 0x22, 0x39, 0xB3, 0x6D, 0xB2, 0x69, 0x93, 0xC9,
  0x96, 0x4C, 0xB3, 0xE9, 0x9D, 0x84, 0x00, 0x30, 0x00, 0xCC, 0x03, 0xC0,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x0D, 0x83, 0x61, 0xD8, 0x66, 0x3F, 0xCF,
  0xF7, 0x0D, 0x83, 0x60, 0xC0, 0x3F, 0x1F, 0xCC, 0x66, 0x33, 0x1B, 0xF9,
  0xFC, 0xC6, 0x63, 0xB1, 0xD8, 0xDF, 0xEF, 0xE0, 0x1E, 0x1F, 0x9C, 0xEC,
  0x3E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x3E,
  0x0F, 0xE3, 0x18, 0xC6, 0x31, 0x9C, 0x67, 0x19, 0x86, 0x61, 0x98, 0xE6,
  0x73, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0xCC, 0x06, 0x03, 0x03, 0xF9, 0xFC,
  0xC0, 0x60, 0x30, 0x18, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xCC, 0x06, 0x03,
  0x03, 0x81, 0xFC, 0xFC, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x1E, 0x1F,
  0x9C, 0xEC, 0x3E, 0x07, 0x03, 0x3F, 0x9E, 0xC3, 0x61, 0xB8, 0xCF, 0xE3,
  0xC0, 0x38, 0x66, 0x1C, 0xC3, 0x98, 0x63, 0x0C, 0xFF, 0x9F, 0xF3, 0x0E,
  0x61, 0xCC, 0x31, 0x86, 0x70, 0xCE, 0x18, 0x39, 0xCC, 0x63, 0x19, 0xCC,
  0x63, 0x18, 0xCE, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0E, 0x06, 0x63, 0x3B, 0x8F, 0x87, 0x80, 0x38, 0xE6, 0x38, 0xCE, 0x1B,
  0x83, 0x60, 0xF8, 0x1F, 0x03, 0xF0, 0x76, 0x0C, 0xC1, 0x9C, 0x71, 0x8E,
  0x38, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0xFF,
  0xE0, 0x38, 0x39, 0xC1, 0xCF, 0x1E, 0x78, 0xF3, 0xCD, 0xBE, 0x7D, 0xB3,
  0xCD, 0xB6, 0x6D, 0xB3, 0x39, 0x99, 0xDD, 0xCC, 0xCE, 0x66, 0x00, 0x38,
  0x67, 0x1C, 0xE3, 0x9E, 0x63, 0xCC, 0xF9, 0x9D, 0x33, 0x3E, 0x67, 0x8C,
  0x71, 0x8E, 0x71, 0xCE, 0x38, 0x1E, 0x1F, 0x9C, 0xEC, 0x3E, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xB9, 0xCF, 0xC3, 0xC0, 0x3F, 0x0F, 0xE3, 0x1C,
  0xC3, 0x31, 0xDC, 0x67, 0xF9, 0xFC, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0x61,
  0xB1, 0xCF, 0xC3, 0xE0, 0x30, 0x08, 0x3F, 0x0F, 0xE3, 0x18, 0xC6, 0x31,
  0x9C, 0xE7, 0xF1, 0xF8, 0x66, 0x19, 0xC6, 0x73, 0x8C, 0xE3, 0x00, 0x0F,
  0x0F, 0xCC, 0x66, 0x33, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x71, 0x98, 0xCF,
  0xE3, 0xC0, 0x7F, 0xBF, 0xC7, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x00, 0x61, 0xB0, 0xD8, 0x6C, 0x7E, 0x3F, 0x1B,
  0x0D, 0x86, 0xC3, 0x63, 0xB1, 0x9F, 0xC7, 0xC0, 0xE1, 0xD8, 0x66, 0x39,
  0x8C, 0x63, 0x19, 0xC6, 0x61, 0x98, 0x7C, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0xC6, 0x7C, 0xE6, 0xCE, 0x6C, 0xE6, 0xDE, 0xCD, 0xEC, 0xD6, 0xCF,
  0x78, 0xF7, 0x8E, 0x78, 0xE7, 0x8E, 0x70, 0xC7, 0x00, 0x18, 0x61, 0xCE,
  0x1D, 0xC0, 0xD8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xB0,
  0x3B, 0x87, 0x18, 0x61, 0x80, 0xC3, 0x63, 0xB1, 0x9D, 0xC6, 0xC3, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x00, 0x3F, 0xCF, 0xF0, 0x38,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0xFC, 0xFF,
  0x00, 0x3C, 0xE3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x8C,
  0x30, 0xE3, 0x80, 0xCC, 0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x67, 0x1C, 0x71,
  0xC6, 0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC3, 0x1C, 0xE3, 0x80,
  0x19, 0xCE, 0xFC, 0xE4, 0xFF, 0xFC, 0xCD, 0x80, 0x1C, 0x3E, 0x77, 0x06,
  0x3E, 0x76, 0xE6, 0xE6, 0xFE, 0x76, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x7F,
  0x73, 0x63, 0x63, 0x63, 0x63, 0xE6, 0xFE, 0xDC, 0x1C, 0x3E, 0x67, 0x63,
  0x60, 0x60, 0xE0, 0x66, 0x7E, 0x3C, 0x01, 0x80, 0xC0, 0xE0, 0x73, 0xB1,
  0xF9, 0x8C, 0xC6, 0x67, 0x73, 0xB9, 0x9C, 0xC7, 0xE3, 0xB0, 0x1E, 0x3E,
  0x63, 0x63, 0x7F, 0x7F, 0x60, 0x60, 0x7E, 0x3C, 0x1C, 0xF3, 0x1C, 0xFB,
  0xE6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x00, 0x1F, 0x1F, 0x98, 0xCC, 0x66,
  0x33, 0x3B, 0x98, 0xCC, 0x7E, 0x1F, 0x01, 0x81, 0xCF, 0xC3, 0xC0, 0x30,
  0x30, 0x30, 0x30, 0x3E, 0x7F, 0x63, 0x63, 0x67, 0x66, 0x66, 0xE6, 0xC6,
  0xC6, 0x39, 0x80, 0x63, 0x39, 0x8C, 0x63, 0x19, 0xCC, 0x00, 0x0C, 0x30,
  0x03, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x3C, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x33, 0xB9, 0xB8, 0xF8, 0x78, 0x3E, 0x1B, 0x1D,
  0x8C, 0xE6, 0x30, 0x39, 0x8C, 0x63, 0x19, 0xCC, 0x63, 0x18, 0xCE, 0x60,
  0x3E, 0xE7, 0xFF, 0x67, 0x36, 0x33, 0x67, 0x36, 0x63, 0x66, 0x7E, 0x67,
  0xC6, 0x6C, 0x66, 0x3E, 0x7F, 0x63, 0x63, 0x67, 0x66, 0x66, 0xE6, 0xC6,
  0xC6, 0x1E, 0x3F, 0x73, 0x63, 0x63, 0x63, 0xE3, 0x66, 0x7E, 0x3C, 0x1F,
  0x1F, 0xCE, 0x66, 0x33, 0x19, 0x8C, 0xCE, 0xE6, 0x7F, 0x37, 0x18, 0x0C,
  0x06, 0x07, 0x00, 0x3F, 0x3F, 0x63, 0x63, 0x67, 0xE7, 0xE6, 0x66, 0x7E,
  0x76, 0x0E, 0x0E, 0x0C, 0x0C, 0x3D, 0xF7, 0x18, 0x61, 0x86, 0x38, 0xC3,
  0x00, 0x1C, 0x3E, 0x66, 0x60, 0x38, 0x1C, 0x0E, 0xC6, 0x7C, 0x78, 0x73,
  0x3D, 0xE6, 0x33, 0x98, 0xC6, 0x38, 0xC0, 0x67, 0xCF, 0x1E, 0x3C, 0xF9,
  0xB3, 0x66, 0xFD, 0xD8, 0xC7, 0x9F, 0x36, 0x6D, 0x8B, 0x1E, 0x38, 0x70,
  0xC0, 0xCC, 0xD9, 0x9B, 0x73, 0x6E, 0xCD, 0x59, 0xEB, 0x3D, 0xC7, 0x38,
  0xE6, 0x18, 0xC0, 0x3B, 0x8D, 0x87, 0xC3, 0xC1, 0xE0, 0xE0, 0x78, 0x6C,
  0x76, 0x33, 0x80, 0x31, 0x99, 0xCC, 0xC6, 0xE3, 0x60, 0xB0, 0x70, 0x38,
  0x1C, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x00, 0x7F, 0x7F, 0x0E, 0x0C, 0x18,
  0x38, 0x70, 0x60, 0xFC, 0xFC, 0x04, 0x71, 0x86, 0x30, 0xC3, 0x18, 0xE1,
  0x86, 0x18, 0x61, 0x86, 0x08, 0x20, 0x13, 0x33, 0x22, 0x26, 0x66, 0x44,
  0x44, 0xC0, 0x10, 0x61, 0x86, 0x18, 0x61, 0x87, 0x1C, 0xE3, 0x0C, 0x30,
  0xC6, 0x18, 0x40, 0x73, 0xFB, 0xDF, 0x8E,
};

const GFXglyph RobotoCondensed_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 4, 0, -13 },
  { 10, 5, 5, 6, 1, -14 },
  { 14, 9, 13, 9, 0, -13 },
  { 29, 8, 17, 9, 1, -15 },
  { 46, 8, 13, 11, 2, -13 },
  { 59, 9, 13, 10, 0, -13 },
  { 74, 3, 5, 3, 1, -14 },
  { 76, 5, 18, 6, 1, -14 },
  { 88, 6, 18, 6, -1, -14 },
  { 102, 7, 8, 8, 1, -13 },
  { 109, 7, 10, 8, 1, -11 },
  { 118, 4, 5, 4, -1, -2 },
  { 121, 4, 2, 6, 1, -7 },
  { 122, 3, 3, 5, 0, -3 },
  { 124, 8, 14, 6, -1, -13 },
  { 138, 7, 13, 9, 1, -13 },
  { 150, 5, 13, 9, 2, -13 },
  { 159, 8, 13, 9, 0, -13 },
  { 172, 8, 13, 9, 0, -13 },
  { 185, 8, 13, 9, 0, -13 },
  { 198, 8, 13, 9, 1, -13 },
  { 211, 7, 13, 9, 1, -13 },
  { 223, 8, 13, 9, 1, -13 },
  { 236, 8, 13, 9, 0, -13 },
  { 249, 7, 13, 9, 1, -13 },
  { 261, 4, 10, 5, 0, -10 },
  { 266, 5, 13, 4, -1, -10 },
  { 275, 7, 9, 8, 0, -10 },
  { 283, 7, 6, 9, 1, -9 },
  { 289, 8, 9, 8, 0, -10 },
  { 298, 7, 13, 8, 1, -13 },
  { 310, 13, 16, 13, 0, -12 },
  { 336, 10, 13, 10, -1, -13 },
  { 353, 9, 13, 10, 0, -13 },
  { 368, 9, 13, 10, 1, -13 },
  { 383, 10, 13, 10, 0, -13 },
  { 400, 9, 13, 9, 0, -13 },
  { 415, 9, 13, 8, 0, -13 },
  { 430, 9, 13, 10, 1, -13 },
  { 445, 11, 13, 11, 0, -13 },
  { 463, 5, 13, 5, 0, -13 },
  { 472, 9, 13, 9, 0, -13 },
  { 487, 11, 13, 10, 0, -13 },
  { 505, 7, 13, 8, 0, -13 },
  { 517, 13, 13, 13, 0, -13 },
  { 539, 11, 13, 11, 0, -13 },
  { 557, 9, 13, 11, 1, -13 },
  { 572, 10, 13, 10, 0, -13 },
  { 589, 9, 15, 11, 1, -13 },
  { 606, 10, 13, 10, 0, -13 },
  { 623, 9, 13, 9, 0, -13 },
  { 638, 9, 13, 9, 1, -13 },
  { 653, 9, 13, 10, 1, -13 },
  { 668, 10, 13, 10, 1, -13 },
  { 685, 12, 13, 13, 2, -13 },
  { 705, 12, 13, 10, -1, -13 },
  { 725, 9, 13, 9, 2, -13 },
  { 740, 10, 13, 9, 0, -13 },
  { 757, 6, 18, 5, 0, -15 },
  { 771, 4, 14, 7, 2, -13 },
  { 778, 6, 18, 5, -1, -15 },
  { 792, 5, 6, 7, 1, -13 },
  { 796, 7, 2, 7, -1, 0 },
  { 798, 3, 3, 6, 2, -14 },
  { 800, 8, 10, 8, 0, -10 },
  { 810, 8, 14, 9, 0, -14 },
  { 824, 8, 10, 8, 0, -10 },
  { 834, 9, 14, 9, 0, -14 },
  { 850, 8, 10, 8, 0, -10 },
  { 860, 6, 14, 6, 1, -14 },
  { 871, 9, 14, 9, 0, -10 },
  { 887, 8, 14, 9, 0, -14 },
  { 901, 5, 13, 4, 0, -13 },
  { 910, 6, 17, 4, -2, -13 },
  { 923, 9, 14, 8, 0, -14 },
  { 939, 5, 14, 4, 0, -14 },
  { 948, 12, 10, 13, 0, -10 },
  { 963, 8, 10, 9, 0, -10 },
  { 973, 8, 10, 9, 0, -10 },
  { 983, 9, 14, 9, -1, -10 },
  { 999, 8, 14, 9, 0, -10 },
  { 1013, 6, 10, 6, 0, -10 },
  { 1021, 8, 10, 8, 0, -10 },
  { 1031, 5, 12, 5, 1, -12 },
  { 1039, 7, 10, 9, 1, -10 },
  { 1048, 7, 10, 8, 1, -10 },
  { 1057, 11, 10, 11, 1, -10 },
  { 1071, 9, 10, 8, -1, -10 },
  { 1083, 9, 14, 8, -1, -10 },
  { 1099, 8, 10, 8, 0, -10 },
  { 1109, 6, 17, 5, 0, -14 },
  { 1122, 4, 15, 4, 0, -13 },
  { 1130, 6, 17, 5, -1, -14 },
  { 1143, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC18PT7B_H_
