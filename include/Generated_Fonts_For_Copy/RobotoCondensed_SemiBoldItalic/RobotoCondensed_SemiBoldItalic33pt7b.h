#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC33PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x78, 0x78, 0x78, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xF0, 0xE0,
  0x3B, 0xB9, 0xDC, 0xEE, 0x77, 0x3B, 0x99, 0x8D, 0xCE, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0xC6, 0x01, 0xCE, 0x01, 0xCE, 0x01, 0x8C, 0x03, 0x9C, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0x38, 0x06, 0x30, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x60, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x39, 0xC0, 0x39,
  0xC0, 0x31, 0x80, 0x73, 0x80, 0x73, 0x80, 0x63, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x87, 0xFF, 0x0F, 0x1E,
  0x1E, 0x3C, 0x78, 0x3C, 0xF0, 0x78, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0x18, 0x6E,
  0x39, 0xDC, 0x63, 0x38, 0xCE, 0x73, 0xB8, 0xFF, 0xE0, 0xFD, 0xC0, 0xF7,
  0x00, 0x1C, 0x00, 0x37, 0x80, 0xFF, 0x83, 0xFF, 0x8E, 0xE7, 0x19, 0xC6,
  0x73, 0x8D, 0xC6, 0x3F, 0x0E, 0x72, 0x1F, 0xE0, 0x1F, 0x80, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x38,
  0x1E, 0x38, 0x1E, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x8F,
  0x3F, 0x8F, 0x7B, 0xCE, 0xFB, 0xFE, 0xF1, 0xFE, 0xF1, 0xFC, 0xF0, 0xFC,
  0xF0, 0xF8, 0xF9, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x1F, 0x1E, 0x7B, 0x9C,
  0xE7, 0x39, 0x9C, 0xE0, 0x00, 0x80, 0x60, 0x3C, 0x1E, 0x0F, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x10, 0x00, 0x04, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F,
  0x03, 0x00, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x06, 0x31,
  0xFD, 0xFF, 0xFF, 0xE1, 0xF8, 0x0F, 0x00, 0xFC, 0x0E, 0x60, 0xE3, 0x87,
  0x1C, 0x10, 0x40, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x38, 0x71,
  0xE3, 0xC7, 0x1E, 0x78, 0x60, 0x7F, 0x7F, 0xFF, 0x67, 0xBD, 0xE7, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xDF, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xFF,
  0x87, 0xBC, 0x1E, 0xF0, 0x79, 0xC1, 0xE7, 0x8F, 0x1F, 0x7C, 0x7F, 0xE0,
  0xFF, 0x01, 0xF8, 0x00, 0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xF7, 0x7A, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x0F, 0xBE, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xDF, 0x3C,
  0x3C, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x7F, 0x01,
  0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF,
  0x0F, 0x3F, 0xFC, 0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xDE,
  0x07, 0xBC, 0x0E, 0x78, 0x3D, 0xF0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E,
  0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF1, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3D, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE1, 0xE7, 0xC0, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0xE3, 0xE3, 0xEF, 0x87, 0xFE, 0x07, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x3D, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xBE, 0x78, 0x79,
  0xE1, 0xF7, 0x83, 0xDE, 0x1F, 0x70, 0x79, 0xE1, 0xE7, 0x8F, 0x9F, 0x7C,
  0x3F, 0xE0, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xE1, 0xE3, 0xC7,
  0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFF, 0x0F, 0x9E, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC3, 0xC7, 0xEF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0xFF, 0x0F, 0xFC, 0x7D, 0xE7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x3E, 0xFB, 0xF7, 0xFF, 0x9F, 0xF8, 0x7B, 0xC0, 0x1E,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00,
  0x18, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x3C, 0x78, 0xF0, 0xE0, 0x03, 0x01, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1C, 0x02, 0x00, 0x00, 0x08, 0x03,
  0x80, 0x7C, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x1E, 0x00, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3C, 0x00, 0xE0, 0x01, 0x00, 0x3F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0x00, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x7E,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x01, 0xF0, 0x3F, 0x87, 0xF9,
  0xFF, 0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F, 0x81, 0xFE, 0x3F,
  0xF7, 0xFF, 0x78, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x07, 0x80, 0x7C, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x07, 0x83, 0x38, 0x7F, 0x8C, 0xE3, 0xFE, 0x37, 0x0E,
  0x38, 0xDC, 0x70, 0xC3, 0x71, 0xC7, 0x0F, 0x8E, 0x1C, 0x3E, 0x38, 0x71,
  0xF8, 0xE1, 0x87, 0xE3, 0x8E, 0x1B, 0x9E, 0x38, 0x6C, 0x78, 0xE3, 0xB1,
  0xE7, 0x8C, 0xC3, 0xFE, 0xF3, 0x8F, 0xFF, 0x8E, 0x1C, 0x7C, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xBC,
  0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x03,
  0xC1, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xC0,
  0x79, 0xF0, 0x1E, 0x78, 0x07, 0xBE, 0x01, 0xFF, 0x00, 0x7C, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x0F, 0x87, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F,
  0x9E, 0x07, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x80, 0x01,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF9, 0xF0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0xF8, 0x1E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF8, 0xF8,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7,
  0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F,
  0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1,
  0xF0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x0F, 0xE7, 0x87, 0xF3, 0xC7, 0xF9, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x9F, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x03, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8,
  0x0F, 0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x1F, 0x80, 0x0F, 0x03, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8,
  0x0F, 0x1F, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x1E, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78,
  0x3C, 0x07, 0x83, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1F, 0x00,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xEF, 0x07, 0x38, 0xF7,
  0x87, 0x9C, 0x73, 0xC3, 0xCE, 0x7B, 0xC1, 0xE7, 0x39, 0xE0, 0xF3, 0x9C,
  0xF0, 0x79, 0xDE, 0x78, 0x7C, 0xEE, 0x3C, 0x3C, 0x7F, 0x3E, 0x1E, 0x3F,
  0x1E, 0x0F, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xC3, 0xE1,
  0xC3, 0xE0, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E,
  0x0F, 0xC1, 0xE1, 0xFC, 0x1E, 0x1F, 0xC1, 0xE1, 0xFE, 0x1E, 0x1E, 0xE3,
  0xE1, 0xEE, 0x3C, 0x1E, 0xE3, 0xC3, 0xE7, 0x3C, 0x3C, 0x73, 0xC3, 0xC7,
  0x7C, 0x3C, 0x7F, 0xC3, 0xC3, 0xF8, 0x7C, 0x3F, 0x87, 0xC3, 0xF8, 0x78,
  0x1F, 0x87, 0x81, 0xF8, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x8F,
  0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0x07, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xEF, 0x80, 0xF3, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0x87, 0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0x87, 0xC1, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x7C, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x78, 0x3E, 0x1E, 0x07, 0x8F, 0x81,
  0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x0F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xC7,
  0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C,
  0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E,
  0x0F, 0x8F, 0x83, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x81, 0xE7,
  0xC1, 0xF3, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x00, 0xE7, 0x80, 0x77, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF7, 0x87,
  0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x1F, 0x0F, 0x3C, 0x7E, 0x3C, 0x78, 0xFC,
  0x78, 0xF3, 0xF8, 0xF1, 0xE7, 0xF3, 0xC3, 0xCE, 0xE7, 0x87, 0xBD, 0xCF,
  0x0F, 0x73, 0xBC, 0x1E, 0xE7, 0x78, 0x3F, 0xCE, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xF0,
  0xF8, 0x3E, 0x07, 0x83, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0xF8,
  0x03, 0xCF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7B,
  0xC0, 0x0F, 0xBE, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x03, 0xE1, 0xF0, 0x3E,
  0x1F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x3C, 0xF0, 0x3D,
  0xE0, 0x3D, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xFC, 0x1F, 0x83, 0xE0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0x03,
  0x80, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xEE, 0x39, 0xCF,
  0x39, 0xC3, 0xF8, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0xF0, 0xF0,
  0xE1, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x9F, 0x3C, 0x3C, 0x00,
  0xF0, 0x03, 0xC1, 0xFE, 0x1F, 0xF8, 0xFF, 0xE7, 0x87, 0x9E, 0x1E, 0xF8,
  0xF9, 0xE7, 0xC7, 0xFF, 0x1F, 0xFC, 0x1E, 0xF0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF,
  0xDF, 0x3F, 0xFE, 0x7B, 0xF8, 0xF3, 0xE0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC,
  0x7D, 0xF7, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE1, 0xEF, 0x0F, 0x7F, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x0F, 0xBC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x78,
  0x7C, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3E,
  0xF0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7D, 0xF7, 0x87, 0xBC, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x02, 0x7E, 0xF1,
  0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F, 0x83, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xCF, 0x0F, 0xEE, 0x1F,
  0xFE, 0x3F, 0x7E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x40, 0xF0, 0x73,
  0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0xF0, 0x7F,
  0xE3, 0xFF, 0xCF, 0xDF, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x78,
  0x3D, 0xE0, 0xF7, 0x87, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0xF0, 0x02, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x7F, 0x0F, 0xC1, 0xF0, 0x3C, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x3C, 0xF8, 0x3D, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7D, 0xE0,
  0x79, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF8, 0xF0, 0x78,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xF0, 0xF0, 0x00, 0x1E, 0xF0, 0xF0, 0x7F, 0xE7, 0xF1, 0xFF,
  0xFF, 0xCF, 0xDF, 0xDF, 0x3C, 0x3E, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3,
  0xCF, 0x0F, 0x0F, 0x3C, 0x3C, 0x3D, 0xE0, 0xF0, 0xF7, 0x87, 0x87, 0xDE,
  0x1E, 0x1E, 0x78, 0x78, 0x79, 0xE1, 0xE1, 0xEF, 0x87, 0x87, 0xBC, 0x3E,
  0x1E, 0xF0, 0xF0, 0xF8, 0x1E, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xDF, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x7C, 0x3D, 0xE0, 0xF7, 0x87, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF0, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x8F, 0xBE, 0x78, 0x7D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xF7, 0xC7, 0xFE,
  0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0x78, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xBE,
  0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0x7C, 0x3F, 0xFC, 0x7B, 0xF8,
  0x79, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x9C, 0x7F, 0xF3, 0xFF, 0xDF, 0xBF, 0x78,
  0x7D, 0xE1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC,
  0x3C, 0xF0, 0xF3, 0xEF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3E, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x1E, 0xE3,
  0xFC, 0x7F, 0x9F, 0xF3, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3C, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x3C, 0x3C, 0xF0, 0xF1, 0xE3, 0xC7, 0xFF,
  0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE3, 0xFF, 0xFF,
  0xFF, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x8F, 0xC7, 0xE1, 0xE0, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xDE, 0x0F,
  0x78, 0x3D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xC1, 0xEF, 0x0F,
  0xBC, 0x3C, 0xF0, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C, 0xE0, 0xF0,
  0xFF, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0x1E, 0x78, 0xF1, 0xCF, 0x0E, 0x78,
  0x77, 0x83, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x8F, 0x78, 0xF1,
  0xEF, 0x3E, 0x39, 0xE7, 0xCF, 0x3D, 0xF9, 0xE7, 0xBF, 0x38, 0xFF, 0x7F,
  0x1F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x00, 0x1E, 0x1F, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF0, 0x78, 0x78, 0xF8, 0x78, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0,
  0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x0F, 0x01, 0x80, 0x20, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38,
  0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38,
  0x70, 0xE1, 0x83, 0x00, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x0F,
  0x07, 0xC3, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x02, 0x00, 0x1E, 0x00, 0x3F, 0x07,
  0x7F, 0x8F, 0x7F, 0xFE, 0x71, 0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 23, 8, 1, -23 },
  { 24, 9, 9, 10, 2, -25 },
  { 35, 16, 23, 17, 1, -23 },
  { 81, 15, 29, 16, 1, -26 },
  { 136, 15, 23, 20, 3, -23 },
  { 180, 16, 23, 18, 1, -23 },
  { 226, 5, 9, 5, 2, -25 },
  { 232, 10, 33, 10, 2, -26 },
  { 274, 10, 33, 10, -1, -26 },
  { 316, 13, 14, 14, 2, -23 },
  { 339, 14, 17, 15, 1, -19 },
  { 369, 7, 9, 7, -2, -4 },
  { 377, 8, 3, 11, 1, -11 },
  { 380, 5, 5, 9, 1, -5 },
  { 384, 15, 25, 11, -2, -23 },
  { 431, 14, 23, 16, 1, -23 },
  { 472, 9, 23, 16, 4, -23 },
  { 498, 16, 23, 16, 0, -23 },
  { 544, 14, 23, 16, 1, -23 },
  { 585, 15, 23, 16, 0, -23 },
  { 629, 15, 23, 16, 1, -23 },
  { 673, 14, 23, 16, 1, -23 },
  { 714, 15, 23, 16, 2, -23 },
  { 758, 15, 23, 16, 1, -23 },
  { 802, 13, 23, 16, 2, -23 },
  { 840, 7, 18, 9, 1, -18 },
  { 856, 10, 23, 8, -2, -18 },
  { 885, 13, 15, 14, 1, -18 },
  { 910, 14, 11, 16, 1, -16 },
  { 930, 13, 16, 15, 1, -18 },
  { 956, 12, 23, 14, 2, -23 },
  { 991, 22, 30, 25, 1, -23 },
  { 1074, 18, 23, 19, -1, -23 },
  { 1126, 17, 23, 18, 0, -23 },
  { 1175, 17, 23, 18, 1, -23 },
  { 1224, 17, 23, 18, 0, -23 },
  { 1273, 17, 23, 16, 0, -23 },
  { 1322, 17, 23, 15, 0, -23 },
  { 1371, 17, 23, 19, 1, -23 },
  { 1420, 20, 23, 20, 0, -23 },
  { 1478, 9, 23, 8, 0, -23 },
  { 1504, 16, 23, 16, 0, -23 },
  { 1550, 20, 23, 18, 0, -23 },
  { 1608, 13, 23, 15, 0, -23 },
  { 1646, 25, 23, 24, 0, -23 },
  { 1718, 20, 23, 20, 0, -23 },
  { 1776, 18, 23, 19, 1, -23 },
  { 1828, 18, 23, 18, 0, -23 },
  { 1880, 18, 27, 19, 1, -23 },
  { 1941, 18, 23, 18, 0, -23 },
  { 1993, 16, 23, 17, 1, -23 },
  { 2039, 16, 23, 17, 3, -23 },
  { 2085, 18, 23, 18, 1, -23 },
  { 2137, 17, 23, 18, 3, -23 },
  { 2186, 23, 23, 24, 3, -23 },
  { 2253, 20, 23, 18, -1, -23 },
  { 2311, 16, 23, 17, 3, -23 },
  { 2357, 18, 23, 17, 0, -23 },
  { 2409, 11, 32, 8, -1, -27 },
  { 2453, 7, 25, 12, 3, -23 },
  { 2475, 11, 32, 8, -2, -27 },
  { 2519, 11, 12, 12, 1, -23 },
  { 2536, 13, 3, 13, -2, 0 },
  { 2541, 7, 5, 10, 3, -25 },
  { 2546, 14, 17, 15, 0, -17 },
  { 2576, 15, 25, 16, 0, -25 },
  { 2623, 13, 17, 15, 1, -17 },
  { 2651, 16, 25, 16, 1, -25 },
  { 2701, 13, 17, 15, 1, -17 },
  { 2729, 12, 25, 10, 1, -25 },
  { 2767, 16, 24, 16, 0, -17 },
  { 2815, 14, 25, 16, 0, -25 },
  { 2859, 8, 24, 8, 0, -24 },
  { 2883, 11, 31, 8, -3, -24 },
  { 2926, 16, 25, 15, 0, -25 },
  { 2976, 9, 25, 8, 0, -25 },
  { 3005, 22, 17, 24, 0, -17 },
  { 3052, 14, 17, 16, 0, -17 },
  { 3082, 14, 17, 16, 1, -17 },
  { 3112, 16, 24, 16, -1, -17 },
  { 3160, 14, 24, 16, 1, -17 },
  { 3202, 11, 17, 10, 0, -17 },
  { 3226, 14, 17, 15, 0, -17 },
  { 3256, 9, 22, 10, 1, -22 },
  { 3281, 14, 17, 16, 1, -17 },
  { 3311, 13, 17, 14, 2, -17 },
  { 3339, 19, 17, 20, 2, -17 },
  { 3380, 16, 17, 14, -1, -17 },
  { 3414, 16, 24, 14, -1, -17 },
  { 3462, 14, 17, 14, 0, -17 },
  { 3492, 10, 32, 10, 1, -26 },
  { 3532, 7, 27, 8, 1, -23 },
  { 3556, 10, 32, 10, -1, -26 },
  { 3596, 16, 7, 18, 1, -13 },
};

const GFXfont RobotoCondensed_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC33PT7B_H_
