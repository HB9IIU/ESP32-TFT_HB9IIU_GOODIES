#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC21PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x31, 0xC0, 0x00, 0x63, 0x86,
  0x00, 0x6D, 0xB6, 0xDB, 0x49, 0x20, 0x04, 0x83, 0x60, 0xD8, 0x26, 0x7F,
  0xDF, 0xF1, 0x30, 0xC8, 0x36, 0x3F, 0xCF, 0xF1, 0xB0, 0x6C, 0x12, 0x0D,
  0x80, 0x06, 0x03, 0x07, 0x87, 0xE3, 0x3B, 0x9D, 0xCE, 0xE0, 0x38, 0x0F,
  0x03, 0x80, 0xEC, 0x76, 0x3B, 0x9D, 0xFC, 0x7C, 0x18, 0x0C, 0x00, 0x70,
  0x3E, 0x0C, 0x9B, 0x26, 0xDB, 0x3F, 0x87, 0x40, 0x30, 0x1B, 0x8D, 0xE3,
  0xCD, 0xB3, 0xCC, 0x83, 0xE0, 0x70, 0x0F, 0x03, 0xF0, 0x66, 0x0C, 0xC1,
  0x98, 0x3E, 0x07, 0x80, 0xE0, 0x3E, 0xEE, 0xD9, 0x9F, 0x71, 0xE7, 0x38,
  0xFF, 0x0F, 0x70, 0x6D, 0xAC, 0x04, 0x31, 0xC6, 0x30, 0xC6, 0x18, 0x63,
  0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x04, 0x18, 0x30, 0x80, 0x10, 0x30,
  0x30, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0C,
  0x18, 0x60, 0xC3, 0x0C, 0x10, 0x00, 0x0C, 0x06, 0x03, 0x1F, 0xF7, 0xF1,
  0xE0, 0xF0, 0xCC, 0x44, 0x00, 0x0C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x18,
  0x38, 0x38, 0x30, 0x37, 0x76, 0xEC, 0xFF, 0xC0, 0x6E, 0x60, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x01, 0x80, 0x1E, 0x1F, 0x8C, 0xEE, 0x76, 0x3B, 0x1F, 0x8F,
  0xC6, 0xE3, 0x71, 0xB1, 0xD8, 0xEE, 0xE3, 0xF1, 0xE0, 0x04, 0xF7, 0xFF,
  0x1C, 0x61, 0x86, 0x38, 0xE3, 0x8C, 0x30, 0xC7, 0x00, 0x0F, 0x07, 0xE3,
  0x9C, 0xC7, 0x31, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x3F, 0xEF, 0xF8, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x01, 0xC0, 0xE0,
  0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x3B, 0x8E, 0x67, 0x1F, 0xC3, 0xC0, 0x01,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE1, 0xB8, 0xEC, 0x33, 0x18, 0xCF,
  0xFB, 0xFE, 0x07, 0x01, 0x80, 0x60, 0x3F, 0x9F, 0xCC, 0x06, 0x07, 0x03,
  0xF1, 0xFC, 0xCE, 0x03, 0x01, 0x80, 0xD8, 0xEE, 0x67, 0xF0, 0xF0, 0x07,
  0x1F, 0x3C, 0x30, 0x70, 0x6E, 0xFF, 0xE7, 0xE3, 0xE3, 0xC3, 0xE7, 0xE6,
  0x7E, 0x3C, 0x7F, 0xDF, 0xF0, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x1E, 0x1F, 0x9C,
  0xEE, 0x77, 0x3B, 0x98, 0xF8, 0xFC, 0xE7, 0x63, 0xB1, 0xD8, 0xEE, 0xE7,
  0xF1, 0xE0, 0x1E, 0x1F, 0x9C, 0xCC, 0x76, 0x3F, 0x1D, 0x8E, 0xCE, 0x7F,
  0x1F, 0x81, 0x81, 0xC1, 0xC3, 0xC1, 0xC0, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x03, 0x38, 0xC0, 0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C,
  0x71, 0x8E, 0x10, 0x00, 0x83, 0x87, 0xCF, 0x86, 0x07, 0xC0, 0xF8, 0x1C,
  0x02, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x20, 0x1C, 0x0F, 0x03,
  0xE0, 0x78, 0x3C, 0xFC, 0xF8, 0x70, 0x40, 0x00, 0x1E, 0x7F, 0x77, 0x67,
  0x07, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x60, 0x70, 0x60, 0x01,
  0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x21, 0x9E, 0x66, 0x7C, 0xCD, 0x99,
  0xB3, 0x33, 0x66, 0x66, 0xD8, 0xCD, 0x33, 0x16, 0x66, 0x2C, 0xCC, 0xD9,
  0xFF, 0x11, 0xDC, 0x20, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0xE0,
  0xCE, 0x1C, 0xE1, 0x8E, 0x3F, 0xE3, 0xFE, 0x70, 0x67, 0x07, 0xE0, 0x70,
  0x1F, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0x8F, 0xE3, 0xFC, 0x71,
  0xCE, 0x39, 0xC7, 0x30, 0xE6, 0x39, 0xFF, 0x3F, 0x80, 0x0F, 0x83, 0xF8,
  0xE7, 0x38, 0x66, 0x0E, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x86,
  0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x1F, 0x83, 0xF8, 0xE7, 0x1C, 0x73,
  0x8E, 0x71, 0xCC, 0x3B, 0x87, 0x70, 0xEE, 0x19, 0xC7, 0x30, 0xE6, 0x39,
  0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xE3, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xFF, 0x3F, 0xC0,
  0x1F, 0xE3, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0xFC, 0x7F,
  0x8E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x83, 0xF8,
  0xE7, 0x38, 0x77, 0x0E, 0xC0, 0x38, 0x07, 0x3E, 0xE7, 0xDC, 0x3B, 0x87,
  0x70, 0xEF, 0x38, 0xFF, 0x0F, 0x80, 0x18, 0x38, 0xC1, 0xCE, 0x0C, 0x70,
  0x63, 0x87, 0x1C, 0x38, 0xFF, 0xCF, 0xFC, 0x70, 0x63, 0x87, 0x1C, 0x38,
  0xC1, 0xC6, 0x0E, 0x70, 0x63, 0x83, 0x00, 0x18, 0x63, 0x8E, 0x38, 0xE3,
  0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xEE, 0x33, 0x8C, 0xE7, 0x1F,
  0x83, 0xC0, 0x18, 0x70, 0xC7, 0x8E, 0x78, 0x73, 0x83, 0xB8, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1C, 0xE0, 0xC7, 0x06, 0x38, 0x70,
  0xE3, 0x87, 0x00, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0xFB, 0xFC, 0x1C, 0x0F, 0x1C, 0x0E,
  0x3C, 0x1E, 0x3E, 0x1E, 0x36, 0x3E, 0x36, 0x3E, 0x36, 0x7E, 0x76, 0x6C,
  0x76, 0xEC, 0x76, 0xDC, 0x76, 0xDC, 0x67, 0x9C, 0x67, 0x9C, 0xE3, 0x18,
  0xE3, 0x18, 0x1C, 0x38, 0xE1, 0xCF, 0x0C, 0x78, 0xE3, 0xE7, 0x1F, 0x38,
  0xD9, 0xCE, 0xEC, 0x73, 0x63, 0x9F, 0x1C, 0xF8, 0xC3, 0xC6, 0x1E, 0x70,
  0xE3, 0x87, 0x00, 0x0F, 0x83, 0xF8, 0xE7, 0x38, 0x77, 0x0E, 0xC1, 0xF8,
  0x3F, 0x06, 0xE0, 0xDC, 0x1B, 0x87, 0x70, 0xEF, 0x38, 0xFE, 0x0F, 0x80,
  0x1F, 0x81, 0xFE, 0x38, 0xE3, 0x86, 0x38, 0x63, 0x86, 0x30, 0xE7, 0x1E,
  0x7F, 0xC7, 0xF8, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F,
  0x83, 0xF8, 0xE7, 0x38, 0x76, 0x0E, 0xC1, 0xF8, 0x3F, 0x06, 0xE0, 0xDC,
  0x3B, 0x87, 0x70, 0xCF, 0x38, 0xFE, 0x0F, 0xC0, 0x38, 0x03, 0x80, 0x20,
  0x1F, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x73, 0xFE, 0x7F,
  0x0E, 0x61, 0xCE, 0x31, 0xC6, 0x39, 0xC3, 0x38, 0x70, 0x07, 0x83, 0xF8,
  0xF3, 0x9C, 0x73, 0x8E, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3B, 0x87,
  0x30, 0xE7, 0x38, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0x30, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x0C, 0xC3, 0x98, 0x77, 0x0E,
  0xE1, 0xDC, 0x33, 0x86, 0x71, 0xCE, 0x78, 0xFE, 0x0F, 0x00, 0xE0, 0xFC,
  0x3B, 0x87, 0x71, 0xCE, 0x39, 0xC6, 0x39, 0xC3, 0x38, 0x6E, 0x0D, 0xC1,
  0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE3, 0x1F, 0x9C, 0x7E, 0x71,
  0xB9, 0xC6, 0xCF, 0x3B, 0x3C, 0xCC, 0xF3, 0x37, 0xDC, 0xDB, 0x63, 0x6D,
  0x8F, 0x3E, 0x3C, 0x70, 0xF1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x1C, 0x38,
  0xE3, 0x83, 0x1C, 0x1D, 0xC0, 0xEE, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0x70, 0x3B, 0x83, 0x9C, 0x38, 0x61, 0xC3, 0x80, 0xE1,
  0xF8, 0x6E, 0x39, 0x8C, 0x67, 0x1F, 0x87, 0xE0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01,
  0xFF, 0x3F, 0xE0, 0x1E, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1,
  0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0xC7, 0x00, 0xC6, 0x39, 0xCE,
  0x31, 0x8C, 0x63, 0x9C, 0xE3, 0x18, 0xC6, 0x1E, 0x3C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE3, 0xC7,
  0x80, 0x18, 0x38, 0xF1, 0xE6, 0xCD, 0xB1, 0x00, 0xFF, 0xFF, 0xE7, 0x30,
  0x1E, 0x1F, 0x8C, 0xE0, 0x71, 0xFB, 0xF9, 0x8D, 0xC6, 0xE7, 0x3F, 0x9F,
  0xC0, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xB8, 0xFE, 0xF7, 0x71, 0xB8,
  0xDC, 0x6C, 0x36, 0x3F, 0x9F, 0xFD, 0xDC, 0x1F, 0x1F, 0x9C, 0xEE, 0x36,
  0x03, 0x01, 0x80, 0xC6, 0x67, 0x3F, 0x0F, 0x00, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x3B, 0x8F, 0xF3, 0x9C, 0x71, 0x8C, 0x71, 0x8E, 0x31,
  0xC6, 0x38, 0xCE, 0x1F, 0xC1, 0xD8, 0x3E, 0x7F, 0x67, 0xE3, 0xFF, 0xFF,
  0xC0, 0xC0, 0xE6, 0xFE, 0x7C, 0x0E, 0x3C, 0xE1, 0x83, 0x1F, 0xBF, 0x38,
  0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0x1F, 0xCF, 0xF7, 0x3D, 0xC6,
  0x61, 0x98, 0xE6, 0x39, 0x8E, 0x73, 0x1F, 0xC3, 0xB0, 0x1C, 0x47, 0x3F,
  0x87, 0xC0, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xB8, 0xFE, 0xE7, 0x73,
  0xB9, 0xD8, 0xEC, 0x76, 0x37, 0x1B, 0x8D, 0xCE, 0x19, 0xC6, 0x03, 0x98,
  0xCE, 0x73, 0x9C, 0xC6, 0x73, 0x80, 0x06, 0x1C, 0x18, 0x00, 0xE1, 0x83,
  0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x31, 0xE3, 0x80, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x73, 0x39, 0xDC, 0x7E, 0x1F, 0x07,
  0xC1, 0xF8, 0x66, 0x39, 0xCE, 0x73, 0x9C, 0x18, 0xCE, 0x73, 0x9C, 0xC6,
  0x73, 0x9C, 0xE6, 0x33, 0x9C, 0x37, 0x38, 0xFF, 0xF3, 0x3D, 0xDC, 0xE3,
  0x73, 0x8D, 0xCE, 0x76, 0x39, 0xD8, 0xC7, 0xE3, 0x1B, 0x9C, 0x6E, 0x73,
  0x80, 0x37, 0x1F, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0x8E, 0xC6, 0xE3, 0x71,
  0xB9, 0xC0, 0x3E, 0x7F, 0x67, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xE6, 0xFE,
  0x78, 0x1B, 0x87, 0xF1, 0x9C, 0xE3, 0x38, 0xCE, 0x33, 0x0C, 0xC7, 0x79,
  0xDF, 0xE7, 0x71, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x1D, 0xCF, 0xF7, 0x39,
  0xC6, 0x63, 0x98, 0xE6, 0x39, 0x8E, 0x67, 0x1F, 0xC3, 0xF0, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x36, 0x7C, 0xFB, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3,
  0x80, 0x1E, 0x1F, 0x9C, 0xEE, 0x03, 0x81, 0xF0, 0x3D, 0xCE, 0xE7, 0x3F,
  0x0F, 0x00, 0x31, 0x9D, 0xFF, 0xB9, 0x8C, 0xE7, 0x39, 0xCF, 0x38, 0x63,
  0xB1, 0xF8, 0xDC, 0x6E, 0x77, 0x3B, 0x1D, 0x8C, 0xCE, 0x7F, 0x1F, 0x80,
  0xE3, 0x73, 0xB9, 0x8C, 0xC6, 0xE3, 0x61, 0xF0, 0xF0, 0x78, 0x38, 0x1C,
  0x00, 0xE6, 0x3E, 0x67, 0xEE, 0x7E, 0xE6, 0xEF, 0xEF, 0xBC, 0x7B, 0xC7,
  0x3C, 0x73, 0x86, 0x38, 0x63, 0x00, 0x39, 0xC3, 0x38, 0x7E, 0x0F, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF8, 0x3B, 0x0E, 0x61, 0xCE, 0x00, 0x38, 0xC7,
  0x38, 0xE6, 0x1D, 0xC1, 0xB8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F, 0x9F, 0xC1, 0xC0, 0xC0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x7F, 0xBF, 0x80, 0x06, 0x1C, 0x30, 0xE1,
  0x83, 0x06, 0x1C, 0x30, 0xE1, 0x83, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xE0,
  0xC0, 0x80, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x88,
  0x46, 0x00, 0x10, 0x30, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x38,
  0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE3, 0x86, 0x00, 0x30, 0xDE, 0x2C, 0xDB,
  0x3E, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 6, 6, 7, 1, -16 },
  { 18, 10, 15, 11, 1, -15 },
  { 37, 9, 19, 10, 1, -17 },
  { 59, 10, 15, 13, 2, -15 },
  { 78, 11, 15, 12, 0, -15 },
  { 99, 3, 5, 3, 1, -16 },
  { 101, 6, 22, 7, 1, -17 },
  { 118, 7, 22, 7, -1, -17 },
  { 138, 9, 9, 9, 1, -15 },
  { 149, 8, 10, 10, 1, -12 },
  { 159, 4, 6, 5, -1, -2 },
  { 162, 5, 2, 7, 1, -7 },
  { 164, 4, 3, 6, 0, -3 },
  { 166, 9, 16, 7, -1, -15 },
  { 184, 9, 15, 10, 1, -15 },
  { 201, 6, 15, 10, 2, -15 },
  { 213, 10, 15, 10, 0, -15 },
  { 232, 10, 15, 10, 0, -15 },
  { 251, 10, 15, 10, 0, -15 },
  { 270, 9, 15, 10, 1, -15 },
  { 287, 8, 15, 10, 1, -15 },
  { 302, 10, 15, 10, 1, -15 },
  { 321, 9, 15, 10, 1, -15 },
  { 338, 9, 15, 10, 1, -15 },
  { 355, 5, 12, 5, 0, -12 },
  { 363, 6, 16, 5, -1, -12 },
  { 375, 9, 9, 9, 0, -11 },
  { 386, 8, 6, 10, 1, -10 },
  { 392, 9, 10, 9, 0, -11 },
  { 404, 8, 15, 9, 1, -15 },
  { 419, 15, 20, 16, 0, -15 },
  { 457, 12, 15, 12, -1, -15 },
  { 480, 11, 15, 11, 0, -15 },
  { 501, 11, 15, 12, 1, -15 },
  { 522, 11, 15, 12, 0, -15 },
  { 543, 11, 15, 10, 0, -15 },
  { 564, 11, 15, 10, 0, -15 },
  { 585, 11, 15, 12, 1, -15 },
  { 606, 13, 15, 13, 0, -15 },
  { 631, 6, 15, 5, 0, -15 },
  { 643, 10, 15, 10, 0, -15 },
  { 662, 13, 15, 11, 0, -15 },
  { 687, 9, 15, 10, 0, -15 },
  { 704, 16, 15, 15, 0, -15 },
  { 734, 13, 15, 13, 0, -15 },
  { 759, 11, 15, 12, 1, -15 },
  { 780, 12, 15, 12, 0, -15 },
  { 803, 11, 18, 12, 1, -15 },
  { 828, 11, 15, 11, 0, -15 },
  { 849, 11, 15, 11, 0, -15 },
  { 870, 10, 15, 11, 2, -15 },
  { 889, 11, 15, 12, 1, -15 },
  { 910, 11, 15, 12, 2, -15 },
  { 931, 14, 15, 15, 2, -15 },
  { 958, 13, 15, 11, -1, -15 },
  { 983, 10, 15, 11, 2, -15 },
  { 1002, 11, 15, 11, 0, -15 },
  { 1023, 7, 20, 5, 0, -17 },
  { 1041, 5, 16, 8, 2, -15 },
  { 1051, 7, 20, 5, -1, -17 },
  { 1069, 7, 7, 8, 1, -15 },
  { 1076, 8, 2, 8, -1, 0 },
  { 1078, 4, 3, 7, 2, -16 },
  { 1080, 9, 11, 10, 0, -11 },
  { 1093, 9, 16, 10, 0, -16 },
  { 1111, 9, 11, 9, 0, -11 },
  { 1124, 11, 16, 10, 0, -16 },
  { 1146, 8, 11, 10, 1, -11 },
  { 1157, 7, 16, 7, 1, -16 },
  { 1171, 10, 15, 10, 0, -11 },
  { 1190, 9, 16, 10, 0, -16 },
  { 1208, 5, 15, 5, 0, -15 },
  { 1218, 7, 19, 5, -2, -15 },
  { 1235, 10, 16, 10, 0, -16 },
  { 1255, 5, 16, 5, 0, -16 },
  { 1265, 14, 11, 15, 0, -11 },
  { 1285, 9, 11, 10, 0, -11 },
  { 1298, 8, 11, 10, 1, -11 },
  { 1309, 10, 15, 10, -1, -11 },
  { 1328, 10, 15, 10, 0, -11 },
  { 1347, 7, 11, 7, 0, -11 },
  { 1357, 9, 11, 9, 0, -11 },
  { 1370, 5, 14, 6, 1, -14 },
  { 1379, 9, 11, 10, 1, -11 },
  { 1392, 9, 11, 9, 1, -11 },
  { 1405, 12, 11, 13, 1, -11 },
  { 1422, 11, 11, 9, -1, -11 },
  { 1438, 11, 15, 9, -1, -11 },
  { 1459, 9, 11, 9, 0, -11 },
  { 1472, 7, 20, 6, 0, -16 },
  { 1490, 5, 18, 5, 0, -15 },
  { 1502, 7, 20, 6, -1, -16 },
  { 1520, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC21PT7B_H_
