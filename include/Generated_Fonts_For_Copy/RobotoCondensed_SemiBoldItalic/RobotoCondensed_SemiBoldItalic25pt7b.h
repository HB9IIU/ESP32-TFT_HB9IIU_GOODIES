#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC25PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x00, 0x0C,
  0x38, 0xE3, 0x00, 0x6E, 0xDB, 0xB6, 0x6C, 0xD9, 0xB6, 0x00, 0x03, 0x70,
  0x66, 0x06, 0x60, 0x66, 0x0E, 0xC3, 0xFF, 0x7F, 0xF0, 0xD8, 0x19, 0x81,
  0x98, 0x1B, 0x0F, 0xFC, 0xFF, 0xC3, 0x60, 0x66, 0x06, 0x60, 0x6C, 0x0C,
  0xC0, 0x01, 0x00, 0x60, 0x0C, 0x07, 0xC1, 0xFC, 0x7F, 0x8E, 0x39, 0xC7,
  0x38, 0xE7, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF7, 0x0E, 0xE3,
  0xDC, 0x73, 0xFE, 0x3F, 0x83, 0xE0, 0x30, 0x06, 0x00, 0x3C, 0x07, 0xC0,
  0x66, 0x2C, 0x66, 0xC6, 0xCC, 0xDC, 0x7D, 0x87, 0xB0, 0x07, 0x00, 0x60,
  0x0D, 0xE1, 0xBE, 0x1B, 0x33, 0x73, 0x66, 0x36, 0x77, 0x03, 0xE0, 0x1C,
  0x03, 0x80, 0x7E, 0x03, 0xF8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x01,
  0xF0, 0x0F, 0x00, 0xF9, 0xCF, 0xCC, 0xE7, 0xE7, 0x3F, 0x38, 0xF1, 0xC7,
  0x8F, 0xFC, 0x7F, 0xE0, 0xF3, 0x80, 0x7F, 0xED, 0xB0, 0x01, 0x07, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x10, 0x08,
  0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06,
  0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x70, 0x60, 0xC0,
  0x80, 0x06, 0x00, 0xC0, 0x18, 0x33, 0x2F, 0xFC, 0x7F, 0x87, 0x81, 0xF0,
  0x33, 0x0C, 0x60, 0x88, 0x00, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x00, 0x39, 0x9C,
  0xE6, 0x73, 0x00, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0x67, 0x0E, 0xE1, 0xDC, 0x3B,
  0x8F, 0x71, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC7, 0x38, 0xE3, 0xF8,
  0x7F, 0x07, 0x80, 0x06, 0x3F, 0xFF, 0xED, 0xC3, 0x87, 0x0E, 0x1C, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE0, 0x07, 0xC0, 0xFE, 0x1F, 0xE3,
  0xCF, 0x38, 0x73, 0x8F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0xFE, 0xFF, 0xCF, 0xFC, 0x07, 0x80,
  0xFE, 0x1F, 0xE3, 0xCF, 0x38, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x0F, 0x80,
  0xFC, 0x01, 0xC0, 0x1C, 0x00, 0xEF, 0x1C, 0x71, 0xC7, 0xFC, 0x7F, 0x81,
  0xE0, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x6E, 0x0F, 0xE1,
  0xDC, 0x1D, 0xC3, 0x9C, 0x71, 0xC7, 0xFE, 0xFF, 0xEF, 0xFE, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x1F, 0xE3, 0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x60,
  0x1F, 0xC3, 0xFC, 0x7F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1D, 0xC7, 0xB8,
  0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x03, 0xC1, 0xE1, 0xF8, 0x70, 0x38, 0x0E,
  0x07, 0x71, 0xFE, 0x7F, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x39,
  0xFE, 0x7F, 0x0F, 0x80, 0x7F, 0xF7, 0xFF, 0x7F, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x1C,
  0xF3, 0x8E, 0x73, 0xCE, 0x71, 0xFE, 0x1F, 0x8F, 0xF1, 0xCE, 0x71, 0xCE,
  0x1D, 0xC7, 0x38, 0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x1E, 0x0F, 0xC7, 0xFB,
  0xCE, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xBF, 0xE7, 0xF8, 0xEE, 0x07,
  0x01, 0xC1, 0xE3, 0xF0, 0xF8, 0x38, 0x00, 0x03, 0xDE, 0x60, 0x00, 0x00,
  0x00, 0x11, 0xCE, 0x70, 0x00, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC3, 0x86, 0x1C, 0x38, 0xE0, 0x80, 0x00, 0x81, 0xC3, 0xE7,
  0xFF, 0xC7, 0x83, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xC0, 0x40, 0x7F, 0xDF,
  0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFB, 0xFE, 0x40, 0x38, 0x1F, 0x07,
  0xE0, 0xF8, 0x1C, 0x7E, 0xFC, 0xF8, 0x70, 0x20, 0x00, 0x3E, 0x3F, 0xBF,
  0xFC, 0x7E, 0x38, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0xF0, 0x30, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0x81,
  0x83, 0x80, 0x61, 0x80, 0x31, 0x87, 0x09, 0xCF, 0xE6, 0xC6, 0x63, 0x66,
  0x31, 0xE3, 0x18, 0xF3, 0x9C, 0x59, 0xCC, 0x6C, 0xC6, 0x36, 0x63, 0x1B,
  0x33, 0x99, 0x9F, 0xF8, 0xC7, 0x38, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x04, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x01, 0xCC, 0x0F, 0x38, 0x38,
  0xE0, 0xE3, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0x83, 0x9E, 0x0E, 0x70,
  0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x9E,
  0x1C, 0xE1, 0xE7, 0x1E, 0x3F, 0xE1, 0xFF, 0x1E, 0x3C, 0xF0, 0xE7, 0x07,
  0x38, 0x39, 0xC3, 0xCF, 0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xC0, 0x7F,
  0x07, 0xFC, 0x70, 0xE7, 0x83, 0xB8, 0x1D, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x0E, 0x70, 0x73, 0xC7, 0x8F, 0xF8, 0x7F,
  0x80, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x38, 0xF1, 0xC3, 0x9E,
  0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xDE, 0x1E, 0xF0, 0xE7, 0x07,
  0x38, 0x79, 0xC3, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE1,
  0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x7F,
  0x87, 0xFC, 0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0x0E, 0x00, 0x71, 0xF7,
  0x9F, 0xB8, 0xFD, 0xC0, 0xEE, 0x0F, 0x70, 0x79, 0xC3, 0x8F, 0xFC, 0x3F,
  0xC0, 0xFC, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1,
  0xC7, 0x83, 0x8E, 0x07, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF9, 0xE0, 0xE3,
  0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0xF0, 0x71, 0xE0,
  0xE0, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC7,
  0x8E, 0x1C, 0x38, 0x71, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xCE, 0x1C, 0xF3, 0xC7, 0xF8, 0x7F, 0x03, 0xE0, 0x1C, 0x1E, 0x38, 0x78,
  0x71, 0xE0, 0xE7, 0x81, 0xCF, 0x07, 0xBC, 0x0E, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xDE, 0x07, 0x9C, 0x0E, 0x3C, 0x1C, 0x78,
  0x38, 0x70, 0xF0, 0xF1, 0xE1, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0x71, 0xD8, 0xFC,
  0x3B, 0x1B, 0x87, 0x67, 0x71, 0xEC, 0xEE, 0x39, 0xB9, 0xC7, 0x3F, 0x78,
  0xE7, 0xCE, 0x1C, 0xF9, 0xC3, 0x8E, 0x38, 0xF1, 0xC7, 0x1E, 0x31, 0xE0,
  0x1E, 0x0E, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0xF1, 0xF1, 0xC7, 0xE3, 0x8E,
  0xC7, 0x1D, 0xCE, 0x3B, 0x9C, 0x73, 0x79, 0xE6, 0xE3, 0xCF, 0xC7, 0x1F,
  0x8E, 0x1F, 0x1C, 0x3E, 0x38, 0x7C, 0xF0, 0x71, 0xE0, 0xE0, 0x07, 0xC0,
  0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x3F, 0x83, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0xC3, 0x8F, 0xF8,
  0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0x0E, 0x1C,
  0x3C, 0xF0, 0xF3, 0x83, 0x8E, 0x1E, 0x3F, 0xF8, 0xFF, 0xC7, 0xFC, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0xC3,
  0x8F, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x70, 0x03, 0xC0, 0x08, 0x00, 0x1F,
  0xE0, 0xFF, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x9E, 0x1C, 0xE0, 0xE7, 0x0F,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF3, 0x87, 0x1C, 0x38, 0xF1, 0xC7, 0x8E,
  0x1C, 0xF0, 0xE7, 0x87, 0x80, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x73,
  0xC3, 0x9C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xC7, 0x0F, 0x38, 0x79, 0xC3, 0x8F, 0xFC, 0x3F, 0xC0, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x87, 0xB8, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x83, 0xBC, 0x3D, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0xC7, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0xE0, 0x7F, 0x83, 0xFC,
  0x1D, 0xE1, 0xE7, 0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0x73, 0xC3, 0x9C,
  0x1C, 0xE0, 0xEE, 0x03, 0x70, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x71, 0xFC, 0x78, 0xEE, 0x3C,
  0x77, 0x1E, 0x7B, 0x9F, 0x39, 0xCD, 0x9C, 0xE6, 0xCE, 0x77, 0x6E, 0x3B,
  0x37, 0x0F, 0x9B, 0x87, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x70, 0xF0, 0x38, 0x78, 0x00, 0x1E, 0x0E, 0x0E, 0x1E, 0x0E, 0x3C, 0x0F,
  0x3C, 0x07, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0, 0x3C,
  0x70, 0x78, 0x70, 0x70, 0x78, 0xF0, 0x77, 0x87, 0x9C, 0x38, 0xE3, 0xC7,
  0x1C, 0x39, 0xE0, 0xEE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F,
  0xFC, 0xFF, 0xE3, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0x1F, 0x1F, 0x1C, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0xE3, 0x8E, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0xC7, 0x1F,
  0x1F, 0x1F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0xF0,
  0x0E, 0x0E, 0x1E, 0x1E, 0x36, 0x36, 0x77, 0x67, 0xE3, 0xFF, 0xFF, 0xFF,
  0xE0, 0x71, 0xC3, 0x86, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xE0, 0x1C, 0x3F,
  0x8F, 0xF3, 0x8E, 0xF1, 0xDC, 0x7B, 0xFE, 0x3F, 0xC3, 0xB8, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0xF1, 0xFF, 0x3F, 0xE7, 0x1D,
  0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x8E, 0xFF, 0xDF, 0xF3, 0xBC,
  0x00, 0x1F, 0x0F, 0xE7, 0xFB, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE3,
  0xB8, 0xEF, 0xF1, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x1D, 0xE7, 0xFC, 0x7F, 0xCF, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE3, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0x8F, 0xF8, 0x7B, 0x00, 0x1F,
  0x0F, 0xE7, 0xFD, 0xC7, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x4F,
  0xF1, 0xFC, 0x3E, 0x00, 0x07, 0x07, 0x87, 0xC7, 0x83, 0x81, 0xC3, 0xF9,
  0xFC, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0x70,
  0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x7F, 0xC7, 0xFC, 0x3D, 0xC0, 0x3C, 0x03,
  0x8F, 0xF8, 0xFF, 0x07, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0xF1, 0xFE, 0x3F, 0xE7, 0x1D, 0xE3, 0xB8, 0x77, 0x1C, 0xE3,
  0x9C, 0x73, 0x8E, 0xE1, 0xDC, 0x3B, 0x8E, 0x00, 0x1C, 0x71, 0xC0, 0x00,
  0xE3, 0x8E, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0xF3, 0x80, 0x03, 0x81,
  0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x87, 0xC7, 0xC3, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0xF3, 0x9E,
  0x3B, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x38,
  0xF3, 0x8E, 0x3C, 0xE1, 0xC0, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C,
  0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x80, 0x3B, 0xCF,
  0x1F, 0xEF, 0x8F, 0xFF, 0xE7, 0x1C, 0x73, 0x8E, 0x3B, 0x87, 0x1D, 0xC7,
  0x0E, 0xE3, 0x8E, 0x71, 0xC7, 0x38, 0xE3, 0xBC, 0x71, 0xDC, 0x78, 0xEE,
  0x38, 0xF0, 0x3B, 0xC7, 0xF8, 0xFF, 0x9C, 0x77, 0x8E, 0xE1, 0xDC, 0x73,
  0x8E, 0x71, 0xCE, 0x3B, 0xC7, 0x70, 0xEE, 0x38, 0x1F, 0x0F, 0xE7, 0xFD,
  0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEF, 0xF9, 0xFC, 0x3E,
  0x00, 0x1D, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0x73,
  0x87, 0x38, 0x73, 0x8E, 0x7F, 0xE7, 0xFC, 0x77, 0x87, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0xEF, 0xD9, 0xFF, 0x78, 0xEE, 0x1D, 0xC3,
  0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0x73, 0xFE, 0x7F, 0xC7, 0xF8, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3B, 0x3F, 0x3F, 0x3C, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x0F, 0x07, 0xF3, 0xFC, 0xE7, 0x38,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xB8, 0xE7, 0x79, 0xFC, 0x3E, 0x00, 0x38,
  0x70, 0xE7, 0xFF, 0xCF, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1F, 0x1E,
  0x3C, 0x71, 0xEE, 0x39, 0xC7, 0x38, 0xEF, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C,
  0xE3, 0x9C, 0x73, 0xFE, 0x7F, 0xC7, 0xB0, 0xE1, 0xFC, 0xF7, 0x39, 0xCE,
  0x77, 0x1D, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x03, 0xC0, 0xE0, 0x38, 0x00,
  0x63, 0x8E, 0xC7, 0x39, 0x8E, 0x73, 0x3C, 0xE6, 0x7B, 0x8D, 0xF7, 0x1B,
  0x6E, 0x3E, 0xF8, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C,
  0x00, 0x1C, 0x71, 0xCE, 0x1C, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x00,
  0xF8, 0x1F, 0x83, 0xF8, 0x39, 0xC7, 0x9C, 0x71, 0xC0, 0x3C, 0x73, 0xCF,
  0x1C, 0xE1, 0xCE, 0x1D, 0xC1, 0xDC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x0F, 0x80, 0xF8, 0x0E, 0x00,
  0x3F, 0xE7, 0xFC, 0xFF, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x02, 0x1C, 0x70, 0xE1, 0x87, 0x0E,
  0x1C, 0x38, 0x73, 0xC7, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x06,
  0x0E, 0x1C, 0x08, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C,
  0x30, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xE0, 0x08, 0x1C, 0x0C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0E, 0x07, 0x0F, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x38, 0x77, 0xE6, 0x7F, 0xEE, 0x7E,
  0xC3, 0xC0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 18, 6, 1, -18 },
  { 15, 7, 7, 8, 2, -19 },
  { 22, 12, 18, 13, 1, -18 },
  { 49, 11, 23, 12, 1, -21 },
  { 81, 12, 18, 15, 2, -18 },
  { 108, 13, 18, 14, 0, -18 },
  { 138, 3, 7, 4, 2, -19 },
  { 141, 8, 26, 8, 1, -20 },
  { 167, 8, 26, 8, -1, -20 },
  { 193, 11, 11, 11, 1, -18 },
  { 209, 10, 13, 12, 1, -15 },
  { 226, 5, 7, 6, -1, -3 },
  { 231, 6, 3, 8, 1, -9 },
  { 234, 3, 4, 7, 1, -4 },
  { 236, 12, 20, 8, -2, -18 },
  { 266, 11, 18, 12, 1, -18 },
  { 291, 7, 18, 12, 3, -18 },
  { 307, 12, 18, 12, 0, -18 },
  { 334, 12, 18, 12, 0, -18 },
  { 361, 12, 18, 12, 0, -18 },
  { 388, 11, 18, 12, 1, -18 },
  { 413, 10, 18, 12, 1, -18 },
  { 436, 12, 18, 12, 1, -18 },
  { 463, 11, 18, 12, 1, -18 },
  { 488, 10, 18, 12, 2, -18 },
  { 511, 5, 14, 7, 1, -14 },
  { 520, 7, 18, 6, -1, -14 },
  { 536, 9, 12, 11, 1, -14 },
  { 550, 10, 8, 12, 1, -12 },
  { 560, 9, 11, 11, 1, -13 },
  { 573, 9, 18, 11, 2, -18 },
  { 594, 17, 23, 19, 1, -17 },
  { 643, 14, 18, 14, -1, -18 },
  { 675, 13, 18, 14, 0, -18 },
  { 705, 13, 18, 14, 1, -18 },
  { 735, 13, 18, 14, 0, -18 },
  { 765, 13, 18, 12, 0, -18 },
  { 795, 13, 18, 12, 0, -18 },
  { 825, 13, 18, 14, 1, -18 },
  { 855, 15, 18, 15, 0, -18 },
  { 889, 7, 18, 6, 0, -18 },
  { 905, 12, 18, 12, 0, -18 },
  { 932, 15, 18, 13, 0, -18 },
  { 966, 10, 18, 12, 0, -18 },
  { 989, 19, 18, 18, 0, -18 },
  { 1032, 15, 18, 15, 0, -18 },
  { 1066, 13, 18, 15, 1, -18 },
  { 1096, 14, 18, 14, 0, -18 },
  { 1128, 13, 21, 15, 1, -18 },
  { 1163, 13, 18, 13, 0, -18 },
  { 1193, 13, 18, 13, 0, -18 },
  { 1223, 12, 18, 13, 2, -18 },
  { 1250, 13, 18, 14, 1, -18 },
  { 1280, 13, 18, 14, 2, -18 },
  { 1310, 17, 18, 18, 2, -18 },
  { 1349, 16, 18, 14, -1, -18 },
  { 1385, 13, 18, 13, 2, -18 },
  { 1415, 14, 18, 13, 0, -18 },
  { 1447, 8, 25, 6, 0, -21 },
  { 1472, 6, 20, 9, 2, -18 },
  { 1487, 8, 25, 6, -1, -21 },
  { 1512, 8, 9, 9, 1, -18 },
  { 1521, 9, 3, 10, -1, 0 },
  { 1525, 6, 4, 8, 2, -19 },
  { 1528, 11, 13, 11, 0, -13 },
  { 1546, 11, 19, 12, 0, -19 },
  { 1573, 10, 13, 11, 1, -13 },
  { 1590, 12, 19, 12, 1, -19 },
  { 1619, 10, 13, 12, 1, -13 },
  { 1636, 9, 19, 8, 1, -19 },
  { 1658, 12, 18, 12, 0, -13 },
  { 1685, 11, 19, 12, 0, -19 },
  { 1712, 6, 18, 6, 0, -18 },
  { 1726, 9, 23, 6, -3, -18 },
  { 1752, 12, 19, 11, 0, -19 },
  { 1781, 7, 19, 6, 0, -19 },
  { 1798, 17, 13, 18, 0, -13 },
  { 1826, 11, 13, 12, 0, -13 },
  { 1844, 10, 13, 12, 1, -13 },
  { 1861, 12, 18, 12, -1, -13 },
  { 1888, 11, 18, 12, 1, -13 },
  { 1913, 8, 13, 8, 0, -13 },
  { 1926, 10, 13, 11, 0, -13 },
  { 1943, 7, 16, 7, 1, -16 },
  { 1957, 11, 13, 12, 1, -13 },
  { 1975, 10, 13, 11, 1, -13 },
  { 1992, 15, 13, 15, 1, -13 },
  { 2017, 12, 13, 11, -1, -13 },
  { 2037, 12, 18, 11, -1, -13 },
  { 2064, 11, 13, 11, 0, -13 },
  { 2082, 7, 24, 7, 1, -20 },
  { 2103, 6, 21, 6, 0, -18 },
  { 2119, 8, 23, 7, -1, -19 },
  { 2142, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC25PT7B_H_
