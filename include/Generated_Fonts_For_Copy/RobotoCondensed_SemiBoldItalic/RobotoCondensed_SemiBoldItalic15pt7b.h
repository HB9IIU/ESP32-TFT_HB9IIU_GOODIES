#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC15PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x66, 0x0C, 0xC0, 0x5D, 0xBA, 0x0A, 0x0A, 0x1A,
  0x3F, 0x14, 0x34, 0x2C, 0x7E, 0x28, 0x58, 0x50, 0x04, 0x10, 0x71, 0xF2,
  0x64, 0x0C, 0x0C, 0x0C, 0x09, 0x33, 0xE7, 0x84, 0x00, 0x70, 0xA7, 0x5E,
  0xA6, 0x82, 0x07, 0x95, 0x5A, 0xB4, 0x30, 0x1C, 0x3E, 0x36, 0x34, 0x3C,
  0x38, 0x7B, 0xCE, 0xCE, 0x7E, 0x7E, 0x7E, 0x13, 0x26, 0x4C, 0xC8, 0x88,
  0x88, 0x84, 0x40, 0x10, 0x86, 0x31, 0x8C, 0x63, 0x18, 0x8C, 0x62, 0x22,
  0x00, 0x10, 0x4F, 0xCC, 0x52, 0x40, 0x18, 0x30, 0x63, 0xF7, 0xE6, 0x0C,
  0x18, 0x6D, 0x60, 0xFC, 0xD8, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10,
  0x20, 0xC1, 0x06, 0x00, 0x39, 0xF4, 0xF3, 0xCF, 0x3C, 0xE2, 0x9B, 0xE7,
  0x00, 0x1F, 0xF2, 0x66, 0x66, 0x64, 0xC0, 0x1C, 0x7D, 0x98, 0x30, 0x61,
  0x86, 0x18, 0x61, 0xFB, 0xF0, 0x1C, 0x7D, 0x98, 0x31, 0xC3, 0x03, 0x02,
  0xCC, 0xF9, 0xE0, 0x06, 0x1C, 0x38, 0xA3, 0xC5, 0x9B, 0x7F, 0xFE, 0x10,
  0x60, 0x7D, 0xF6, 0x10, 0xFB, 0xE0, 0xC3, 0x9B, 0xE7, 0x00, 0x18, 0xE6,
  0x30, 0xFB, 0xEC, 0xF3, 0xCB, 0xE7, 0x00, 0xFF, 0xF8, 0x30, 0x41, 0x86,
  0x0C, 0x30, 0x61, 0x83, 0x00, 0x1C, 0x7C, 0x99, 0x33, 0xC7, 0x1B, 0x22,
  0xCC, 0xF9, 0xE0, 0x39, 0xFC, 0xF3, 0xCF, 0xF7, 0x86, 0x1B, 0xCE, 0x00,
  0x62, 0x00, 0x00, 0xCC, 0x33, 0x00, 0x00, 0x26, 0x6C, 0x04, 0x77, 0xB0,
  0x70, 0xE0, 0x80, 0xFF, 0xF0, 0x00, 0xFB, 0xE0, 0x41, 0xC1, 0xC3, 0x3D,
  0x88, 0x00, 0x7B, 0xEC, 0x86, 0x18, 0xC6, 0x18, 0x01, 0x04, 0x00, 0x0F,
  0x83, 0x18, 0xC1, 0x13, 0xB4, 0xD6, 0xB6, 0xF6, 0xD6, 0x92, 0xD6, 0xDB,
  0xF1, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x03, 0x03, 0xC1, 0xE1, 0xB0, 0xD8,
  0xCC, 0x7E, 0x3F, 0x30, 0x98, 0x60, 0x3E, 0x3F, 0x23, 0x63, 0x66, 0x7C,
  0x66, 0x66, 0x46, 0xFE, 0xFC, 0x3C, 0xFD, 0x9E, 0x3C, 0x18, 0x30, 0x62,
  0xCD, 0xF9, 0xE0, 0x3C, 0x3E, 0x23, 0x63, 0x63, 0x63, 0x63, 0x66, 0x46,
  0xFC, 0xF8, 0x3F, 0x3F, 0x20, 0x60, 0x7C, 0x7C, 0x60, 0x60, 0x40, 0xFC,
  0xFC, 0x3F, 0x3E, 0x20, 0x60, 0x7C, 0x7C, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0x3C, 0xFD, 0x9E, 0x0C, 0x19, 0xF7, 0xE3, 0xC7, 0xF9, 0xE0, 0x31, 0x98,
  0xC8, 0x6C, 0x37, 0xF3, 0xF9, 0x8C, 0xC6, 0x43, 0x61, 0xB1, 0x80, 0x33,
  0x36, 0x66, 0x66, 0x6C, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06,
  0xCD, 0xF1, 0xC0, 0x33, 0x99, 0x89, 0x8D, 0x87, 0xC3, 0xC1, 0xF0, 0xD8,
  0x4C, 0x63, 0x31, 0x80, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x18, 0x43, 0xFF,
  0xC0, 0x30, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0x94, 0xF7, 0x9A, 0xB3, 0x76,
  0x4E, 0xD9, 0x9B, 0x32, 0x00, 0x31, 0x98, 0xCE, 0x6F, 0x36, 0xB3, 0x59,
  0xBC, 0xDE, 0x47, 0x63, 0xB1, 0x80, 0x3C, 0xFD, 0x9E, 0x1C, 0x78, 0xF1,
  0xE3, 0xC5, 0xF9, 0xE0, 0x3E, 0x3F, 0x23, 0x63, 0x63, 0x7E, 0x7C, 0x60,
  0x40, 0xC0, 0xC0, 0x3C, 0xFD, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xCD, 0xF9,
  0xE0, 0x60, 0x80, 0x3E, 0x3F, 0x23, 0x63, 0x63, 0x7E, 0x7C, 0x6C, 0x4C,
  0xC6, 0xC6, 0x1E, 0x3F, 0x63, 0x60, 0x30, 0x1C, 0x0E, 0x06, 0xC6, 0x7C,
  0x38, 0xFE, 0xFE, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x63, 0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0xCC, 0xFC, 0x78, 0xC3,
  0xC7, 0xC6, 0x66, 0x6C, 0x6C, 0x68, 0x78, 0x78, 0x70, 0x70, 0xC4, 0x59,
  0x9B, 0x33, 0x6E, 0x4D, 0xD9, 0xAB, 0x3D, 0x63, 0xB8, 0x67, 0x0C, 0xE1,
  0x98, 0x00, 0x33, 0x19, 0x8D, 0x86, 0xC1, 0xC0, 0xC0, 0xF0, 0x78, 0x6C,
  0x73, 0x31, 0x80, 0xC7, 0x66, 0x6C, 0x6C, 0x78, 0x38, 0x30, 0x30, 0x30,
  0x60, 0x60, 0x3F, 0x7F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xFE,
  0xFE, 0x39, 0xCC, 0xC6, 0x31, 0x8C, 0x42, 0x31, 0x8E, 0x70, 0xCC, 0x46,
  0x66, 0x66, 0x62, 0x23, 0x39, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x88, 0xCE,
  0x70, 0x37, 0x5D, 0x90, 0xFF, 0xF0, 0x62, 0x3D, 0xF0, 0xCF, 0x6F, 0x3F,
  0xDF, 0x30, 0x60, 0x83, 0x07, 0xCF, 0xD9, 0xB3, 0x47, 0x9B, 0xF7, 0xC0,
  0x3D, 0xF6, 0x50, 0xC3, 0x37, 0x9E, 0x03, 0x02, 0x06, 0x06, 0x3E, 0x7E,
  0x66, 0x44, 0xCC, 0xCC, 0x7C, 0x7C, 0x3C, 0xF9, 0x92, 0x2F, 0xD8, 0x1F,
  0x3C, 0x1C, 0xF3, 0x0C, 0x78, 0x86, 0x18, 0x61, 0x86, 0x10, 0x3E, 0xFD,
  0x9A, 0x3C, 0x59, 0x9F, 0x3E, 0x0D, 0xF1, 0xC0, 0x30, 0x60, 0x83, 0x07,
  0xCF, 0x99, 0x32, 0x4D, 0x9B, 0x36, 0x60, 0x33, 0x06, 0x66, 0x66, 0x4C,
  0xC0, 0x0C, 0x30, 0x06, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x73, 0x80,
  0x30, 0x60, 0x83, 0x06, 0x6D, 0x9E, 0x38, 0x79, 0xB3, 0x36, 0x60, 0x33,
  0x26, 0x66, 0x66, 0x64, 0xCC, 0x7D, 0xDF, 0xF6, 0x4D, 0xB3, 0x4C, 0xF3,
  0x3C, 0xCF, 0x32, 0x7C, 0xF9, 0x93, 0x24, 0xD9, 0xB3, 0x66, 0x3C, 0xF9,
  0x9A, 0x3C, 0x79, 0x9F, 0x3C, 0x3E, 0x3F, 0x33, 0x33, 0x23, 0x66, 0x7E,
  0x7C, 0x60, 0x60, 0x40, 0x3E, 0xFD, 0x9A, 0x2C, 0xD9, 0x9F, 0x3E, 0x0C,
  0x10, 0x60, 0x7B, 0xD8, 0xC4, 0x63, 0x18, 0x39, 0xB6, 0x1C, 0x3B, 0x3D,
  0x9E, 0x66, 0xFC, 0xCC, 0xCC, 0xCC, 0x66, 0xCD, 0x9B, 0x24, 0xD9, 0x9F,
  0x3E, 0xCF, 0x6D, 0xB4, 0xF3, 0x86, 0x18, 0xD9, 0x6D, 0xB6, 0xDF, 0x4E,
  0xE7, 0x73, 0x31, 0x98, 0x66, 0xD8, 0xE1, 0xC3, 0x0F, 0x36, 0x64, 0x66,
  0xD9, 0xB3, 0xC7, 0x8E, 0x1C, 0x10, 0x61, 0xC3, 0x00, 0x7C, 0xF8, 0x60,
  0xC3, 0x0C, 0x3E, 0x7C, 0x08, 0x8C, 0x63, 0x11, 0x98, 0x63, 0x18, 0xC4,
  0x30, 0x80, 0x24, 0x92, 0xD2, 0x49, 0x6C, 0x10, 0x86, 0x21, 0x08, 0x63,
  0x31, 0x88, 0x46, 0x31, 0x00, 0x67, 0xFA, 0x70,
};

const GFXglyph RobotoCondensed_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 1, -11 },
  { 9, 8, 11, 8, 0, -11 },
  { 20, 7, 14, 7, 0, -13 },
  { 33, 7, 11, 9, 1, -11 },
  { 43, 8, 11, 8, 0, -11 },
  { 54, 2, 4, 2, 1, -11 },
  { 55, 4, 15, 5, 1, -12 },
  { 63, 5, 15, 5, -1, -12 },
  { 73, 6, 6, 7, 1, -11 },
  { 78, 7, 8, 7, 0, -9 },
  { 85, 3, 4, 3, -1, -2 },
  { 87, 3, 2, 5, 1, -6 },
  { 88, 3, 2, 4, 0, -2 },
  { 89, 7, 12, 5, -1, -11 },
  { 100, 6, 11, 7, 1, -11 },
  { 109, 4, 11, 7, 2, -11 },
  { 115, 7, 11, 7, 0, -11 },
  { 125, 7, 11, 7, 0, -11 },
  { 135, 7, 11, 7, 0, -11 },
  { 145, 6, 11, 7, 1, -11 },
  { 154, 6, 11, 7, 1, -11 },
  { 163, 7, 11, 7, 1, -11 },
  { 173, 7, 11, 7, 0, -11 },
  { 183, 6, 11, 7, 1, -11 },
  { 192, 4, 8, 4, 0, -8 },
  { 196, 4, 10, 4, -1, -8 },
  { 201, 6, 7, 7, 0, -8 },
  { 207, 6, 6, 7, 1, -8 },
  { 212, 6, 7, 7, 0, -8 },
  { 218, 6, 11, 6, 1, -11 },
  { 227, 11, 13, 11, 0, -10 },
  { 245, 9, 11, 9, -1, -11 },
  { 258, 8, 11, 8, 0, -11 },
  { 269, 7, 11, 8, 1, -11 },
  { 279, 8, 11, 8, 0, -11 },
  { 290, 8, 11, 7, 0, -11 },
  { 301, 8, 11, 7, 0, -11 },
  { 312, 7, 11, 9, 1, -11 },
  { 322, 9, 11, 9, 0, -11 },
  { 335, 4, 11, 4, 0, -11 },
  { 341, 7, 11, 7, 0, -11 },
  { 351, 9, 11, 8, 0, -11 },
  { 364, 6, 11, 7, 0, -11 },
  { 373, 11, 11, 11, 0, -11 },
  { 389, 9, 11, 9, 0, -11 },
  { 402, 7, 11, 9, 1, -11 },
  { 412, 8, 11, 8, 0, -11 },
  { 423, 7, 13, 9, 1, -11 },
  { 435, 8, 11, 8, 0, -11 },
  { 446, 8, 11, 8, 0, -11 },
  { 457, 8, 11, 8, 1, -11 },
  { 468, 8, 11, 8, 1, -11 },
  { 479, 8, 11, 8, 1, -11 },
  { 490, 11, 11, 11, 1, -11 },
  { 506, 9, 11, 8, 0, -11 },
  { 519, 8, 11, 8, 1, -11 },
  { 530, 8, 11, 8, 0, -11 },
  { 541, 5, 14, 4, 0, -12 },
  { 550, 4, 12, 6, 1, -11 },
  { 556, 5, 14, 4, -1, -12 },
  { 565, 4, 5, 6, 1, -11 },
  { 568, 6, 2, 6, -1, 0 },
  { 570, 4, 2, 5, 1, -11 },
  { 571, 6, 8, 7, 0, -8 },
  { 577, 7, 12, 7, 0, -12 },
  { 588, 6, 8, 7, 0, -8 },
  { 594, 8, 12, 7, 0, -12 },
  { 606, 7, 8, 7, 0, -8 },
  { 613, 6, 12, 5, 0, -12 },
  { 622, 7, 11, 7, 0, -8 },
  { 632, 7, 12, 7, 0, -12 },
  { 643, 4, 11, 4, 0, -11 },
  { 649, 6, 14, 4, -2, -11 },
  { 660, 7, 12, 7, 0, -12 },
  { 671, 4, 12, 4, 0, -12 },
  { 677, 10, 8, 11, 0, -8 },
  { 687, 7, 8, 7, 0, -8 },
  { 694, 7, 8, 7, 0, -8 },
  { 701, 8, 11, 7, -1, -8 },
  { 712, 7, 11, 7, 0, -8 },
  { 722, 5, 8, 5, 0, -8 },
  { 727, 6, 8, 7, 0, -8 },
  { 733, 4, 10, 4, 1, -10 },
  { 738, 7, 8, 7, 0, -8 },
  { 745, 6, 8, 6, 1, -8 },
  { 751, 9, 8, 9, 1, -8 },
  { 760, 7, 8, 7, 0, -8 },
  { 767, 7, 11, 6, 0, -8 },
  { 777, 7, 8, 7, 0, -8 },
  { 784, 5, 15, 4, 0, -12 },
  { 794, 3, 13, 4, 0, -11 },
  { 799, 5, 15, 4, -1, -12 },
  { 809, 7, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC15PT7B_H_
