#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC8PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xE0, 0x33, 0x76, 0x7A, 0x22, 0x54, 0x2A, 0x64, 0xDE,
  0xBE, 0xC0, 0x25, 0x67, 0xBF, 0xC0, 0x29, 0x49, 0x22, 0x55, 0x58, 0x23,
  0x62, 0x22, 0xE4, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x25, 0x59, 0xA6,
  0x35, 0x60, 0x65, 0x12, 0x4E, 0x65, 0x36, 0xAE, 0x13, 0x6A, 0xE2, 0x74,
  0x62, 0xA6, 0x24, 0x69, 0xA6, 0x71, 0x22, 0x44, 0x25, 0x56, 0xAE, 0xD6,
  0xE5, 0x00, 0x42, 0x42, 0x80, 0x39, 0x80, 0x70, 0xE0, 0x47, 0x00, 0xF6,
  0x20, 0x11, 0xA7, 0x6D, 0xD6, 0xE8, 0x18, 0x22, 0x55, 0xF9, 0x75, 0x57,
  0x9E, 0x35, 0x48, 0x96, 0x65, 0x55, 0x9E, 0x74, 0x46, 0x8E, 0x74, 0x46,
  0x88, 0x35, 0x4B, 0x97, 0x4A, 0x54, 0xE9, 0x48, 0x55, 0xA0, 0x11, 0x12,
  0xAE, 0x5A, 0x98, 0xCA, 0x48, 0x49, 0x29, 0xC0, 0x45, 0x36, 0xEE, 0xBA,
  0xA0, 0x4A, 0x5C, 0xEB, 0x48, 0x32, 0x95, 0x29, 0x30, 0x75, 0x57, 0x88,
  0x32, 0x95, 0x29, 0x30, 0x40, 0x75, 0x56, 0xA9, 0x35, 0x42, 0x96, 0xF4,
  0x44, 0x88, 0x4A, 0x95, 0x29, 0x30, 0x9A, 0xAC, 0xCC, 0xAD, 0x7D, 0xEB,
  0x50, 0x5A, 0x98, 0xC6, 0x48, 0xBA, 0xCC, 0x88, 0x71, 0x24, 0x4F, 0x69,
  0x29, 0x24, 0xFC, 0x55, 0x6A, 0x0E, 0x80, 0xE0, 0x80, 0x6E, 0xF0, 0x44,
  0x69, 0xAE, 0x72, 0x70, 0x11, 0x7A, 0xAE, 0x7E, 0x30, 0x6B, 0xA5, 0x00,
  0x79, 0xAE, 0x2C, 0x49, 0xDB, 0x40, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x44,
  0x6C, 0xAA, 0x56, 0xA0, 0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x69, 0xA6, 0x69,
  0xAE, 0x88, 0x7A, 0xAE, 0x22, 0x72, 0x40, 0x68, 0xF0, 0x76, 0xC0, 0x5A,
  0xAE, 0xA6, 0x44, 0xAD, 0x54, 0xA0, 0x66, 0x6A, 0xA6, 0x44, 0x48, 0x6D,
  0x70, 0x49, 0x45, 0x20, 0x55, 0xA8, 0x55, 0xA8, 0x70,
};

const GFXglyph RobotoCondensed_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 3, 6, 5, 1, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 3, 8, 2, 0, -6 },
  { 21, 2, 8, 3, 0, -6 },
  { 23, 4, 4, 3, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 3, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 3, 6, 4, 1, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 3, 3, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 3, 4, 0, -4 },
  { 71, 2, 6, 3, 1, -6 },
  { 73, 6, 8, 6, 0, -6 },
  { 79, 4, 6, 5, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 6, 4, 0, -6 },
  { 97, 4, 6, 5, 0, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 2, 6, 2, 0, -6 },
  { 106, 4, 6, 4, 0, -6 },
  { 109, 5, 6, 4, 0, -6 },
  { 113, 3, 6, 4, 0, -6 },
  { 116, 6, 6, 6, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 4, 6, 4, 0, -6 },
  { 132, 5, 7, 5, 0, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 6, 4, 1, -6 },
  { 146, 5, 6, 4, 0, -6 },
  { 150, 4, 6, 4, 1, -6 },
  { 153, 5, 6, 6, 1, -6 },
  { 157, 5, 6, 4, 0, -6 },
  { 161, 4, 6, 4, 1, -6 },
  { 164, 4, 6, 4, 0, -6 },
  { 167, 3, 8, 2, 0, -7 },
  { 170, 1, 6, 3, 1, -6 },
  { 171, 2, 8, 2, 0, -7 },
  { 173, 3, 3, 3, 0, -6 },
  { 175, 3, 1, 3, 0, 0 },
  { 176, 1, 1, 3, 1, -6 },
  { 177, 3, 4, 4, 0, -4 },
  { 179, 4, 6, 4, 0, -6 },
  { 182, 3, 4, 4, 0, -4 },
  { 184, 4, 6, 4, 0, -6 },
  { 187, 3, 4, 4, 0, -4 },
  { 189, 3, 6, 3, 0, -6 },
  { 192, 4, 6, 4, 0, -4 },
  { 195, 3, 6, 4, 0, -6 },
  { 198, 2, 6, 2, 0, -6 },
  { 200, 3, 8, 2, -1, -6 },
  { 203, 4, 6, 4, 0, -6 },
  { 206, 2, 6, 2, 0, -6 },
  { 208, 5, 4, 6, 0, -4 },
  { 211, 3, 4, 4, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 6, 4, 0, -4 },
  { 218, 4, 6, 4, 0, -4 },
  { 221, 3, 4, 3, 0, -4 },
  { 223, 3, 4, 4, 0, -4 },
  { 225, 2, 5, 2, 0, -5 },
  { 227, 4, 4, 4, 0, -4 },
  { 229, 4, 4, 3, 0, -4 },
  { 231, 5, 4, 5, 0, -4 },
  { 234, 4, 4, 3, 0, -4 },
  { 236, 4, 6, 3, 0, -4 },
  { 239, 3, 4, 3, 0, -4 },
  { 241, 3, 7, 2, 0, -6 },
  { 244, 2, 7, 2, 0, -6 },
  { 246, 2, 7, 2, 0, -6 },
  { 248, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC8PT7B_H_
