#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC16PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x26, 0x66, 0x60, 0xCC, 0x52, 0xB5, 0x20, 0x0D, 0x0B,
  0x0A, 0x1A, 0x3F, 0x14, 0x34, 0x7E, 0x2C, 0x28, 0x68, 0x58, 0x04, 0x04,
  0x1C, 0x3E, 0x32, 0x33, 0x30, 0x38, 0x1C, 0x06, 0x46, 0x66, 0x7C, 0x38,
  0x10, 0x30, 0x70, 0x5A, 0xDA, 0x56, 0x7C, 0x08, 0x18, 0x36, 0x2B, 0x69,
  0x4B, 0x0E, 0x1C, 0x3E, 0x36, 0x36, 0x3C, 0x18, 0x7B, 0x6F, 0xCF, 0xCE,
  0x7E, 0x7F, 0x7E, 0x08, 0x8C, 0xC6, 0x23, 0x18, 0xC4, 0x21, 0x08, 0x43,
  0x08, 0x40, 0x10, 0x86, 0x30, 0x84, 0x23, 0x18, 0xC6, 0x23, 0x19, 0x88,
  0x80, 0x10, 0x4D, 0x5F, 0x71, 0x60, 0x80, 0x08, 0x30, 0x63, 0xF7, 0xE2,
  0x0C, 0x18, 0x6D, 0xAC, 0xFE, 0xE8, 0x06, 0x0C, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x30, 0x41, 0x82, 0x0C, 0x00, 0x39, 0xF6, 0x71, 0xCF, 0x3C, 0xF3,
  0xCF, 0x2F, 0x9C, 0x17, 0xF3, 0x33, 0x66, 0x66, 0x66, 0x1C, 0x3E, 0x66,
  0x66, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0xFE, 0x1C, 0x3E, 0x66,
  0x06, 0x06, 0x1E, 0x1C, 0x06, 0x06, 0xC6, 0x7C, 0x78, 0x06, 0x1C, 0x38,
  0xF3, 0x66, 0xDB, 0x7F, 0xFE, 0x18, 0x30, 0x60, 0x3E, 0xFD, 0x83, 0x07,
  0x9F, 0x83, 0x06, 0x0D, 0x9B, 0xE3, 0x80, 0x1C, 0xF6, 0x18, 0xFB, 0xFC,
  0xF3, 0xCF, 0x3F, 0x9C, 0x7F, 0xFC, 0x30, 0x61, 0x83, 0x0E, 0x18, 0x70,
  0xC1, 0x86, 0x00, 0x1C, 0x3E, 0x36, 0x36, 0x36, 0x3E, 0x3C, 0x66, 0x66,
  0x66, 0x7C, 0x38, 0x39, 0xF6, 0xF3, 0xCF, 0x3F, 0xDF, 0x08, 0x67, 0x38,
  0x33, 0x00, 0x00, 0x0E, 0x40, 0x38, 0x80, 0x00, 0x00, 0x04, 0x63, 0x18,
  0x80, 0x02, 0x18, 0xF3, 0x8E, 0x0F, 0x07, 0x04, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x40, 0xE0, 0xF0, 0x71, 0xCF, 0x18, 0x40, 0x39, 0xFC, 0xC3, 0x18,
  0xC2, 0x18, 0x00, 0x06, 0x10, 0x07, 0x81, 0x88, 0x40, 0x93, 0x96, 0xDA,
  0x92, 0x56, 0x4A, 0xC9, 0xDB, 0x3B, 0x6B, 0x36, 0x20, 0x04, 0x00, 0xC4,
  0x0F, 0x80, 0x03, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0xC8, 0x64, 0x7F, 0x3F,
  0xB8, 0xD8, 0x6C, 0x30, 0x3E, 0x3F, 0x33, 0x33, 0x63, 0x7E, 0x7E, 0x63,
  0x63, 0x66, 0xFE, 0xFC, 0x1C, 0x7E, 0x63, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC6, 0xC6, 0xFC, 0x78, 0x3E, 0x3F, 0x33, 0x33, 0x63, 0x63, 0x63, 0x63,
  0x63, 0x66, 0xFE, 0xF8, 0x3F, 0x3F, 0x30, 0x30, 0x60, 0x7E, 0x7E, 0x60,
  0x60, 0x60, 0xFE, 0xFC, 0x3F, 0x3F, 0x30, 0x30, 0x60, 0x7E, 0x7E, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0x1C, 0x7E, 0x63, 0xC3, 0xC0, 0xCF, 0xCE, 0xC6,
  0xC6, 0xC6, 0xFE, 0x78, 0x30, 0xCC, 0x73, 0x18, 0xC6, 0x61, 0x9F, 0xE7,
  0xF9, 0x8E, 0x63, 0x18, 0xCC, 0x33, 0x0C, 0x33, 0x33, 0x76, 0x66, 0x66,
  0xEC, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0xCC, 0xFC,
  0x78, 0x31, 0x8C, 0xE3, 0x70, 0xD8, 0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x6E,
  0x19, 0x8C, 0x63, 0x1C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0xF7, 0xE0, 0x38, 0x73, 0x87, 0x38, 0xF3, 0x8E, 0x69, 0xE6, 0x9E,
  0x69, 0x66, 0xB6, 0x6E, 0x66, 0xEC, 0xCC, 0xCC, 0xCC, 0x30, 0xCE, 0x63,
  0x98, 0xE6, 0x69, 0x9B, 0x66, 0xD9, 0x9C, 0x67, 0x19, 0xCC, 0x73, 0x0C,
  0x1C, 0x7E, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC, 0x78,
  0x3E, 0x1F, 0x8C, 0x66, 0x36, 0x1B, 0x19, 0xFC, 0xFC, 0x60, 0x30, 0x30,
  0x18, 0x00, 0x1C, 0x7E, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xC6,
  0xFC, 0x7C, 0x0C, 0x04, 0x3E, 0x1F, 0x8C, 0xC6, 0x66, 0x33, 0xF9, 0xF0,
  0xD8, 0x66, 0x33, 0x31, 0x98, 0xC0, 0x1E, 0x3F, 0x33, 0x30, 0x30, 0x3C,
  0x1E, 0x06, 0xC6, 0x66, 0x7E, 0x3C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x63, 0x63, 0x63, 0xC3, 0xC6, 0xC6,
  0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0xE3, 0xF1, 0x98, 0xCC, 0xC6, 0x63,
  0x61, 0xB0, 0xD8, 0x78, 0x3C, 0x0C, 0x06, 0x00, 0xC6, 0x78, 0xCD, 0x39,
  0xA7, 0x64, 0xEC, 0xBD, 0x97, 0xE2, 0xBC, 0x77, 0x8E, 0x61, 0x8C, 0x31,
  0x80, 0x31, 0x99, 0x8C, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3E, 0x33,
  0x39, 0x98, 0xC0, 0xE3, 0x67, 0x66, 0x6C, 0x6C, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x3F, 0xBF, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x70, 0x30, 0x3F, 0x9F, 0xC0, 0x39, 0xCC, 0x62, 0x31, 0x8C, 0x63, 0x19,
  0x8C, 0x63, 0x9C, 0xC4, 0x66, 0x66, 0x66, 0x63, 0x33, 0x30, 0x19, 0xC6,
  0x31, 0x8C, 0xC6, 0x31, 0x8C, 0x63, 0x33, 0x9C, 0x31, 0x9C, 0xAD, 0xCC,
  0xFF, 0xF0, 0xCC, 0x3C, 0xFD, 0x98, 0x33, 0xCD, 0xB3, 0x7E, 0x7C, 0x30,
  0x60, 0xC1, 0x67, 0xEC, 0xD9, 0xB3, 0x67, 0x8F, 0xF6, 0xC0, 0x3C, 0xFD,
  0x9B, 0x04, 0x18, 0x33, 0x3E, 0x38, 0x03, 0x03, 0x03, 0x3B, 0x7E, 0x66,
  0x66, 0xC6, 0xC6, 0xC4, 0x7C, 0x7C, 0x1C, 0x7D, 0x9B, 0x37, 0xF8, 0x18,
  0x3E, 0x38, 0x39, 0xD9, 0xEF, 0x33, 0x18, 0xC6, 0x31, 0x80, 0x3B, 0x7E,
  0x66, 0x66, 0x46, 0xC6, 0xC6, 0x7C, 0x7C, 0x0C, 0xFC, 0x70, 0x30, 0x60,
  0xC3, 0xE7, 0xEC, 0xD9, 0xB3, 0x67, 0x9B, 0x36, 0x60, 0x33, 0x02, 0x66,
  0x66, 0x64, 0xCC, 0x0C, 0x30, 0x06, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x0C,
  0x33, 0xCE, 0x00, 0x30, 0x30, 0x30, 0x66, 0x6E, 0x7C, 0x78, 0x78, 0x78,
  0xCC, 0xCC, 0xCC, 0x33, 0x33, 0x66, 0x66, 0x66, 0xCC, 0x6D, 0xCF, 0xFD,
  0x99, 0xB3, 0x36, 0x66, 0xC9, 0xB3, 0x36, 0x66, 0xCC, 0xC0, 0x6C, 0xFD,
  0x9B, 0x36, 0x6C, 0xF3, 0x66, 0xCC, 0x1C, 0x7D, 0x9B, 0x34, 0x78, 0xD1,
  0xBE, 0x38, 0x36, 0x3F, 0x33, 0x33, 0x33, 0x33, 0x63, 0x7E, 0x6C, 0x60,
  0x60, 0x40, 0x3A, 0x7E, 0x66, 0x66, 0xC6, 0xC6, 0xCC, 0x7C, 0x7C, 0x0C,
  0x0C, 0x0C, 0x7B, 0xD8, 0xC6, 0x33, 0x18, 0xC0, 0x3C, 0xF9, 0x9B, 0x83,
  0x83, 0xB3, 0x7E, 0x78, 0x66, 0xFF, 0xCC, 0xCC, 0xCE, 0xE0, 0x66, 0xCD,
  0x9B, 0x36, 0x6C, 0xD3, 0x3E, 0x7C, 0xCF, 0x3D, 0xB6, 0xD3, 0xC7, 0x18,
  0x60, 0xC9, 0xEC, 0xF6, 0x5B, 0x6F, 0xF7, 0x73, 0xB9, 0x9C, 0xCC, 0x00,
  0x33, 0x36, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x66, 0x66, 0x66, 0xCD, 0xB3,
  0x67, 0x8F, 0x0C, 0x18, 0x30, 0xC3, 0x86, 0x00, 0x7E, 0xFC, 0x30, 0xC3,
  0x06, 0x18, 0x7E, 0xFC, 0x08, 0xC4, 0x63, 0x18, 0xCC, 0xC3, 0x18, 0xC6,
  0x31, 0x84, 0x32, 0x22, 0x22, 0x66, 0x44, 0x44, 0xCC, 0x10, 0xC6, 0x31,
  0x88, 0x63, 0x31, 0x8C, 0x46, 0x31, 0x00, 0x63, 0xFE, 0x70,
};

const GFXglyph RobotoCondensed_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 5, 4, 5, 1, -12 },
  { 10, 8, 12, 8, 0, -12 },
  { 22, 8, 16, 8, 0, -14 },
  { 38, 8, 12, 10, 1, -12 },
  { 50, 8, 12, 9, 0, -12 },
  { 62, 2, 4, 3, 1, -12 },
  { 63, 5, 17, 5, 1, -13 },
  { 74, 5, 17, 5, -1, -13 },
  { 85, 6, 7, 7, 1, -12 },
  { 91, 7, 8, 7, 0, -9 },
  { 98, 3, 5, 4, -1, -2 },
  { 100, 4, 2, 5, 1, -6 },
  { 101, 3, 2, 4, 0, -2 },
  { 102, 7, 13, 5, -1, -12 },
  { 114, 6, 12, 8, 1, -12 },
  { 123, 4, 12, 8, 2, -12 },
  { 129, 8, 12, 8, 0, -12 },
  { 141, 8, 12, 8, 0, -12 },
  { 153, 7, 12, 8, 0, -12 },
  { 164, 7, 12, 8, 1, -12 },
  { 175, 6, 12, 8, 1, -12 },
  { 184, 7, 12, 8, 1, -12 },
  { 195, 8, 12, 8, 0, -12 },
  { 207, 6, 12, 8, 1, -12 },
  { 216, 4, 9, 4, 0, -9 },
  { 221, 5, 12, 4, -1, -9 },
  { 229, 7, 8, 7, 0, -9 },
  { 236, 6, 6, 8, 1, -8 },
  { 241, 7, 8, 7, 0, -9 },
  { 248, 6, 12, 7, 1, -12 },
  { 257, 11, 15, 12, 0, -11 },
  { 278, 9, 12, 9, -1, -12 },
  { 292, 8, 12, 9, 0, -12 },
  { 304, 8, 12, 9, 1, -12 },
  { 316, 8, 12, 9, 0, -12 },
  { 328, 8, 12, 8, 0, -12 },
  { 340, 8, 12, 7, 0, -12 },
  { 352, 8, 12, 9, 1, -12 },
  { 364, 10, 12, 10, 0, -12 },
  { 379, 4, 12, 4, 0, -12 },
  { 385, 8, 12, 8, 0, -12 },
  { 397, 10, 12, 9, 0, -12 },
  { 412, 7, 12, 7, 0, -12 },
  { 423, 12, 12, 12, 0, -12 },
  { 441, 10, 12, 10, 0, -12 },
  { 456, 8, 12, 9, 1, -12 },
  { 468, 9, 12, 9, 0, -12 },
  { 482, 8, 14, 9, 1, -12 },
  { 496, 9, 12, 9, 0, -12 },
  { 510, 8, 12, 8, 0, -12 },
  { 522, 8, 12, 8, 1, -12 },
  { 534, 8, 12, 9, 1, -12 },
  { 546, 9, 12, 9, 1, -12 },
  { 560, 11, 12, 12, 1, -12 },
  { 577, 9, 12, 9, 0, -12 },
  { 591, 8, 12, 8, 1, -12 },
  { 603, 9, 12, 8, 0, -12 },
  { 617, 5, 16, 4, 0, -13 },
  { 627, 4, 13, 6, 1, -12 },
  { 634, 5, 16, 4, -1, -13 },
  { 644, 5, 6, 6, 1, -12 },
  { 648, 6, 2, 6, -1, 0 },
  { 650, 3, 2, 5, 2, -12 },
  { 651, 7, 9, 7, 0, -9 },
  { 659, 7, 12, 8, 0, -12 },
  { 670, 7, 9, 7, 0, -9 },
  { 678, 8, 12, 8, 0, -12 },
  { 690, 7, 9, 7, 0, -9 },
  { 698, 5, 12, 5, 1, -12 },
  { 706, 8, 12, 8, 0, -9 },
  { 718, 7, 12, 8, 0, -12 },
  { 729, 4, 12, 4, 0, -12 },
  { 735, 6, 15, 4, -2, -12 },
  { 747, 8, 12, 7, 0, -12 },
  { 759, 4, 12, 4, 0, -12 },
  { 765, 11, 9, 12, 0, -9 },
  { 778, 7, 9, 8, 0, -9 },
  { 786, 7, 9, 8, 0, -9 },
  { 794, 8, 12, 8, -1, -9 },
  { 806, 8, 12, 8, 0, -9 },
  { 818, 5, 9, 5, 0, -9 },
  { 824, 7, 9, 7, 0, -9 },
  { 832, 4, 11, 5, 1, -11 },
  { 838, 7, 9, 8, 0, -9 },
  { 846, 6, 9, 7, 1, -9 },
  { 853, 9, 9, 10, 1, -9 },
  { 864, 8, 9, 7, -1, -9 },
  { 873, 7, 12, 7, 0, -9 },
  { 884, 7, 9, 7, 0, -9 },
  { 892, 5, 16, 5, 0, -13 },
  { 902, 4, 14, 4, 0, -12 },
  { 909, 5, 15, 5, -1, -12 },
  { 919, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC16PT7B_H_
