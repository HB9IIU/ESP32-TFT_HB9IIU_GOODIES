#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC40PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xC0,
  0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1D, 0xE7, 0xBC, 0xE7, 0x1C, 0xE3,
  0x9C, 0x70, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3C, 0xF0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x07, 0x9E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03,
  0xCF, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x79, 0xE0, 0x07, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xCF, 0x83, 0xE1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0xC3,
  0xF1, 0xF9, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xCF, 0x04, 0xE1, 0xC3, 0xB8, 0x71, 0xEE, 0x1C,
  0x73, 0x8F, 0x38, 0xE3, 0xDE, 0x38, 0xEF, 0x0F, 0xFB, 0x81, 0xFD, 0xC0,
  0x3E, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x7C, 0x07, 0xBF, 0x81,
  0xDF, 0xF0, 0xEF, 0x3C, 0x7B, 0xC7, 0x1C, 0xE1, 0xCE, 0x38, 0x77, 0x8E,
  0x1F, 0xC3, 0x8F, 0x60, 0xF3, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7C, 0xF8,
  0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xF7, 0xC0,
  0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x79,
  0xFF, 0x8F, 0x7F, 0xF1, 0xEF, 0x9F, 0x7F, 0xE3, 0xEF, 0x7C, 0x3F, 0xEF,
  0x87, 0xF9, 0xF0, 0x7F, 0x3E, 0x0F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xE3, 0xE0, 0x7B, 0xDE, 0xEF, 0x7B, 0xDC,
  0xE7, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x0C, 0x00, 0x40, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0x8E, 0x39,
  0xF7, 0x7D, 0xFF, 0xFE, 0x1F, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xEF, 0x01, 0xE3, 0x81, 0xE1, 0xE0, 0x60, 0x70, 0x10, 0x20, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x33, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF1, 0xF1, 0xF0, 0x78,
  0xF8, 0x3E, 0x78, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81,
  0xE7, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0x3E, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0xC1, 0xE3, 0xE1, 0xF1,
  0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x30, 0x0F, 0x07, 0xF3, 0xFE, 0x7F, 0xE7, 0xFE, 0x7B, 0xE6, 0x3E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x9F, 0x87,
  0xC3, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xE3, 0xF1, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x78, 0xF0, 0x1F, 0x3E,
  0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xDF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x1F, 0x0F, 0x83, 0xF3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x01, 0xFE, 0x07,
  0xFE, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0x7C, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFE, 0x0F, 0xCF, 0x83, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x3E, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE1, 0xF1, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE3, 0xE7, 0xEF, 0x87, 0xDF, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x1F, 0xBF,
  0xFF, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0xC0, 0x00,
  0x06, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0xF8, 0xFC, 0xFC, 0xF8, 0x70, 0x01, 0x80,
  0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x10, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7E,
  0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7E,
  0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0F, 0x07, 0xC0, 0xE3,
  0xC1, 0xFE, 0x1C, 0x70, 0x7F, 0xE3, 0x9E, 0x1F, 0x3C, 0x73, 0xC7, 0x87,
  0x0E, 0x70, 0xF0, 0xE1, 0xDE, 0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x87, 0x70,
  0xF0, 0xE0, 0xFE, 0x3C, 0x1C, 0x1F, 0xC7, 0x87, 0x83, 0xF8, 0xF0, 0xF0,
  0xEE, 0x1E, 0x1E, 0x1D, 0xC3, 0xC3, 0x83, 0xB8, 0x78, 0xF0, 0xE7, 0x0F,
  0x1E, 0x1C, 0xE1, 0xE7, 0xC7, 0x1C, 0x3F, 0xFF, 0xE3, 0x83, 0xF3, 0xF8,
  0x70, 0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFC, 0x3F, 0x87, 0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0x07, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03,
  0xF1, 0xF0, 0x1F, 0x8F, 0x83, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xE1, 0xF0, 0x3F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8,
  0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFC, 0x7F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x3F, 0x0F, 0x87, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xE1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0,
  0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC3, 0xFE, 0xF8, 0x3F, 0xEF, 0x83, 0xFE, 0xF8, 0x7F, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xFC, 0x0F, 0xC7, 0xF3, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E,
  0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x3E, 0x07,
  0xE7, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x7F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x8F, 0xC0,
  0x0F, 0x9F, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x0F, 0x78, 0x1F, 0xF0, 0x3D, 0xE0, 0x7F, 0xC1, 0xF7, 0x83,
  0xFF, 0x07, 0xDE, 0x0F, 0x7C, 0x1F, 0x78, 0x3D, 0xF0, 0x7D, 0xE1, 0xE7,
  0xC1, 0xF7, 0x87, 0xBE, 0x07, 0xDE, 0x3C, 0xF8, 0x3E, 0x38, 0xF3, 0xE0,
  0xF8, 0xF7, 0x8F, 0x83, 0xE3, 0xDE, 0x3E, 0x0F, 0x8F, 0xF9, 0xF0, 0x3E,
  0x3F, 0xC7, 0xC0, 0xF8, 0xFF, 0x1F, 0x07, 0xC3, 0xF8, 0x7C, 0x1F, 0x0F,
  0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0,
  0xF8, 0x3F, 0x07, 0x83, 0xE0, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3E, 0x0F,
  0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x1F,
  0xF8, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F,
  0x1C, 0x7C, 0x1F, 0x1E, 0xFC, 0x3F, 0x1E, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x07, 0xF8, 0x7C,
  0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0xFE, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xC7,
  0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xF0, 0x3E, 0x0F, 0xE7, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x1F, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xCF,
  0xE1, 0xF0, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x0F, 0x87, 0xF3, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x3F,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xE7, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xF7,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC,
  0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00,
  0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0,
  0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x03, 0xFF, 0x03,
  0xC0, 0xFF, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F, 0x03, 0xEF, 0x83, 0xF0, 0xF9,
  0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC7, 0xF8, 0x78, 0xF8, 0xFF,
  0x1F, 0x1F, 0x1F, 0xE3, 0xE3, 0xE7, 0xFC, 0x78, 0x7C, 0xF7, 0x9F, 0x0F,
  0x9E, 0xF3, 0xE1, 0xF7, 0xDE, 0x78, 0x3E, 0xF3, 0xDF, 0x07, 0xDE, 0x7B,
  0xE0, 0xFF, 0x8F, 0x78, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xF1, 0xF8,
  0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xEF, 0x80, 0x07, 0xEF, 0x80, 0x07, 0xCF, 0xC0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x87, 0xC0, 0x1F, 0x87, 0xC0, 0x3F, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x9F,
  0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E,
  0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3C, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xEE, 0x1E, 0x70, 0xF3, 0xCF, 0x1E,
  0x78, 0xF7, 0x87, 0xBC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0x00, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x00, 0x1F,
  0x03, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xE7, 0xE1, 0xF3, 0xE0,
  0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x87,
  0xFF, 0xC1, 0xF3, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xEF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xF1,
  0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F,
  0x9F, 0x8F, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFB, 0xFC, 0x3E, 0x7E, 0x00,
  0x03, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x3F, 0xDE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7E, 0x7F, 0x1F, 0x87, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFB, 0xC0, 0x3E, 0x78, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7C, 0x0F, 0x7C, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x08, 0x7E, 0x3C, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x81, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xF8, 0xFC, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xF9, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x82,
  0x03, 0xF0, 0x70, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x9F, 0x07,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0,
  0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E, 0x07, 0xDF,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0xFC, 0x7C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7E,
  0x07, 0xDF, 0x80, 0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xF1,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x0F, 0x3E, 0x0F, 0x83, 0xFF, 0xE7, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF9, 0xFE, 0x7E, 0x3E, 0x1F,
  0x87, 0xC7, 0xC3, 0xE0, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x83, 0xE7,
  0xC1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0x83, 0xE3, 0xC1, 0xF0,
  0x7C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x3E, 0x7C,
  0x1F, 0x07, 0xCF, 0x83, 0xC1, 0xF1, 0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07,
  0xCF, 0x83, 0xE0, 0xF8, 0x0F, 0x3E, 0x0F, 0xBF, 0x87, 0xFF, 0xE3, 0xFF,
  0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF7, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1,
  0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7C, 0x7C,
  0x7E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0x9F,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x07,
  0xC3, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E,
  0x3F, 0x1F, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3E, 0xFF, 0x07, 0xCF, 0x80,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xC3, 0xFD, 0xE1,
  0xFF, 0x78, 0xFF, 0xFE, 0x3F, 0x3F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x38, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF1, 0xF0, 0xF0,
  0x7C, 0xF8, 0x3E, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0x7C, 0x3E,
  0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xE0, 0x1E, 0x07, 0xCF,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0,
  0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFE, 0xF0, 0x1F, 0x7C, 0x00, 0xF8, 0x1F, 0xF8,
  0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x7C,
  0xF8, 0x7C, 0xF0, 0x7D, 0xF0, 0x7D, 0xF0, 0x7D, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0xF8, 0x3C, 0x1E, 0xF8, 0x7C, 0x3E, 0x78, 0x7C, 0x3E,
  0x78, 0x7C, 0x3C, 0x78, 0xFC, 0x7C, 0x78, 0xFC, 0x7C, 0x79, 0xFC, 0x78,
  0x79, 0xFC, 0xF8, 0x79, 0xFC, 0xF0, 0x7B, 0xDC, 0xF0, 0x7B, 0xDD, 0xF0,
  0x7F, 0x9D, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E,
  0x3F, 0x03, 0xC7, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x3C, 0x07, 0xC7,
  0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE3, 0xE0,
  0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xE0, 0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x00, 0x30, 0x07, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xF0, 0x3E, 0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x40, 0x07,
  0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x20, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x77, 0xFC, 0x3D, 0xFF, 0x8F, 0xFB, 0xE7, 0xFC, 0x7F, 0xEF,
  0x0F, 0xFB, 0x81, 0xFC, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 28, 10, 1, -28 },
  { 36, 11, 10, 12, 3, -30 },
  { 50, 20, 28, 21, 1, -28 },
  { 120, 18, 36, 20, 1, -32 },
  { 201, 18, 28, 25, 4, -28 },
  { 264, 19, 28, 22, 1, -28 },
  { 331, 5, 10, 6, 3, -30 },
  { 338, 12, 41, 12, 2, -32 },
  { 400, 13, 41, 13, -2, -32 },
  { 467, 17, 17, 17, 2, -28 },
  { 504, 17, 21, 19, 1, -24 },
  { 549, 8, 12, 9, -2, -5 },
  { 561, 9, 4, 13, 2, -14 },
  { 566, 6, 6, 11, 1, -6 },
  { 571, 17, 30, 13, -2, -28 },
  { 635, 17, 28, 20, 2, -28 },
  { 695, 12, 28, 20, 4, -28 },
  { 737, 19, 28, 20, 0, -28 },
  { 804, 18, 28, 20, 1, -28 },
  { 867, 19, 28, 20, 0, -28 },
  { 934, 19, 28, 20, 1, -28 },
  { 1001, 16, 28, 20, 2, -28 },
  { 1057, 18, 28, 20, 2, -28 },
  { 1120, 18, 28, 20, 1, -28 },
  { 1183, 15, 28, 20, 3, -28 },
  { 1236, 8, 22, 10, 1, -22 },
  { 1258, 11, 29, 10, -2, -22 },
  { 1298, 16, 19, 17, 1, -22 },
  { 1336, 16, 12, 19, 2, -19 },
  { 1360, 16, 18, 18, 1, -21 },
  { 1396, 14, 28, 17, 3, -28 },
  { 1445, 27, 37, 30, 1, -28 },
  { 1570, 22, 28, 23, -2, -28 },
  { 1647, 21, 28, 22, 0, -28 },
  { 1721, 20, 28, 22, 2, -28 },
  { 1791, 21, 28, 22, 0, -28 },
  { 1865, 21, 28, 19, 0, -28 },
  { 1939, 20, 28, 19, 0, -28 },
  { 2009, 20, 28, 23, 2, -28 },
  { 2079, 24, 28, 24, 0, -28 },
  { 2163, 10, 28, 10, 1, -28 },
  { 2198, 20, 28, 19, 0, -28 },
  { 2268, 24, 28, 21, 0, -28 },
  { 2352, 16, 28, 19, 0, -28 },
  { 2408, 30, 28, 29, 0, -28 },
  { 2513, 24, 28, 24, 0, -28 },
  { 2597, 21, 28, 23, 2, -28 },
  { 2671, 22, 28, 22, 0, -28 },
  { 2748, 20, 33, 23, 2, -28 },
  { 2831, 21, 28, 21, 0, -28 },
  { 2905, 20, 28, 21, 1, -28 },
  { 2975, 20, 28, 21, 3, -28 },
  { 3045, 22, 28, 22, 1, -28 },
  { 3122, 22, 28, 22, 3, -28 },
  { 3199, 27, 28, 29, 4, -28 },
  { 3294, 24, 28, 22, -1, -28 },
  { 3378, 21, 28, 21, 3, -28 },
  { 3452, 23, 28, 21, -1, -28 },
  { 3533, 14, 40, 10, -1, -33 },
  { 3603, 9, 30, 15, 3, -28 },
  { 3637, 13, 40, 10, -2, -33 },
  { 3702, 13, 14, 15, 1, -28 },
  { 3725, 15, 4, 16, -2, 0 },
  { 3733, 8, 6, 13, 4, -30 },
  { 3739, 17, 21, 18, 0, -21 },
  { 3784, 18, 30, 19, 0, -30 },
  { 3852, 16, 21, 18, 1, -21 },
  { 3894, 19, 30, 19, 1, -30 },
  { 3966, 16, 21, 19, 1, -21 },
  { 4008, 14, 30, 13, 1, -30 },
  { 4061, 19, 29, 19, 0, -21 },
  { 4130, 17, 30, 19, 0, -30 },
  { 4194, 10, 30, 10, 0, -30 },
  { 4232, 14, 38, 9, -4, -30 },
  { 4299, 19, 30, 18, 0, -30 },
  { 4371, 10, 30, 10, 0, -30 },
  { 4409, 27, 21, 29, 0, -21 },
  { 4480, 17, 21, 19, 0, -21 },
  { 4525, 17, 21, 19, 1, -21 },
  { 4570, 19, 29, 19, -1, -21 },
  { 4639, 18, 29, 19, 1, -21 },
  { 4705, 13, 21, 13, 0, -21 },
  { 4740, 17, 21, 18, 0, -21 },
  { 4785, 11, 26, 12, 1, -26 },
  { 4821, 18, 21, 19, 1, -21 },
  { 4869, 16, 21, 17, 2, -21 },
  { 4911, 24, 21, 25, 2, -21 },
  { 4974, 19, 21, 17, -1, -21 },
  { 5024, 19, 29, 17, -1, -21 },
  { 5093, 17, 21, 17, 0, -21 },
  { 5138, 12, 38, 12, 1, -31 },
  { 5195, 8, 33, 10, 1, -28 },
  { 5228, 13, 38, 12, -2, -31 },
  { 5290, 18, 9, 22, 2, -16 },
};

const GFXfont RobotoCondensed_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC40PT7B_H_
