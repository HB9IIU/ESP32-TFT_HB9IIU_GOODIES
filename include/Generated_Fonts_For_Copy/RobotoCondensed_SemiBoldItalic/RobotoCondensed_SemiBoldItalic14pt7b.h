#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC14PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x66, 0x40, 0xCC, 0xDF, 0xAA, 0x0A, 0x3C, 0x53, 0xF3,
  0x45, 0x3F, 0x34, 0x50, 0xA0, 0x08, 0x38, 0xF3, 0x36, 0x06, 0x07, 0x06,
  0xCC, 0xF9, 0xE1, 0x00, 0x61, 0xAA, 0x54, 0xC7, 0x03, 0x8E, 0xA9, 0xD6,
  0x18, 0x1C, 0x78, 0x91, 0x63, 0x8E, 0x77, 0xE6, 0xFC, 0xEC, 0xFA, 0x12,
  0x64, 0xCC, 0x88, 0x88, 0x88, 0xC4, 0x20, 0x84, 0x31, 0x8C, 0x63, 0x11,
  0x8C, 0x44, 0x40, 0x30, 0x8F, 0x98, 0x52, 0x40, 0x18, 0x61, 0x1F, 0x7C,
  0xC3, 0x0C, 0x6D, 0x60, 0xE0, 0xF0, 0x04, 0x30, 0x82, 0x10, 0x43, 0x08,
  0x61, 0x0C, 0x00, 0x39, 0xEC, 0xF3, 0xCA, 0x29, 0xA6, 0xF3, 0xC0, 0x3E,
  0xA6, 0x66, 0x64, 0xCC, 0x3C, 0xF9, 0x98, 0x20, 0xC3, 0x0C, 0x30, 0xC1,
  0xF8, 0x3C, 0x79, 0x98, 0x20, 0xC7, 0x03, 0x66, 0x7C, 0xF0, 0x0C, 0x18,
  0x71, 0xE2, 0xCD, 0xB2, 0x7E, 0x18, 0x30, 0x3E, 0x7C, 0x83, 0xC6, 0xC1,
  0x83, 0x26, 0x78, 0x70, 0x1B, 0xD1, 0xED, 0xCE, 0x73, 0xFB, 0x80, 0xFC,
  0x30, 0x86, 0x10, 0xC6, 0x18, 0xC3, 0x00, 0x1C, 0x79, 0x9B, 0x23, 0xC7,
  0x13, 0x66, 0x7C, 0xF0, 0x3B, 0xF3, 0x9C, 0xED, 0xE2, 0xF7, 0x00, 0x6C,
  0x00, 0x36, 0x33, 0x00, 0x00, 0x26, 0x6C, 0x04, 0x77, 0x30, 0x70, 0xE0,
  0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x41, 0xC3, 0xC3, 0x39, 0x88, 0x00, 0x77,
  0xF6, 0x33, 0x31, 0x80, 0xC6, 0x00, 0x0F, 0x06, 0x22, 0x05, 0x99, 0x4A,
  0x56, 0x9D, 0x27, 0x4A, 0x96, 0xB6, 0xC4, 0x01, 0x80, 0x3C, 0x00, 0x06,
  0x0E, 0x0E, 0x0A, 0x1A, 0x13, 0x3F, 0x3F, 0x63, 0x63, 0x3C, 0x7D, 0x8B,
  0x36, 0x6F, 0x99, 0xA3, 0xFD, 0xF0, 0x3C, 0xFB, 0x1E, 0x0C, 0x18, 0x20,
  0x46, 0xFC, 0xE0, 0x3C, 0x7D, 0x9B, 0x16, 0x6C, 0xD9, 0xA3, 0xFD, 0xF0,
  0x3E, 0x7D, 0x83, 0x06, 0x0F, 0x98, 0x20, 0xFD, 0xF8, 0x3E, 0x7D, 0x83,
  0x07, 0xCF, 0x98, 0x20, 0xC1, 0x80, 0x3C, 0xFF, 0x1E, 0x0C, 0x1B, 0xA3,
  0x46, 0xFC, 0xF0, 0x31, 0x11, 0x98, 0xCC, 0x67, 0xF3, 0xF9, 0x88, 0x8C,
  0xC6, 0x63, 0x00, 0x32, 0x66, 0x66, 0x64, 0xCC, 0x06, 0x0C, 0x10, 0x60,
  0xC1, 0x83, 0x66, 0xF8, 0xE0, 0x33, 0x13, 0x1B, 0x0D, 0x87, 0x83, 0xC1,
  0xB0, 0x98, 0xCC, 0x63, 0x00, 0x30, 0x86, 0x18, 0x61, 0x86, 0x10, 0xFF,
  0xF0, 0x30, 0xCC, 0x77, 0x1D, 0xC7, 0x7B, 0xDE, 0xB5, 0xE9, 0x36, 0xCD,
  0xB2, 0x60, 0x31, 0x19, 0x9C, 0xCF, 0x66, 0xB3, 0x59, 0xA8, 0x9C, 0xC6,
  0x63, 0x00, 0x3C, 0xFB, 0x1E, 0x3C, 0x78, 0xE1, 0x46, 0xFC, 0xE0, 0x3E,
  0x3E, 0x63, 0x63, 0x7E, 0x7C, 0x60, 0x40, 0xC0, 0xC0, 0x3C, 0xFB, 0x1E,
  0x3C, 0x78, 0xE1, 0x46, 0xF8, 0xF0, 0x60, 0x40, 0x3C, 0x7D, 0x8B, 0x37,
  0xEF, 0x9B, 0x26, 0xCD, 0x98, 0x1C, 0x7D, 0x9B, 0x03, 0x83, 0x81, 0x62,
  0x7C, 0xF0, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC0, 0x23,
  0x63, 0x63, 0x62, 0x66, 0x66, 0x46, 0x46, 0x7C, 0x38, 0xC6, 0xC6, 0xC4,
  0x4C, 0x4C, 0x58, 0x78, 0x70, 0x70, 0x60, 0xCC, 0xF3, 0x2D, 0xDB, 0x76,
  0xD5, 0x3D, 0xCE, 0x73, 0x98, 0xE6, 0x31, 0x80, 0x63, 0x36, 0x36, 0x3C,
  0x18, 0x38, 0x3C, 0x6C, 0x6C, 0xC4, 0xC6, 0x99, 0x33, 0xC7, 0x86, 0x08,
  0x30, 0x60, 0xC0, 0x7F, 0x7E, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xFC,
  0xFC, 0x32, 0x26, 0x66, 0x64, 0x4C, 0xCC, 0xCC, 0xD9, 0x24, 0xDB, 0x6C,
  0x80, 0x38, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x70, 0x11, 0x8E,
  0xD4, 0x80, 0xFC, 0x64, 0x39, 0xB0, 0xDF, 0xCF, 0x2D, 0x9A, 0x20, 0x86,
  0x1F, 0x6D, 0x94, 0xD3, 0xCF, 0xFF, 0x80, 0x39, 0xB4, 0xF0, 0xC3, 0x27,
  0x9C, 0x06, 0x0C, 0x19, 0xB6, 0xC9, 0xB3, 0x66, 0xCD, 0xF9, 0xE0, 0x39,
  0xB4, 0xD3, 0xFF, 0x06, 0x9E, 0x19, 0xCC, 0xF2, 0x31, 0x8C, 0x62, 0x10,
  0x36, 0xD9, 0x16, 0x6C, 0xD9, 0x9F, 0x3C, 0x09, 0xB3, 0xC0, 0x20, 0x86,
  0x1F, 0x6D, 0xB4, 0xD3, 0xCF, 0x2C, 0x80, 0x22, 0x06, 0x66, 0x64, 0x4C,
  0xC0, 0x11, 0x03, 0x33, 0x32, 0x66, 0x66, 0xCC, 0x20, 0x41, 0x83, 0x66,
  0xCF, 0x1C, 0x38, 0xD9, 0xB3, 0x20, 0x32, 0x26, 0x66, 0x64, 0x4C, 0xC0,
  0x7F, 0x9B, 0xE6, 0xC9, 0x32, 0x4D, 0xB3, 0x6C, 0x9B, 0x26, 0x7D, 0xB6,
  0xD3, 0x4F, 0x3C, 0xB2, 0x39, 0xB4, 0x71, 0xCF, 0x37, 0x9E, 0x7D, 0xB6,
  0x53, 0x4F, 0x3F, 0xFE, 0xC2, 0x08, 0x00, 0x34, 0xD9, 0x36, 0x6C, 0xD9,
  0xBF, 0x3C, 0x18, 0x30, 0x60, 0x7B, 0xD8, 0x84, 0x63, 0x18, 0x39, 0xB6,
  0x1C, 0x38, 0x2D, 0x9C, 0x37, 0x26, 0x66, 0x66, 0x60, 0x64, 0xC9, 0xB2,
  0x64, 0xD9, 0x9E, 0x3C, 0xDE, 0xF5, 0xEF, 0x73, 0x88, 0x9B, 0x9A, 0xBA,
  0xBE, 0xAC, 0xCC, 0xCC, 0xC8, 0x6D, 0xB3, 0x8C, 0x31, 0xCD, 0xB6, 0x6D,
  0xB6, 0x9E, 0x79, 0xC7, 0x18, 0x63, 0x0C, 0x00, 0x7C, 0x31, 0x8C, 0x21,
  0x8C, 0x3E, 0x19, 0x8C, 0x42, 0x33, 0x0C, 0x62, 0x10, 0x82, 0x00, 0x24,
  0x96, 0x92, 0x4B, 0x40, 0x20, 0x84, 0x21, 0x08, 0x43, 0x31, 0x08, 0xC6,
  0x20, 0xE7, 0xF9, 0x80,
};

const GFXglyph RobotoCondensed_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 7, 10, 7, 0, -10 },
  { 17, 7, 12, 7, 0, -11 },
  { 28, 7, 10, 9, 1, -10 },
  { 37, 7, 10, 8, 0, -10 },
  { 46, 2, 4, 2, 1, -11 },
  { 47, 4, 14, 4, 1, -11 },
  { 54, 5, 14, 4, -1, -11 },
  { 63, 6, 6, 6, 1, -10 },
  { 68, 6, 8, 7, 0, -9 },
  { 74, 3, 4, 3, -1, -2 },
  { 76, 3, 1, 5, 1, -5 },
  { 77, 2, 2, 4, 0, -2 },
  { 78, 6, 11, 5, -1, -10 },
  { 87, 6, 10, 7, 1, -10 },
  { 95, 4, 10, 7, 2, -10 },
  { 100, 7, 10, 7, 0, -10 },
  { 109, 7, 10, 7, 0, -10 },
  { 118, 7, 10, 7, 0, -10 },
  { 127, 7, 10, 7, 0, -10 },
  { 136, 5, 10, 7, 1, -10 },
  { 143, 6, 10, 7, 1, -10 },
  { 151, 7, 10, 7, 0, -10 },
  { 160, 5, 10, 7, 1, -10 },
  { 167, 3, 8, 4, 0, -8 },
  { 170, 4, 10, 3, -1, -8 },
  { 175, 6, 7, 6, 0, -8 },
  { 181, 5, 5, 7, 1, -7 },
  { 185, 6, 7, 6, 0, -8 },
  { 191, 5, 10, 6, 1, -10 },
  { 198, 10, 13, 10, 0, -10 },
  { 215, 8, 10, 8, -1, -10 },
  { 225, 7, 10, 8, 0, -10 },
  { 234, 7, 10, 8, 1, -10 },
  { 243, 7, 10, 8, 0, -10 },
  { 252, 7, 10, 7, 0, -10 },
  { 261, 7, 10, 6, 0, -10 },
  { 270, 7, 10, 8, 1, -10 },
  { 279, 9, 10, 8, 0, -10 },
  { 291, 4, 10, 4, 0, -10 },
  { 296, 7, 10, 7, 0, -10 },
  { 305, 9, 10, 7, 0, -10 },
  { 317, 6, 10, 6, 0, -10 },
  { 325, 10, 10, 10, 0, -10 },
  { 338, 9, 10, 8, 0, -10 },
  { 350, 7, 10, 8, 1, -10 },
  { 359, 8, 10, 8, 0, -10 },
  { 369, 7, 12, 8, 1, -10 },
  { 380, 7, 10, 7, 0, -10 },
  { 389, 7, 10, 7, 0, -10 },
  { 398, 7, 10, 7, 1, -10 },
  { 407, 8, 10, 8, 0, -10 },
  { 417, 8, 10, 8, 1, -10 },
  { 427, 10, 10, 10, 1, -10 },
  { 440, 8, 10, 8, 0, -10 },
  { 450, 7, 10, 7, 1, -10 },
  { 459, 8, 10, 7, 0, -10 },
  { 469, 4, 14, 4, 0, -12 },
  { 476, 3, 11, 5, 1, -10 },
  { 481, 5, 14, 4, -1, -12 },
  { 490, 5, 5, 5, 0, -10 },
  { 494, 6, 1, 5, -1, 0 },
  { 495, 3, 2, 4, 1, -10 },
  { 496, 6, 8, 6, 0, -8 },
  { 502, 6, 11, 7, 0, -11 },
  { 511, 6, 8, 6, 0, -8 },
  { 517, 7, 11, 7, 0, -11 },
  { 527, 6, 8, 6, 0, -8 },
  { 533, 5, 11, 4, 0, -11 },
  { 540, 7, 11, 7, 0, -8 },
  { 550, 6, 11, 7, 0, -11 },
  { 559, 4, 11, 3, 0, -11 },
  { 565, 4, 14, 3, -1, -11 },
  { 572, 7, 11, 6, 0, -11 },
  { 582, 4, 11, 3, 0, -11 },
  { 588, 10, 8, 10, 0, -8 },
  { 598, 6, 8, 7, 0, -8 },
  { 604, 6, 8, 7, 0, -8 },
  { 610, 6, 11, 7, 0, -8 },
  { 619, 7, 11, 7, 0, -8 },
  { 629, 5, 8, 4, 0, -8 },
  { 634, 6, 8, 6, 0, -8 },
  { 640, 4, 9, 4, 0, -9 },
  { 645, 7, 8, 7, 0, -8 },
  { 652, 5, 8, 6, 1, -8 },
  { 657, 8, 8, 9, 1, -8 },
  { 665, 6, 8, 6, 0, -8 },
  { 671, 6, 11, 6, 0, -8 },
  { 680, 6, 8, 6, 0, -8 },
  { 686, 5, 13, 4, 0, -11 },
  { 695, 3, 12, 3, 0, -10 },
  { 700, 5, 14, 4, -1, -11 },
  { 709, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC14PT7B_H_
