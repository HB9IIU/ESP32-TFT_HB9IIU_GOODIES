#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC50PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x07, 0x80, 0x3E, 0x3C, 0xF8, 0xF3, 0xE7,
  0xCF, 0x1F, 0x3C, 0x7C, 0xF1, 0xE7, 0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE3,
  0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x3C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x3E, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F,
  0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F,
  0xCF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x78, 0x18, 0x78, 0x78, 0x1C,
  0x78, 0x78, 0x3C, 0x78, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0,
  0x78, 0x79, 0xF0, 0x78, 0x79, 0xE0, 0x78, 0xFB, 0xC0, 0x7F, 0xF7, 0x80,
  0x3F, 0xEF, 0x80, 0x3F, 0xEF, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0xFB, 0xFC, 0x00, 0xF7, 0xFE,
  0x01, 0xEF, 0xFE, 0x03, 0xCF, 0x1E, 0x07, 0xDF, 0x0F, 0x07, 0x9E, 0x0F,
  0x0F, 0x1E, 0x0F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1F, 0x3C, 0x1E, 0x1E,
  0x7C, 0x1E, 0x1E, 0x38, 0x1E, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF9, 0xF8,
  0x03, 0xF1, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE1, 0xF8,
  0x07, 0xE1, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0x1F, 0xFE, 0x1F, 0x3F, 0xFF, 0x1F,
  0x7F, 0x3F, 0x3F, 0x7E, 0x3F, 0xBE, 0xFE, 0x1F, 0xBE, 0xFE, 0x1F, 0xFE,
  0xFC, 0x0F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFE, 0xFE, 0x0F, 0xF8, 0x7E, 0x00, 0x80, 0x00, 0x3E, 0x7C, 0xF9,
  0xE3, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x00, 0x00, 0x02, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x04, 0x07, 0x81, 0x70, 0x70, 0x7F, 0xC7, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xF3, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xE0,
  0x7C, 0x1F, 0x03, 0x80, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF0, 0x78, 0x04, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF1, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xFC,
  0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF9,
  0xFB, 0x8F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xF1,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF9, 0xFC, 0x07,
  0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0x18, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x3F, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0xFF, 0x7F,
  0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xC0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0x3F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x7C, 0x1F,
  0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F, 0xC7,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xE3, 0xF0, 0x3F,
  0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0,
  0xFE, 0x7F, 0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7C, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0x81,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xCF,
  0xEF, 0xE1, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0xE0, 0x7C, 0x07, 0xE0, 0x3C, 0x1E, 0x03, 0xFE, 0x0F, 0x0F,
  0x83, 0xFF, 0xC3, 0xC3, 0xC1, 0xFF, 0xF0, 0xF1, 0xF0, 0x7C, 0x3C, 0x1C,
  0x78, 0x3E, 0x1F, 0x07, 0x3E, 0x0F, 0x07, 0xC1, 0xCF, 0x07, 0xC1, 0xE0,
  0x73, 0xC1, 0xE0, 0x78, 0x3D, 0xF0, 0xF8, 0x3E, 0x0F, 0x78, 0x3E, 0x0F,
  0x83, 0xDE, 0x0F, 0x03, 0xC0, 0xF7, 0x87, 0xC0, 0xF0, 0x3D, 0xE1, 0xF0,
  0x3C, 0x0F, 0xF8, 0x7C, 0x1F, 0x03, 0xBE, 0x1F, 0x07, 0xC1, 0xEF, 0x07,
  0xC1, 0xE0, 0x7B, 0xC1, 0xF0, 0x78, 0x1C, 0xF0, 0x7C, 0x3E, 0x0F, 0x3C,
  0x1F, 0x0F, 0x83, 0xCF, 0x07, 0xC7, 0xE1, 0xE3, 0xC1, 0xFF, 0xF8, 0xF0,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3C, 0x0F, 0xF3, 0xFE, 0x0F, 0x81, 0xF8, 0xFE,
  0x01, 0xE0, 0x10, 0x04, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xF0, 0x7F, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x87, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFC,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xF0, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x81, 0xFF, 0xE7, 0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC,
  0x7E, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00,
  0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0x87, 0xF8, 0x00, 0x7E, 0x3F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFE, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x0F, 0xFE, 0x07, 0xEF,
  0x80, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xDF, 0x81, 0xFB, 0xE0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x03, 0xEF, 0xE0, 0x7E, 0x78, 0x3F, 0x7E, 0x07, 0xF3, 0xE1,
  0xF3, 0xF0, 0x3F, 0x1F, 0x1F, 0x9F, 0x81, 0xF8, 0xF8, 0xF8, 0xFC, 0x0F,
  0xC7, 0xC7, 0xCF, 0xE0, 0x7E, 0x3E, 0x7C, 0x7E, 0x03, 0xF1, 0xF3, 0xE3,
  0xF0, 0x3F, 0x8F, 0xBE, 0x1F, 0x81, 0xFC, 0x7D, 0xF0, 0xFC, 0x0F, 0xC1,
  0xFF, 0x8F, 0xE0, 0x7E, 0x0F, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0xC3, 0xF0,
  0x1F, 0x83, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x80, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0x81,
  0xFF, 0x80, 0x7E, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x7F,
  0xF0, 0x3F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xBE,
  0x0F, 0xC0, 0xFE, 0xF8, 0x3F, 0x03, 0xF3, 0xE1, 0xFC, 0x0F, 0xC7, 0x87,
  0xF0, 0x3F, 0x1F, 0x1F, 0x81, 0xFC, 0x7C, 0x7E, 0x07, 0xF1, 0xF1, 0xF8,
  0x1F, 0xC3, 0xE7, 0xE0, 0x7E, 0x0F, 0xBF, 0x81, 0xF8, 0x3E, 0xFE, 0x07,
  0xE0, 0x7B, 0xF0, 0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x03, 0xF0,
  0x1F, 0xFC, 0x0F, 0xC0, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xC0, 0xFC, 0x03,
  0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F,
  0x81, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0,
  0x7F, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xE7, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC1, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xE7, 0xFF,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xFC, 0x0F, 0xC1,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE7,
  0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x01, 0xF1, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFF, 0x01, 0xF8, 0x07, 0xEF,
  0xC0, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0xFE, 0xFC, 0x0F, 0xE0, 0x3F,
  0x3F, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xF3, 0xF0, 0x7F, 0x81,
  0xF8, 0xFC, 0x1F, 0xF0, 0x7E, 0x3F, 0x07, 0xFC, 0x3F, 0x8F, 0xC3, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0xF0, 0xFC, 0x3F, 0x1F,
  0x7C, 0x7E, 0x0F, 0xC7, 0xDF, 0x1F, 0x83, 0xF1, 0xF7, 0xC7, 0xE0, 0xFC,
  0xF9, 0xF3, 0xF0, 0x3F, 0x3E, 0x7C, 0xFC, 0x0F, 0xCF, 0x9F, 0x3F, 0x03,
  0xF7, 0xC7, 0xDF, 0x80, 0xFD, 0xF1, 0xF7, 0xE0, 0x3F, 0x7C, 0x7D, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xDF, 0x80, 0x1F,
  0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xE1,
  0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xBC, 0x0F, 0xBE, 0x1F, 0x3E, 0x1F, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x7C,
  0x1E, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F, 0x83, 0xF0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xF3, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0x87, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFE, 0x3F, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xF8, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE7, 0xC0, 0x3F, 0x7F, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xC7, 0xF1, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0,
  0xFE, 0x7F, 0xCF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x7F, 0xF0,
  0xFC, 0xFF, 0x83, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x7F, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0xFC, 0x07, 0xFC, 0xFC, 0x0F, 0xFE, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xC7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0x07, 0xF8, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x3F, 0x01, 0xFF, 0x3E, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF3, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x20, 0x1F, 0xC0, 0x78, 0x3F, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x3F, 0x7F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E,
  0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0xE0,
  0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x9F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0xFF, 0x0F, 0xC1, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0xDF, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F,
  0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xBF, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xC7, 0xC0, 0x7E, 0x03,
  0xF7, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0xFF, 0xCF, 0xF0, 0xFC, 0x1F, 0xE1,
  0xFC, 0x7E, 0x07, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x03, 0xF1, 0xF8, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE0, 0x7E, 0x3F, 0x81,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7,
  0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x81,
  0xF8, 0xFC, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x3F, 0x7F, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xCF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E,
  0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xE3, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0x9F, 0x80, 0xFC,
  0xFC, 0x0F, 0xC7, 0xF1, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x03, 0xF7,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0x3F, 0xE0, 0x3F, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x1F, 0xFB,
  0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x1F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x81, 0xF8, 0x7F, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xCF,
  0x87, 0xEF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F,
  0xC4, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE,
  0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0x3F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8,
  0xFC, 0x1F, 0x87, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF, 0xC0, 0x7E, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x07, 0xE0,
  0xFD, 0xF8, 0x3F, 0x07, 0xEF, 0xC3, 0xF8, 0x7E, 0x7E, 0x1F, 0xC3, 0xF3,
  0xF1, 0xFE, 0x1F, 0x9F, 0x8F, 0xF1, 0xF8, 0xFC, 0x7F, 0x8F, 0xC7, 0xE7,
  0xFC, 0x7C, 0x3F, 0x3F, 0xE7, 0xE1, 0xFB, 0xEF, 0x3F, 0x0F, 0xDF, 0x79,
  0xF0, 0x3E, 0xF3, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0,
  0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E,
  0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03,
  0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F,
  0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x07,
  0xC3, 0xF0, 0x07, 0xC7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x07,
  0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x01, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x3C, 0x7F, 0xC0, 0x79, 0xFF, 0xC1, 0xF7, 0xFF, 0xC3, 0xEF, 0xDF,
  0xCF, 0x9F, 0x0F, 0xFF, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xF9, 0xF0, 0x1F,
  0xE0, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 36, 12, 1, -36 },
  { 55, 14, 13, 16, 3, -38 },
  { 78, 25, 36, 26, 1, -36 },
  { 191, 22, 46, 24, 2, -41 },
  { 318, 24, 36, 31, 4, -36 },
  { 426, 24, 37, 28, 1, -36 },
  { 537, 7, 13, 8, 3, -38 },
  { 549, 16, 51, 16, 2, -40 },
  { 651, 15, 51, 16, -2, -40 },
  { 747, 20, 21, 22, 3, -36 },
  { 800, 20, 26, 23, 2, -30 },
  { 865, 10, 14, 11, -3, -6 },
  { 883, 12, 5, 16, 2, -18 },
  { 891, 7, 7, 14, 1, -7 },
  { 898, 22, 39, 17, -3, -36 },
  { 1006, 21, 36, 24, 2, -36 },
  { 1101, 14, 36, 24, 6, -36 },
  { 1164, 24, 36, 24, 0, -36 },
  { 1272, 22, 36, 24, 1, -36 },
  { 1371, 22, 36, 24, 1, -36 },
  { 1470, 23, 36, 24, 2, -36 },
  { 1574, 20, 36, 24, 2, -36 },
  { 1664, 24, 36, 24, 2, -36 },
  { 1772, 23, 36, 24, 1, -36 },
  { 1876, 20, 36, 24, 3, -36 },
  { 1966, 11, 27, 13, 1, -27 },
  { 2004, 13, 35, 12, -2, -27 },
  { 2061, 20, 23, 22, 1, -27 },
  { 2119, 21, 16, 24, 2, -24 },
  { 2161, 20, 23, 22, 1, -27 },
  { 2219, 18, 36, 21, 4, -36 },
  { 2300, 34, 46, 37, 1, -35 },
  { 2496, 27, 36, 29, -2, -36 },
  { 2618, 26, 36, 27, 0, -36 },
  { 2735, 26, 36, 28, 2, -36 },
  { 2852, 26, 36, 27, 0, -36 },
  { 2969, 26, 36, 24, 0, -36 },
  { 3086, 25, 36, 23, 0, -36 },
  { 3199, 26, 36, 28, 2, -36 },
  { 3316, 30, 36, 30, 0, -36 },
  { 3451, 12, 36, 13, 1, -36 },
  { 3505, 24, 36, 24, 0, -36 },
  { 3613, 30, 36, 27, 0, -36 },
  { 3748, 20, 36, 23, 0, -36 },
  { 3838, 37, 36, 37, 0, -36 },
  { 4005, 30, 36, 30, 0, -36 },
  { 4140, 26, 36, 29, 2, -36 },
  { 4257, 27, 36, 27, 0, -36 },
  { 4379, 26, 42, 29, 2, -36 },
  { 4516, 27, 36, 27, 0, -36 },
  { 4638, 25, 36, 26, 1, -36 },
  { 4751, 24, 36, 26, 4, -36 },
  { 4859, 27, 36, 28, 2, -36 },
  { 4981, 27, 36, 28, 4, -36 },
  { 5103, 34, 36, 36, 5, -36 },
  { 5256, 30, 36, 27, -1, -36 },
  { 5391, 25, 36, 26, 4, -36 },
  { 5504, 28, 36, 26, -1, -36 },
  { 5630, 17, 49, 13, -1, -41 },
  { 5735, 12, 39, 18, 4, -36 },
  { 5794, 17, 49, 13, -3, -41 },
  { 5899, 16, 18, 19, 2, -36 },
  { 5935, 19, 5, 19, -3, 0 },
  { 5947, 10, 7, 16, 5, -37 },
  { 5956, 20, 26, 23, 1, -26 },
  { 6021, 22, 38, 24, 0, -38 },
  { 6126, 20, 26, 22, 1, -26 },
  { 6191, 24, 38, 24, 1, -38 },
  { 6305, 21, 26, 23, 1, -26 },
  { 6374, 17, 39, 16, 2, -39 },
  { 6457, 24, 36, 24, 0, -26 },
  { 6565, 22, 38, 24, 0, -38 },
  { 6670, 13, 36, 12, 0, -36 },
  { 6729, 17, 46, 12, -5, -36 },
  { 6827, 24, 38, 23, 0, -38 },
  { 6941, 13, 38, 12, 0, -38 },
  { 7003, 34, 26, 36, 0, -26 },
  { 7114, 22, 26, 24, 0, -26 },
  { 7186, 21, 26, 24, 1, -26 },
  { 7255, 24, 36, 24, -2, -26 },
  { 7363, 22, 36, 24, 1, -26 },
  { 7462, 17, 26, 16, 0, -26 },
  { 7518, 21, 26, 22, 0, -26 },
  { 7587, 13, 33, 15, 2, -33 },
  { 7641, 22, 26, 24, 1, -26 },
  { 7713, 20, 26, 22, 3, -26 },
  { 7778, 29, 26, 31, 3, -26 },
  { 7873, 25, 26, 22, -2, -26 },
  { 7955, 24, 36, 21, -1, -26 },
  { 8063, 23, 26, 22, -1, -26 },
  { 8138, 16, 48, 15, 1, -39 },
  { 8234, 10, 43, 12, 1, -36 },
  { 8288, 16, 48, 15, -2, -39 },
  { 8384, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC50PT7B_H_
