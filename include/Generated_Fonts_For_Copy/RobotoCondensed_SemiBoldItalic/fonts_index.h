#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_SemiBoldItalic6pt7b, 6, "RobotoCondensed_SemiBoldItalic6pt7b" },
  { &RobotoCondensed_SemiBoldItalic7pt7b, 7, "RobotoCondensed_SemiBoldItalic7pt7b" },
  { &RobotoCondensed_SemiBoldItalic8pt7b, 8, "RobotoCondensed_SemiBoldItalic8pt7b" },
  { &RobotoCondensed_SemiBoldItalic9pt7b, 9, "RobotoCondensed_SemiBoldItalic9pt7b" },
  { &RobotoCondensed_SemiBoldItalic10pt7b, 10, "RobotoCondensed_SemiBoldItalic10pt7b" },
  { &RobotoCondensed_SemiBoldItalic11pt7b, 11, "RobotoCondensed_SemiBoldItalic11pt7b" },
  { &RobotoCondensed_SemiBoldItalic12pt7b, 12, "RobotoCondensed_SemiBoldItalic12pt7b" },
  { &RobotoCondensed_SemiBoldItalic13pt7b, 13, "RobotoCondensed_SemiBoldItalic13pt7b" },
  { &RobotoCondensed_SemiBoldItalic14pt7b, 14, "RobotoCondensed_SemiBoldItalic14pt7b" },
  { &RobotoCondensed_SemiBoldItalic15pt7b, 15, "RobotoCondensed_SemiBoldItalic15pt7b" },
  { &RobotoCondensed_SemiBoldItalic16pt7b, 16, "RobotoCondensed_SemiBoldItalic16pt7b" },
  { &RobotoCondensed_SemiBoldItalic17pt7b, 17, "RobotoCondensed_SemiBoldItalic17pt7b" },
  { &RobotoCondensed_SemiBoldItalic18pt7b, 18, "RobotoCondensed_SemiBoldItalic18pt7b" },
  { &RobotoCondensed_SemiBoldItalic19pt7b, 19, "RobotoCondensed_SemiBoldItalic19pt7b" },
  { &RobotoCondensed_SemiBoldItalic20pt7b, 20, "RobotoCondensed_SemiBoldItalic20pt7b" },
  { &RobotoCondensed_SemiBoldItalic21pt7b, 21, "RobotoCondensed_SemiBoldItalic21pt7b" },
  { &RobotoCondensed_SemiBoldItalic22pt7b, 22, "RobotoCondensed_SemiBoldItalic22pt7b" },
  { &RobotoCondensed_SemiBoldItalic23pt7b, 23, "RobotoCondensed_SemiBoldItalic23pt7b" },
  { &RobotoCondensed_SemiBoldItalic24pt7b, 24, "RobotoCondensed_SemiBoldItalic24pt7b" },
  { &RobotoCondensed_SemiBoldItalic25pt7b, 25, "RobotoCondensed_SemiBoldItalic25pt7b" },
  { &RobotoCondensed_SemiBoldItalic26pt7b, 26, "RobotoCondensed_SemiBoldItalic26pt7b" },
  { &RobotoCondensed_SemiBoldItalic27pt7b, 27, "RobotoCondensed_SemiBoldItalic27pt7b" },
  { &RobotoCondensed_SemiBoldItalic28pt7b, 28, "RobotoCondensed_SemiBoldItalic28pt7b" },
  { &RobotoCondensed_SemiBoldItalic29pt7b, 29, "RobotoCondensed_SemiBoldItalic29pt7b" },
  { &RobotoCondensed_SemiBoldItalic30pt7b, 30, "RobotoCondensed_SemiBoldItalic30pt7b" },
  { &RobotoCondensed_SemiBoldItalic31pt7b, 31, "RobotoCondensed_SemiBoldItalic31pt7b" },
  { &RobotoCondensed_SemiBoldItalic32pt7b, 32, "RobotoCondensed_SemiBoldItalic32pt7b" },
  { &RobotoCondensed_SemiBoldItalic33pt7b, 33, "RobotoCondensed_SemiBoldItalic33pt7b" },
  { &RobotoCondensed_SemiBoldItalic34pt7b, 34, "RobotoCondensed_SemiBoldItalic34pt7b" },
  { &RobotoCondensed_SemiBoldItalic35pt7b, 35, "RobotoCondensed_SemiBoldItalic35pt7b" },
  { &RobotoCondensed_SemiBoldItalic36pt7b, 36, "RobotoCondensed_SemiBoldItalic36pt7b" },
  { &RobotoCondensed_SemiBoldItalic37pt7b, 37, "RobotoCondensed_SemiBoldItalic37pt7b" },
  { &RobotoCondensed_SemiBoldItalic38pt7b, 38, "RobotoCondensed_SemiBoldItalic38pt7b" },
  { &RobotoCondensed_SemiBoldItalic39pt7b, 39, "RobotoCondensed_SemiBoldItalic39pt7b" },
  { &RobotoCondensed_SemiBoldItalic40pt7b, 40, "RobotoCondensed_SemiBoldItalic40pt7b" },
  { &RobotoCondensed_SemiBoldItalic41pt7b, 41, "RobotoCondensed_SemiBoldItalic41pt7b" },
  { &RobotoCondensed_SemiBoldItalic42pt7b, 42, "RobotoCondensed_SemiBoldItalic42pt7b" },
  { &RobotoCondensed_SemiBoldItalic43pt7b, 43, "RobotoCondensed_SemiBoldItalic43pt7b" },
  { &RobotoCondensed_SemiBoldItalic44pt7b, 44, "RobotoCondensed_SemiBoldItalic44pt7b" },
  { &RobotoCondensed_SemiBoldItalic45pt7b, 45, "RobotoCondensed_SemiBoldItalic45pt7b" },
  { &RobotoCondensed_SemiBoldItalic46pt7b, 46, "RobotoCondensed_SemiBoldItalic46pt7b" },
  { &RobotoCondensed_SemiBoldItalic47pt7b, 47, "RobotoCondensed_SemiBoldItalic47pt7b" },
  { &RobotoCondensed_SemiBoldItalic48pt7b, 48, "RobotoCondensed_SemiBoldItalic48pt7b" },
  { &RobotoCondensed_SemiBoldItalic49pt7b, 49, "RobotoCondensed_SemiBoldItalic49pt7b" },
  { &RobotoCondensed_SemiBoldItalic50pt7b, 50, "RobotoCondensed_SemiBoldItalic50pt7b" },
  { &RobotoCondensed_SemiBoldItalic51pt7b, 51, "RobotoCondensed_SemiBoldItalic51pt7b" },
  { &RobotoCondensed_SemiBoldItalic52pt7b, 52, "RobotoCondensed_SemiBoldItalic52pt7b" },
  { &RobotoCondensed_SemiBoldItalic53pt7b, 53, "RobotoCondensed_SemiBoldItalic53pt7b" },
  { &RobotoCondensed_SemiBoldItalic54pt7b, 54, "RobotoCondensed_SemiBoldItalic54pt7b" },
  { &RobotoCondensed_SemiBoldItalic55pt7b, 55, "RobotoCondensed_SemiBoldItalic55pt7b" },
  { &RobotoCondensed_SemiBoldItalic56pt7b, 56, "RobotoCondensed_SemiBoldItalic56pt7b" },
  { &RobotoCondensed_SemiBoldItalic57pt7b, 57, "RobotoCondensed_SemiBoldItalic57pt7b" },
  { &RobotoCondensed_SemiBoldItalic58pt7b, 58, "RobotoCondensed_SemiBoldItalic58pt7b" },
  { &RobotoCondensed_SemiBoldItalic59pt7b, 59, "RobotoCondensed_SemiBoldItalic59pt7b" },
  { &RobotoCondensed_SemiBoldItalic60pt7b, 60, "RobotoCondensed_SemiBoldItalic60pt7b" },
  { &RobotoCondensed_SemiBoldItalic61pt7b, 61, "RobotoCondensed_SemiBoldItalic61pt7b" },
  { &RobotoCondensed_SemiBoldItalic62pt7b, 62, "RobotoCondensed_SemiBoldItalic62pt7b" },
  { &RobotoCondensed_SemiBoldItalic63pt7b, 63, "RobotoCondensed_SemiBoldItalic63pt7b" },
  { &RobotoCondensed_SemiBoldItalic64pt7b, 64, "RobotoCondensed_SemiBoldItalic64pt7b" },
  { &RobotoCondensed_SemiBoldItalic65pt7b, 65, "RobotoCondensed_SemiBoldItalic65pt7b" },
  { &RobotoCondensed_SemiBoldItalic66pt7b, 66, "RobotoCondensed_SemiBoldItalic66pt7b" },
  { &RobotoCondensed_SemiBoldItalic67pt7b, 67, "RobotoCondensed_SemiBoldItalic67pt7b" },
  { &RobotoCondensed_SemiBoldItalic68pt7b, 68, "RobotoCondensed_SemiBoldItalic68pt7b" },
  { &RobotoCondensed_SemiBoldItalic69pt7b, 69, "RobotoCondensed_SemiBoldItalic69pt7b" },
  { &RobotoCondensed_SemiBoldItalic70pt7b, 70, "RobotoCondensed_SemiBoldItalic70pt7b" },
  { &RobotoCondensed_SemiBoldItalic71pt7b, 71, "RobotoCondensed_SemiBoldItalic71pt7b" },
  { &RobotoCondensed_SemiBoldItalic72pt7b, 72, "RobotoCondensed_SemiBoldItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
