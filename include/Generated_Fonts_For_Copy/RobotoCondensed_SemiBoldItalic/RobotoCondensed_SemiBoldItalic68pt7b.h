#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC68PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x8F,
  0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E,
  0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD,
  0xFF, 0x80, 0xFF, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0,
  0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x7F, 0x0F, 0x80, 0x30, 0x7E, 0x0F, 0xC0, 0x78, 0x7C, 0x0F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x0F,
  0x8F, 0xC0, 0xFC, 0x1F, 0x8F, 0x80, 0xFC, 0x1F, 0x9F, 0x80, 0x7E, 0x3F,
  0x3F, 0x00, 0x7F, 0xFF, 0x3E, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0x3F, 0xFC,
  0xFC, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x3F,
  0x7F, 0xFC, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0xFD,
  0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x3E, 0x01, 0xF1, 0xF8, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x3E, 0x3F, 0x03, 0xF0, 0x3E, 0x3F, 0x03,
  0xF0, 0x7E, 0x7E, 0x03, 0xF0, 0x7E, 0x3C, 0x03, 0xF0, 0xFE, 0x08, 0x01,
  0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xF8, 0xFF, 0xBF,
  0xE1, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x7F, 0xC7, 0xFC, 0xFE, 0x7F, 0xC1,
  0xFF, 0x7F, 0x3F, 0xE0, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0x8F, 0xF0,
  0x1F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xE3, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x18, 0x07, 0xC0,
  0x71, 0xF8, 0x3E, 0x0F, 0x8F, 0xF1, 0xF3, 0xFC, 0xFF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xC0, 0x02, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x0F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xDF, 0xF7, 0xFD, 0xFF, 0x3F, 0x83, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0x3F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F,
  0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00,
  0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF,
  0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF9,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0x3F, 0xCF, 0x07, 0xF9, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xCF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x7F,
  0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xDF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x07,
  0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x03, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x7F, 0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x03,
  0xFD, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x87, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE7, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F,
  0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x3F,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE7, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFC,
  0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFC, 0x03, 0xF9,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFE, 0x7F,
  0xC1, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x03, 0xF0, 0x07,
  0xFF, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x7C, 0x1F, 0x80, 0x7F,
  0xFF, 0xC0, 0xF8, 0x3F, 0x01, 0xFF, 0x7F, 0x81, 0xF0, 0xFC, 0x07, 0xF8,
  0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x81,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x1F, 0x81, 0xFC, 0x07,
  0xE0, 0x3E, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0xF9, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF3, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xEF, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0x9F, 0x81, 0xFC, 0x07, 0xE0,
  0x1F, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x7E, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF9, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xE3, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xCF, 0xC0, 0xFE, 0x03, 0xF0, 0x0F,
  0x9F, 0x81, 0xFC, 0x0F, 0xE0, 0x3E, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7C,
  0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xE1,
  0xF8, 0x0F, 0xE3, 0xFE, 0x0F, 0x83, 0xF0, 0x1F, 0xFF, 0xFC, 0x7F, 0x03,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x3F, 0xF9, 0xFF, 0xF0, 0x0F,
  0x80, 0x7F, 0xE3, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x83, 0xFF, 0x00, 0x3F,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x07, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F,
  0xE0, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF,
  0xF1, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xCF, 0xF8, 0x07,
  0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFC,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xF9, 0xFF,
  0x80, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x7F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x03, 0xFF,
  0xF8, 0x07, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F,
  0xEF, 0xF0, 0x0F, 0xFB, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFC, 0xFE, 0x01,
  0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xE0,
  0x3F, 0x9F, 0xF0, 0x0F, 0xF1, 0xF8, 0x0F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F,
  0x07, 0xF1, 0xFE, 0x01, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x80, 0x7F, 0xC7,
  0xF0, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF8, 0x07, 0xF8,
  0x7F, 0x1F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xC7, 0xF0, 0xFF, 0x00, 0xFF,
  0x83, 0xF3, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFC, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF8, 0x3F, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0x00,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0xF8, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF0,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x03,
  0xFF, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFD, 0xF8, 0x07, 0xF8, 0x07, 0xFD,
  0xF8, 0x07, 0xF8, 0x07, 0xF9, 0xFC, 0x0F, 0xF8, 0x07, 0xF9, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x7E, 0x0F, 0xF0, 0x0F, 0xF0, 0x7E,
  0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0x9F, 0xE0, 0x1F, 0xF0,
  0x3F, 0x9F, 0xE0, 0x1F, 0xE0, 0x1F, 0xBF, 0xE0, 0x3F, 0xE0, 0x1F, 0xBF,
  0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0xC0,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0x01, 0xFE, 0x1F, 0xDF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xBF, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x7F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE3, 0xF9, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF3, 0xF8, 0xFF,
  0x00, 0x7F, 0x9F, 0xC7, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x8F, 0xE7, 0xF8,
  0x01, 0xFE, 0xFE, 0x1F, 0xCF, 0xF0, 0x03, 0xFD, 0xFC, 0x3F, 0xBF, 0xC0,
  0x07, 0xFB, 0xF8, 0x7F, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0xFE, 0xFF, 0x00,
  0x1F, 0xFF, 0xC1, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xF9, 0xFE,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07,
  0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF,
  0x00, 0x7E, 0x7C, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81,
  0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x3F, 0xC3, 0xFF, 0x07, 0xFC, 0x7F, 0xC0,
  0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xF0, 0x0F,
  0xFC, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE1, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07,
  0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFC, 0x7F, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0x03, 0xFC, 0x7F,
  0xF8, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xE7, 0xFE,
  0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF,
  0x03, 0xFE, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0x01, 0xFF,
  0xE7, 0xFC, 0x03, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x40,
  0xFF, 0x80, 0x0C, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xF9, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0x00, 0x7F, 0xFC, 0xFF, 0x00,
  0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x3C, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x00, 0xFF, 0x80, 0x38,
  0x01, 0xFF, 0x80, 0x3E, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x7F, 0x9F, 0xF8, 0x03, 0xFD, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF,
  0x80, 0x7F, 0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x03, 0xFE,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFC, 0x07,
  0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x83,
  0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xE1,
  0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x80, 0x07, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xDF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0xF3, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xDF, 0xFE, 0x1F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE1,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0xFF, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0x03, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80,
  0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F,
  0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07,
  0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0x80, 0x3F,
  0xE3, 0xFF, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xC0, 0xFF,
  0xFC, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0x80, 0x7F,
  0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1,
  0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x83,
  0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xBF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xC7, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0xF9, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xF0,
  0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x80,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F,
  0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xFF, 0x3F,
  0xC0, 0x7F, 0x3F, 0xBF, 0x3F, 0xC0, 0x7F, 0x3F, 0x3F, 0x3F, 0x80, 0x7F,
  0x7F, 0x3F, 0x7F, 0x80, 0x7F, 0x7F, 0x3F, 0x7F, 0x80, 0x7F, 0x7E, 0x3F,
  0x7F, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x0F, 0xFF,
  0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0x80, 0x7E, 0x3F, 0xFF,
  0xC0, 0xFE, 0x7F, 0xFF, 0xE0, 0xFE, 0x7F, 0x9F, 0xF3, 0xFC, 0x7F, 0x0F,
  0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xF8, 0xFC, 0x01,
  0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 49, 17, 1, -48 },
  { 106, 19, 18, 21, 5, -51 },
  { 149, 34, 48, 35, 2, -48 },
  { 353, 30, 63, 33, 2, -56 },
  { 590, 32, 50, 42, 6, -49 },
  { 790, 33, 50, 38, 1, -49 },
  { 997, 10, 18, 11, 4, -51 },
  { 1020, 21, 69, 21, 3, -54 },
  { 1202, 21, 69, 21, -3, -54 },
  { 1384, 29, 29, 30, 3, -48 },
  { 1490, 29, 35, 32, 2, -40 },
  { 1617, 14, 20, 15, -4, -8 },
  { 1652, 16, 7, 22, 3, -24 },
  { 1666, 10, 10, 19, 1, -9 },
  { 1679, 30, 52, 22, -4, -48 },
  { 1874, 29, 50, 33, 3, -49 },
  { 2056, 19, 48, 33, 8, -48 },
  { 2170, 32, 49, 33, 0, -49 },
  { 2366, 31, 50, 33, 1, -49 },
  { 2560, 31, 48, 33, 1, -48 },
  { 2746, 31, 49, 33, 2, -48 },
  { 2936, 27, 49, 33, 3, -48 },
  { 3102, 32, 48, 33, 3, -48 },
  { 3294, 30, 50, 33, 2, -49 },
  { 3482, 26, 49, 33, 5, -49 },
  { 3642, 15, 38, 18, 1, -37 },
  { 3714, 19, 49, 16, -3, -37 },
  { 3831, 26, 32, 29, 2, -37 },
  { 3935, 28, 21, 33, 3, -32 },
  { 4009, 27, 31, 30, 1, -36 },
  { 4114, 25, 50, 29, 5, -49 },
  { 4271, 47, 62, 51, 1, -47 },
  { 4636, 38, 48, 39, -3, -48 },
  { 4864, 35, 48, 37, 1, -48 },
  { 5074, 35, 50, 38, 3, -49 },
  { 5293, 35, 48, 37, 1, -48 },
  { 5503, 34, 48, 32, 1, -48 },
  { 5707, 34, 48, 31, 1, -48 },
  { 5911, 35, 50, 39, 3, -49 },
  { 6130, 40, 48, 41, 1, -48 },
  { 6370, 17, 48, 18, 1, -48 },
  { 6472, 33, 49, 32, 0, -48 },
  { 6675, 40, 48, 36, 1, -48 },
  { 6915, 27, 48, 32, 1, -48 },
  { 7077, 50, 48, 50, 1, -48 },
  { 7377, 40, 48, 41, 1, -48 },
  { 7617, 35, 50, 40, 3, -49 },
  { 7836, 36, 48, 37, 1, -48 },
  { 8052, 35, 58, 40, 3, -49 },
  { 8306, 35, 48, 36, 1, -48 },
  { 8516, 35, 50, 35, 1, -49 },
  { 8735, 34, 48, 36, 5, -48 },
  { 8939, 37, 49, 38, 2, -48 },
  { 9166, 37, 48, 38, 5, -48 },
  { 9388, 47, 48, 50, 6, -48 },
  { 9670, 42, 48, 37, -2, -48 },
  { 9922, 34, 48, 36, 6, -48 },
  { 10126, 38, 48, 35, -1, -48 },
  { 10354, 22, 67, 17, -1, -56 },
  { 10539, 15, 52, 25, 6, -48 },
  { 10637, 23, 67, 17, -4, -56 },
  { 10830, 22, 24, 25, 2, -48 },
  { 10896, 26, 7, 26, -4, 0 },
  { 10919, 14, 10, 22, 7, -51 },
  { 10937, 28, 38, 31, 1, -37 },
  { 11070, 30, 52, 33, 0, -51 },
  { 11265, 27, 38, 30, 2, -37 },
  { 11394, 32, 52, 33, 2, -51 },
  { 11602, 28, 38, 31, 2, -37 },
  { 11735, 24, 52, 21, 2, -52 },
  { 11891, 32, 51, 33, 0, -37 },
  { 12095, 29, 51, 32, 0, -51 },
  { 12280, 17, 50, 16, 0, -50 },
  { 12387, 24, 64, 16, -7, -50 },
  { 12579, 33, 51, 31, 0, -51 },
  { 12790, 18, 51, 16, 0, -51 },
  { 12905, 46, 37, 49, 0, -37 },
  { 13118, 29, 37, 32, 0, -37 },
  { 13253, 29, 38, 33, 2, -37 },
  { 13391, 32, 51, 33, -2, -37 },
  { 13595, 30, 51, 33, 2, -37 },
  { 13787, 23, 37, 21, 0, -37 },
  { 13894, 28, 38, 30, 0, -37 },
  { 14027, 19, 46, 20, 2, -45 },
  { 14137, 30, 37, 32, 2, -36 },
  { 14276, 27, 36, 29, 4, -36 },
  { 14398, 40, 36, 42, 4, -36 },
  { 14578, 33, 36, 30, -2, -36 },
  { 14727, 33, 50, 29, -2, -36 },
  { 14934, 30, 36, 30, -1, -36 },
  { 15069, 21, 65, 20, 2, -53 },
  { 15240, 15, 57, 17, 1, -48 },
  { 15347, 21, 65, 20, -3, -53 },
  { 15518, 32, 15, 37, 3, -28 },
};

const GFXfont RobotoCondensed_SemiBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC68PT7B_H_
