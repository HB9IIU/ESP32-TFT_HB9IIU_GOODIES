#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC7PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x07, 0x6E, 0xC0, 0x2D, 0xBB, 0xD0, 0x99, 0x76,
  0x66, 0x4A, 0xE0, 0xC0, 0x16, 0xA8, 0x15, 0x58, 0x0E, 0x80, 0x5D, 0x20,
  0xC0, 0xC0, 0x80, 0x09, 0x48, 0x76, 0xDE, 0xDA, 0x80, 0x64, 0xAE, 0x65,
  0x1E, 0x2D, 0xF2, 0x68, 0x9E, 0x6B, 0xD6, 0x72, 0x24, 0x40, 0x6D, 0x5E,
  0x77, 0x94, 0x42, 0x42, 0x80, 0x39, 0x00, 0x7C, 0x0F, 0x00, 0x65, 0x24,
  0x32, 0x6F, 0xBF, 0xC1, 0x80, 0x26, 0x6E, 0x90, 0x65, 0xEA, 0xE0, 0x75,
  0x89, 0x60, 0x65, 0x9A, 0xE0, 0x74, 0xE8, 0xE0, 0x64, 0xE8, 0x80, 0x75,
  0xB9, 0x60, 0x55, 0xF9, 0x90, 0x5A, 0x80, 0x24, 0x9C, 0x56, 0xCA, 0xA0,
  0x4A, 0x4E, 0x4A, 0xF7, 0x5B, 0x00, 0x55, 0xBB, 0xA0, 0x75, 0x99, 0x60,
  0x75, 0xE8, 0x80, 0x75, 0x99, 0x62, 0x65, 0x6A, 0xA0, 0x64, 0x6A, 0xE0,
  0xEA, 0x48, 0x55, 0x9A, 0xE0, 0xB7, 0x68, 0x5D, 0xDA, 0xA0, 0x56, 0x66,
  0xA0, 0xBB, 0x48, 0x72, 0x44, 0xE0, 0x56, 0xA8, 0x78, 0x56, 0xA8, 0x4A,
  0x80, 0xC0, 0x80, 0x67, 0xF0, 0x4E, 0xDE, 0x76, 0x70, 0x26, 0xAA, 0xE0,
  0x77, 0x70, 0x59, 0x48, 0x76, 0xFE, 0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24,
  0x80, 0x4F, 0x6A, 0x5A, 0x80, 0x7D, 0x6B, 0x60, 0x76, 0xD0, 0x76, 0xF0,
  0x76, 0xF8, 0x76, 0xF2, 0x6A, 0x71, 0xE0, 0x76, 0xC0, 0x36, 0xF0, 0xB5,
  0x20, 0xAB, 0x7A, 0xA9, 0x50, 0xB5, 0x28, 0x00, 0x69, 0x70, 0x5A, 0xA0,
  0x5A, 0xA0, 0x56, 0xA0, 0x5A,
};

const GFXglyph RobotoCondensed_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 7, 3, 0, -6 },
  { 10, 3, 5, 4, 1, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 5, 2, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 2, 5, 3, 1, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 4, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 2, 5, 2, 0, -4 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 2, 3, 0, -3 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 5, 3, 0, -5 },
  { 60, 5, 7, 5, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 3, 0, -5 },
  { 80, 4, 5, 3, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 2, 5, 2, 0, -5 },
  { 91, 3, 5, 3, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 5, 5, 5, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 6, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 3, 5, 4, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 3, 5, 4, 1, -5 },
  { 127, 4, 5, 5, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 3, 5, 4, 1, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 2, 7, 2, 0, -6 },
  { 140, 1, 5, 3, 1, -5 },
  { 141, 2, 7, 2, 0, -6 },
  { 143, 3, 3, 3, 0, -5 },
  { 145, 2, 1, 3, 0, 0 },
  { 146, 1, 1, 2, 1, -5 },
  { 147, 3, 4, 3, 0, -4 },
  { 149, 3, 5, 3, 0, -5 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 4, 5, 3, 0, -5 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 3, 5, 2, 0, -5 },
  { 160, 3, 5, 3, 0, -4 },
  { 162, 3, 5, 3, 0, -5 },
  { 164, 2, 5, 2, 0, -5 },
  { 166, 3, 7, 2, -1, -5 },
  { 169, 3, 5, 3, 0, -5 },
  { 171, 2, 5, 2, 0, -5 },
  { 173, 5, 4, 5, 0, -4 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 3, 5, 3, 0, -4 },
  { 182, 3, 5, 3, 0, -4 },
  { 184, 2, 4, 2, 0, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 2, 5, 2, 0, -5 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 3, 4, 3, 0, -4 },
  { 197, 3, 6, 3, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 2, 6, 2, 0, -5 },
  { 204, 2, 6, 2, 0, -5 },
  { 206, 2, 6, 2, 0, -5 },
  { 208, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC7PT7B_H_
