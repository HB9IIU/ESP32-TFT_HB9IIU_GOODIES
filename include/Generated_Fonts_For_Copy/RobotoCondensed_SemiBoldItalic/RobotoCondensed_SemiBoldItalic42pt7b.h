#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC42PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x1C, 0x00, 0x38, 0xF7, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1E,
  0x71, 0xCF, 0x1C, 0xF3, 0xCE, 0x3C, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x01,
  0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0,
  0x01, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x1C, 0x70, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00,
  0x71, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1C,
  0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0,
  0xFE, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3C, 0xE0, 0x0F, 0x1E, 0x1D, 0xE3, 0xC7,
  0xB8, 0x78, 0xE7, 0x0F, 0x3C, 0xE1, 0xCF, 0x1C, 0x39, 0xC3, 0xCF, 0x78,
  0x7F, 0xDE, 0x07, 0xF3, 0x80, 0x7C, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xCF, 0x80, 0x7B, 0xF8, 0x1E, 0xFF, 0x83, 0xBC, 0xF0, 0xF7, 0x8E,
  0x3C, 0xE1, 0xCF, 0x3C, 0x39, 0xC7, 0x87, 0x78, 0xF0, 0xFE, 0x1E, 0x3C,
  0x81, 0xEF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xEF, 0x80, 0x78,
  0x78, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F,
  0x9F, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x0F, 0x1F, 0xF0, 0xF3, 0xEF, 0x9F, 0x7C, 0xF9, 0xFF, 0xC7, 0xDE,
  0xF8, 0x7F, 0xEF, 0x83, 0xFE, 0xF8, 0x3F, 0xCF, 0x81, 0xF8, 0xFC, 0x1F,
  0x8F, 0xE7, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xF7, 0xE0, 0xFC,
  0x3E, 0x7B, 0xDE, 0xF7, 0xBB, 0xDE, 0xF7, 0xB8, 0x00, 0x10, 0x01, 0x80,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x03, 0x87, 0x0D, 0xF3, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFE, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xF3, 0xC0, 0xF1, 0xE0, 0xF0, 0x78,
  0x38, 0x38, 0x08, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x20, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x9F, 0x87,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0xFD, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xF0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3F, 0x3F, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x1F, 0x07,
  0xE3, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x3E, 0x87, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xE7, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xF1, 0xF8,
  0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC, 0x3F, 0x0F, 0x87, 0xC1,
  0xF1, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF9, 0xF0, 0x1F,
  0x3E, 0x07, 0xE7, 0xC0, 0xF8, 0xFC, 0x3F, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0xC0,
  0x3E, 0xFC, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x7C, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x1F,
  0x80, 0x60, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C,
  0x1F, 0x07, 0xF7, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0xBE, 0x0F, 0xBF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFC, 0xFD, 0xF8, 0x3E,
  0xFC, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xFC, 0x3E, 0x3F, 0x7F, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0x0F, 0x83,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0xC7, 0xE0, 0xF9, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xE3, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF8,
  0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x0F, 0xCF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0x7E, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x0F, 0x0F, 0xC7,
  0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xE0, 0x01,
  0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x02, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0,
  0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x38, 0x00, 0x08,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0x87, 0xFF, 0x0F,
  0xFC, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x1F, 0x03, 0x87, 0x83, 0xFE, 0x1C,
  0x38, 0x3F, 0xF8, 0xF3, 0xC1, 0xF7, 0xC3, 0x9E, 0x1E, 0x1C, 0x1C, 0xE1,
  0xE0, 0xE1, 0xEF, 0x0F, 0x0F, 0x0F, 0x78, 0xF0, 0x78, 0x73, 0x87, 0x83,
  0x83, 0xBC, 0x3C, 0x1C, 0x1D, 0xE1, 0xE1, 0xE0, 0xEF, 0x1E, 0x0F, 0x07,
  0x78, 0xF0, 0x70, 0x73, 0x87, 0x87, 0x83, 0x9C, 0x3C, 0x3C, 0x3C, 0xE1,
  0xE3, 0xE1, 0xC7, 0x0F, 0xFF, 0x1E, 0x38, 0x3F, 0xBF, 0xE1, 0xE1, 0xFD,
  0xFE, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x04, 0x00, 0x07,
  0xF1, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83,
  0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E,
  0x07, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0,
  0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E,
  0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x83, 0xFE, 0xFC, 0x3F,
  0xF7, 0xC1, 0xFF, 0xBE, 0x0F, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0x7C,
  0x1F, 0xC0, 0x3E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0x8F, 0xE0, 0x07, 0xCF, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0xC0, 0x07, 0xF3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3D, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7,
  0xC1, 0xEF, 0x83, 0xE7, 0x87, 0xDF, 0x07, 0xCF, 0x0F, 0x3E, 0x0F, 0x9E,
  0x1E, 0x7C, 0x1F, 0x3C, 0x7D, 0xF8, 0x3E, 0x78, 0xF3, 0xE0, 0xFC, 0xF3,
  0xE7, 0xC1, 0xF1, 0xE7, 0x8F, 0x83, 0xE3, 0xDF, 0x1F, 0x07, 0xC7, 0xBC,
  0x7E, 0x0F, 0x87, 0xF8, 0xF8, 0x1F, 0x0F, 0xE1, 0xF0, 0x7E, 0x1F, 0xC3,
  0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0xC0, 0x3E, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x07, 0xE0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F,
  0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFB, 0xC3, 0xF0, 0x3E, 0xF0, 0xFC,
  0x1F, 0xBC, 0x3E, 0x07, 0xE7, 0x8F, 0x81, 0xF1, 0xE3, 0xE0, 0x7C, 0x78,
  0xF8, 0x1F, 0x1E, 0x7E, 0x07, 0xC3, 0xDF, 0x83, 0xF0, 0xF7, 0xC0, 0xFC,
  0x3D, 0xF0, 0x3E, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0,
  0xF8, 0x1F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xC0, 0x3F,
  0x81, 0xF0, 0x0F, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF,
  0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x01, 0xFB,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F,
  0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x07, 0xC1, 0xF8,
  0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8,
  0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x01,
  0xF7, 0xC0, 0xF8, 0x0F, 0xBE, 0x07, 0xC0, 0xFD, 0xF0, 0x3E, 0x07, 0xCF,
  0x83, 0xF0, 0x3E, 0x7C, 0x1F, 0xC3, 0xF3, 0xE0, 0xFE, 0x1F, 0x1F, 0x0F,
  0xF0, 0xF8, 0xF8, 0x7F, 0x87, 0xC7, 0xC3, 0xFC, 0x7C, 0x3E, 0x3F, 0xE3,
  0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x79, 0xF0, 0x7C, 0xFB, 0xCF, 0x83,
  0xE7, 0x9E, 0x7C, 0x1F, 0x7C, 0xF7, 0xC0, 0xFB, 0xE7, 0xBE, 0x07, 0xDE,
  0x3D, 0xF0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE7, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0,
  0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x3E, 0x3F, 0x01,
  0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0x7C,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xDE, 0x0F, 0x78, 0x78,
  0xE1, 0xE3, 0x8F, 0x0F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF0,
  0x7C, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF1,
  0xF0, 0xFC, 0xF8, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xE7, 0xF3, 0xF7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0x7E, 0x7F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xF1, 0xF0,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF7, 0xF0,
  0xFC, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x03, 0xF3,
  0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xCF,
  0x81, 0xF9, 0xF8, 0x3E, 0x3F, 0xDF, 0xC7, 0xFF, 0xF1, 0xF7, 0xFE, 0x3E,
  0x7F, 0x87, 0xC7, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xFB, 0xF1, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7D,
  0xF0, 0x7C, 0xF8, 0x3E, 0x3F, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE7, 0xE0, 0xFF, 0x7C, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xBF, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xEF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xF3, 0xE0, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xF9, 0xF0, 0x7D,
  0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x0C, 0x3F,
  0x9F, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF1,
  0xF0, 0x7F, 0xDF, 0x0F, 0xFD, 0xF0, 0xFF, 0xFE, 0x1F, 0xDF, 0xE1, 0xF0,
  0x7E, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7,
  0xC0, 0xF8, 0x7E, 0x0F, 0x87, 0xFB, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x06, 0x03, 0xE0, 0x78, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFB, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFD, 0xFC, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0x01, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xF3,
  0xF0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xF7, 0xC0, 0x7E, 0x7C, 0x07,
  0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0x0F, 0x9F, 0x07, 0xC0, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0xEF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFD, 0xFF, 0xBF, 0x0F, 0x83, 0xF0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3F, 0x07, 0xC1, 0xF1, 0xF0, 0x3E,
  0x0F, 0x8F, 0x83, 0xF0, 0x7C, 0x7C, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x3F,
  0x1F, 0x07, 0xC1, 0xF1, 0xF8, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x7C,
  0x1F, 0x83, 0xE3, 0xE0, 0xF8, 0x1F, 0x1F, 0x07, 0xC1, 0xF8, 0xF8, 0x3E,
  0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x7C, 0x0F, 0x83, 0xE0, 0x0F, 0x9F, 0x03,
  0xDF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xDF, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F,
  0x3E, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F,
  0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0x9F, 0x8F, 0x83,
  0xE7, 0xE0, 0xFD, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xFC,
  0x1F, 0x1F, 0x9F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8,
  0x00, 0x07, 0xDF, 0x80, 0x7B, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xE7, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1,
  0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x07, 0xC3, 0xF9, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7E, 0xFF, 0x07, 0xC7, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0xE1, 0xFE, 0x78,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xF9, 0xFC, 0xFC, 0x1F, 0x9F, 0x03, 0xF3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xFC, 0x3F, 0x1F,
  0xCF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xBC, 0x3F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x87,
  0xC3, 0xE1, 0xE0, 0xF8, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x1F, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xF0, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F,
  0xC7, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xFC, 0x3F,
  0x1F, 0xDF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0x7C,
  0x00, 0xF8, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x3E, 0xF0, 0x7C, 0x3E, 0xF0, 0xFC, 0x3E,
  0xF0, 0xFC, 0x7C, 0xF1, 0xFC, 0x7C, 0xF1, 0xFC, 0x78, 0xF1, 0xFC, 0xF8,
  0xF3, 0xFC, 0xF8, 0xF3, 0xFC, 0xF0, 0xF7, 0xBD, 0xF0, 0xF7, 0xBD, 0xF0,
  0xF7, 0x9D, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F,
  0xC7, 0xE0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7D, 0xF8, 0x03, 0xDF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x1F, 0xBE,
  0x01, 0xF3, 0xE0, 0x3E, 0x3F, 0x07, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1,
  0xF0, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F,
  0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x00,
  0x00, 0x10, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0x01, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x01,
  0xC0, 0x08, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x1D, 0xFF, 0x07, 0xBF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xBC, 0x1F, 0xF7, 0x83, 0xFC, 0x00, 0x1E,
  0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 30, 10, 1, -30 },
  { 39, 12, 11, 13, 3, -32 },
  { 56, 21, 30, 22, 1, -30 },
  { 135, 19, 38, 20, 1, -34 },
  { 226, 19, 30, 26, 4, -30 },
  { 298, 20, 30, 23, 1, -30 },
  { 373, 5, 11, 7, 3, -32 },
  { 380, 13, 42, 13, 2, -33 },
  { 449, 13, 42, 13, -2, -33 },
  { 518, 17, 18, 18, 2, -30 },
  { 557, 18, 22, 20, 1, -25 },
  { 607, 8, 12, 10, -2, -5 },
  { 619, 10, 4, 14, 2, -15 },
  { 624, 6, 6, 12, 1, -6 },
  { 629, 19, 33, 14, -3, -30 },
  { 708, 18, 30, 20, 2, -30 },
  { 776, 12, 30, 20, 5, -30 },
  { 821, 20, 30, 20, 0, -30 },
  { 896, 19, 30, 20, 1, -30 },
  { 968, 20, 30, 20, 0, -30 },
  { 1043, 20, 30, 20, 1, -30 },
  { 1118, 17, 30, 20, 2, -30 },
  { 1182, 20, 30, 20, 2, -30 },
  { 1257, 19, 30, 20, 1, -30 },
  { 1329, 16, 30, 20, 3, -30 },
  { 1389, 9, 23, 11, 1, -23 },
  { 1415, 12, 30, 10, -2, -23 },
  { 1460, 16, 20, 18, 1, -23 },
  { 1500, 17, 14, 20, 2, -20 },
  { 1530, 17, 19, 19, 1, -22 },
  { 1571, 15, 30, 18, 3, -30 },
  { 1628, 29, 38, 31, 1, -29 },
  { 1766, 23, 30, 24, -2, -30 },
  { 1853, 22, 30, 23, 0, -30 },
  { 1936, 21, 30, 23, 2, -30 },
  { 2015, 22, 30, 23, 0, -30 },
  { 2098, 22, 30, 20, 0, -30 },
  { 2181, 21, 30, 19, 0, -30 },
  { 2260, 21, 30, 24, 2, -30 },
  { 2339, 26, 30, 25, 0, -30 },
  { 2437, 10, 30, 11, 1, -30 },
  { 2475, 21, 30, 20, 0, -30 },
  { 2554, 25, 30, 22, 0, -30 },
  { 2648, 17, 30, 19, 0, -30 },
  { 2712, 31, 30, 31, 0, -30 },
  { 2829, 26, 30, 25, 0, -30 },
  { 2927, 22, 30, 25, 2, -30 },
  { 3010, 23, 30, 23, 0, -30 },
  { 3097, 22, 35, 25, 2, -30 },
  { 3194, 22, 30, 22, 0, -30 },
  { 3277, 21, 30, 22, 1, -30 },
  { 3356, 21, 30, 22, 3, -30 },
  { 3435, 23, 30, 23, 1, -30 },
  { 3522, 23, 30, 23, 3, -30 },
  { 3609, 29, 30, 31, 4, -30 },
  { 3718, 26, 30, 23, -1, -30 },
  { 3816, 21, 30, 22, 4, -30 },
  { 3895, 24, 30, 22, -1, -30 },
  { 3985, 14, 42, 11, -1, -35 },
  { 4059, 9, 33, 15, 4, -30 },
  { 4097, 14, 42, 11, -2, -35 },
  { 4171, 14, 15, 16, 1, -30 },
  { 4198, 16, 4, 16, -2, 0 },
  { 4206, 9, 6, 13, 4, -31 },
  { 4213, 17, 22, 19, 1, -22 },
  { 4260, 19, 32, 20, 0, -32 },
  { 4336, 17, 22, 19, 1, -22 },
  { 4383, 20, 32, 20, 1, -32 },
  { 4463, 17, 22, 19, 1, -22 },
  { 4510, 15, 32, 13, 1, -32 },
  { 4570, 20, 31, 20, 0, -22 },
  { 4648, 18, 32, 20, 0, -32 },
  { 4720, 11, 31, 10, 0, -31 },
  { 4763, 14, 40, 10, -4, -31 },
  { 4833, 20, 32, 19, 0, -32 },
  { 4913, 11, 32, 10, 0, -32 },
  { 4957, 29, 22, 30, 0, -22 },
  { 5037, 18, 22, 20, 0, -22 },
  { 5087, 18, 22, 20, 1, -22 },
  { 5137, 20, 31, 20, -1, -22 },
  { 5215, 19, 31, 20, 1, -22 },
  { 5289, 14, 22, 13, 0, -22 },
  { 5328, 18, 22, 19, 0, -22 },
  { 5378, 12, 28, 12, 1, -28 },
  { 5420, 19, 22, 20, 1, -22 },
  { 5473, 17, 22, 18, 2, -22 },
  { 5520, 24, 22, 26, 3, -22 },
  { 5586, 20, 22, 18, -1, -22 },
  { 5641, 20, 31, 18, -1, -22 },
  { 5719, 19, 22, 18, -1, -22 },
  { 5772, 13, 40, 12, 1, -33 },
  { 5837, 9, 36, 10, 1, -30 },
  { 5878, 13, 40, 12, -2, -33 },
  { 5943, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC42PT7B_H_
