#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC12PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x86, 0xC0, 0xB6, 0x80, 0x14, 0x51, 0x9F, 0x2B, 0xE5,
  0x14, 0x50, 0x10, 0xE6, 0xDB, 0x60, 0xC1, 0xB2, 0x59, 0xC2, 0x00, 0x62,
  0xAA, 0xBC, 0x20, 0xE5, 0x65, 0x18, 0x38, 0xA6, 0x8E, 0x71, 0x5D, 0xF6,
  0x7C, 0xE0, 0x2D, 0x69, 0x24, 0x92, 0x44, 0x21, 0x11, 0x11, 0x11, 0x32,
  0x24, 0x80, 0x25, 0x3C, 0xCA, 0x00, 0x11, 0xBE, 0x42, 0x00, 0x6B, 0x00,
  0x60, 0x70, 0x08, 0x21, 0x84, 0x10, 0x82, 0x10, 0x43, 0x00, 0x76, 0xA7,
  0x39, 0x4A, 0x56, 0xE0, 0x37, 0xA2, 0x26, 0x66, 0x40, 0x39, 0xB4, 0xC2,
  0x18, 0xC6, 0x10, 0xF8, 0x39, 0xA0, 0xC2, 0x30, 0x20, 0xB6, 0x70, 0x08,
  0x63, 0x8A, 0x79, 0x6F, 0x84, 0x10, 0x3C, 0x86, 0x1E, 0x48, 0x20, 0xB6,
  0x70, 0x36, 0xCF, 0x99, 0x9B, 0xE0, 0xF8, 0xC4, 0x62, 0x31, 0x18, 0x80,
  0x39, 0xB6, 0xDA, 0x71, 0x2C, 0xB6, 0x70, 0x76, 0xA5, 0x2D, 0x78, 0xCC,
  0xC0, 0x6C, 0x00, 0xB0, 0x23, 0x00, 0x00, 0x66, 0x40, 0x09, 0xF9, 0xC3,
  0x08, 0x78, 0x1E, 0x43, 0x86, 0xE8, 0x00, 0x7D, 0x13, 0x64, 0x08, 0xC0,
  0x1E, 0x31, 0x21, 0x4D, 0x55, 0xB5, 0xA5, 0x9E, 0x80, 0x40, 0x38, 0x18,
  0x63, 0x8A, 0x2D, 0xB7, 0xF3, 0x84, 0x3D, 0xB6, 0x5B, 0x79, 0x34, 0xF2,
  0xF8, 0x3C, 0x49, 0x9A, 0x04, 0x08, 0x13, 0x26, 0x78, 0x39, 0xB6, 0x59,
  0x45, 0x34, 0xF6, 0xF0, 0x3D, 0x86, 0x18, 0x79, 0x04, 0x30, 0xF8, 0x3D,
  0x86, 0x18, 0x79, 0x04, 0x30, 0xC0, 0x79, 0x2C, 0xE0, 0x82, 0xE8, 0xB6,
  0x70, 0x22, 0xC5, 0x9B, 0x37, 0xE8, 0x91, 0x62, 0xCC, 0x2D, 0xB4, 0x96,
  0xC0, 0x0C, 0x30, 0x82, 0x08, 0x6D, 0xB4, 0x70, 0x26, 0xD9, 0xA3, 0xC7,
  0x0F, 0x16, 0x64, 0xCC, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xF8, 0x31, 0xB9,
  0xDC, 0xEA, 0xE5, 0x52, 0xA9, 0x6D, 0xB6, 0xDB, 0x00, 0x22, 0xC5, 0xDB,
  0xB5, 0x6B, 0x93, 0x66, 0xCC, 0x1C, 0x49, 0x9A, 0x34, 0x68, 0x91, 0x36,
  0x38, 0x3C, 0xC9, 0x9B, 0x24, 0xCF, 0x10, 0x60, 0xC0, 0x1C, 0x49, 0x9A,
  0x34, 0x68, 0x91, 0x36, 0x78, 0x10, 0x20, 0x3D, 0xB6, 0x59, 0x4D, 0xE5,
  0xB2, 0xC8, 0x39, 0xB6, 0x58, 0x38, 0x2C, 0xD2, 0x70, 0xFC, 0xC2, 0x08,
  0x61, 0x86, 0x18, 0x40, 0x66, 0xCD, 0x92, 0x24, 0x49, 0xB3, 0x24, 0x78,
  0xCF, 0x3C, 0xB6, 0xD1, 0x47, 0x18, 0x60, 0xD9, 0xDB, 0xDB, 0xFA, 0xEE,
  0xEE, 0xEC, 0xCC, 0xCC, 0x66, 0x58, 0xB1, 0xC3, 0x07, 0x1E, 0x24, 0xCC,
  0xCF, 0x25, 0x94, 0x71, 0x86, 0x18, 0x40, 0x7C, 0x18, 0x20, 0xC3, 0x04,
  0x18, 0x60, 0xF8, 0x36, 0x66, 0x44, 0x44, 0xCC, 0xCC, 0xDB, 0x64, 0x92,
  0x6C, 0x31, 0x33, 0x32, 0x22, 0x26, 0x6E, 0x33, 0x55, 0xF8, 0x48, 0x32,
  0xC6, 0xFD, 0xED, 0xC0, 0x63, 0x1E, 0xD4, 0xA7, 0x3B, 0xF0, 0x3A, 0x51,
  0x8C, 0x6D, 0xC0, 0x04, 0x37, 0xD2, 0x4B, 0x2D, 0xB6, 0x78, 0x3A, 0x53,
  0xFC, 0x61, 0xC0, 0x39, 0x1C, 0xC6, 0x21, 0x08, 0xC0, 0x7D, 0x24, 0xB2,
  0xDB, 0x67, 0xA4, 0xF0, 0x63, 0x1E, 0x94, 0xA7, 0x7B, 0xD8, 0x2C, 0x34,
  0x96, 0xD8, 0x13, 0x03, 0x22, 0x26, 0x66, 0x4C, 0x61, 0x86, 0x96, 0x71,
  0xCD, 0x34, 0xD8, 0x2D, 0xB4, 0x96, 0xC0, 0x7F, 0x49, 0x49, 0x4B, 0xDB,
  0xDB, 0xDA, 0x5B, 0x52, 0x9D, 0xEF, 0x60, 0x3B, 0x53, 0x9C, 0xED, 0xC0,
  0x5B, 0x52, 0x9C, 0xEE, 0xD0, 0x80, 0x7D, 0x24, 0xB2, 0xDB, 0x67, 0x84,
  0x10, 0x77, 0x44, 0xCC, 0xC0, 0x32, 0xD0, 0xE1, 0xE9, 0xC0, 0x27, 0x66,
  0x44, 0x46, 0x4D, 0x24, 0x92, 0xDB, 0x67, 0x80, 0x9B, 0xAA, 0xEC, 0xC0,
  0xB7, 0x6A, 0xF6, 0xCD, 0x9B, 0x24, 0x00, 0x4B, 0xDC, 0x47, 0x6B, 0x40,
  0x49, 0x65, 0x1C, 0x71, 0x86, 0x10, 0xC0, 0x78, 0xCC, 0x46, 0x63, 0xC0,
  0x12, 0x22, 0x6C, 0x44, 0x44, 0x40, 0x25, 0x24, 0x92, 0x52, 0x00, 0x4D,
  0xB6, 0x52, 0x5A, 0x00, 0x65, 0x55, 0x80,
};

const GFXglyph RobotoCondensed_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 11, 6, 0, -10 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 2, 1, -9 },
  { 38, 3, 13, 4, 1, -10 },
  { 43, 4, 13, 4, -1, -10 },
  { 50, 5, 5, 5, 1, -9 },
  { 54, 5, 5, 6, 0, -6 },
  { 58, 3, 3, 3, -1, -1 },
  { 60, 3, 1, 4, 0, -4 },
  { 61, 2, 2, 3, 0, -2 },
  { 62, 6, 10, 4, -1, -9 },
  { 70, 5, 9, 6, 1, -9 },
  { 76, 4, 9, 6, 1, -9 },
  { 81, 6, 9, 6, 0, -9 },
  { 88, 6, 9, 6, 0, -9 },
  { 95, 6, 9, 6, 0, -9 },
  { 102, 6, 9, 6, 0, -9 },
  { 109, 4, 9, 6, 1, -9 },
  { 114, 5, 9, 6, 1, -9 },
  { 120, 6, 9, 6, 0, -9 },
  { 127, 5, 9, 6, 1, -9 },
  { 133, 3, 7, 3, 0, -7 },
  { 136, 4, 9, 3, -1, -7 },
  { 141, 5, 6, 5, 0, -7 },
  { 145, 5, 3, 6, 0, -5 },
  { 147, 5, 5, 5, 0, -6 },
  { 151, 4, 9, 5, 1, -9 },
  { 156, 8, 11, 9, 0, -8 },
  { 167, 6, 9, 7, 0, -9 },
  { 174, 6, 9, 7, 0, -9 },
  { 181, 7, 9, 7, 0, -9 },
  { 189, 6, 9, 7, 0, -9 },
  { 196, 6, 9, 6, 0, -9 },
  { 203, 6, 9, 6, 0, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 7, 9, 7, 0, -9 },
  { 225, 3, 9, 3, 0, -9 },
  { 229, 6, 9, 6, 0, -9 },
  { 236, 7, 9, 6, 0, -9 },
  { 244, 5, 9, 6, 0, -9 },
  { 250, 9, 9, 9, 0, -9 },
  { 261, 7, 9, 7, 0, -9 },
  { 269, 7, 9, 7, 0, -9 },
  { 277, 7, 9, 7, 0, -9 },
  { 285, 7, 11, 7, 0, -9 },
  { 295, 6, 9, 6, 0, -9 },
  { 302, 6, 9, 6, 0, -9 },
  { 309, 6, 9, 6, 1, -9 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 6, 9, 7, 1, -9 },
  { 331, 8, 9, 9, 1, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 6, 9, 6, 1, -9 },
  { 355, 7, 9, 6, 0, -9 },
  { 363, 4, 12, 3, 0, -10 },
  { 369, 3, 10, 4, 1, -9 },
  { 373, 4, 12, 3, -1, -10 },
  { 379, 4, 4, 5, 0, -9 },
  { 381, 5, 1, 5, -1, 0 },
  { 382, 3, 2, 4, 1, -9 },
  { 383, 5, 7, 6, 0, -7 },
  { 388, 5, 9, 6, 0, -9 },
  { 394, 5, 7, 5, 0, -7 },
  { 399, 6, 9, 6, 0, -9 },
  { 406, 5, 7, 6, 0, -7 },
  { 411, 5, 9, 4, 0, -9 },
  { 417, 6, 9, 6, 0, -7 },
  { 424, 5, 9, 6, 0, -9 },
  { 430, 3, 10, 3, 0, -10 },
  { 434, 4, 12, 3, -1, -10 },
  { 440, 6, 9, 5, 0, -9 },
  { 447, 3, 9, 3, 0, -9 },
  { 451, 8, 7, 9, 0, -7 },
  { 458, 5, 7, 6, 0, -7 },
  { 463, 5, 7, 6, 0, -7 },
  { 468, 5, 9, 6, 0, -7 },
  { 474, 6, 9, 6, 0, -7 },
  { 481, 4, 7, 4, 0, -7 },
  { 485, 5, 7, 5, 0, -7 },
  { 490, 4, 8, 4, 0, -8 },
  { 494, 6, 7, 6, 0, -7 },
  { 500, 4, 7, 5, 1, -7 },
  { 504, 7, 7, 7, 1, -7 },
  { 511, 5, 7, 5, 0, -7 },
  { 516, 6, 9, 5, 0, -7 },
  { 523, 5, 7, 5, 0, -7 },
  { 528, 4, 11, 4, 0, -9 },
  { 534, 3, 11, 3, 0, -9 },
  { 539, 3, 11, 4, 0, -9 },
  { 544, 6, 3, 7, 0, -5 },
};

const GFXfont RobotoCondensed_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC12PT7B_H_
