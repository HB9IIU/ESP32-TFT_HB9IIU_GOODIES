#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC47PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00, 0x3C,
  0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0xCF, 0xBC, 0x79, 0xE3, 0xCF, 0x1E,
  0x78, 0xF3, 0x87, 0x3C, 0x79, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xE1,
  0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0xC7,
  0x80, 0x03, 0xC7, 0x80, 0x03, 0x87, 0x80, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xF8, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0xF8, 0x0F, 0xC7,
  0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x78, 0xF0, 0x31, 0xE1, 0xC1, 0xEF, 0x07, 0x0F, 0x3C, 0x1C, 0x3C, 0xF0,
  0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0x0F, 0x7C, 0x3C, 0x7D, 0xE0, 0x7F, 0xEF,
  0x01, 0xFF, 0xF8, 0x03, 0xFD, 0xE0, 0x07, 0xCF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xEF, 0x80, 0x0F, 0x7F, 0x00, 0x7B, 0xFE, 0x03, 0xDF, 0xFC, 0x0F,
  0x78, 0xF0, 0x7B, 0xC3, 0xC3, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF0,
  0xF3, 0xC3, 0xC3, 0xDE, 0x0F, 0x0F, 0x78, 0x3C, 0x78, 0x40, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3E, 0x1F, 0xF8, 0x7C,
  0x7F, 0xF1, 0xF1, 0xFB, 0xF3, 0xE7, 0xE7, 0xE7, 0xCF, 0xC7, 0xFF, 0xBF,
  0x0F, 0xFE, 0x7E, 0x0F, 0xFC, 0xFC, 0x1F, 0xF1, 0xF8, 0x1F, 0xE3, 0xF0,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFE, 0xFC, 0x07, 0xF0, 0xFC, 0x3C, 0xF3, 0xDF, 0x7D, 0xE7,
  0x9E, 0x7B, 0xCF, 0x3C, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x02, 0x07, 0x82, 0x38, 0x70, 0xE7, 0xF7, 0x7F,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x01, 0xF3, 0xE0, 0x3E, 0x1E, 0x03, 0xC1,
  0xF0, 0x18, 0x0E, 0x00, 0x80, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC3, 0xF0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0,
  0x78, 0x04, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x83, 0xF1, 0xF0, 0x3F,
  0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x87,
  0xE3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0x83, 0xFE, 0x3F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xF1, 0xF2, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0xFC, 0xFC,
  0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xF0, 0x07,
  0xCF, 0xC0, 0x3E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xFC, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xBF, 0x03, 0xEF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0x0F, 0xCF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xF9, 0xF0,
  0x7E, 0x3F, 0x1F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xE3,
  0xF0, 0x7E, 0x0F, 0x87, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xCF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xBF, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x03, 0xE0,
  0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x1E, 0x00, 0x00, 0xC0, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0,
  0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00,
  0x08, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF0, 0x7E, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F,
  0x0F, 0x80, 0xFC, 0x0F, 0x0F, 0x03, 0xFE, 0x0F, 0x1F, 0x07, 0xFF, 0x87,
  0x1E, 0x0F, 0xFF, 0x87, 0x1E, 0x0F, 0x8F, 0x07, 0x3C, 0x1F, 0x0F, 0x07,
  0x3C, 0x1E, 0x0F, 0x07, 0x7C, 0x3C, 0x1F, 0x07, 0x78, 0x3C, 0x1E, 0x0F,
  0x78, 0x7C, 0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0x0F, 0xF8, 0x78, 0x3E, 0x0F,
  0xF0, 0x78, 0x3C, 0x0E, 0xF0, 0xF8, 0x3C, 0x0E, 0xF0, 0xF8, 0x3C, 0x1E,
  0xF0, 0xF8, 0x7C, 0x1C, 0xF0, 0xF8, 0x78, 0x1C, 0xF0, 0xF8, 0xF8, 0x3C,
  0xF0, 0xF8, 0xF8, 0x78, 0xF0, 0x7F, 0xFC, 0xF0, 0xF0, 0x7F, 0xBF, 0xF0,
  0xF0, 0x7F, 0x1F, 0xE0, 0xF0, 0x1E, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F,
  0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0,
  0x03, 0xE7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F,
  0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x7F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xFE, 0x7E, 0x0F, 0xFE, 0x7E, 0x0F, 0xFE, 0xFC, 0x0F, 0xFE, 0xFC, 0x1F,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x87,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x07, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xF7,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0x3C, 0x0F, 0xBF, 0x03, 0xE7, 0x81,
  0xF7, 0xE0, 0xFC, 0xF0, 0x7C, 0xF8, 0x1F, 0x9E, 0x0F, 0xBF, 0x03, 0xF3,
  0xE3, 0xE7, 0xE0, 0x7E, 0x7C, 0x7C, 0xFC, 0x0F, 0xCF, 0x9F, 0x1F, 0x81,
  0xF9, 0xF3, 0xE3, 0xF0, 0x7E, 0x3E, 0x78, 0xFC, 0x0F, 0xC3, 0xDF, 0x1F,
  0x81, 0xF8, 0x7B, 0xE3, 0xF0, 0x3F, 0x0F, 0xF8, 0x7E, 0x07, 0xE1, 0xFF,
  0x0F, 0xC0, 0xFC, 0x3F, 0xC3, 0xF0, 0x3F, 0x07, 0xF8, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x01,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0,
  0x7F, 0x80, 0x3F, 0x03, 0xFE, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0x80, 0xFF,
  0x80, 0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x03, 0xF7, 0x81,
  0xF8, 0x1F, 0xBC, 0x0F, 0xC0, 0xFD, 0xF0, 0xFC, 0x07, 0xEF, 0x87, 0xE0,
  0x3F, 0x3C, 0x3F, 0x03, 0xF9, 0xF1, 0xF8, 0x1F, 0x8F, 0x8F, 0xC0, 0xFC,
  0x3C, 0x7E, 0x07, 0xE1, 0xE7, 0xE0, 0x3F, 0x0F, 0xBF, 0x01, 0xF8, 0x7D,
  0xF8, 0x1F, 0x81, 0xEF, 0xC0, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xE0,
  0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0xFC,
  0x03, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x83, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7E,
  0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xE1, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC,
  0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC,
  0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0x7C, 0x3F, 0xE1, 0xF8, 0x7C,
  0x7D, 0xE3, 0xF0, 0x7C, 0x7D, 0xE3, 0xF0, 0x7C, 0x7D, 0xE3, 0xF0, 0x7C,
  0xF9, 0xE3, 0xE0, 0x7C, 0xF9, 0xE7, 0xE0, 0x7C, 0xF1, 0xE7, 0xE0, 0x7D,
  0xF1, 0xE7, 0xC0, 0x7D, 0xF1, 0xEF, 0xC0, 0x7D, 0xE1, 0xEF, 0xC0, 0x7F,
  0xE1, 0xEF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x3E, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0x3C, 0x3E, 0x78, 0x78,
  0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x7C, 0x1F, 0xF8, 0x3E,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC3, 0xF7, 0xE0, 0x7C, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFE, 0xF8, 0x1F, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF3,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xF8, 0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E,
  0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFD, 0xFF, 0x87, 0xE7,
  0xF8, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x1F, 0x7E,
  0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0,
  0x7E, 0x3F, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC7, 0xE0,
  0x3F, 0xEF, 0xC0, 0xFF, 0xDF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xDF, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x0F, 0xCF,
  0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0C, 0x3F, 0x07, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xF9,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0,
  0x1F, 0x8F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x0F,
  0xC3, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFD,
  0xF0, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x20, 0x1F, 0x81, 0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C,
  0x07, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xE0,
  0xFC, 0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xE3, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x7C, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0xCF, 0x81, 0xF8, 0x0F, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0xE7, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0x1F,
  0x83, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x3F, 0x1F,
  0x83, 0xF0, 0x3F, 0x1F, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3E, 0x3F,
  0x03, 0xF0, 0x7E, 0x3F, 0x03, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0x7E, 0x3E,
  0x07, 0xE0, 0x7E, 0x3E, 0x07, 0xE0, 0x7E, 0x7E, 0x07, 0xE0, 0x7C, 0x7E,
  0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xC0, 0xFC, 0x7E, 0x0F, 0xC0, 0xFC, 0x7C,
  0x0F, 0xC0, 0xFC, 0x7C, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0xF8, 0xFC,
  0x0F, 0xC1, 0xF8, 0x0F, 0xCF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F,
  0x81, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xF3,
  0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF3, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xDF, 0xF8, 0x1F, 0xBF, 0xE0, 0x3F, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0xF8, 0x3F, 0xEF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xDF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7,
  0xC1, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC3, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x87, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x7F, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0x9F, 0x80,
  0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xC7, 0xC0,
  0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x1E, 0x07, 0xFF, 0x03, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F,
  0x87, 0xEF, 0x87, 0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC7, 0xE7,
  0xC7, 0xF8, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0x3F, 0xE7, 0xE3, 0xE7, 0xFC,
  0xF8, 0x7C, 0xF7, 0x9F, 0x0F, 0xBE, 0xF7, 0xC1, 0xF7, 0x9E, 0xF8, 0x3F,
  0xF3, 0xDF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0xFC,
  0x07, 0xE7, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC,
  0x3E, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F,
  0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00,
  0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x80, 0xF3, 0xFF, 0x07, 0xDF, 0xFE, 0x1E, 0x7F,
  0xF8, 0xF9, 0xF3, 0xFF, 0xEF, 0x87, 0xFF, 0x3E, 0x0F, 0xFC, 0xF0, 0x1F,
  0xE0, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 33, 12, 1, -33 },
  { 47, 13, 12, 15, 3, -35 },
  { 67, 24, 33, 24, 1, -33 },
  { 166, 21, 42, 23, 1, -38 },
  { 277, 22, 33, 29, 4, -33 },
  { 368, 23, 33, 26, 1, -33 },
  { 463, 6, 12, 8, 3, -35 },
  { 472, 15, 48, 15, 2, -37 },
  { 562, 15, 48, 15, -2, -37 },
  { 652, 20, 20, 20, 2, -33 },
  { 702, 20, 25, 22, 1, -28 },
  { 765, 10, 14, 11, -3, -6 },
  { 783, 11, 5, 15, 2, -17 },
  { 790, 7, 7, 13, 1, -7 },
  { 797, 21, 36, 16, -3, -33 },
  { 892, 20, 33, 23, 2, -33 },
  { 975, 14, 33, 23, 5, -33 },
  { 1033, 22, 33, 23, 0, -33 },
  { 1124, 21, 33, 23, 1, -33 },
  { 1211, 22, 33, 23, 0, -33 },
  { 1302, 21, 33, 23, 2, -33 },
  { 1389, 19, 33, 23, 2, -33 },
  { 1468, 22, 33, 23, 2, -33 },
  { 1559, 21, 33, 23, 1, -33 },
  { 1646, 19, 33, 23, 3, -33 },
  { 1725, 10, 26, 12, 1, -26 },
  { 1758, 13, 34, 11, -2, -26 },
  { 1814, 18, 21, 20, 1, -25 },
  { 1862, 19, 14, 23, 2, -22 },
  { 1896, 19, 22, 21, 1, -25 },
  { 1949, 18, 33, 20, 3, -33 },
  { 2024, 32, 43, 35, 1, -33 },
  { 2196, 26, 33, 27, -2, -33 },
  { 2304, 25, 33, 25, 0, -33 },
  { 2408, 24, 33, 26, 2, -33 },
  { 2507, 25, 33, 26, 0, -33 },
  { 2611, 24, 33, 22, 0, -33 },
  { 2710, 24, 33, 22, 0, -33 },
  { 2809, 24, 33, 27, 2, -33 },
  { 2908, 29, 33, 28, 0, -33 },
  { 3028, 11, 33, 12, 1, -33 },
  { 3074, 23, 33, 22, 0, -33 },
  { 3169, 29, 33, 25, 0, -33 },
  { 3289, 19, 33, 22, 0, -33 },
  { 3368, 35, 33, 35, 0, -33 },
  { 3513, 29, 33, 28, 0, -33 },
  { 3633, 24, 33, 28, 2, -33 },
  { 3732, 26, 33, 26, 0, -33 },
  { 3840, 24, 39, 28, 2, -33 },
  { 3957, 25, 33, 25, 0, -33 },
  { 4061, 24, 33, 24, 1, -33 },
  { 4160, 23, 33, 25, 4, -33 },
  { 4255, 25, 33, 26, 2, -33 },
  { 4359, 25, 33, 26, 4, -33 },
  { 4463, 32, 33, 34, 4, -33 },
  { 4595, 29, 33, 25, -1, -33 },
  { 4715, 24, 33, 25, 4, -33 },
  { 4814, 27, 33, 24, -1, -33 },
  { 4926, 16, 47, 12, -1, -39 },
  { 5020, 11, 36, 17, 4, -33 },
  { 5070, 16, 47, 12, -3, -39 },
  { 5164, 15, 17, 18, 2, -33 },
  { 5196, 18, 5, 18, -3, 0 },
  { 5208, 9, 7, 15, 5, -35 },
  { 5216, 19, 25, 22, 1, -25 },
  { 5276, 21, 35, 23, 0, -35 },
  { 5368, 19, 25, 21, 1, -25 },
  { 5428, 23, 35, 23, 1, -35 },
  { 5529, 19, 25, 22, 1, -25 },
  { 5589, 16, 35, 15, 2, -35 },
  { 5659, 22, 35, 23, 0, -25 },
  { 5756, 20, 35, 22, 0, -35 },
  { 5844, 12, 34, 11, 0, -34 },
  { 5895, 17, 44, 11, -5, -34 },
  { 5989, 23, 35, 22, 0, -35 },
  { 6090, 12, 35, 11, 0, -35 },
  { 6143, 32, 25, 34, 0, -25 },
  { 6243, 20, 25, 22, 0, -25 },
  { 6306, 20, 25, 23, 1, -25 },
  { 6369, 23, 35, 23, -2, -25 },
  { 6470, 21, 35, 23, 1, -25 },
  { 6562, 16, 25, 15, 0, -25 },
  { 6612, 20, 25, 21, 0, -25 },
  { 6675, 13, 31, 14, 2, -31 },
  { 6726, 21, 25, 22, 1, -25 },
  { 6792, 19, 25, 20, 2, -25 },
  { 6852, 27, 25, 29, 3, -25 },
  { 6937, 22, 25, 20, -1, -25 },
  { 7006, 23, 35, 20, -1, -25 },
  { 7107, 21, 25, 20, -1, -25 },
  { 7173, 15, 45, 14, 1, -37 },
  { 7258, 10, 39, 11, 1, -33 },
  { 7307, 15, 45, 14, -2, -37 },
  { 7392, 22, 10, 26, 2, -19 },
};

const GFXfont RobotoCondensed_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC47PT7B_H_
