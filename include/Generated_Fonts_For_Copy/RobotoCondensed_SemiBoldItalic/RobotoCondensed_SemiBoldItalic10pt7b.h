#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC10PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x30, 0xFC, 0x29, 0x5E, 0x6F, 0x31, 0x80, 0x11, 0x96,
  0x83, 0x0B, 0x4E, 0x40, 0xC5, 0xB8, 0x47, 0x54, 0xC0, 0x32, 0x94, 0xDF,
  0xE9, 0xE0, 0xE0, 0x12, 0x44, 0x44, 0x84, 0x44, 0x48, 0x92, 0x92, 0x90,
  0x23, 0xC8, 0xA0, 0x22, 0xF2, 0x60, 0x5C, 0x60, 0xC0, 0x08, 0x84, 0x42,
  0x21, 0x08, 0x32, 0xD6, 0xBD, 0x69, 0x80, 0x3D, 0xA4, 0x90, 0x72, 0xC6,
  0x22, 0x23, 0xC0, 0x32, 0xC6, 0x61, 0x49, 0x80, 0x19, 0x9C, 0xAF, 0x18,
  0xC0, 0x7A, 0x1C, 0x21, 0x69, 0x80, 0x36, 0x75, 0xD5, 0x60, 0x78, 0xC4,
  0x62, 0x31, 0x00, 0x32, 0xD6, 0xED, 0x69, 0x80, 0x6B, 0xBA, 0xE6, 0xC0,
  0x40, 0xC0, 0x40, 0xA8, 0x16, 0xE2, 0x70, 0x1C, 0x43, 0x78, 0xF4, 0xAC,
  0x20, 0x1C, 0x45, 0x6B, 0x5A, 0xB5, 0x6F, 0x40, 0x70, 0x11, 0x8C, 0xF7,
  0xE6, 0x20, 0x7A, 0x52, 0xE4, 0xEF, 0xC0, 0x39, 0x24, 0x10, 0xC1, 0x27,
  0x00, 0x72, 0x52, 0x94, 0xEF, 0xC0, 0x7A, 0x10, 0xE4, 0x63, 0xC0, 0x7A,
  0x10, 0xE4, 0x62, 0x00, 0x39, 0x34, 0x16, 0xC9, 0x27, 0x00, 0x65, 0x14,
  0xDE, 0x4B, 0x28, 0x80, 0x69, 0x25, 0xB0, 0x08, 0xC4, 0x21, 0x49, 0x80,
  0x6D, 0x65, 0x1C, 0x53, 0x49, 0x80, 0x64, 0x44, 0x4C, 0xF0, 0x62, 0xCD,
  0x9B, 0x56, 0xFA, 0xA5, 0x00, 0x65, 0x96, 0xD6, 0x5B, 0x69, 0x80, 0x39,
  0xA4, 0xD2, 0xC9, 0x27, 0x00, 0x79, 0x24, 0x9E, 0x43, 0x08, 0x00, 0x39,
  0x24, 0xD2, 0xC9, 0x27, 0x06, 0x7A, 0x52, 0xE5, 0x6A, 0x60, 0x3A, 0x50,
  0x61, 0xED, 0xC0, 0xFB, 0x18, 0x84, 0x21, 0x00, 0x4D, 0x24, 0x92, 0xCB,
  0x67, 0x00, 0x9C, 0xA5, 0x6E, 0x31, 0x00, 0x97, 0x6A, 0xD5, 0xED, 0x9B,
  0x26, 0x00, 0x4D, 0xA3, 0x0C, 0x71, 0x4D, 0x80, 0x9C, 0xB8, 0xC4, 0x21,
  0x00, 0x78, 0xC4, 0x46, 0x63, 0xC0, 0x69, 0x24, 0xB4, 0x98, 0xAB, 0xD5,
  0x33, 0x22, 0x22, 0x26, 0x44, 0x26, 0x65, 0x70, 0xD0, 0x75, 0x79, 0xF0,
  0x44, 0x47, 0x5D, 0xDF, 0x75, 0xC9, 0x60, 0x08, 0x46, 0xED, 0x6A, 0x4E,
  0x75, 0xFC, 0x70, 0x36, 0x46, 0x44, 0x4C, 0x7A, 0xB5, 0xA7, 0x1B, 0x80,
  0x44, 0x47, 0x5D, 0x99, 0x41, 0x25, 0xA0, 0x20, 0x92, 0xD2, 0xC0, 0x42,
  0x10, 0xA6, 0x72, 0x92, 0x69, 0x25, 0xB4, 0x7E, 0xA7, 0x5E, 0xA9, 0x40,
  0x75, 0xD9, 0x90, 0x72, 0xB5, 0xA6, 0x00, 0x75, 0xDD, 0xF8, 0x80, 0x7E,
  0xB5, 0x27, 0x18, 0x80, 0x6B, 0x68, 0x75, 0x69, 0x60, 0x6B, 0xA4, 0x90,
  0x5A, 0xB5, 0xA7, 0x00, 0xAA, 0xCC, 0x80, 0xAF, 0x7D, 0x6B, 0x00, 0x53,
  0x98, 0xCB, 0x00, 0x52, 0x98, 0xC4, 0x22, 0x00, 0x73, 0x64, 0xF0, 0x25,
  0x28, 0x92, 0x48, 0x55, 0x6A, 0x49, 0x22, 0x96, 0x90, 0x6C, 0xC0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 2, 3, 3, 1, -8 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 5, 7, 6, 1, -7 },
  { 21, 5, 7, 6, 0, -7 },
  { 26, 1, 3, 2, 1, -8 },
  { 27, 4, 10, 3, 0, -8 },
  { 32, 3, 10, 3, 0, -8 },
  { 36, 5, 4, 4, 0, -7 },
  { 39, 4, 5, 5, 0, -6 },
  { 42, 2, 3, 2, -1, -1 },
  { 43, 3, 1, 3, 0, -4 },
  { 44, 2, 1, 3, 0, -1 },
  { 45, 5, 8, 3, -1, -7 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 3, 7, 5, 1, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 5, 7, 5, 0, -7 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 4, 7, 5, 0, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 4, 7, 5, 1, -7 },
  { 96, 2, 5, 3, 0, -5 },
  { 98, 2, 7, 2, 0, -5 },
  { 100, 4, 4, 4, 0, -5 },
  { 102, 5, 3, 5, 0, -5 },
  { 104, 4, 4, 4, 0, -5 },
  { 106, 3, 7, 4, 1, -7 },
  { 109, 7, 9, 7, 0, -7 },
  { 117, 5, 7, 6, 0, -7 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 6, 7, 6, 0, -7 },
  { 133, 5, 7, 6, 0, -7 },
  { 138, 5, 7, 5, 0, -7 },
  { 143, 5, 7, 5, 0, -7 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 3, 7, 3, 0, -7 },
  { 163, 5, 7, 5, 0, -7 },
  { 168, 6, 7, 5, 0, -7 },
  { 174, 4, 7, 5, 0, -7 },
  { 178, 7, 7, 7, 0, -7 },
  { 185, 6, 7, 6, 0, -7 },
  { 191, 6, 7, 6, 0, -7 },
  { 197, 6, 7, 5, 0, -7 },
  { 203, 6, 8, 6, 0, -7 },
  { 209, 5, 7, 5, 0, -7 },
  { 214, 5, 7, 5, 0, -7 },
  { 219, 5, 7, 5, 1, -7 },
  { 224, 6, 7, 6, 0, -7 },
  { 230, 5, 7, 6, 1, -7 },
  { 235, 7, 7, 7, 1, -7 },
  { 242, 6, 7, 5, 0, -7 },
  { 248, 5, 7, 5, 1, -7 },
  { 253, 5, 7, 5, 0, -7 },
  { 258, 3, 10, 3, 0, -8 },
  { 262, 2, 8, 4, 1, -7 },
  { 264, 4, 10, 3, -1, -8 },
  { 269, 4, 4, 4, 0, -7 },
  { 271, 4, 1, 4, -1, 0 },
  { 272, 2, 2, 3, 1, -8 },
  { 273, 4, 5, 5, 0, -5 },
  { 276, 4, 8, 5, 0, -8 },
  { 280, 4, 5, 4, 0, -5 },
  { 283, 5, 8, 5, 0, -8 },
  { 288, 4, 5, 5, 0, -5 },
  { 291, 4, 8, 3, 0, -8 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 4, 8, 5, 0, -8 },
  { 304, 3, 7, 2, 0, -7 },
  { 307, 3, 9, 2, -1, -7 },
  { 311, 5, 8, 5, 0, -8 },
  { 316, 3, 8, 2, 0, -8 },
  { 319, 7, 5, 7, 0, -5 },
  { 324, 4, 5, 5, 0, -5 },
  { 327, 5, 5, 5, 0, -5 },
  { 331, 4, 7, 5, 0, -5 },
  { 335, 5, 7, 5, 0, -5 },
  { 340, 3, 5, 3, 0, -5 },
  { 342, 4, 5, 4, 0, -5 },
  { 345, 3, 7, 3, 0, -7 },
  { 348, 5, 5, 5, 0, -5 },
  { 352, 4, 5, 4, 1, -5 },
  { 355, 5, 5, 6, 1, -5 },
  { 359, 5, 5, 4, 0, -5 },
  { 363, 5, 7, 4, 0, -5 },
  { 368, 4, 5, 4, 0, -5 },
  { 371, 3, 10, 3, 0, -8 },
  { 375, 2, 8, 2, 0, -7 },
  { 377, 3, 10, 3, 0, -8 },
  { 381, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC10PT7B_H_
