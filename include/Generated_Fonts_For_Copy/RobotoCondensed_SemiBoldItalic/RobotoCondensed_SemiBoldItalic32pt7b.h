#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC32PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC7,
  0x8F, 0x1C, 0x00, 0x00, 0x01, 0x87, 0x8F, 0x1E, 0x38, 0x00, 0x73, 0xB9,
  0xDC, 0xEE, 0x66, 0x73, 0x3B, 0x9D, 0xCC, 0x00, 0xCE, 0x01, 0xCE, 0x01,
  0xCC, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x98, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFE, 0x06, 0x30, 0x06, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0xE0, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x39, 0xC0, 0x39, 0x80, 0x33, 0x80, 0x73,
  0x80, 0x73, 0x00, 0x67, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0xF8,
  0x07, 0xF8, 0x3F, 0xE1, 0xF7, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0xDF, 0x1F, 0xF8, 0x3F,
  0xC0, 0x7E, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xFC, 0x01,
  0xDC, 0x07, 0x38, 0x6E, 0x31, 0xDC, 0xE7, 0x39, 0xDC, 0x73, 0xB8, 0xFE,
  0xE0, 0xFF, 0x80, 0xF6, 0x00, 0x1C, 0x00, 0x77, 0x80, 0xDF, 0x83, 0xFF,
  0x0E, 0xE7, 0x39, 0x8E, 0x77, 0x1D, 0xCE, 0x3F, 0x0C, 0x64, 0x1D, 0xC0,
  0x3F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7B, 0xC1,
  0xE3, 0x83, 0xC7, 0x07, 0x1E, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xC0, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0xEF, 0x79, 0xFC, 0xF7, 0xF8, 0xFE, 0xF1, 0xFD,
  0xE1, 0xFB, 0xC3, 0xE7, 0xCF, 0xCF, 0xFF, 0x8F, 0xFF, 0x87, 0xCF, 0x00,
  0x77, 0x77, 0x7E, 0xEE, 0x00, 0x81, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0xE0, 0x20, 0x04, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0C, 0x02, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0x01, 0xFC,
  0x0E, 0xE0, 0xE3, 0x86, 0x1C, 0x10, 0x40, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x1E,
  0x38, 0x71, 0xE3, 0xC7, 0x1E, 0x78, 0x60, 0x7F, 0x7F, 0xFF, 0x2F, 0xFF,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x1F,
  0xC0, 0xFF, 0x87, 0x9E, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x78,
  0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0E, 0x78, 0x79, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0x73, 0xC3, 0xC7, 0x0F, 0x1E, 0x78, 0x7F, 0xE0, 0xFF, 0x01,
  0xF0, 0x00, 0x01, 0x83, 0xCF, 0xDF, 0xEF, 0xF7, 0x7A, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xF1,
  0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xDF, 0x3C, 0x3C, 0xF0, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0xE0, 0x73, 0xC3, 0xCF, 0x0F, 0x3E, 0xFC, 0x7F,
  0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xDE, 0x07, 0xB8, 0x1E, 0xF0,
  0x39, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x3C, 0x3F, 0xFE, 0x7F,
  0xFD, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC3, 0xE7, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3,
  0xC3, 0xCF, 0x87, 0xFE, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F,
  0x81, 0xFC, 0x1F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3B, 0xE3,
  0xFF, 0x9F, 0xFC, 0xF9, 0xF7, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7B, 0x83, 0xDE, 0x3C, 0xFB, 0xE3, 0xFE, 0x1F, 0xE0, 0x3C, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xDF, 0x1E,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0x7B, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xE1, 0xE3, 0xC7, 0x8F, 0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xCF,
  0x0F, 0x3E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x79, 0xE7, 0x87, 0x3C, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3C, 0xF3, 0xE7, 0xFF, 0x1F, 0xF8, 0x7B, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x08,
  0x78, 0xF9, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x3C,
  0x78, 0xF1, 0xC0, 0x02, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0xF0,
  0xE0, 0x40, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0xF8, 0xFE,
  0x0F, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x1C, 0x00,
  0x40, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xCF, 0xFE, 0xFF, 0xF0, 0x20, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF0, 0x0F, 0x07, 0xF1, 0xFE, 0x7F, 0x8F, 0xE0, 0xF8, 0x0E,
  0x00, 0x80, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xDF, 0x78, 0xFF, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x38, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x3E, 0x01, 0xE0,
  0x1C, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x0F, 0x86,
  0x38, 0x7F, 0x1C, 0xC3, 0xFC, 0x77, 0x1C, 0x71, 0xDC, 0x71, 0xC7, 0xE3,
  0x87, 0x1B, 0x8E, 0x18, 0x6E, 0x38, 0xE1, 0xB9, 0xE3, 0x8E, 0xC7, 0x0E,
  0x3B, 0x1C, 0x70, 0xCC, 0x71, 0xC7, 0x31, 0xFF, 0xB8, 0xC3, 0xEF, 0xC3,
  0x87, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x20, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x01, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1E, 0x0F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x8F, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x8F, 0x1F, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x80,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF7, 0xE1, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0xF0, 0x1E,
  0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0xDF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xF0, 0xF0,
  0xF0, 0x78, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x83,
  0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x7C,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x3F, 0x87, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0xF1,
  0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x0F, 0xE7, 0x8F, 0xF3, 0xC7, 0xFB, 0xE0, 0x7D, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1,
  0xF0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF0, 0x7D, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C,
  0x3E, 0x07, 0x87, 0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF3,
  0xC0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F,
  0x81, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3C, 0x07,
  0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xDC, 0x1D, 0xC3, 0xFC, 0x3D, 0xC3, 0xBC,
  0x3D, 0xE3, 0xBC, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xEF, 0x78,
  0x3C, 0xEE, 0x78, 0x78, 0xFE, 0x78, 0x78, 0xFC, 0x78, 0x78, 0xFC, 0x78,
  0x78, 0xF8, 0xF8, 0x78, 0xF8, 0xF0, 0x78, 0x70, 0xF0, 0xF0, 0x70, 0xF0,
  0x0F, 0x01, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF1, 0xF8, 0x1E,
  0x3F, 0x87, 0xC7, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xE3, 0xC3, 0xDC, 0x78,
  0xFB, 0x8F, 0x1E, 0x73, 0xC3, 0xC7, 0x78, 0x78, 0xEF, 0x0F, 0x1D, 0xE1,
  0xE3, 0xFC, 0x7C, 0x3F, 0x8F, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x0F, 0x87,
  0x81, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xE1, 0xE0, 0xF1, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0,
  0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0xF8, 0xFC, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xE0, 0xF1, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x9F, 0xC7, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3E,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xF3, 0xC0, 0xF8, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBE, 0x3E, 0x1E, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0xFD, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7,
  0xC0, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F,
  0x3E, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x79, 0xF0, 0x3C, 0xF0, 0x3E, 0x78, 0x1E, 0x3E, 0x1F, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07,
  0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE1,
  0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF0, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF,
  0x1F, 0x8F, 0x3C, 0x7E, 0x78, 0xF3, 0xF9, 0xE3, 0xCE, 0xE7, 0x8F, 0x7B,
  0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0xC3, 0xFC, 0xEE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x00, 0x0F,
  0x81, 0xE0, 0xF8, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0xCF, 0x80,
  0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x01, 0xF3, 0xC0, 0x1E, 0x3E, 0x03, 0xE1,
  0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0xF0,
  0x3E, 0xF0, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x79,
  0xE0, 0x39, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xE0,
  0xF8, 0x1F, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F,
  0x1E, 0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0E, 0x07, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0x80, 0xF0, 0x1E,
  0x07, 0xC1, 0xD8, 0x3B, 0x8F, 0x71, 0xCE, 0x79, 0xCE, 0x3B, 0xC7, 0x00,
  0x7F, 0xF7, 0xFF, 0xBF, 0xFC, 0x78, 0xF0, 0xF0, 0xE1, 0xE0, 0x03, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFE,
  0x3F, 0xF9, 0xFF, 0xE7, 0x87, 0x9E, 0x3C, 0xF0, 0xF1, 0xE7, 0xC7, 0xFF,
  0x1F, 0xFC, 0x1E, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xBC, 0x1F, 0xF8, 0x7F, 0xF3, 0xF7, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7,
  0x83, 0xDE, 0x1E, 0x7C, 0xFB, 0xFF, 0xCF, 0x7F, 0x3C, 0xF0, 0x07, 0xC0,
  0xFF, 0x0F, 0xFC, 0xF9, 0xE7, 0x87, 0xBC, 0x3F, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE1, 0xEF, 0x1E, 0x7D, 0xF1, 0xFF, 0x0F, 0xF0,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x07, 0x9E, 0x1F, 0xBC, 0x7F, 0xF9, 0xF3, 0xE3, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0xBF, 0x1F, 0xFC, 0x1F, 0xF8, 0x1E, 0x70, 0x07,
  0xC0, 0xFF, 0x0F, 0xFC, 0x79, 0xE7, 0x87, 0xBC, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x04, 0x7E, 0xF1, 0xFF, 0x87,
  0xF8, 0x1F, 0x80, 0x01, 0xE0, 0xFC, 0x3F, 0x87, 0xD1, 0xF0, 0x3C, 0x07,
  0x83, 0xFC, 0x7F, 0x8F, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0x07, 0xDE, 0x1F, 0xFC, 0x7F, 0xF9, 0xF3, 0xF3, 0xC3, 0xC7, 0x87, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x9F, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0x70, 0x01, 0xE0, 0x03, 0xC2,
  0x07, 0x87, 0x3E, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xBC, 0x1F,
  0xF8, 0xFF, 0xE3, 0xE7, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xDE,
  0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x70, 0x7B, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78,
  0xF0, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x3E,
  0x1E, 0x7C, 0x1C, 0x78, 0x3C, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7D, 0xE0, 0x79, 0xE0, 0x79, 0xE0,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x1E, 0xF0, 0xF0, 0x7F,
  0xEF, 0xE1, 0xFF, 0xFF, 0x8F, 0x9F, 0x9F, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0,
  0xF3, 0xC3, 0xC3, 0xCF, 0x0E, 0x1E, 0x38, 0x78, 0x79, 0xE1, 0xE1, 0xE7,
  0x87, 0x87, 0x9E, 0x1E, 0x1E, 0x78, 0x78, 0x79, 0xE1, 0xC3, 0xCF, 0x0F,
  0x0F, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF0, 0x1E, 0xF0, 0x7F, 0xE3, 0xFF,
  0xCF, 0x9F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x79, 0xF7, 0x87, 0xBC, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x7C, 0xF9,
  0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x0F, 0x78, 0x1F, 0xF8, 0x3F, 0xF8, 0xFD,
  0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0xCF, 0x8F, 0xFE, 0x3D, 0xF8, 0x79,
  0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0xDF, 0x3E, 0x78, 0x7B, 0xC1,
  0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xE7, 0xCF, 0xFF, 0x1F, 0xF8, 0x3D, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0xE3, 0xFC, 0x7F,
  0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x7F, 0x87,
  0xFE, 0x7C, 0xF3, 0xC7, 0x9E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0x7D, 0xE1, 0xEF, 0x0F, 0x3C, 0x79, 0xFF, 0x87, 0xF8, 0x1F, 0x80,
  0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xFF, 0xFF, 0xFC, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3D, 0x1F, 0x0F, 0x83, 0xC0,
  0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xEF,
  0xCF, 0xFE, 0x1F, 0xF8, 0x3D, 0xE0, 0xF0, 0xF7, 0x87, 0xBC, 0x79, 0xE3,
  0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x0E, 0x70, 0x77, 0x83, 0xB8, 0x1D, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0xF1, 0xE3,
  0xDE, 0x3C, 0x7B, 0xC7, 0x8F, 0x79, 0xF3, 0xCF, 0x3E, 0x79, 0xEF, 0xCE,
  0x3D, 0xFB, 0xC7, 0xBF, 0x78, 0xFE, 0xEE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC0,
  0x70, 0x70, 0x00, 0x1E, 0x1E, 0x1E, 0x3E, 0x0F, 0x3C, 0x0F, 0x78, 0x0F,
  0x78, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8,
  0x78, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x80, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x0F, 0x83, 0x80, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0x80, 0x06, 0x1C,
  0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C,
  0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x80, 0x04, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x7C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x0C,
  0x00, 0x1E, 0x00, 0x7E, 0x1D, 0xFE, 0x3B, 0xFE, 0xFF, 0x1F, 0xDC, 0x3F,
  0x80, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 23, 8, 1, -23 },
  { 22, 9, 8, 10, 2, -24 },
  { 31, 16, 23, 17, 1, -23 },
  { 77, 14, 29, 16, 1, -26 },
  { 128, 15, 23, 20, 3, -23 },
  { 172, 15, 23, 18, 1, -23 },
  { 216, 4, 8, 5, 2, -24 },
  { 220, 9, 32, 10, 2, -25 },
  { 256, 10, 32, 10, -1, -25 },
  { 296, 13, 14, 14, 2, -23 },
  { 319, 13, 17, 15, 1, -19 },
  { 347, 7, 9, 7, -2, -4 },
  { 355, 8, 3, 10, 1, -11 },
  { 358, 4, 5, 9, 1, -5 },
  { 361, 14, 25, 11, -2, -23 },
  { 405, 14, 23, 16, 1, -23 },
  { 446, 9, 23, 16, 4, -23 },
  { 472, 15, 23, 16, 0, -23 },
  { 516, 14, 23, 16, 1, -23 },
  { 557, 15, 23, 16, 0, -23 },
  { 601, 15, 23, 16, 1, -23 },
  { 645, 13, 23, 16, 1, -23 },
  { 683, 14, 23, 16, 2, -23 },
  { 724, 14, 23, 16, 1, -23 },
  { 765, 13, 23, 16, 2, -23 },
  { 803, 7, 18, 8, 1, -18 },
  { 819, 8, 23, 8, -1, -18 },
  { 842, 12, 15, 14, 1, -17 },
  { 865, 13, 9, 15, 1, -15 },
  { 880, 12, 15, 14, 1, -17 },
  { 903, 12, 23, 14, 2, -23 },
  { 938, 22, 29, 24, 1, -22 },
  { 1018, 17, 23, 18, -1, -23 },
  { 1067, 17, 23, 17, 0, -23 },
  { 1116, 17, 23, 18, 1, -23 },
  { 1165, 17, 23, 18, 0, -23 },
  { 1214, 17, 23, 15, 0, -23 },
  { 1263, 16, 23, 15, 0, -23 },
  { 1309, 17, 23, 18, 1, -23 },
  { 1358, 19, 23, 19, 0, -23 },
  { 1413, 8, 23, 8, 0, -23 },
  { 1436, 16, 23, 15, 0, -23 },
  { 1482, 19, 23, 17, 0, -23 },
  { 1537, 13, 23, 15, 0, -23 },
  { 1575, 24, 23, 24, 0, -23 },
  { 1644, 19, 23, 19, 0, -23 },
  { 1699, 17, 23, 19, 1, -23 },
  { 1748, 18, 23, 18, 0, -23 },
  { 1800, 17, 27, 19, 1, -23 },
  { 1858, 17, 23, 17, 0, -23 },
  { 1907, 16, 23, 17, 1, -23 },
  { 1953, 15, 23, 17, 3, -23 },
  { 1997, 17, 23, 18, 1, -23 },
  { 2046, 17, 23, 18, 3, -23 },
  { 2095, 22, 23, 23, 3, -23 },
  { 2159, 20, 23, 17, -1, -23 },
  { 2217, 16, 23, 17, 3, -23 },
  { 2263, 17, 23, 16, 0, -23 },
  { 2312, 11, 31, 8, -1, -26 },
  { 2355, 7, 25, 12, 3, -23 },
  { 2377, 11, 31, 8, -2, -26 },
  { 2420, 11, 11, 12, 1, -23 },
  { 2436, 13, 3, 12, -2, 0 },
  { 2441, 7, 5, 10, 3, -24 },
  { 2446, 14, 17, 15, 0, -17 },
  { 2476, 14, 24, 15, 0, -24 },
  { 2518, 13, 17, 14, 1, -17 },
  { 2546, 15, 24, 15, 1, -24 },
  { 2591, 13, 17, 15, 1, -17 },
  { 2619, 11, 24, 10, 1, -24 },
  { 2652, 15, 24, 16, 0, -17 },
  { 2697, 14, 24, 15, 0, -24 },
  { 2739, 8, 23, 8, 0, -23 },
  { 2762, 11, 30, 7, -3, -23 },
  { 2804, 16, 24, 15, 0, -24 },
  { 2852, 8, 24, 8, 0, -24 },
  { 2876, 22, 17, 23, 0, -17 },
  { 2923, 14, 17, 15, 0, -17 },
  { 2953, 13, 17, 15, 1, -17 },
  { 2981, 15, 24, 15, -1, -17 },
  { 3026, 14, 24, 15, 1, -17 },
  { 3068, 11, 17, 10, 0, -17 },
  { 3092, 13, 17, 14, 0, -17 },
  { 3120, 9, 21, 9, 1, -21 },
  { 3144, 14, 17, 15, 1, -17 },
  { 3174, 13, 17, 14, 2, -17 },
  { 3202, 19, 17, 20, 2, -17 },
  { 3243, 16, 17, 14, -1, -17 },
  { 3277, 16, 24, 14, -1, -17 },
  { 3325, 14, 17, 14, 0, -17 },
  { 3355, 10, 31, 9, 1, -25 },
  { 3394, 7, 27, 8, 0, -23 },
  { 3418, 10, 31, 9, -1, -25 },
  { 3457, 15, 7, 18, 1, -13 },
};

const GFXfont RobotoCondensed_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC32PT7B_H_
