#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC67PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x87, 0xE7,
  0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x1C, 0x3F, 0x07, 0xC0,
  0x3C, 0xFC, 0x0F, 0x80, 0xFD, 0xF8, 0x1F, 0x03, 0xF3, 0xF0, 0x3E, 0x07,
  0xC7, 0xE0, 0x7C, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xF8,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC, 0x3F, 0x1F, 0x00,
  0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xE7, 0xE0, 0x01,
  0xFF, 0x8F, 0xC0, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07,
  0xC7, 0xFE, 0x00, 0x1F, 0x9F, 0xFE, 0x00, 0x7E, 0x7F, 0xFE, 0x00, 0xF9,
  0xFF, 0xFC, 0x03, 0xF3, 0xF0, 0xFC, 0x0F, 0xC7, 0xE1, 0xF8, 0x1F, 0x1F,
  0x81, 0xF0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0xF8,
  0x0F, 0x8F, 0xC1, 0xF0, 0x3F, 0x3F, 0x03, 0xE0, 0x7E, 0x7C, 0x07, 0xC0,
  0xFD, 0xF8, 0x0F, 0x81, 0xF1, 0xE0, 0x1F, 0x87, 0xE1, 0x80, 0x3F, 0x9F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xF8, 0xFF, 0xBF, 0xE3, 0xF8,
  0xFF, 0x9F, 0xF1, 0xFC, 0x7F, 0x87, 0xFC, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF,
  0x3F, 0xE0, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xE3, 0xFE, 0x01, 0xFF,
  0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE7, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x8F, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x18, 0x07, 0xC0,
  0x63, 0xE0, 0x7C, 0x3E, 0x3F, 0xCF, 0x8F, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE1,
  0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0xF8, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0E, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE,
  0x3F, 0x87, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF3, 0xFC, 0x78, 0x3F, 0xC6, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF7,
  0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF1, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0x80,
  0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x07, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xF0, 0x03, 0xFD, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFE, 0x7F, 0xE0, 0x7F, 0xCF,
  0xF8, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xE7,
  0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xFF, 0xC0, 0x7C, 0x1F, 0x80, 0x7F, 0xFF,
  0x81, 0xF0, 0x7E, 0x03, 0xFF, 0xFE, 0x07, 0xC1, 0xF0, 0x0F, 0xF1, 0xF8,
  0x1F, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x7C, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC7, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF3,
  0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x3E,
  0x07, 0xF0, 0x1F, 0x80, 0x7D, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF7, 0xE0,
  0x7E, 0x01, 0xF8, 0x0F, 0x9F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x7E, 0x0F,
  0xE0, 0x3F, 0x00, 0xF9, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xE7, 0xC0, 0xFE,
  0x03, 0xF0, 0x1F, 0x1F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0xFC, 0x0F, 0xC0,
  0x7E, 0x01, 0xF3, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x8F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x3E, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF0, 0xFC, 0x0F, 0xE1, 0xFE,
  0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xFC, 0x7E, 0x0F, 0xC0, 0x7F, 0xFB, 0xFF,
  0xF0, 0x1F, 0x01, 0xFF, 0xEF, 0xFF, 0xC0, 0x7C, 0x03, 0xFF, 0x1F, 0xFC,
  0x01, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xE3, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xE7, 0xF8, 0x07, 0xFF,
  0xF1, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F,
  0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xF9, 0xFF,
  0x80, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x07, 0xFB,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0x80, 0x7F, 0x7F, 0xC0, 0x7F, 0x9F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x0F,
  0xF1, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFC, 0x0F, 0xE7, 0xFC, 0x07,
  0xFC, 0x7E, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0x07, 0xF1, 0xFE, 0x01,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x80,
  0x7F, 0x87, 0xF3, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xF9, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7E, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x03,
  0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF,
  0xF8, 0x0F, 0xF8, 0x07, 0xF9, 0xF8, 0x0F, 0xF8, 0x07, 0xF9, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF9, 0xFC, 0x0F, 0xF0, 0x0F, 0xF9, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF8, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF0, 0x7E, 0x1F, 0xF0, 0x1F, 0xF0, 0x7E, 0x1F, 0xE0,
  0x1F, 0xF0, 0x7F, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x3F, 0xE0, 0x1F, 0xF0,
  0x3F, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xBF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xBF, 0xC0, 0x3F, 0xE0, 0x1F, 0xBF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F,
  0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x1F,
  0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFF, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xF8, 0x7F, 0x80,
  0x7F, 0x0F, 0xE7, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x9F, 0x87, 0xF8, 0x07,
  0xF0, 0xFE, 0x7E, 0x3F, 0xC0, 0x1F, 0xC7, 0xF1, 0xF8, 0xFF, 0x00, 0x7F,
  0x1F, 0xC7, 0xE3, 0xFC, 0x01, 0xFC, 0x7E, 0x1F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF8, 0x7E, 0x7F, 0x80, 0x1F, 0xCF, 0xE1, 0xF9, 0xFE, 0x00, 0x7F, 0x7F,
  0x07, 0xE7, 0xF8, 0x01, 0xFD, 0xFC, 0x1F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0,
  0x7E, 0xFF, 0x00, 0x1F, 0xFF, 0x81, 0xFB, 0xFC, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xC7, 0xF8, 0xFF, 0xC0, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE,
  0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFB, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7,
  0xFE, 0x03, 0xFE, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xCF, 0xFF, 0xC0, 0xFF, 0x1F,
  0xFE, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x3F,
  0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x1F, 0xE0,
  0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0xF3,
  0xFC, 0x01, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F,
  0x00, 0x03, 0xFF, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F,
  0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x06, 0x07, 0xFC, 0x03, 0xC0,
  0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xF1, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xFC, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xBF, 0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x3C, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x00,
  0xFF, 0x80, 0x38, 0x01, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x7F, 0x9F, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F,
  0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x0F, 0xF3, 0xFF,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0x9F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xE7, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0x07, 0xFC, 0x0F,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC7, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF1, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0xFF, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE3, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC7, 0xFC,
  0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0x00, 0x3F, 0xC0, 0x78, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xC0,
  0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x7F, 0x87, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3,
  0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFB, 0xFC, 0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xF7, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xD8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x7F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0x7F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0x7F, 0x03, 0xFE, 0x1F, 0xC0,
  0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xE0,
  0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF0,
  0x0F, 0xF7, 0xF8, 0x0F, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xE0, 0x7F, 0x9F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x81, 0xFC, 0x7F, 0x83, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xFC, 0x1F, 0xC3,
  0xFC, 0x3F, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0xE1, 0xFC, 0x0F, 0xE3, 0xFF, 0xC7, 0xF8, 0x1F, 0xCF, 0xFF, 0x8F, 0xE0,
  0x3F, 0x9F, 0xBF, 0x1F, 0xC0, 0x7F, 0x7F, 0x7E, 0x7F, 0x80, 0xFE, 0xFE,
  0xFC, 0xFE, 0x01, 0xFD, 0xF9, 0xFD, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0xF0,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFC, 0x3F, 0xFC, 0x01, 0xF8, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xF8, 0x0F,
  0xC7, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xF8, 0xFF, 0x3F, 0x8F, 0xFF, 0xFC,
  0xFE, 0x0F, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xE3, 0xF0, 0x0F, 0xFF, 0xC7,
  0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 49, 17, 1, -48 },
  { 106, 18, 18, 21, 5, -50 },
  { 147, 33, 48, 35, 2, -48 },
  { 345, 30, 63, 33, 2, -56 },
  { 582, 31, 50, 41, 6, -49 },
  { 776, 33, 50, 37, 1, -49 },
  { 983, 9, 17, 11, 4, -50 },
  { 1003, 21, 68, 21, 3, -53 },
  { 1182, 21, 68, 21, -3, -53 },
  { 1361, 28, 29, 29, 3, -48 },
  { 1463, 28, 35, 31, 2, -40 },
  { 1586, 14, 19, 15, -4, -8 },
  { 1620, 16, 7, 22, 3, -24 },
  { 1634, 10, 10, 19, 1, -9 },
  { 1647, 30, 52, 22, -4, -48 },
  { 1842, 28, 50, 33, 3, -49 },
  { 2017, 20, 48, 33, 7, -48 },
  { 2137, 32, 49, 33, 0, -49 },
  { 2333, 30, 50, 33, 1, -49 },
  { 2521, 30, 48, 33, 1, -48 },
  { 2701, 31, 49, 33, 2, -48 },
  { 2891, 27, 49, 33, 3, -48 },
  { 3057, 31, 48, 33, 3, -48 },
  { 3243, 30, 50, 33, 2, -49 },
  { 3431, 26, 49, 33, 5, -49 },
  { 3591, 15, 37, 18, 1, -36 },
  { 3661, 18, 47, 16, -3, -36 },
  { 3767, 26, 31, 29, 2, -36 },
  { 3868, 27, 21, 32, 3, -32 },
  { 3939, 27, 31, 30, 1, -36 },
  { 4044, 24, 50, 29, 5, -49 },
  { 4194, 46, 61, 50, 1, -46 },
  { 4545, 37, 48, 39, -3, -48 },
  { 4767, 34, 48, 36, 1, -48 },
  { 4971, 34, 50, 37, 3, -49 },
  { 5184, 34, 48, 37, 1, -48 },
  { 5388, 34, 48, 32, 1, -48 },
  { 5592, 33, 48, 31, 1, -48 },
  { 5790, 34, 50, 38, 3, -49 },
  { 6003, 40, 48, 40, 1, -48 },
  { 6243, 17, 48, 17, 1, -48 },
  { 6345, 33, 49, 32, 0, -48 },
  { 6548, 40, 48, 36, 1, -48 },
  { 6788, 26, 48, 31, 1, -48 },
  { 6944, 49, 48, 49, 1, -48 },
  { 7238, 40, 48, 40, 1, -48 },
  { 7478, 35, 50, 39, 3, -49 },
  { 7697, 36, 48, 37, 1, -48 },
  { 7913, 35, 57, 39, 3, -49 },
  { 8163, 35, 48, 36, 1, -48 },
  { 8373, 34, 50, 35, 1, -49 },
  { 8586, 33, 48, 35, 5, -48 },
  { 8784, 36, 49, 37, 2, -48 },
  { 9005, 36, 48, 37, 5, -48 },
  { 9221, 46, 48, 49, 6, -48 },
  { 9497, 41, 48, 36, -2, -48 },
  { 9743, 33, 48, 35, 6, -48 },
  { 9941, 38, 48, 34, -1, -48 },
  { 10169, 22, 66, 17, -1, -55 },
  { 10351, 15, 52, 25, 6, -48 },
  { 10449, 23, 66, 17, -4, -55 },
  { 10639, 22, 24, 25, 2, -48 },
  { 10705, 26, 7, 26, -4, 0 },
  { 10728, 13, 10, 21, 7, -50 },
  { 10745, 27, 37, 31, 1, -36 },
  { 10870, 30, 51, 32, 0, -50 },
  { 11062, 27, 37, 30, 2, -36 },
  { 11187, 33, 51, 32, 1, -50 },
  { 11398, 27, 37, 31, 2, -36 },
  { 11523, 23, 51, 21, 2, -51 },
  { 11670, 32, 50, 33, 0, -36 },
  { 11870, 29, 50, 32, 0, -50 },
  { 12052, 17, 49, 16, 0, -49 },
  { 12157, 24, 63, 16, -7, -49 },
  { 12346, 33, 50, 31, 0, -50 },
  { 12553, 17, 50, 16, 0, -50 },
  { 12660, 45, 36, 48, 0, -36 },
  { 12863, 29, 36, 32, 0, -36 },
  { 12994, 28, 37, 32, 2, -36 },
  { 13124, 32, 50, 32, -2, -36 },
  { 13324, 29, 50, 32, 2, -36 },
  { 13506, 22, 36, 21, 0, -36 },
  { 13605, 28, 37, 30, 0, -36 },
  { 13735, 19, 45, 20, 2, -44 },
  { 13842, 29, 36, 32, 2, -35 },
  { 13973, 26, 35, 29, 4, -35 },
  { 14087, 39, 35, 41, 4, -35 },
  { 14258, 32, 35, 29, -2, -35 },
  { 14398, 33, 49, 29, -2, -35 },
  { 14601, 30, 35, 29, -1, -35 },
  { 14733, 20, 64, 20, 2, -52 },
  { 14893, 14, 57, 16, 1, -48 },
  { 14993, 21, 64, 20, -3, -52 },
  { 15161, 31, 14, 37, 3, -26 },
};

const GFXfont RobotoCondensed_SemiBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC67PT7B_H_
