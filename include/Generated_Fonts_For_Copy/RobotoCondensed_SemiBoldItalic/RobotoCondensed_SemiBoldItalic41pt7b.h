#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC41PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x70, 0x00, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x1C, 0xE3, 0xBC, 0x77,
  0x9E, 0xE3, 0x9C, 0x73, 0x8E, 0x00, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x9E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xF3, 0xC0,
  0x0E, 0x38, 0x00, 0xE3, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x03, 0xCF, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x79, 0xE0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xE3,
  0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x38,
  0xE0, 0x07, 0x8E, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0xC1, 0xF1, 0xF0, 0xFC, 0x7E, 0x7E,
  0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x39, 0xE0, 0x8F, 0x1C, 0x1D, 0xC3, 0x87, 0x38, 0x71, 0xE7,
  0x0E, 0x78, 0xE1, 0xCE, 0x1C, 0x7B, 0xC3, 0xCE, 0xF0, 0x7F, 0xDC, 0x07,
  0xF7, 0x00, 0x7D, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x78, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x1D, 0xE7, 0x07, 0x38, 0xF1, 0xEF, 0x1E, 0x39, 0xE3, 0xCE,
  0x3C, 0x7B, 0xC7, 0x0E, 0xF0, 0xF1, 0xCC, 0x1E, 0x78, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE1, 0xF1, 0xFF, 0x1F, 0x3F, 0xF1, 0xE7, 0xEF,
  0x9E, 0x7C, 0xFB, 0xEF, 0x87, 0xFE, 0xF8, 0x7F, 0xCF, 0x83, 0xFC, 0xF8,
  0x3F, 0x8F, 0x81, 0xF0, 0xFC, 0x7F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0x7C, 0x0F, 0xC7, 0xE0, 0x7B, 0xDE, 0xF7, 0x7B, 0xDE, 0xF7, 0x38,
  0x00, 0x10, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0C, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x0C, 0x00, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x07, 0x0D, 0xF7,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0xF0, 0x38, 0x38, 0x08, 0x10,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x20, 0xFF, 0xFF,
  0xEF, 0xFB, 0xFE, 0x33, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xFC,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x20,
  0x3C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFC, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xCF, 0xC7, 0xC1,
  0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xFC, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xF7, 0xC0, 0x3F, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0x7C, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7D, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC7, 0xC0, 0x20, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF9, 0xF0, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7E,
  0x7E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x1E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C,
  0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x3E, 0x7E, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0xFC,
  0x7E, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x0E, 0x0F,
  0x87, 0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x3E, 0x1F, 0x8F, 0xC7, 0xC1, 0xE0,
  0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC1,
  0xF0, 0x3C, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0x7F, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x1F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x10, 0x00,
  0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xDF, 0x8F, 0xFE,
  0x0F, 0xFC, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xE0, 0xE0, 0x3E, 0x07, 0x1E, 0x0F, 0xF0, 0x71, 0xC1, 0xFF,
  0x87, 0x3C, 0x3E, 0x78, 0x73, 0x87, 0xC7, 0x87, 0x78, 0x78, 0x78, 0x77,
  0x8F, 0x07, 0x07, 0x70, 0xF0, 0x70, 0x77, 0x0F, 0x0F, 0x0F, 0xF1, 0xE0,
  0xF0, 0xEF, 0x1E, 0x0E, 0x0E, 0xF1, 0xE1, 0xE0, 0xEE, 0x1E, 0x1E, 0x1C,
  0xE1, 0xE1, 0xE1, 0xCE, 0x1E, 0x3E, 0x3C, 0xE1, 0xF7, 0xE7, 0x8E, 0x1F,
  0xFF, 0xF0, 0xE0, 0xFC, 0xFE, 0x0F, 0x07, 0x87, 0xC0, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3,
  0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0xF0, 0x1F, 0x81, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xC0, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7C,
  0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFE, 0xFF, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x81, 0xF0, 0x7F, 0x3F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7C, 0x7F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFE,
  0x7F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0xFF, 0xDF, 0x87, 0xFE, 0xF8, 0x3F, 0xE7, 0xC1, 0xFF, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F,
  0x8F, 0x80, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x00,
  0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x07, 0xC3,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x3F, 0x80,
  0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0,
  0x1F, 0x1F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8,
  0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3D, 0xE0, 0x7F, 0xE0, 0xFB, 0xC0, 0xF7, 0xC1, 0xF7, 0x83,
  0xEF, 0x03, 0xEF, 0x07, 0xBE, 0x07, 0xDF, 0x1F, 0x7C, 0x0F, 0x9E, 0x3C,
  0xF8, 0x1F, 0x3C, 0xF9, 0xF0, 0x7C, 0x79, 0xE7, 0xE0, 0xF8, 0xF3, 0xCF,
  0x81, 0xF1, 0xEF, 0x1F, 0x03, 0xE3, 0xDE, 0x3E, 0x07, 0xC7, 0xF8, 0x7C,
  0x1F, 0x8F, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xC0,
  0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC1, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xC0, 0xFE, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x7F, 0x80, 0xF8, 0x3F,
  0xC0, 0x7C, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x03,
  0xEF, 0x0F, 0x83, 0xF7, 0x87, 0xC1, 0xFB, 0xC3, 0xE0, 0xF9, 0xE3, 0xF0,
  0x7C, 0x79, 0xF0, 0x3E, 0x3C, 0xF8, 0x1F, 0x1E, 0x7C, 0x1F, 0x87, 0x3E,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0x81, 0xF0, 0x3F,
  0xC1, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xF0, 0x7C, 0x03, 0xF8, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFF,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x1F,
  0x81, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x07, 0xC1, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x3F,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7E,
  0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xE7, 0xF1, 0xF8, 0x3F, 0x1F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0x7F, 0x7F, 0x87, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0,
  0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01,
  0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F,
  0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x03, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0xC0,
  0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x3E, 0xF8,
  0x1F, 0x03, 0xEF, 0x83, 0xF0, 0x7E, 0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xF0,
  0x7C, 0xF8, 0x7F, 0x0F, 0xCF, 0x87, 0xF0, 0xF8, 0xF8, 0x7F, 0x0F, 0x8F,
  0x8F, 0xF0, 0xF8, 0xF8, 0xFF, 0x1F, 0x0F, 0x9F, 0xF1, 0xF0, 0xF9, 0xEF,
  0x1F, 0x0F, 0x9E, 0xF3, 0xE0, 0xFB, 0xEF, 0x3E, 0x0F, 0xBC, 0xF3, 0xE0,
  0xFB, 0xCF, 0x7C, 0x0F, 0xFC, 0xF7, 0xC0, 0xFF, 0x8F, 0x7C, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x00,
  0xFC, 0xFC, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07,
  0xC3, 0xF0, 0x1E, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8,
  0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0x78, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0,
  0x7C, 0x1F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x03, 0xDE, 0x0F,
  0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x0E, 0x3C, 0x39, 0xE0, 0xF7, 0x83, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x3E, 0x1E,
  0x1F, 0x0F, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xE3, 0xF1, 0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x79,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x83, 0xE7,
  0xF3, 0xF1, 0xFF, 0xFC, 0xFB, 0xFE, 0x3E, 0xFF, 0x0F, 0x8F, 0x80, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9,
  0xF0, 0x3C, 0xF8, 0x1F, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x3E,
  0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x7C, 0x0F,
  0xF7, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7E, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xF1, 0xF1, 0xF0, 0x79, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x0C, 0x3F, 0x1E, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x01, 0xF1, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFC, 0xFE, 0x7E, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7E, 0x1F, 0x8F, 0xE7, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x20,
  0x3E, 0x0E, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xEF,
  0x81, 0xF7, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xF1, 0xF0, 0xFC,
  0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE0,
  0x01, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x80, 0x00, 0x10, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x0B, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x7F, 0x0F, 0x8F, 0xE1, 0xF0, 0xFC, 0x1F, 0x1F, 0x81, 0xF3, 0xF0, 0x1F,
  0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xE7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x3F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x00, 0x0F, 0x3E, 0x0F, 0x80, 0xF7, 0xF1, 0xFC, 0x1F, 0xFF, 0xBF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x1F, 0x8F, 0xF3, 0xF1, 0xF0, 0xFC, 0x1F, 0x1F, 0x07,
  0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x81, 0xF3, 0xE0, 0xF8, 0x3E,
  0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xE0,
  0xF8, 0x3E, 0x7C, 0x1F, 0x03, 0xE7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07,
  0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xCF, 0xC1, 0xF0, 0x7C, 0xF8,
  0x3E, 0x07, 0xCF, 0x83, 0xE0, 0xF8, 0x0F, 0x3E, 0x07, 0xDF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xCF, 0xC7, 0xC3, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x3F, 0x3F, 0x3F, 0x1F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0x9F, 0x00, 0xF7, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7,
  0xF3, 0xF0, 0xFF, 0xFE, 0x3E, 0xFF, 0x87, 0xDF, 0xE0, 0xF8, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xC3, 0xFD, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x1F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x3C, 0x3D, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xF9, 0xF0, 0x3E, 0xF8, 0x3E, 0x3E, 0x1F, 0x1F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x87, 0xFF, 0x7F, 0xE7, 0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x87, 0xF8, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x07,
  0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xE7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xBE, 0x07, 0xCF, 0x00,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xCF, 0x07, 0xC7, 0xC3, 0xE3, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F,
  0xBE, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x3C, 0x1F, 0x78, 0x3C, 0x1F, 0x78, 0x7C, 0x1E, 0x78, 0x7C, 0x3E, 0x78,
  0x7C, 0x3E, 0x78, 0xFC, 0x7C, 0x78, 0xFE, 0x7C, 0x79, 0xFE, 0x78, 0x79,
  0xFE, 0xF8, 0x79, 0xFE, 0xF8, 0x7B, 0xDE, 0xF0, 0x7B, 0xDF, 0xF0, 0x7F,
  0x9F, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87,
  0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0x3E, 0x03,
  0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0,
  0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F,
  0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB,
  0xE0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3C, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x01, 0x00, 0x1C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x38, 0x01, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0xF0, 0x3D, 0xFF, 0x07, 0xBF, 0xF1, 0xEF, 0xBF, 0x7D, 0xE1,
  0xFF, 0xBC, 0x3F, 0xE7, 0x03, 0xF8, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 29, 10, 1, -29 },
  { 38, 11, 11, 13, 3, -31 },
  { 54, 20, 29, 21, 1, -29 },
  { 127, 18, 37, 20, 1, -33 },
  { 211, 19, 29, 25, 4, -29 },
  { 280, 20, 29, 23, 1, -29 },
  { 353, 5, 11, 7, 3, -31 },
  { 360, 12, 42, 13, 2, -33 },
  { 423, 13, 41, 13, -2, -32 },
  { 490, 17, 18, 18, 2, -29 },
  { 529, 17, 21, 19, 1, -24 },
  { 574, 8, 12, 9, -2, -5 },
  { 586, 10, 4, 13, 2, -14 },
  { 591, 6, 6, 11, 1, -6 },
  { 596, 18, 32, 14, -2, -29 },
  { 668, 17, 29, 20, 2, -29 },
  { 730, 11, 29, 20, 5, -29 },
  { 770, 19, 29, 20, 0, -29 },
  { 839, 18, 29, 20, 1, -29 },
  { 905, 19, 29, 20, 0, -29 },
  { 974, 19, 29, 20, 1, -29 },
  { 1043, 16, 29, 20, 2, -29 },
  { 1101, 19, 29, 20, 2, -29 },
  { 1170, 18, 29, 20, 1, -29 },
  { 1236, 16, 29, 20, 3, -29 },
  { 1294, 9, 23, 11, 1, -23 },
  { 1320, 11, 30, 10, -2, -23 },
  { 1362, 16, 19, 18, 1, -22 },
  { 1400, 17, 12, 20, 2, -19 },
  { 1426, 16, 19, 18, 1, -22 },
  { 1464, 15, 29, 18, 3, -29 },
  { 1519, 28, 37, 30, 1, -28 },
  { 1649, 23, 29, 24, -2, -29 },
  { 1733, 22, 29, 22, 0, -29 },
  { 1813, 21, 29, 23, 2, -29 },
  { 1890, 22, 29, 23, 0, -29 },
  { 1970, 21, 29, 20, 0, -29 },
  { 2047, 21, 29, 19, 0, -29 },
  { 2124, 21, 29, 23, 2, -29 },
  { 2201, 25, 29, 24, 0, -29 },
  { 2292, 10, 29, 11, 1, -29 },
  { 2329, 20, 29, 19, 0, -29 },
  { 2402, 25, 29, 22, 0, -29 },
  { 2493, 17, 29, 19, 0, -29 },
  { 2555, 31, 29, 30, 0, -29 },
  { 2668, 25, 29, 24, 0, -29 },
  { 2759, 21, 29, 24, 2, -29 },
  { 2836, 23, 29, 22, 0, -29 },
  { 2920, 21, 34, 24, 2, -29 },
  { 3010, 22, 29, 22, 0, -29 },
  { 3090, 20, 29, 21, 1, -29 },
  { 3163, 20, 29, 21, 3, -29 },
  { 3236, 23, 29, 23, 1, -29 },
  { 3320, 22, 29, 23, 3, -29 },
  { 3400, 28, 29, 30, 4, -29 },
  { 3502, 25, 29, 22, -1, -29 },
  { 3593, 21, 29, 21, 3, -29 },
  { 3670, 23, 29, 21, -1, -29 },
  { 3754, 14, 41, 10, -1, -34 },
  { 3826, 10, 32, 15, 3, -29 },
  { 3866, 13, 41, 10, -2, -34 },
  { 3933, 14, 15, 15, 1, -29 },
  { 3960, 15, 4, 16, -2, 0 },
  { 3968, 8, 6, 13, 4, -31 },
  { 3974, 17, 22, 19, 0, -22 },
  { 4021, 18, 31, 20, 0, -31 },
  { 4091, 17, 22, 18, 1, -22 },
  { 4138, 20, 31, 20, 1, -31 },
  { 4216, 17, 22, 19, 1, -22 },
  { 4263, 15, 31, 13, 1, -31 },
  { 4322, 19, 30, 20, 0, -22 },
  { 4394, 18, 31, 19, 0, -31 },
  { 4464, 10, 31, 10, 0, -31 },
  { 4503, 14, 39, 10, -4, -31 },
  { 4572, 20, 31, 19, 0, -31 },
  { 4650, 11, 31, 10, 0, -31 },
  { 4693, 28, 22, 30, 0, -22 },
  { 4770, 18, 22, 20, 0, -22 },
  { 4820, 17, 22, 20, 1, -22 },
  { 4867, 19, 30, 20, -1, -22 },
  { 4939, 18, 30, 20, 1, -22 },
  { 5007, 14, 22, 13, 0, -22 },
  { 5046, 17, 22, 18, 0, -22 },
  { 5093, 12, 27, 12, 1, -27 },
  { 5134, 18, 22, 20, 1, -22 },
  { 5184, 17, 22, 18, 2, -22 },
  { 5231, 24, 22, 25, 2, -22 },
  { 5297, 20, 22, 18, -1, -22 },
  { 5352, 20, 30, 17, -1, -22 },
  { 5427, 18, 22, 18, 0, -22 },
  { 5477, 13, 39, 12, 1, -32 },
  { 5541, 8, 34, 10, 1, -29 },
  { 5575, 13, 39, 12, -2, -32 },
  { 5639, 19, 9, 22, 2, -17 },
};

const GFXfont RobotoCondensed_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC41PT7B_H_
