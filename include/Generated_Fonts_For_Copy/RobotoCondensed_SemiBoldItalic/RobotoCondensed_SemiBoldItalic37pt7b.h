#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC37PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x73, 0xDC, 0xF7, 0x39, 0xCE,
  0xF3, 0xB8, 0xEE, 0x3B, 0x9C, 0xE7, 0x31, 0xC0, 0x00, 0x71, 0xC0, 0x1C,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x39, 0xC0, 0x1E, 0x70, 0x07,
  0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE,
  0x1F, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF8, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x03, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C,
  0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xC7, 0x0C, 0x71, 0xC7, 0xBC, 0x71, 0xCE, 0x1C, 0xE3, 0x87, 0x78,
  0xF3, 0x9C, 0x1F, 0xEE, 0x07, 0xF7, 0x00, 0x7B, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x39, 0xE0, 0x0E, 0xFC, 0x07, 0x7F, 0x83, 0xBC, 0xE1, 0xEE,
  0x38, 0x73, 0x8E, 0x38, 0xE3, 0x9C, 0x38, 0xE7, 0x0E, 0x38, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x3C, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0,
  0xF3, 0xFE, 0x3D, 0xF7, 0x9E, 0xF9, 0xF7, 0xBE, 0x3F, 0xEF, 0x8F, 0xF3,
  0xC1, 0xFC, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xE3, 0xE0, 0x39, 0xCE, 0xF7, 0xB9, 0xCE, 0x77, 0x80, 0x00,
  0x40, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0x80, 0x02, 0x00, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x06, 0x00, 0x40, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x04, 0x1C, 0x2E, 0x33, 0xFF, 0xFF, 0xBF,
  0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0x00, 0xEF, 0x03, 0xCE, 0x0F, 0x1E,
  0x1C, 0x1C, 0x00, 0x20, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F,
  0x3C, 0x79, 0xE1, 0x80, 0xFF, 0x7F, 0xBF, 0xDF, 0xE0, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xDF, 0x07, 0xBE, 0x0F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xCF, 0x0F,
  0x9F, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x60,
  0x7C, 0x3F, 0x3F, 0xE7, 0xFD, 0xFF, 0xB9, 0xF4, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C,
  0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xDF, 0x01, 0xEF, 0x81, 0xE7, 0x81, 0xF3, 0xC0,
  0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x78, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xE1, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x3E, 0x0F, 0x9F, 0x07,
  0xC7, 0x83, 0xC3, 0xE3, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF7, 0x87, 0xFF, 0x9F, 0xFE, 0xFF,
  0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE3, 0xE7, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00,
  0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x1F, 0x1F, 0x1E, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF8,
  0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C,
  0xF8, 0x7C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7C, 0x7B, 0xE1, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF,
  0xE7, 0xFF, 0x9F, 0xFE, 0x1E, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x3F, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x1F,
  0x3F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x70, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x3C, 0x02, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07,
  0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x20, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x10, 0x00, 0xE0,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00,
  0x7C, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x38,
  0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFC,
  0x7F, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x03, 0xC0, 0x3C,
  0x00, 0xE0, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x1E,
  0x0F, 0x83, 0x8E, 0x0F, 0xF1, 0xCE, 0x0F, 0xF8, 0xE7, 0x0F, 0x1C, 0x77,
  0x8F, 0x1E, 0x3B, 0x87, 0x0E, 0x1D, 0xC7, 0x87, 0x0E, 0xE3, 0xC3, 0x87,
  0xE1, 0xC3, 0xC3, 0xF0, 0xE1, 0xC1, 0xF8, 0xF0, 0xE1, 0xDC, 0x78, 0x70,
  0xEE, 0x3C, 0x78, 0x77, 0x1E, 0x3C, 0x73, 0x8F, 0x3E, 0x39, 0xC3, 0xFF,
  0xF8, 0xE1, 0xFB, 0xF8, 0x70, 0x78, 0xF8, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78,
  0x3C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3E,
  0x01, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F,
  0x83, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x3E,
  0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03,
  0xDE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xEF, 0x00, 0xF3, 0xC0,
  0x7C, 0xF8, 0x1F, 0x3F, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1F,
  0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE1,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C,
  0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC3, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xF8, 0x7C,
  0x7C, 0x0F, 0x8F, 0x80, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x87, 0xFD, 0xF0, 0xFF, 0xBE, 0x1F, 0xE7,
  0xC3, 0xFC, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x7C, 0x07, 0xCF,
  0x81, 0xF1, 0xF8, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80,
  0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x78,
  0x03, 0xC1, 0xF0, 0x0F, 0x80, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1F, 0x1F,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0xFC, 0x1E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x87, 0xE0,
  0x3E, 0x3F, 0x00, 0xF1, 0xF8, 0x03, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7D,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x3C, 0x00, 0xF8, 0xF8, 0x03,
  0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0,
  0x7F, 0xC1, 0xEF, 0x0F, 0x7C, 0x1E, 0xF0, 0xF7, 0x81, 0xE7, 0x1E, 0x78,
  0x3E, 0x71, 0xE7, 0x83, 0xE7, 0x1C, 0xF8, 0x3E, 0x7B, 0xCF, 0x83, 0xE7,
  0xB8, 0xF8, 0x3C, 0x7F, 0x8F, 0x07, 0xC7, 0xF8, 0xF0, 0x7C, 0x7F, 0x1F,
  0x07, 0xC3, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x83, 0xC3, 0xE0, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x78,
  0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFE, 0x07, 0xC1, 0xFC, 0x0F, 0x83,
  0xF8, 0x1E, 0x07, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x3E, 0xE1, 0xF0, 0x7D,
  0xC3, 0xE0, 0xFB, 0xC7, 0x81, 0xE7, 0x8F, 0x03, 0xC7, 0x3E, 0x0F, 0x8F,
  0x7C, 0x1F, 0x1E, 0xF8, 0x3E, 0x1D, 0xF0, 0x7C, 0x3B, 0xC0, 0xF0, 0x7F,
  0x83, 0xE0, 0xFF, 0x07, 0xC0, 0xFE, 0x0F, 0x81, 0xFC, 0x1F, 0x03, 0xF8,
  0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xF8, 0xFC, 0x7C, 0x0F, 0x8F,
  0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0x80, 0x3E, 0xF0,
  0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF8,
  0x7E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x1E, 0x07, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xF8, 0xFC, 0x7C, 0x0F, 0x8F, 0x80, 0xF3, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x3D, 0xF0,
  0x0F, 0xBE, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0,
  0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF8, 0x7E, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1,
  0xF1, 0xE0, 0x7C, 0xF8, 0x0F, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x1F, 0x0F,
  0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xE0, 0x1E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x78, 0x7C, 0x07, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x7C,
  0x1F, 0x07, 0xC3, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0x78, 0x07, 0xC7, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7,
  0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x0F,
  0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x3E, 0xF8, 0x7E, 0x0F, 0x3E,
  0x1F, 0x87, 0xCF, 0x87, 0xE1, 0xE1, 0xE3, 0xF8, 0x78, 0x78, 0xFE, 0x3E,
  0x1E, 0x3F, 0x8F, 0x07, 0x9E, 0xE3, 0xC1, 0xE7, 0xB9, 0xF0, 0x79, 0xCE,
  0x78, 0x1E, 0xF3, 0x9E, 0x07, 0xBC, 0xEF, 0x81, 0xEE, 0x3B, 0xC0, 0x7F,
  0x8E, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x0F,
  0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xF8, 0x00, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x7C, 0x00, 0x7C, 0x78, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xDF, 0x00, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8,
  0x3E, 0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x00, 0xF8, 0x7C, 0x3E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8,
  0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1C,
  0xF3, 0xCF, 0x38, 0x77, 0x87, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xC0, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1E, 0x3E, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x7C,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF1, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x78, 0xF8, 0x7C, 0x7F, 0xFE, 0x7F, 0xFE, 0x3E, 0xFE, 0x1E, 0x3E, 0x00,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xCF, 0x87, 0xDE,
  0x0F, 0xBC, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x0F, 0xBC, 0x1E, 0x7C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x07, 0xCF, 0x07, 0xFB,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x07, 0x87, 0x81, 0xE3,
  0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x79, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE3, 0xE3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x04, 0x7C, 0x18, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE7, 0xC1, 0xFD, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x7C,
  0x0F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x1E, 0x07,
  0x87, 0xC1, 0xE1, 0xF0, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x3E, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0x83, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E,
  0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C,
  0xF8, 0x3C, 0xF8, 0x7C, 0x07, 0x03, 0xC3, 0xE0, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x00,
  0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1, 0xF3, 0xF0,
  0x78, 0xF8, 0x1E, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7E, 0xF0, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xE1, 0xE0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0x1F, 0x7C, 0x3E, 0x0F, 0xFF, 0x3F, 0x87, 0xFF, 0xBF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xF1, 0xF8, 0xF8, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3E, 0x7C,
  0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x9E, 0x0F, 0x07, 0xCF, 0x07, 0x83, 0xCF,
  0x83, 0xC1, 0xE7, 0xC3, 0xE0, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0x7C,
  0xF0, 0x7C, 0x3E, 0x78, 0x3C, 0x1E, 0x7C, 0x1E, 0x0F, 0x3E, 0x1F, 0x07,
  0x9F, 0x0F, 0x87, 0xC0, 0x1F, 0x7C, 0x1E, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F,
  0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E,
  0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x03, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xBE, 0x03, 0xDF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0x83,
  0xC1, 0xE1, 0xF0, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xDF, 0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0x07, 0xCF, 0x1F, 0xEF, 0x3F, 0xEF, 0x3F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFF,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x1E, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x71, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xBE, 0x0F, 0x7C, 0x3E, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x7F, 0x1F, 0xC3, 0xE0,
  0x78, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8,
  0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3E, 0x78, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xCF, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xE0, 0xF3, 0xC1,
  0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x78, 0x7F, 0xE1, 0xE1,
  0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3C, 0xF9, 0xF8, 0xF3, 0xE7, 0xE7, 0xCF,
  0x9F, 0x9E, 0x3E, 0xFE, 0x78, 0x7B, 0xBB, 0xE1, 0xFE, 0xEF, 0x07, 0xFB,
  0xBC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E,
  0x0F, 0x00, 0x1F, 0x07, 0xC3, 0xC3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x07,
  0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0x80,
  0x79, 0xE0, 0x3E, 0x7C, 0x1F, 0x1F, 0x07, 0xC3, 0xC3, 0xE0, 0xF8, 0x1F,
  0x07, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x03, 0xC7,
  0xC0, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x70, 0x02, 0x00, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x70,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00,
  0x04, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x3C, 0x0F, 0x83, 0xF0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0x80,
  0x40, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0xF3, 0xFC, 0x3D, 0xFF, 0x9E, 0x79,
  0xFF, 0x9C, 0x3F, 0xCF, 0x07, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 9, 1, -26 },
  { 31, 10, 10, 11, 3, -28 },
  { 44, 18, 26, 19, 1, -26 },
  { 103, 17, 33, 18, 1, -30 },
  { 174, 18, 26, 23, 3, -26 },
  { 233, 18, 26, 20, 1, -26 },
  { 292, 5, 10, 6, 2, -28 },
  { 299, 11, 37, 12, 2, -29 },
  { 350, 12, 37, 12, -2, -29 },
  { 406, 15, 16, 16, 2, -26 },
  { 436, 16, 19, 17, 1, -21 },
  { 474, 7, 11, 8, -2, -4 },
  { 484, 9, 4, 12, 2, -13 },
  { 489, 5, 5, 10, 1, -5 },
  { 493, 16, 28, 12, -2, -26 },
  { 549, 15, 26, 18, 2, -26 },
  { 598, 11, 26, 18, 4, -26 },
  { 634, 17, 26, 18, 0, -26 },
  { 690, 16, 26, 18, 1, -26 },
  { 742, 17, 26, 18, 0, -26 },
  { 798, 17, 26, 18, 1, -26 },
  { 854, 14, 26, 18, 2, -26 },
  { 900, 17, 26, 18, 2, -26 },
  { 956, 16, 26, 18, 1, -26 },
  { 1008, 14, 26, 18, 3, -26 },
  { 1054, 8, 20, 10, 1, -20 },
  { 1074, 10, 27, 9, -2, -20 },
  { 1108, 14, 17, 16, 1, -20 },
  { 1138, 15, 12, 18, 2, -18 },
  { 1161, 14, 17, 16, 1, -20 },
  { 1191, 13, 26, 16, 3, -26 },
  { 1234, 25, 34, 28, 1, -26 },
  { 1341, 20, 26, 21, -1, -26 },
  { 1406, 19, 26, 20, 0, -26 },
  { 1468, 18, 26, 20, 2, -26 },
  { 1527, 20, 26, 20, 0, -26 },
  { 1592, 19, 26, 18, 0, -26 },
  { 1654, 19, 26, 17, 0, -26 },
  { 1716, 19, 26, 21, 2, -26 },
  { 1778, 23, 26, 22, 0, -26 },
  { 1853, 9, 26, 10, 1, -26 },
  { 1883, 18, 26, 18, 0, -26 },
  { 1942, 22, 26, 20, 0, -26 },
  { 2014, 15, 26, 17, 0, -26 },
  { 2063, 28, 26, 27, 0, -26 },
  { 2154, 23, 26, 22, 0, -26 },
  { 2229, 19, 26, 22, 2, -26 },
  { 2291, 20, 26, 20, 0, -26 },
  { 2356, 19, 31, 22, 2, -26 },
  { 2430, 20, 26, 20, 0, -26 },
  { 2495, 18, 26, 19, 1, -26 },
  { 2554, 18, 26, 19, 3, -26 },
  { 2613, 20, 26, 20, 1, -26 },
  { 2678, 20, 26, 21, 3, -26 },
  { 2743, 26, 26, 27, 3, -26 },
  { 2828, 23, 26, 20, -1, -26 },
  { 2903, 19, 26, 19, 3, -26 },
  { 2965, 20, 26, 19, 0, -26 },
  { 3030, 13, 37, 9, -1, -31 },
  { 3091, 9, 28, 14, 3, -26 },
  { 3123, 12, 37, 9, -2, -31 },
  { 3179, 12, 13, 14, 1, -26 },
  { 3199, 14, 4, 14, -2, 0 },
  { 3206, 7, 6, 12, 4, -28 },
  { 3212, 16, 20, 17, 0, -20 },
  { 3252, 17, 28, 18, 0, -28 },
  { 3312, 15, 20, 17, 1, -20 },
  { 3350, 18, 28, 18, 1, -28 },
  { 3413, 15, 20, 17, 1, -20 },
  { 3451, 13, 28, 12, 1, -28 },
  { 3497, 18, 28, 18, 0, -20 },
  { 3560, 16, 28, 18, 0, -28 },
  { 3616, 9, 28, 9, 0, -28 },
  { 3648, 13, 36, 9, -4, -28 },
  { 3707, 18, 28, 17, 0, -28 },
  { 3770, 10, 28, 9, 0, -28 },
  { 3805, 25, 20, 27, 0, -20 },
  { 3868, 16, 20, 18, 0, -20 },
  { 3908, 16, 20, 18, 1, -20 },
  { 3948, 18, 28, 18, -1, -20 },
  { 4011, 16, 28, 18, 1, -20 },
  { 4067, 12, 20, 12, 0, -20 },
  { 4097, 15, 20, 16, 0, -20 },
  { 4135, 10, 24, 11, 1, -24 },
  { 4165, 16, 20, 18, 1, -20 },
  { 4205, 15, 20, 16, 2, -20 },
  { 4243, 22, 20, 23, 2, -20 },
  { 4298, 18, 20, 16, -1, -20 },
  { 4343, 18, 28, 16, -1, -20 },
  { 4406, 16, 20, 16, 0, -20 },
  { 4446, 11, 36, 11, 1, -29 },
  { 4496, 7, 31, 9, 1, -26 },
  { 4524, 11, 36, 11, -1, -29 },
  { 4574, 18, 8, 20, 1, -15 },
};

const GFXfont RobotoCondensed_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC37PT7B_H_
