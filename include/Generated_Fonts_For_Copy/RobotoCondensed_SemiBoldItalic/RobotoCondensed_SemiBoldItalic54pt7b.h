#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC54PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0x40, 0x00, 0x3E, 0x3E, 0x7C, 0x7D, 0xF0, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xF1, 0xF3,
  0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x78, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF9, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE,
  0x07, 0xF0, 0x7F, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE3, 0xE0, 0x63, 0xE1, 0xF0, 0x7D,
  0xF0, 0xF8, 0x3C, 0xF8, 0x7C, 0x3E, 0x78, 0x3E, 0x3E, 0x3C, 0x1F, 0x1E,
  0x1E, 0x0F, 0x9F, 0x0F, 0x07, 0x9F, 0x07, 0xC7, 0xCF, 0x03, 0xFF, 0xEF,
  0x80, 0xFF, 0xEF, 0x80, 0x3F, 0xE7, 0x80, 0x0F, 0xE7, 0xC0, 0x00, 0x87,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE7, 0xF0, 0x01, 0xE7, 0xFC, 0x01, 0xF7, 0xFF, 0x01, 0xF7, 0xFF, 0x80,
  0xF3, 0xE3, 0xE0, 0xFB, 0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0x78, 0xF8, 0x7C,
  0x78, 0x78, 0x3E, 0x7C, 0x3C, 0x1F, 0x7C, 0x1E, 0x0F, 0xBC, 0x0F, 0x07,
  0x9E, 0x07, 0xC7, 0xC2, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x07, 0xC3, 0xFF, 0xC1, 0xF1, 0xFF, 0xF8, 0xFC, 0xFE, 0xFE,
  0x3F, 0x3F, 0x9F, 0xCF, 0xDF, 0xC7, 0xF7, 0xE7, 0xF0, 0xFF, 0xFB, 0xF8,
  0x3F, 0xFE, 0xFE, 0x07, 0xFF, 0x3F, 0x81, 0xFF, 0xCF, 0xE0, 0x3F, 0xE3,
  0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xE0, 0x7F,
  0xC3, 0xF8, 0x01, 0x00, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x02, 0x03, 0xC0, 0x9E, 0x0F, 0x1F, 0x7F, 0x79, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0x9E, 0x00, 0x7C, 0x7C,
  0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0x3C, 0x0F, 0x80, 0x60, 0x1C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x1E, 0x00, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E,
  0x07, 0xE0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0xFE, 0x03, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xFC, 0xF8, 0xFC, 0xC1, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8,
  0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xF9,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE3,
  0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xE0, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x7E, 0x03, 0xFB, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x07,
  0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0,
  0x3F, 0x9F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x81, 0xF8, 0x3F,
  0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E,
  0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC7, 0xF0, 0x7E, 0x7F, 0x03, 0xF3, 0xF0,
  0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x81,
  0xFD, 0xFC, 0x1F, 0xE7, 0xFB, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xF7, 0xE0, 0x3E, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x7C, 0x07, 0xFE, 0x07, 0x87,
  0xC0, 0x7F, 0xF8, 0x3C, 0x3E, 0x07, 0xFF, 0xE1, 0xE3, 0xE0, 0x7F, 0x3E,
  0x0F, 0x1F, 0x07, 0xE1, 0xF0, 0x78, 0xF0, 0x3E, 0x0F, 0x83, 0xCF, 0x83,
  0xE0, 0x7C, 0x1E, 0x7C, 0x1F, 0x03, 0xC0, 0xF3, 0xC1, 0xF0, 0x3E, 0x07,
  0xBE, 0x0F, 0x81, 0xF0, 0x3D, 0xF0, 0x7C, 0x0F, 0x81, 0xEF, 0x87, 0xE0,
  0x78, 0x0F, 0x78, 0x3E, 0x07, 0xC0, 0xF3, 0xC1, 0xF0, 0x3E, 0x07, 0xBE,
  0x0F, 0x81, 0xF0, 0x3D, 0xF0, 0x7C, 0x0F, 0x01, 0xEF, 0x83, 0xE0, 0xF8,
  0x1E, 0x7C, 0x1F, 0x07, 0xC0, 0xF3, 0xE0, 0xF8, 0x7E, 0x0F, 0x1F, 0x07,
  0xC3, 0xF0, 0x78, 0xF8, 0x3E, 0x3F, 0x87, 0x87, 0xC1, 0xFF, 0xFE, 0xFC,
  0x3E, 0x0F, 0xFD, 0xFF, 0xC1, 0xF0, 0x3F, 0xCF, 0xFC, 0x07, 0x80, 0xFC,
  0x3F, 0xC0, 0x3C, 0x01, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0x87, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x0F,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFE, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x03, 0xFF, 0xE7, 0xF0, 0x3F, 0xFE, 0x7F, 0x03, 0xFF, 0xC7, 0xF0,
  0x3F, 0xFC, 0x7E, 0x07, 0xFF, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFF, 0x7F,
  0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x7F, 0xC0, 0x03, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xF0, 0x00, 0x1F,
  0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x07, 0xEF, 0x80, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0x3F, 0xFC, 0x07,
  0xEF, 0x80, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x0F, 0xEF, 0x80,
  0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x0F, 0xC7, 0xC1, 0xF3, 0xF8, 0x0F, 0xC7,
  0xC3, 0xF3, 0xF8, 0x1F, 0xC7, 0xC3, 0xE3, 0xF8, 0x1F, 0xC7, 0xC7, 0xE3,
  0xF0, 0x1F, 0xC7, 0xC7, 0xC7, 0xF0, 0x1F, 0xC7, 0xCF, 0xC7, 0xF0, 0x1F,
  0xC7, 0xCF, 0x87, 0xF0, 0x1F, 0x87, 0xFF, 0x87, 0xF0, 0x3F, 0x83, 0xFF,
  0x87, 0xF0, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0x0F, 0xE0,
  0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x07,
  0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x07, 0xFE, 0x00,
  0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xE0,
  0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFE,
  0x07, 0xE0, 0x1F, 0xDF, 0x07, 0xF0, 0x1F, 0xCF, 0x83, 0xF8, 0x0F, 0xE7,
  0xE1, 0xFC, 0x07, 0xF1, 0xF0, 0xFE, 0x03, 0xF8, 0xF8, 0x7F, 0x01, 0xFC,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x3F, 0x80, 0xFE, 0x0F, 0x9F, 0xC0, 0x7F,
  0x07, 0xCF, 0xE0, 0x3F, 0x83, 0xF7, 0xF0, 0x1F, 0xC0, 0xFB, 0xF8, 0x0F,
  0xE0, 0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03,
  0xF8, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFE, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x3F, 0x80,
  0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E,
  0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xBF, 0x80, 0x7E, 0x01, 0xFD,
  0xFC, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0x7E, 0x7F, 0x03, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x01, 0xF8, 0xFE,
  0x0F, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x07,
  0xE1, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F,
  0xFE, 0x1F, 0x83, 0xF8, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xFF, 0x8F, 0xE0,
  0xFE, 0x3E, 0xFC, 0x7E, 0x07, 0xF3, 0xF7, 0xE7, 0xF0, 0x3F, 0x9F, 0xBF,
  0x3F, 0x81, 0xFC, 0xF8, 0xF9, 0xF8, 0x0F, 0xEF, 0xC7, 0xCF, 0xC0, 0x7F,
  0x7C, 0x3E, 0xFE, 0x03, 0xFB, 0xE1, 0xF7, 0xE0, 0x1F, 0xFF, 0x0F, 0xBF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x1F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07,
  0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x7E, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xE3, 0xF1, 0xFE, 0x0F, 0xCF,
  0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xF7, 0xE0, 0x7F, 0x9F, 0x80, 0x20, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE,
  0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0xC3, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7E, 0xFF, 0xF0, 0xFE, 0xFF, 0xE0,
  0xFC, 0x3F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE,
  0x3F, 0xC7, 0xF0, 0x7F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xDF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC,
  0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xFE, 0x3F, 0x00, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03,
  0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF7, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0x7E,
  0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7,
  0xF0, 0x0F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x10, 0x3F, 0x80, 0x60, 0x7F, 0x83,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x1F, 0xF9, 0xF8, 0x0F, 0xFF, 0x7E,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0x81,
  0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0xFE,
  0x00, 0x04, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x08, 0x01,
  0xFC, 0x03, 0x80, 0xFE, 0x01, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x03, 0xF1, 0xFC,
  0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80,
  0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xE3, 0xF8, 0x0F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x00,
  0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7E, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x7F,
  0x80, 0x3F, 0x3F, 0xC0, 0x0F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F,
  0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x00, 0x40, 0x02, 0x00, 0x3F, 0x3F, 0xC1, 0xFE, 0x01, 0xFF,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC7, 0xFF, 0x1F, 0xC1, 0xFC, 0x1F,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFF, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0xC7,
  0xF0, 0x1F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xE0,
  0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x1F, 0xC3, 0xF0,
  0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x07, 0xF1, 0xFC, 0x07, 0xE0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xCF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80,
  0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8,
  0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF,
  0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x80,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F,
  0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xF0,
  0x3F, 0xBF, 0xF8, 0x0F, 0xE7, 0xF8, 0x03, 0xF8, 0x30, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x3F, 0x03, 0xFF, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF7,
  0xE0, 0x01, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x3F, 0xFF, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE1, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x20, 0x00, 0x1F, 0x80,
  0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFE, 0xFC, 0x00, 0x40, 0x00,
  0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x7E, 0xFE, 0x07,
  0xC0, 0x7E, 0xFE, 0x0F, 0xC0, 0xFE, 0xFE, 0x0F, 0xC0, 0xFC, 0xFE, 0x0F,
  0xC0, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE1, 0xF8, 0x7E, 0x3F,
  0xE1, 0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0x7E, 0x3F, 0xE3, 0xF0, 0x7E, 0x7F,
  0xE3, 0xF0, 0x7E, 0x7F, 0xE7, 0xE0, 0x7C, 0xFF, 0xE7, 0xE0, 0x7C, 0xFB,
  0xE7, 0xE0, 0x7D, 0xFB, 0xEF, 0xC0, 0x7D, 0xF3, 0xEF, 0xC0, 0x7D, 0xF3,
  0xEF, 0x80, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80,
  0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF7,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x00, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x03,
  0xC7, 0xFE, 0x03, 0xE7, 0xFF, 0x81, 0xF3, 0xFF, 0xE0, 0xFB, 0xFF, 0xF8,
  0xFD, 0xF8, 0xFF, 0xFC, 0xF8, 0x3F, 0xFE, 0xFC, 0x0F, 0xFE, 0x7C, 0x07,
  0xFF, 0x3E, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 39, 13, 1, -38 },
  { 65, 15, 14, 17, 4, -41 },
  { 92, 27, 38, 28, 1, -38 },
  { 221, 24, 51, 26, 2, -45 },
  { 374, 25, 40, 33, 5, -39 },
  { 499, 26, 40, 30, 1, -39 },
  { 629, 8, 14, 9, 3, -41 },
  { 643, 16, 55, 17, 3, -43 },
  { 753, 16, 55, 17, -2, -43 },
  { 863, 22, 23, 24, 3, -38 },
  { 927, 22, 28, 25, 2, -32 },
  { 1004, 11, 16, 12, -3, -6 },
  { 1026, 13, 6, 18, 2, -20 },
  { 1036, 8, 8, 15, 1, -7 },
  { 1044, 24, 41, 18, -3, -38 },
  { 1167, 23, 40, 26, 2, -39 },
  { 1282, 16, 38, 26, 6, -38 },
  { 1358, 25, 39, 26, 0, -39 },
  { 1480, 24, 40, 26, 1, -39 },
  { 1600, 24, 38, 26, 1, -38 },
  { 1714, 25, 39, 26, 2, -38 },
  { 1836, 22, 39, 26, 2, -38 },
  { 1944, 25, 38, 26, 3, -38 },
  { 2063, 24, 40, 26, 1, -39 },
  { 2183, 21, 39, 26, 4, -39 },
  { 2286, 12, 30, 14, 1, -29 },
  { 2331, 15, 39, 13, -3, -29 },
  { 2405, 21, 25, 23, 1, -29 },
  { 2471, 22, 17, 26, 2, -26 },
  { 2518, 22, 25, 24, 1, -29 },
  { 2587, 20, 40, 23, 4, -39 },
  { 2687, 37, 49, 40, 1, -37 },
  { 2914, 30, 38, 31, -2, -38 },
  { 3057, 28, 38, 29, 0, -38 },
  { 3190, 28, 40, 30, 2, -39 },
  { 3330, 29, 38, 30, 0, -38 },
  { 3468, 28, 38, 26, 0, -38 },
  { 3601, 28, 38, 25, 0, -38 },
  { 3734, 28, 40, 31, 2, -39 },
  { 3874, 33, 38, 32, 0, -38 },
  { 4031, 13, 38, 14, 1, -38 },
  { 4093, 26, 39, 26, 0, -38 },
  { 4220, 33, 38, 29, 0, -38 },
  { 4377, 22, 38, 25, 0, -38 },
  { 4482, 40, 38, 40, 0, -38 },
  { 4672, 33, 38, 32, 0, -38 },
  { 4829, 28, 40, 32, 2, -39 },
  { 4969, 30, 38, 30, 0, -38 },
  { 5112, 28, 46, 32, 2, -39 },
  { 5273, 28, 38, 29, 1, -38 },
  { 5406, 27, 40, 28, 1, -39 },
  { 5541, 27, 38, 28, 4, -38 },
  { 5670, 29, 39, 30, 2, -38 },
  { 5812, 29, 38, 30, 4, -38 },
  { 5950, 37, 38, 39, 5, -38 },
  { 6126, 34, 38, 29, -2, -38 },
  { 6288, 27, 38, 28, 5, -38 },
  { 6417, 30, 38, 28, -1, -38 },
  { 6560, 18, 54, 14, -1, -45 },
  { 6682, 12, 41, 20, 5, -38 },
  { 6744, 18, 54, 14, -3, -45 },
  { 6866, 17, 19, 20, 2, -38 },
  { 6907, 21, 6, 21, -3, 0 },
  { 6923, 11, 8, 17, 5, -40 },
  { 6934, 22, 31, 25, 1, -30 },
  { 7020, 24, 42, 26, 0, -41 },
  { 7146, 22, 31, 24, 1, -30 },
  { 7232, 26, 42, 26, 1, -41 },
  { 7369, 23, 31, 25, 1, -30 },
  { 7459, 19, 42, 17, 2, -42 },
  { 7559, 26, 41, 26, 0, -30 },
  { 7693, 23, 41, 26, 0, -41 },
  { 7811, 14, 40, 13, 0, -40 },
  { 7881, 19, 51, 13, -6, -40 },
  { 8003, 26, 41, 25, 0, -41 },
  { 8137, 14, 41, 13, 0, -41 },
  { 8209, 37, 30, 39, 0, -30 },
  { 8348, 23, 30, 26, 0, -30 },
  { 8435, 23, 31, 26, 1, -30 },
  { 8525, 26, 41, 26, -2, -30 },
  { 8659, 24, 41, 26, 1, -30 },
  { 8782, 18, 30, 17, 0, -30 },
  { 8850, 23, 31, 24, 0, -30 },
  { 8940, 15, 37, 16, 2, -36 },
  { 9010, 23, 30, 26, 2, -29 },
  { 9097, 21, 29, 23, 3, -29 },
  { 9174, 32, 29, 33, 3, -29 },
  { 9290, 27, 29, 24, -2, -29 },
  { 9388, 27, 40, 23, -2, -29 },
  { 9523, 24, 29, 24, -1, -29 },
  { 9610, 17, 52, 16, 1, -42 },
  { 9721, 11, 45, 13, 1, -38 },
  { 9783, 17, 52, 16, -2, -42 },
  { 9894, 25, 12, 30, 2, -22 },
};

const GFXfont RobotoCondensed_SemiBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC54PT7B_H_
