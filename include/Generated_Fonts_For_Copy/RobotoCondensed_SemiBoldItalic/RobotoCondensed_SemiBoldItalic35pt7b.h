#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC35PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0,
  0xF0, 0x70, 0x39, 0xCE, 0x77, 0x9D, 0xCF, 0x73, 0x9C, 0xE7, 0x39, 0x8E,
  0xE3, 0x00, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C,
  0xE0, 0x0E, 0x70, 0x06, 0x38, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xC1,
  0xC6, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0x80, 0x39, 0xC1, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFE, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCE,
  0x01, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0x78, 0x78, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x73, 0x86, 0xE3, 0x8E, 0xE3, 0x8E,
  0xE3, 0x9C, 0xE3, 0xB8, 0xE3, 0xB8, 0x7F, 0x70, 0x7F, 0xE0, 0x3C, 0xE0,
  0x01, 0xC0, 0x03, 0xBC, 0x07, 0x7E, 0x07, 0xFF, 0x0E, 0xE7, 0x1C, 0xE3,
  0x1D, 0xC7, 0x39, 0xC7, 0x71, 0xC7, 0x61, 0xC7, 0x20, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xF3,
  0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x3D, 0xFF, 0x9E, 0xF3, 0xDE,
  0xF9, 0xFF, 0x78, 0x7F, 0xBC, 0x3F, 0x9E, 0x0F, 0xCF, 0x87, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0x9F, 0x00, 0x3B, 0xDE, 0xE7, 0x39,
  0xDC, 0xE0, 0x00, 0x40, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0x80, 0x20, 0x02,
  0x00, 0x60, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x01, 0x80, 0x20,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x63, 0x8F, 0xEE, 0xFF,
  0xFF, 0xCF, 0xFE, 0x0F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x70, 0x78, 0xE1,
  0xC3, 0x82, 0x0C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x3C, 0xF0, 0xC0, 0x7F,
  0xBF, 0xDF, 0xEF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C, 0xF1, 0xF3,
  0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xFE,
  0xFF, 0xBF, 0xEC, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x9F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xDE, 0x03, 0xDE, 0x07, 0xBE,
  0x07, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1D, 0xE0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x08, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0x78, 0x78,
  0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xE0,
  0x7F, 0x83, 0xFC, 0x1F, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7B, 0xE1,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3E, 0xF0, 0xF3, 0xFF, 0xC7, 0xFE,
  0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C,
  0x7C, 0x7F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0x1F, 0x1E, 0x3C, 0x3E,
  0xF8, 0x3D, 0xF0, 0x7B, 0xC1, 0xF7, 0xC3, 0xCF, 0x8F, 0x8F, 0xFF, 0x1F,
  0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE,
  0x3C, 0x7D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x83,
  0xDE, 0x1F, 0x78, 0x7D, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x78,
  0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0,
  0x20, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFF,
  0x8F, 0xF0, 0x3F, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x08, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x20, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x78, 0x0F, 0xE0, 0xFF,
  0x8F, 0xF8, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x07,
  0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x1C, 0x1F, 0x06, 0x1C, 0x3F, 0xC7, 0x38, 0x7F, 0xC7, 0x38, 0xF1,
  0xC7, 0x70, 0xE3, 0xC7, 0x71, 0xE3, 0x87, 0x71, 0xC3, 0x87, 0xE1, 0xC3,
  0x86, 0xE3, 0xC3, 0x86, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x0E, 0xE3, 0x87,
  0x0C, 0xE3, 0x8F, 0x1C, 0xE3, 0x8F, 0x18, 0xE3, 0xFF, 0xF8, 0xE1, 0xF7,
  0xF0, 0xE1, 0xE3, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x01,
  0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3E, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x07,
  0xC7, 0x81, 0xE1, 0xE1, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xE0, 0xF0, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3C, 0x7C, 0x1F, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x07,
  0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x7C, 0x3E,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0xC3, 0xC1, 0xF0,
  0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x87,
  0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0xFF, 0x7C, 0x7F, 0xDE, 0x1F, 0xE7, 0x87, 0xF9, 0xE0,
  0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x7C, 0x1F,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8,
  0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x00,
  0xF0, 0xF8, 0x07, 0x80, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C,
  0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x7C, 0x1E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x87, 0x8F, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1E,
  0x0F, 0x80, 0xF0, 0xFC, 0x07, 0x8F, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x07, 0xF8, 0x7B, 0x81, 0xFE, 0x1E, 0xE0, 0x77, 0x87, 0xB8,
  0x3F, 0xE1, 0xEE, 0x0E, 0xF0, 0x7B, 0x87, 0xBC, 0x3E, 0xF1, 0xEF, 0x0F,
  0xBC, 0xF3, 0xC3, 0xCF, 0x3D, 0xF0, 0xF3, 0xDE, 0x78, 0x3C, 0x77, 0x9E,
  0x0F, 0x1D, 0xC7, 0x87, 0xC7, 0xF3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E,
  0x3E, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8,
  0x38, 0x7C, 0x00, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xF0, 0x3E, 0x1F,
  0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xF0, 0x78, 0x3F, 0x83, 0xC3, 0xFC, 0x1E,
  0x1F, 0xE1, 0xF0, 0xF7, 0x8F, 0x87, 0x9C, 0x78, 0x3C, 0xE3, 0xC3, 0xE7,
  0x9E, 0x1F, 0x3D, 0xF0, 0xF8, 0xEF, 0x87, 0x87, 0x7C, 0x3C, 0x3F, 0xC1,
  0xE0, 0xFE, 0x1F, 0x07, 0xF0, 0xF8, 0x3F, 0x87, 0xC1, 0xFC, 0x3C, 0x07,
  0xE1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0x8F,
  0x80, 0xF1, 0xF0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x0F, 0x3E,
  0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0xC1, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x3E, 0x1E, 0x07, 0xC3,
  0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F,
  0x03, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF8, 0x7C, 0x3E, 0x07, 0x8F,
  0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x3E,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0xC1, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF8,
  0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x07, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C, 0x7C, 0x07, 0x87,
  0x81, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0xC3, 0xC0, 0xF8, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x07,
  0xCF, 0x87, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78,
  0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x87, 0xC3, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0xF8,
  0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1E,
  0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC, 0x3C, 0xF8, 0xFC, 0x3C,
  0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0x78, 0xF9, 0xFC, 0x78, 0xF9, 0xDC, 0xF8,
  0xF3, 0xDC, 0xF0, 0xF3, 0xDC, 0xF0, 0xF3, 0x9D, 0xF0, 0xF7, 0x9D, 0xE0,
  0x77, 0x1D, 0xE0, 0x77, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xE0,
  0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E,
  0x78, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0xF9, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xE7, 0x81, 0xF1, 0xE0, 0x7C,
  0x78, 0x3E, 0x1F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F,
  0x3C, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x00, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xEC, 0x1C, 0xE1,
  0xCE, 0x38, 0xE3, 0x8E, 0x78, 0xEF, 0x0E, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x03, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0xC7, 0xC0, 0x0F, 0x03, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF9, 0xF1, 0xF3, 0xC3, 0xE7, 0x87, 0x9F, 0x0F, 0x1F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3C, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C,
  0x3C, 0x7F, 0xFC, 0xFF, 0xF8, 0xF7, 0xF8, 0xF3, 0xE0, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0xFE, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0xFE, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF, 0xFF, 0x1F,
  0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x0F, 0x9E,
  0x0F, 0xEF, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xC3, 0xE3, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0xC7, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0x78,
  0x00, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x7C, 0x3D, 0xE0, 0xF7,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x7F, 0xC7, 0xFC,
  0x7F, 0xC1, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0x03, 0xC7, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0,
  0xF9, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F,
  0x07, 0xC7, 0x83, 0xC3, 0xE1, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x07, 0xBE, 0x00, 0x1E, 0x00, 0x0F, 0x06, 0x0F, 0x83, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x78, 0x3F,
  0xF8, 0x7F, 0xF9, 0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x1F, 0x7C, 0x3E, 0xF8, 0x79, 0xE0, 0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xF0,
  0x70, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x1F, 0x8F,
  0x1F, 0x87, 0x8F, 0x83, 0xCF, 0x83, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x00,
  0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x00, 0x1E, 0x78, 0x7C, 0x1F, 0xFC, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3E, 0x1F, 0x1F, 0x3E, 0x1E, 0x1F,
  0x3C, 0x1E, 0x1F, 0x3C, 0x1E, 0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x3C, 0x1E,
  0x7C, 0x3C, 0x1E, 0x7C, 0x3C, 0x3E, 0x78, 0x3C, 0x3E, 0x78, 0x3C, 0x3C,
  0x78, 0x7C, 0x3C, 0xF8, 0x78, 0x3C, 0xF8, 0x78, 0x3C, 0xF0, 0x78, 0x7C,
  0x1E, 0x78, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x1F, 0x7C, 0x3E, 0xF8, 0x79, 0xE0, 0xF0, 0x07, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xDE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDF, 0x0F,
  0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0x7C, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x3C,
  0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xC1, 0xF1,
  0xF0, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3C, 0xF8, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xF9, 0xFF, 0xF7, 0xC3, 0xEF,
  0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xF7, 0x83,
  0xCF, 0x07, 0x9F, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7D, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xA3, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFB, 0xE3,
  0xC3, 0xC7, 0x87, 0xCF, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xCF, 0x07, 0x9F, 0x0F, 0x1F, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0,
  0x1F, 0x00, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x1F, 0xF7, 0xFF, 0xFE,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE1, 0xF7, 0xC3, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x7D,
  0xF0, 0xFB, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9F, 0x1F, 0x3F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF0, 0x7D, 0xE0, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C,
  0xF0, 0xF3, 0xE7, 0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF1, 0xEF, 0x1F, 0x1E, 0xF1,
  0xF1, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3, 0xCF, 0x7F, 0x3C, 0xF7, 0x77, 0x8F,
  0x77, 0x78, 0x7F, 0x77, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x1F, 0x0F,
  0x87, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xF7, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x7C, 0x7C, 0x7C, 0x3E,
  0x00, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xF3, 0xE0,
  0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF9, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x08, 0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x04, 0x03, 0x80, 0xF0, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x7C, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x80, 0xC0, 0x00,
  0x0F, 0x00, 0x1F, 0xC1, 0xCF, 0xE1, 0xEF, 0xF8, 0xE7, 0x1F, 0xF3, 0x87,
  0xF3, 0xC3, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 25, 9, 1, -25 },
  { 26, 10, 9, 11, 2, -26 },
  { 38, 17, 25, 18, 1, -25 },
  { 92, 16, 32, 17, 1, -29 },
  { 156, 16, 25, 22, 3, -25 },
  { 206, 17, 25, 19, 1, -25 },
  { 260, 5, 9, 6, 2, -26 },
  { 266, 10, 36, 11, 2, -28 },
  { 311, 11, 36, 11, -2, -28 },
  { 361, 14, 15, 15, 2, -25 },
  { 388, 15, 18, 16, 1, -21 },
  { 422, 7, 10, 8, -2, -4 },
  { 431, 9, 4, 11, 1, -13 },
  { 436, 5, 5, 10, 1, -5 },
  { 440, 15, 27, 12, -2, -25 },
  { 491, 14, 25, 17, 2, -25 },
  { 535, 10, 25, 17, 4, -25 },
  { 567, 16, 25, 17, 0, -25 },
  { 617, 15, 25, 17, 1, -25 },
  { 664, 16, 25, 17, 0, -25 },
  { 714, 16, 25, 17, 1, -25 },
  { 764, 14, 25, 17, 2, -25 },
  { 808, 16, 25, 17, 2, -25 },
  { 858, 15, 25, 17, 1, -25 },
  { 905, 14, 25, 17, 2, -25 },
  { 949, 7, 19, 9, 1, -19 },
  { 966, 10, 25, 8, -2, -19 },
  { 998, 14, 16, 15, 1, -19 },
  { 1026, 15, 12, 17, 1, -17 },
  { 1049, 14, 17, 15, 1, -19 },
  { 1079, 13, 25, 15, 2, -25 },
  { 1120, 24, 32, 26, 1, -24 },
  { 1216, 19, 25, 20, -1, -25 },
  { 1276, 18, 25, 19, 0, -25 },
  { 1333, 18, 25, 19, 1, -25 },
  { 1390, 18, 25, 19, 0, -25 },
  { 1447, 18, 25, 17, 0, -25 },
  { 1504, 18, 25, 16, 0, -25 },
  { 1561, 18, 25, 20, 1, -25 },
  { 1618, 21, 25, 21, 0, -25 },
  { 1684, 9, 25, 9, 0, -25 },
  { 1713, 17, 25, 17, 0, -25 },
  { 1767, 21, 25, 19, 0, -25 },
  { 1833, 14, 25, 16, 0, -25 },
  { 1877, 26, 25, 26, 0, -25 },
  { 1959, 21, 25, 21, 0, -25 },
  { 2025, 19, 25, 20, 1, -25 },
  { 2085, 19, 25, 19, 0, -25 },
  { 2145, 19, 29, 20, 1, -25 },
  { 2214, 19, 25, 19, 0, -25 },
  { 2274, 17, 25, 18, 1, -25 },
  { 2328, 17, 25, 18, 3, -25 },
  { 2382, 19, 25, 19, 1, -25 },
  { 2442, 18, 25, 19, 3, -25 },
  { 2499, 24, 25, 26, 3, -25 },
  { 2574, 22, 25, 19, -1, -25 },
  { 2643, 18, 25, 18, 3, -25 },
  { 2700, 19, 25, 18, 0, -25 },
  { 2760, 12, 35, 9, -1, -29 },
  { 2813, 8, 27, 13, 3, -25 },
  { 2840, 12, 35, 9, -2, -29 },
  { 2893, 12, 12, 13, 1, -25 },
  { 2911, 14, 4, 14, -2, 0 },
  { 2918, 8, 5, 11, 3, -26 },
  { 2923, 15, 18, 16, 0, -18 },
  { 2957, 16, 26, 17, 0, -26 },
  { 3009, 14, 18, 16, 1, -18 },
  { 3041, 17, 26, 17, 1, -26 },
  { 3097, 14, 18, 16, 1, -18 },
  { 3129, 12, 26, 11, 1, -26 },
  { 3168, 17, 25, 17, 0, -18 },
  { 3222, 15, 26, 17, 0, -26 },
  { 3271, 9, 25, 8, 0, -25 },
  { 3300, 13, 32, 8, -4, -25 },
  { 3352, 17, 26, 16, 0, -26 },
  { 3408, 9, 26, 8, 0, -26 },
  { 3438, 24, 18, 25, 0, -18 },
  { 3492, 15, 18, 17, 0, -18 },
  { 3526, 15, 18, 17, 1, -18 },
  { 3560, 17, 25, 17, -1, -18 },
  { 3614, 15, 25, 17, 1, -18 },
  { 3661, 12, 18, 11, 0, -18 },
  { 3688, 15, 18, 15, 0, -18 },
  { 3722, 10, 23, 10, 1, -23 },
  { 3751, 15, 18, 17, 1, -18 },
  { 3785, 14, 18, 15, 2, -18 },
  { 3817, 20, 18, 22, 2, -18 },
  { 3862, 17, 18, 15, -1, -18 },
  { 3901, 17, 25, 15, -1, -18 },
  { 3955, 15, 18, 15, 0, -18 },
  { 3989, 11, 33, 10, 1, -27 },
  { 4035, 7, 30, 9, 1, -25 },
  { 4062, 10, 33, 10, -1, -27 },
  { 4104, 17, 8, 19, 1, -15 },
};

const GFXfont RobotoCondensed_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC35PT7B_H_
