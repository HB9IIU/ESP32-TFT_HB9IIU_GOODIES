#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoCondensed_SemiBoldItalic
// Headers: 67

#include "RobotoCondensed_SemiBoldItalic6pt7b.h"
#include "RobotoCondensed_SemiBoldItalic7pt7b.h"
#include "RobotoCondensed_SemiBoldItalic8pt7b.h"
#include "RobotoCondensed_SemiBoldItalic9pt7b.h"
#include "RobotoCondensed_SemiBoldItalic10pt7b.h"
#include "RobotoCondensed_SemiBoldItalic11pt7b.h"
#include "RobotoCondensed_SemiBoldItalic12pt7b.h"
#include "RobotoCondensed_SemiBoldItalic13pt7b.h"
#include "RobotoCondensed_SemiBoldItalic14pt7b.h"
#include "RobotoCondensed_SemiBoldItalic15pt7b.h"
#include "RobotoCondensed_SemiBoldItalic16pt7b.h"
#include "RobotoCondensed_SemiBoldItalic17pt7b.h"
#include "RobotoCondensed_SemiBoldItalic18pt7b.h"
#include "RobotoCondensed_SemiBoldItalic19pt7b.h"
#include "RobotoCondensed_SemiBoldItalic20pt7b.h"
#include "RobotoCondensed_SemiBoldItalic21pt7b.h"
#include "RobotoCondensed_SemiBoldItalic22pt7b.h"
#include "RobotoCondensed_SemiBoldItalic23pt7b.h"
#include "RobotoCondensed_SemiBoldItalic24pt7b.h"
#include "RobotoCondensed_SemiBoldItalic25pt7b.h"
#include "RobotoCondensed_SemiBoldItalic26pt7b.h"
#include "RobotoCondensed_SemiBoldItalic27pt7b.h"
#include "RobotoCondensed_SemiBoldItalic28pt7b.h"
#include "RobotoCondensed_SemiBoldItalic29pt7b.h"
#include "RobotoCondensed_SemiBoldItalic30pt7b.h"
#include "RobotoCondensed_SemiBoldItalic31pt7b.h"
#include "RobotoCondensed_SemiBoldItalic32pt7b.h"
#include "RobotoCondensed_SemiBoldItalic33pt7b.h"
#include "RobotoCondensed_SemiBoldItalic34pt7b.h"
#include "RobotoCondensed_SemiBoldItalic35pt7b.h"
#include "RobotoCondensed_SemiBoldItalic36pt7b.h"
#include "RobotoCondensed_SemiBoldItalic37pt7b.h"
#include "RobotoCondensed_SemiBoldItalic38pt7b.h"
#include "RobotoCondensed_SemiBoldItalic39pt7b.h"
#include "RobotoCondensed_SemiBoldItalic40pt7b.h"
#include "RobotoCondensed_SemiBoldItalic41pt7b.h"
#include "RobotoCondensed_SemiBoldItalic42pt7b.h"
#include "RobotoCondensed_SemiBoldItalic43pt7b.h"
#include "RobotoCondensed_SemiBoldItalic44pt7b.h"
#include "RobotoCondensed_SemiBoldItalic45pt7b.h"
#include "RobotoCondensed_SemiBoldItalic46pt7b.h"
#include "RobotoCondensed_SemiBoldItalic47pt7b.h"
#include "RobotoCondensed_SemiBoldItalic48pt7b.h"
#include "RobotoCondensed_SemiBoldItalic49pt7b.h"
#include "RobotoCondensed_SemiBoldItalic50pt7b.h"
#include "RobotoCondensed_SemiBoldItalic51pt7b.h"
#include "RobotoCondensed_SemiBoldItalic52pt7b.h"
#include "RobotoCondensed_SemiBoldItalic53pt7b.h"
#include "RobotoCondensed_SemiBoldItalic54pt7b.h"
#include "RobotoCondensed_SemiBoldItalic55pt7b.h"
#include "RobotoCondensed_SemiBoldItalic56pt7b.h"
#include "RobotoCondensed_SemiBoldItalic57pt7b.h"
#include "RobotoCondensed_SemiBoldItalic58pt7b.h"
#include "RobotoCondensed_SemiBoldItalic59pt7b.h"
#include "RobotoCondensed_SemiBoldItalic60pt7b.h"
#include "RobotoCondensed_SemiBoldItalic61pt7b.h"
#include "RobotoCondensed_SemiBoldItalic62pt7b.h"
#include "RobotoCondensed_SemiBoldItalic63pt7b.h"
#include "RobotoCondensed_SemiBoldItalic64pt7b.h"
#include "RobotoCondensed_SemiBoldItalic65pt7b.h"
#include "RobotoCondensed_SemiBoldItalic66pt7b.h"
#include "RobotoCondensed_SemiBoldItalic67pt7b.h"
#include "RobotoCondensed_SemiBoldItalic68pt7b.h"
#include "RobotoCondensed_SemiBoldItalic69pt7b.h"
#include "RobotoCondensed_SemiBoldItalic70pt7b.h"
#include "RobotoCondensed_SemiBoldItalic71pt7b.h"
#include "RobotoCondensed_SemiBoldItalic72pt7b.h"
