#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC63PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x1F, 0x8F, 0xC7,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1,
  0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0xF8, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x01, 0xF0,
  0xFC, 0x07, 0x1F, 0x83, 0xE0, 0x3C, 0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0xF8,
  0x3F, 0x3E, 0x07, 0xC1, 0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0x81, 0xF1, 0xF8,
  0x7C, 0x1F, 0x9F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFE, 0xFC, 0x03, 0xFF, 0xE7, 0xC0, 0x1F, 0xFE, 0x7E, 0x00, 0x7F, 0xE7,
  0xE0, 0x01, 0xFE, 0x3E, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x8F, 0xE0, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0xDF, 0xFE, 0x00, 0x7D,
  0xFF, 0xF8, 0x07, 0xCF, 0xCF, 0xC0, 0x7E, 0x7C, 0x3F, 0x07, 0xE7, 0xE0,
  0xF8, 0x3E, 0x3E, 0x07, 0xC3, 0xF1, 0xF0, 0x3E, 0x3F, 0x0F, 0x81, 0xF1,
  0xF0, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0xFD, 0xF8, 0x1F, 0x07, 0xCF, 0x80,
  0xF8, 0x3E, 0x78, 0x07, 0xC3, 0xF0, 0xC0, 0x3F, 0x3F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0xC3,
  0xF8, 0xFF, 0xFF, 0x87, 0xE3, 0xFE, 0xFF, 0x9F, 0xC7, 0xF8, 0xFF, 0x3F,
  0x9F, 0xE1, 0xFF, 0x7F, 0x3F, 0xC1, 0xFF, 0xFC, 0x7F, 0x83, 0xFF, 0xF9,
  0xFE, 0x03, 0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0x8F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F, 0x80, 0x7F,
  0xF0, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xF1,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0xC0, 0x3E, 0x02, 0x3C, 0x0F, 0x03, 0xDF, 0xC3, 0xC7, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x03, 0x00,
  0x38, 0x00, 0x40, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC0, 0x3C, 0x00, 0x40, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x3F, 0x1F, 0xE7,
  0xFB, 0xFE, 0xFF, 0x9F, 0xE7, 0xF8, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xFC,
  0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF7,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xF7, 0xFB, 0xE1,
  0xFC, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0x03,
  0xFE, 0x00, 0x10, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE,
  0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x8F, 0xC0, 0x3F, 0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x03,
  0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3,
  0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81,
  0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC,
  0x03, 0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB,
  0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0xE7, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x07, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x80,
  0x3E, 0x03, 0xF0, 0x0F, 0xFE, 0x03, 0xE0, 0x3E, 0x01, 0xFF, 0xF0, 0x1E,
  0x07, 0xE0, 0x3F, 0xFF, 0x81, 0xE0, 0x7C, 0x07, 0xFF, 0xF8, 0x1E, 0x0F,
  0xC0, 0xFF, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x1E, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x81, 0xF0, 0x1E, 0x1F, 0x03, 0xF0,
  0x1F, 0x01, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x3F, 0x07, 0xE0, 0x3F,
  0x01, 0xE3, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x3E, 0x03,
  0xE7, 0xE0, 0xFC, 0x07, 0xE0, 0x3E, 0x7E, 0x0F, 0xC0, 0x7E, 0x03, 0xE7,
  0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xC7, 0xC0,
  0xFC, 0x07, 0xC0, 0x7C, 0x7C, 0x1F, 0xC0, 0xFC, 0x07, 0xCF, 0xC1, 0xF8,
  0x0F, 0xC0, 0x7C, 0xFC, 0x1F, 0x80, 0xF8, 0x07, 0x8F, 0xC1, 0xF8, 0x1F,
  0x80, 0xF8, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x0F, 0xC1, 0xF8, 0x3F, 0x81,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F, 0xC0, 0xFE, 0xFF, 0x87, 0xE0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0xFF, 0xE7, 0xFF, 0x80, 0x7C,
  0x07, 0xFC, 0x7F, 0xF0, 0x07, 0xC0, 0x3F, 0x83, 0xFE, 0x00, 0x7C, 0x00,
  0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF9, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xE0,
  0x00, 0x7F, 0x87, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFB,
  0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xDF,
  0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x00, 0x7F, 0xFF, 0x01, 0xFD, 0xF8,
  0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0x80,
  0x3F, 0xBF, 0x80, 0xFF, 0x7E, 0x01, 0xFD, 0xFE, 0x03, 0xFD, 0xF8, 0x07,
  0xF7, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x01, 0xFE, 0x3F, 0x03, 0xF1, 0xFC, 0x07, 0xF8, 0xFC, 0x1F, 0xCF,
  0xF0, 0x1F, 0xE3, 0xF0, 0x7E, 0x3F, 0xC0, 0x7F, 0x8F, 0xC3, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x7F, 0x1F, 0xE0,
  0x3F, 0xC3, 0xF1, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xC7, 0xE1, 0xFE, 0x03,
  0xFC, 0x1F, 0xBF, 0x87, 0xF8, 0x0F, 0xF0, 0x7E, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x83, 0xFC, 0x07, 0xF8,
  0x1F, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0x81, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xFE,
  0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFB, 0xF0, 0x3F, 0xC0, 0x7F, 0x9F, 0x81,
  0xFE, 0x03, 0xFC, 0xFC, 0x0F, 0xF0, 0x1F, 0xE3, 0xF0, 0x7F, 0x80, 0xFF,
  0x1F, 0x83, 0xFC, 0x07, 0xF8, 0xFC, 0x1F, 0xE0, 0x7F, 0xC7, 0xF1, 0xFE,
  0x03, 0xFC, 0x1F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFC, 0x7F, 0x80, 0xFF, 0x07,
  0xE3, 0xFC, 0x07, 0xF8, 0x1F, 0x9F, 0xE0, 0x3F, 0xC0, 0xFC, 0xFF, 0x03,
  0xFC, 0x07, 0xEF, 0xF0, 0x1F, 0xE0, 0x3F, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x9F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x9F, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0D, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC,
  0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F,
  0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xF8,
  0x1F, 0xE1, 0xFE, 0x0F, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x1F,
  0xC1, 0xFB, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x7E, 0x1F, 0xE0, 0x7F, 0x0F,
  0xEF, 0xC3, 0xF8, 0x0F, 0xE1, 0xF9, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x3F,
  0x1F, 0xE0, 0x3F, 0x8F, 0xE7, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0xFC, 0x7F,
  0x00, 0xFE, 0x7F, 0x1F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE3, 0xF3, 0xF8, 0x03,
  0xF9, 0xF8, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x0F, 0xDF, 0xE0, 0x0F, 0xEF,
  0xC1, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x3F, 0x7F, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80,
  0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x03,
  0xF1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x1F, 0x7F, 0x00, 0xFC, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC3, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE3,
  0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x3F, 0xBF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC,
  0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F,
  0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xF7, 0xFF,
  0xF0, 0x7F, 0x7F, 0xFE, 0x0F, 0xF3, 0xFF, 0xC0, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF,
  0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0xE7, 0xF8, 0x03,
  0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC3, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xC0, 0x01, 0xFF, 0x3F, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x08,
  0x3F, 0xE0, 0x1E, 0x0F, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x87,
  0xF0, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0x80, 0x0F, 0xF9, 0xFC,
  0x00, 0x02, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x03, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0xFF, 0x80, 0x7F,
  0x9F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x0F, 0xF8,
  0x00, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xEF, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xE7,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xE3, 0xFE, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x87, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x3F, 0xE0, 0x1F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xF9, 0xFF, 0x00, 0x0F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01,
  0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFD, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xE0, 0x3F, 0xCF, 0xFF, 0x00,
  0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x7F, 0xF9, 0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0x7F, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x10, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xCF, 0xC0, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xB0, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x1F,
  0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0x9F, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x00,
  0xFF, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xEF, 0xE0,
  0x3F, 0x80, 0xFE, 0xFE, 0x07, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x81, 0xFC,
  0xFE, 0x0F, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x83, 0xFC, 0xFE, 0x0F, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x0F, 0xE3,
  0xFF, 0x87, 0xF0, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F, 0xE7, 0xFF, 0xCF, 0xE0,
  0xFE, 0x7E, 0xFC, 0xFE, 0x0F, 0xE7, 0xEF, 0xDF, 0xC0, 0xFE, 0xFC, 0xFD,
  0xFC, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0xFF, 0xFC, 0xFF, 0xF8, 0x07, 0xFF,
  0x8F, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0x0F,
  0xC3, 0xFF, 0xC0, 0x3F, 0x1F, 0xFF, 0x80, 0xF8, 0xFF, 0xFF, 0x07, 0xE3,
  0xFF, 0xFE, 0x3F, 0x8F, 0xC3, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xF1, 0xF8,
  0x0F, 0xFF, 0xC7, 0xE0, 0x3F, 0xFE, 0x1F, 0x00, 0x7F, 0xF0, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 46, 16, 1, -45 },
  { 93, 18, 17, 20, 4, -47 },
  { 132, 31, 45, 33, 2, -45 },
  { 307, 28, 60, 31, 2, -53 },
  { 517, 29, 47, 39, 6, -46 },
  { 688, 31, 47, 35, 1, -46 },
  { 871, 9, 16, 10, 4, -47 },
  { 889, 19, 64, 20, 3, -50 },
  { 1041, 20, 64, 20, -3, -50 },
  { 1201, 26, 27, 27, 3, -45 },
  { 1289, 26, 32, 29, 2, -36 },
  { 1393, 13, 18, 14, -4, -7 },
  { 1423, 15, 7, 20, 3, -23 },
  { 1437, 10, 9, 17, 1, -8 },
  { 1449, 28, 49, 21, -4, -45 },
  { 1621, 26, 47, 31, 3, -46 },
  { 1774, 18, 45, 31, 7, -45 },
  { 1876, 30, 46, 31, 0, -46 },
  { 2049, 29, 47, 31, 1, -46 },
  { 2220, 28, 45, 31, 1, -45 },
  { 2378, 29, 46, 31, 2, -45 },
  { 2545, 25, 46, 31, 3, -45 },
  { 2689, 29, 45, 31, 3, -45 },
  { 2853, 28, 47, 31, 2, -46 },
  { 3018, 25, 46, 31, 4, -46 },
  { 3162, 14, 35, 16, 1, -34 },
  { 3224, 17, 45, 15, -3, -34 },
  { 3320, 25, 29, 27, 1, -34 },
  { 3411, 25, 20, 30, 3, -30 },
  { 3474, 25, 30, 28, 1, -34 },
  { 3568, 23, 47, 27, 4, -46 },
  { 3704, 44, 58, 47, 1, -44 },
  { 4023, 35, 45, 36, -3, -45 },
  { 4220, 32, 45, 34, 1, -45 },
  { 4400, 32, 47, 35, 3, -46 },
  { 4588, 32, 45, 35, 1, -45 },
  { 4768, 32, 45, 30, 1, -45 },
  { 4948, 31, 45, 29, 1, -45 },
  { 5123, 32, 47, 36, 3, -46 },
  { 5311, 37, 45, 38, 1, -45 },
  { 5520, 16, 45, 16, 1, -45 },
  { 5610, 31, 46, 30, 0, -45 },
  { 5789, 37, 45, 34, 1, -45 },
  { 5998, 25, 45, 29, 1, -45 },
  { 6139, 46, 45, 46, 1, -45 },
  { 6398, 37, 45, 38, 1, -45 },
  { 6607, 32, 47, 37, 3, -46 },
  { 6795, 34, 45, 35, 1, -45 },
  { 6987, 32, 54, 37, 3, -46 },
  { 7203, 33, 45, 34, 1, -45 },
  { 7389, 32, 47, 33, 1, -46 },
  { 7577, 31, 45, 33, 5, -45 },
  { 7752, 34, 46, 35, 2, -45 },
  { 7948, 34, 45, 35, 5, -45 },
  { 8140, 43, 45, 46, 6, -45 },
  { 8382, 39, 45, 34, -2, -45 },
  { 8602, 32, 45, 33, 5, -45 },
  { 8782, 35, 45, 32, -1, -45 },
  { 8979, 21, 62, 16, -1, -52 },
  { 9142, 15, 49, 23, 5, -45 },
  { 9234, 21, 62, 16, -4, -52 },
  { 9397, 21, 22, 24, 2, -45 },
  { 9455, 25, 6, 24, -4, 0 },
  { 9474, 13, 9, 20, 6, -47 },
  { 9489, 26, 35, 29, 1, -34 },
  { 9603, 28, 48, 30, 0, -47 },
  { 9771, 26, 35, 28, 1, -34 },
  { 9885, 31, 48, 30, 1, -47 },
  { 10071, 25, 35, 29, 2, -34 },
  { 10181, 22, 48, 20, 2, -48 },
  { 10313, 30, 47, 31, 0, -34 },
  { 10490, 27, 47, 30, 0, -47 },
  { 10649, 16, 46, 15, 0, -46 },
  { 10741, 23, 59, 15, -7, -46 },
  { 10911, 31, 47, 29, 0, -47 },
  { 11094, 16, 47, 15, 0, -47 },
  { 11188, 43, 34, 46, 0, -34 },
  { 11371, 27, 34, 30, 0, -34 },
  { 11486, 26, 35, 30, 2, -34 },
  { 11600, 30, 47, 30, -2, -34 },
  { 11777, 29, 47, 30, 1, -34 },
  { 11948, 21, 34, 20, 0, -34 },
  { 12038, 26, 35, 28, 0, -34 },
  { 12152, 17, 42, 19, 2, -41 },
  { 12242, 27, 34, 30, 2, -33 },
  { 12357, 26, 33, 27, 3, -33 },
  { 12465, 36, 33, 39, 4, -33 },
  { 12614, 31, 33, 27, -2, -33 },
  { 12742, 31, 46, 27, -2, -33 },
  { 12921, 28, 33, 27, -1, -33 },
  { 13037, 20, 60, 18, 1, -49 },
  { 13187, 13, 53, 15, 1, -45 },
  { 13274, 19, 60, 18, -2, -49 },
  { 13417, 30, 14, 35, 2, -26 },
};

const GFXfont RobotoCondensed_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC63PT7B_H_
