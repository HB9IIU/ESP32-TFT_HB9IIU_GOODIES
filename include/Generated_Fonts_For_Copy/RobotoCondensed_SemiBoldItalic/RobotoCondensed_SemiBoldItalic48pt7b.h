#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC48PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0x80, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x79, 0xF1, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C,
  0x38, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0xF0, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xC7, 0x83,
  0x0F, 0x0F, 0x07, 0x9E, 0x1E, 0x1E, 0x78, 0x3C, 0x78, 0xF0, 0x79, 0xF1,
  0xE0, 0xF3, 0xC3, 0xC3, 0xCF, 0x03, 0xC7, 0xBE, 0x07, 0xFF, 0x78, 0x0F,
  0xFD, 0xE0, 0x0F, 0xF7, 0x80, 0x0F, 0xCF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xBF, 0xC0, 0x1E, 0xFF, 0xC0, 0x7B,
  0xFF, 0x80, 0xF7, 0x8F, 0x03, 0xCF, 0x0F, 0x0F, 0x3C, 0x1E, 0x3E, 0x78,
  0x3C, 0x78, 0xF0, 0xF1, 0xE1, 0xE1, 0xE7, 0x83, 0xC3, 0xC7, 0x07, 0xC7,
  0x84, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x3F, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xF8, 0x7C, 0x7F, 0xF0, 0xF9, 0xFF, 0xF1, 0xF3, 0xF7, 0xE3,
  0xEF, 0xC7, 0xEF, 0x9F, 0x8F, 0xDF, 0x7E, 0x0F, 0xFE, 0xFC, 0x1F, 0xF9,
  0xF8, 0x1F, 0xF3, 0xF0, 0x3F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFD, 0xFC, 0x0F,
  0xE1, 0xF8, 0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF3, 0xE7,
  0x8F, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0x00, 0x00, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x38, 0x78, 0x77,
  0xE7, 0x9F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xBC, 0x00, 0xFB, 0xE0, 0x1F, 0x1E,
  0x03, 0xE1, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0xE0, 0x08, 0x08, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x78, 0x04, 0x00, 0x7F,
  0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xFF, 0xEF,
  0x8E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x1F,
  0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7C, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFF,
  0x3F, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x79, 0xFB, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x3F, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x7F,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xC0, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFC, 0x3F, 0x80, 0x20, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0,
  0xFE, 0x3F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x9F, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x8F, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x3F, 0x3F, 0x07, 0xE7,
  0xE3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07,
  0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0x1F, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0x1F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3F, 0x7E, 0x07, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xDF, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x00, 0x07,
  0x83, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0x03, 0x80, 0x00, 0xE0, 0x0F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x08, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE0, 0xFD,
  0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x3F, 0x01, 0xC1, 0xE0,
  0x3F, 0xE0, 0xF0, 0xF0, 0x3F, 0xF8, 0x78, 0xF0, 0x3F, 0xFC, 0x3C, 0x78,
  0x3E, 0x1E, 0x1E, 0x7C, 0x3E, 0x1F, 0x0F, 0x3C, 0x1E, 0x0F, 0x07, 0x9E,
  0x1F, 0x07, 0x83, 0xDF, 0x0F, 0x03, 0xC1, 0xEF, 0x07, 0x83, 0xE0, 0xF7,
  0x87, 0xC1, 0xE0, 0x73, 0xC3, 0xE0, 0xF0, 0x3B, 0xE1, 0xE0, 0x78, 0x3D,
  0xE0, 0xF0, 0x7C, 0x1E, 0xF0, 0xF8, 0x3C, 0x0E, 0x78, 0x7C, 0x1E, 0x07,
  0x3C, 0x3E, 0x1F, 0x07, 0x9E, 0x1F, 0x0F, 0x83, 0x8F, 0x07, 0xCF, 0xC3,
  0xC7, 0x83, 0xFF, 0xFF, 0xC3, 0xC1, 0xFF, 0xFF, 0xC1, 0xE0, 0x7F, 0x3F,
  0xC0, 0xF0, 0x1E, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x3F,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x87, 0xF0,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x87, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F,
  0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x1F,
  0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xFF, 0x3F, 0x07, 0xFF, 0x1F, 0x83, 0xFF, 0x9F, 0xC1, 0xFF, 0xCF, 0xC0,
  0xFF, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x87,
  0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xF1,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x80,
  0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0x83, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F,
  0xDE, 0x03, 0xEF, 0xC0, 0xFD, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x07, 0xEF,
  0x80, 0xF9, 0xF0, 0x7D, 0xF8, 0x1F, 0x9F, 0x0F, 0xDF, 0x81, 0xF9, 0xF0,
  0xF9, 0xF8, 0x1F, 0x9F, 0x0F, 0x9F, 0x81, 0xF9, 0xF1, 0xF1, 0xF0, 0x1F,
  0x8F, 0x1F, 0x3F, 0x01, 0xF8, 0xF3, 0xE3, 0xF0, 0x3F, 0x8F, 0x3E, 0x3F,
  0x03, 0xF0, 0xF7, 0xC3, 0xF0, 0x3F, 0x0F, 0xFC, 0x7F, 0x03, 0xF0, 0xFF,
  0x87, 0xE0, 0x3F, 0x0F, 0xF8, 0x7E, 0x03, 0xF0, 0xFF, 0x07, 0xE0, 0x7F,
  0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFE, 0x01, 0xF8,
  0x1F, 0xF0, 0x0F, 0xC0, 0xFF, 0x80, 0x7E, 0x07, 0xFE, 0x03, 0xF0, 0x3F,
  0xF0, 0x3F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xFE, 0x0F, 0xC0, 0xFD, 0xF0,
  0x7E, 0x07, 0xE7, 0x83, 0xF0, 0x3F, 0x3C, 0x1F, 0x81, 0xF9, 0xF1, 0xF8,
  0x1F, 0xCF, 0x8F, 0xC0, 0xFC, 0x3C, 0x7E, 0x07, 0xE1, 0xF3, 0xF0, 0x3F,
  0x0F, 0x9F, 0x81, 0xF8, 0x7D, 0xFC, 0x0F, 0xC1, 0xEF, 0xC0, 0xFE, 0x0F,
  0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0xFC,
  0x0F, 0xC0, 0x7F, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0x00, 0x7F, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xC7,
  0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x9F, 0xC0,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x07, 0xF8, 0x7F,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xC7, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x1F,
  0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x07,
  0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x01,
  0xF8, 0x0F, 0xDF, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x03, 0xF7, 0xE0,
  0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xF8, 0xF8, 0x1F, 0xC0, 0xFC, 0x7C,
  0x1F, 0xF0, 0xFC, 0x3E, 0x0F, 0xF8, 0x7E, 0x1F, 0x0F, 0xFC, 0x3F, 0x0F,
  0x87, 0xFE, 0x3F, 0x07, 0xC3, 0xFF, 0x1F, 0x83, 0xE3, 0xEF, 0x8F, 0xC1,
  0xF1, 0xF7, 0xC7, 0xC0, 0xF8, 0xFB, 0xE7, 0xE0, 0x7C, 0xF9, 0xF3, 0xF0,
  0x3E, 0x7C, 0xF9, 0xF0, 0x1F, 0x3E, 0x7D, 0xF8, 0x0F, 0xBE, 0x3E, 0xFC,
  0x07, 0xDF, 0x1F, 0x7C, 0x03, 0xEF, 0x8F, 0xFE, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x0F, 0xBF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xEF, 0x07, 0xDE, 0x0F, 0x3C,
  0x3E, 0x78, 0x7C, 0xF1, 0xF1, 0xE3, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1E, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x78,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC3, 0xF7,
  0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xDF, 0x83,
  0xF3, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0xFC,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x81, 0xF9, 0xFE, 0x3F, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xEF, 0xFE, 0x3F, 0x3F, 0xC1, 0xF8, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xE7,
  0xE0, 0x3F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F,
  0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xC3, 0xF0, 0x3F, 0xEF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xBE, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x30, 0x7F, 0x0F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x07, 0xFC,
  0xFC, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F,
  0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x04, 0x03, 0xF8, 0x1E, 0x0F, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFC, 0x7F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x80, 0x00, 0x80, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x81,
  0xF8, 0xFE, 0x03, 0xF3, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0xF8, 0x07, 0xEF, 0xF1,
  0xFF, 0x03, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0x1F, 0xF1, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x3F, 0x03,
  0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x0F, 0x87, 0xE0,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x7C, 0x3F,
  0x03, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xE1,
  0xF8, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x7E, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E,
  0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E,
  0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xC0, 0x3F,
  0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xBF, 0xF0, 0x3F, 0x3F, 0xC0, 0x7E,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x1F, 0xF3,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x1F, 0xE3,
  0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3E, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xCF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0xFC,
  0x0F, 0xC7, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFC, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F,
  0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xE0, 0x7E, 0x3F, 0x03,
  0xF0, 0xFC, 0x1F, 0x87, 0xE3, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xEF, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0x81,
  0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7E,
  0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x1F,
  0x03, 0xFF, 0x81, 0xF0, 0x7E, 0xF8, 0x1F, 0x07, 0xEF, 0x83, 0xF0, 0x7E,
  0xF8, 0x3F, 0x0F, 0xCF, 0x87, 0xF0, 0xFC, 0xF8, 0x7F, 0x0F, 0x8F, 0x87,
  0xF1, 0xF8, 0xF8, 0xFF, 0x1F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF9, 0xFF, 0xBF,
  0x0F, 0x9F, 0xFB, 0xF0, 0xF9, 0xEF, 0xBE, 0x0F, 0xBE, 0xFF, 0xE0, 0xFB,
  0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0x7C, 0xFE, 0x00, 0xFD,
  0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0x80, 0xF3, 0xFF, 0x03, 0xCF, 0xFE, 0x1F, 0x7F, 0xFC, 0xFD,
  0xF3, 0xFF, 0xEF, 0x87, 0xFF, 0xBE, 0x0F, 0xFC, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 34, 12, 1, -34 },
  { 52, 14, 13, 15, 3, -36 },
  { 75, 24, 34, 25, 1, -34 },
  { 177, 22, 44, 23, 1, -39 },
  { 298, 23, 34, 30, 4, -34 },
  { 396, 23, 34, 27, 1, -34 },
  { 494, 7, 13, 8, 3, -36 },
  { 506, 15, 49, 15, 2, -38 },
  { 598, 15, 49, 15, -2, -38 },
  { 690, 20, 21, 21, 2, -34 },
  { 743, 21, 25, 22, 1, -28 },
  { 809, 10, 14, 11, -3, -6 },
  { 827, 12, 5, 16, 2, -17 },
  { 835, 7, 7, 13, 1, -7 },
  { 842, 21, 37, 16, -3, -34 },
  { 940, 20, 34, 23, 2, -34 },
  { 1025, 14, 34, 23, 5, -34 },
  { 1085, 23, 34, 23, 0, -34 },
  { 1183, 21, 34, 23, 1, -34 },
  { 1273, 21, 34, 23, 1, -34 },
  { 1363, 22, 34, 23, 2, -34 },
  { 1457, 19, 34, 23, 2, -34 },
  { 1538, 23, 34, 23, 2, -34 },
  { 1636, 22, 34, 23, 1, -34 },
  { 1730, 19, 34, 23, 3, -34 },
  { 1811, 10, 27, 13, 1, -27 },
  { 1845, 13, 35, 12, -2, -27 },
  { 1902, 19, 22, 21, 1, -26 },
  { 1955, 20, 15, 23, 2, -23 },
  { 1993, 19, 23, 21, 1, -26 },
  { 2048, 18, 34, 21, 3, -34 },
  { 2125, 33, 44, 36, 1, -33 },
  { 2307, 26, 34, 28, -2, -34 },
  { 2418, 25, 34, 26, 0, -34 },
  { 2525, 25, 34, 27, 2, -34 },
  { 2632, 25, 34, 26, 0, -34 },
  { 2739, 25, 34, 23, 0, -34 },
  { 2846, 24, 34, 22, 0, -34 },
  { 2948, 25, 34, 27, 2, -34 },
  { 3055, 29, 34, 29, 0, -34 },
  { 3179, 12, 34, 12, 1, -34 },
  { 3230, 23, 34, 23, 0, -34 },
  { 3328, 29, 34, 26, 0, -34 },
  { 3452, 19, 34, 22, 0, -34 },
  { 3533, 36, 34, 35, 0, -34 },
  { 3686, 29, 34, 29, 0, -34 },
  { 3810, 25, 34, 28, 2, -34 },
  { 3917, 26, 34, 26, 0, -34 },
  { 4028, 25, 40, 28, 2, -34 },
  { 4153, 26, 34, 26, 0, -34 },
  { 4264, 24, 34, 25, 1, -34 },
  { 4366, 23, 34, 25, 4, -34 },
  { 4464, 26, 34, 26, 2, -34 },
  { 4575, 25, 34, 27, 4, -34 },
  { 4682, 33, 34, 35, 4, -34 },
  { 4823, 29, 34, 26, -1, -34 },
  { 4947, 24, 34, 25, 4, -34 },
  { 5049, 27, 34, 25, -1, -34 },
  { 5164, 16, 48, 12, -1, -40 },
  { 5260, 11, 37, 18, 4, -34 },
  { 5311, 16, 48, 12, -3, -40 },
  { 5407, 15, 17, 18, 2, -34 },
  { 5439, 19, 5, 19, -3, 0 },
  { 5451, 10, 7, 15, 5, -36 },
  { 5460, 19, 26, 22, 1, -26 },
  { 5522, 21, 36, 23, 0, -36 },
  { 5617, 20, 26, 21, 1, -26 },
  { 5682, 23, 36, 23, 1, -36 },
  { 5786, 20, 26, 22, 1, -26 },
  { 5851, 16, 36, 15, 2, -36 },
  { 5923, 23, 36, 23, 0, -26 },
  { 6027, 21, 36, 23, 0, -36 },
  { 6122, 12, 36, 11, 0, -36 },
  { 6176, 17, 46, 11, -5, -36 },
  { 6274, 23, 36, 22, 0, -36 },
  { 6378, 13, 36, 11, 0, -36 },
  { 6437, 33, 26, 35, 0, -26 },
  { 6545, 21, 26, 23, 0, -26 },
  { 6614, 21, 26, 23, 1, -26 },
  { 6683, 23, 36, 23, -2, -26 },
  { 6787, 22, 36, 23, 1, -26 },
  { 6886, 16, 26, 15, 0, -26 },
  { 6938, 20, 26, 21, 0, -26 },
  { 7003, 13, 32, 14, 2, -32 },
  { 7055, 21, 26, 23, 1, -26 },
  { 7124, 19, 26, 21, 3, -26 },
  { 7186, 28, 26, 30, 3, -26 },
  { 7277, 23, 26, 21, -1, -26 },
  { 7352, 23, 36, 20, -1, -26 },
  { 7456, 22, 26, 21, -1, -26 },
  { 7528, 15, 45, 14, 1, -37 },
  { 7613, 10, 40, 12, 1, -34 },
  { 7663, 15, 46, 14, -2, -37 },
  { 7750, 22, 10, 26, 2, -19 },
};

const GFXfont RobotoCondensed_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC48PT7B_H_
