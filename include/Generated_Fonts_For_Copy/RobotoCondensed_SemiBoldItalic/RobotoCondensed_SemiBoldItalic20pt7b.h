#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC20PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x18, 0xC6, 0x60, 0x00, 0xCE, 0x30, 0x6D, 0xB4,
  0x92, 0xD8, 0x06, 0xC1, 0xB0, 0x48, 0x36, 0x3F, 0xCF, 0xF1, 0xB0, 0x6C,
  0x7F, 0x9F, 0xE3, 0x60, 0x90, 0x6C, 0x1B, 0x00, 0x04, 0x02, 0x07, 0x87,
  0xE7, 0x33, 0x99, 0xCC, 0xE0, 0x3C, 0x0F, 0x01, 0x98, 0xCC, 0x67, 0x73,
  0xF8, 0xF0, 0x30, 0x10, 0x00, 0x70, 0x7C, 0x36, 0x7B, 0x69, 0xE7, 0xA1,
  0xF0, 0x3E, 0x1F, 0x9E, 0xDB, 0x79, 0xB0, 0xF8, 0x38, 0x0F, 0x07, 0xE1,
  0x98, 0xE6, 0x3B, 0x07, 0xC1, 0xC0, 0xF3, 0x7E, 0xD9, 0xFE, 0x79, 0x8C,
  0x7F, 0x8F, 0x70, 0x6D, 0xAC, 0x04, 0x31, 0x8C, 0x31, 0x86, 0x18, 0xE3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x86, 0x08, 0x10, 0x60, 0x83, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x30, 0x80,
  0x0C, 0x08, 0x08, 0xEF, 0x7E, 0x38, 0x7C, 0x64, 0x44, 0x1C, 0x1C, 0x18,
  0x18, 0xFF, 0xFF, 0x38, 0x38, 0x30, 0x30, 0x37, 0x66, 0xEC, 0xFF, 0x80,
  0x7D, 0x80, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0x63,
  0xE3, 0xE3, 0xE3, 0xC7, 0xC7, 0xC6, 0xEE, 0xFC, 0x78, 0x0C, 0xF7, 0xF6,
  0x18, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0xC0, 0x0F, 0x0F, 0xCE, 0x66,
  0x37, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0xF7, 0xF8,
  0x0F, 0x0F, 0xCE, 0x66, 0x30, 0x18, 0x1C, 0x3C, 0x3E, 0x03, 0x01, 0xB8,
  0xCC, 0xE7, 0xE1, 0xE0, 0x03, 0x81, 0xC1, 0xE1, 0xF0, 0xF8, 0xD8, 0xEC,
  0x66, 0x67, 0x7F, 0xFF, 0xE0, 0xC0, 0x60, 0x70, 0x3F, 0x9F, 0xCC, 0x0E,
  0x06, 0x03, 0xE1, 0xF8, 0xCE, 0x07, 0x03, 0xB1, 0xDD, 0xCF, 0xE3, 0xC0,
  0x06, 0x1E, 0x38, 0x70, 0x60, 0x7E, 0xFE, 0xE7, 0xC7, 0xC7, 0xC7, 0xE6,
  0x7E, 0x38, 0x7F, 0xBF, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x00, 0x1E, 0x3F, 0x73, 0x73, 0x63, 0x77,
  0x3E, 0x7E, 0xE6, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x1E, 0x3F, 0x77, 0x63,
  0xE3, 0xE3, 0x67, 0x7F, 0x3F, 0x06, 0x0E, 0x1C, 0x78, 0x70, 0x31, 0xCC,
  0x00, 0x00, 0x00, 0x67, 0x18, 0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0x1C, 0x61, 0x84, 0x00, 0x01, 0x07, 0x1F, 0x7C, 0x60, 0xF8, 0x3E,
  0x0E, 0x02, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x20, 0x30, 0x3C, 0x1F,
  0x07, 0x0F, 0x3E, 0x78, 0x60, 0x80, 0x3C, 0x7E, 0x67, 0xE7, 0x06, 0x0E,
  0x1C, 0x38, 0x30, 0x30, 0x00, 0x60, 0x70, 0x60, 0x03, 0xE0, 0x1F, 0xE0,
  0xC0, 0x86, 0x03, 0x31, 0xCC, 0xCF, 0x96, 0x66, 0x59, 0x11, 0x4C, 0xCD,
  0x33, 0x3C, 0xCC, 0xF3, 0x32, 0xCF, 0xD9, 0x1B, 0xC6, 0x00, 0x18, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x01, 0x80, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x1D,
  0x83, 0x30, 0xE6, 0x18, 0xC7, 0xFC, 0xFF, 0xB8, 0x77, 0x0F, 0xC0, 0xC0,
  0x1F, 0x87, 0xF8, 0xE7, 0x1C, 0x63, 0x0C, 0x63, 0x8F, 0xE3, 0xFC, 0x71,
  0x8E, 0x39, 0x86, 0x31, 0xCF, 0xF9, 0xFC, 0x00, 0x0F, 0x0F, 0xE3, 0x1D,
  0xC7, 0x60, 0xF8, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0xEC, 0x3B, 0x9C, 0x7F,
  0x0F, 0x00, 0x1F, 0x07, 0xF0, 0xE7, 0x1C, 0x63, 0x0C, 0x61, 0x8C, 0x33,
  0x86, 0x71, 0xCE, 0x39, 0x86, 0x31, 0xCF, 0xF1, 0xF8, 0x00, 0x1F, 0xCF,
  0xF3, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0xF9, 0xFC, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xF3, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0xF1, 0xFC, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0x0F,
  0xE3, 0x9D, 0xC3, 0x60, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xB0, 0x6E, 0x3B,
  0x8E, 0x7F, 0x8F, 0x80, 0x18, 0x33, 0x87, 0x38, 0x73, 0x87, 0x30, 0x63,
  0x06, 0x3F, 0xE7, 0xFE, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x0C, 0xE1, 0xCE,
  0x1C, 0x19, 0xCE, 0x73, 0x98, 0xCE, 0x73, 0x98, 0xC6, 0x70, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xCE, 0x73,
  0x9C, 0x7E, 0x0F, 0x00, 0x18, 0x73, 0x8E, 0x39, 0xC3, 0xB8, 0x37, 0x03,
  0x70, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x63, 0x06, 0x38, 0xE3, 0x8E,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xFF, 0xFF, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x8D, 0x8D, 0x9F, 0x3B, 0x6E, 0x76, 0xD8, 0xEF, 0x31, 0x9E, 0x63,
  0x39, 0xCE, 0x73, 0x9C, 0xC7, 0x00, 0x18, 0x33, 0xC7, 0x3C, 0x73, 0xC7,
  0x3C, 0x63, 0x66, 0x36, 0xE7, 0x6E, 0x73, 0xE7, 0x3C, 0x63, 0xC6, 0x3C,
  0xE1, 0xCE, 0x1C, 0x0F, 0x0F, 0xE3, 0x9D, 0xC3, 0x60, 0xF8, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x6E, 0x1B, 0x8E, 0x7F, 0x0F, 0x00, 0x1F, 0x87, 0xF8,
  0xE3, 0x9C, 0x73, 0x0E, 0x61, 0xCC, 0x73, 0xFE, 0x7F, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x0F, 0xE3, 0x9D, 0xC3, 0x60, 0xF8,
  0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x6E, 0x3B, 0x9E, 0x7F, 0x0F, 0x80, 0x70,
  0x0C, 0x02, 0x00, 0x1F, 0x87, 0xF8, 0xE3, 0x1C, 0x73, 0x0C, 0x61, 0x8C,
  0x73, 0xFC, 0x7F, 0x0E, 0xE1, 0x8C, 0x31, 0xCE, 0x39, 0xC7, 0x00, 0x0F,
  0x87, 0xF3, 0x9C, 0xE3, 0x30, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xB8, 0x66,
  0x19, 0xCE, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x70, 0xDC, 0x37,
  0x1D, 0x87, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xE3, 0xB0, 0xEC, 0x3B, 0x9C,
  0xFE, 0x0F, 0x00, 0xC1, 0xF0, 0x7E, 0x3B, 0x8E, 0xE3, 0x39, 0xCE, 0x61,
  0xB8, 0x6C, 0x1B, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x00, 0xC7, 0x1B, 0x1C,
  0xEC, 0x73, 0xB3, 0xCC, 0xCF, 0x33, 0x3D, 0xCD, 0xB6, 0x36, 0xD8, 0xDB,
  0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x00, 0x1C, 0x70,
  0xE3, 0x83, 0x38, 0x1D, 0xC0, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x80, 0xFC, 0x06, 0x60, 0x73, 0x87, 0x1C, 0x38, 0xE0, 0xC1, 0xB8, 0xEE,
  0x31, 0x9C, 0x66, 0x1B, 0x07, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x00, 0x3F, 0xE7, 0xFC, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0F, 0xF9, 0xFF, 0x00, 0x1C,
  0x73, 0x8E, 0x30, 0xC3, 0x0C, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x38, 0xE3,
  0x8E, 0x00, 0xCC, 0xCE, 0xEE, 0x66, 0x66, 0x77, 0x73, 0x30, 0x1C, 0x38,
  0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18,
  0x71, 0xE3, 0xC0, 0x18, 0x63, 0x9B, 0x6F, 0x3C, 0xC0, 0xFE, 0xFE, 0xE6,
  0x30, 0x1E, 0x3F, 0x73, 0x03, 0x3F, 0x7F, 0x67, 0xE7, 0xE7, 0x7E, 0x76,
  0x18, 0x1C, 0x0E, 0x06, 0x03, 0x71, 0xFC, 0xCE, 0xE7, 0x73, 0xB1, 0xD8,
  0xEC, 0x6E, 0x77, 0xFB, 0x78, 0x1E, 0x1F, 0x9C, 0xCC, 0x76, 0x03, 0x01,
  0x80, 0xC6, 0x67, 0x3F, 0x0F, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x1D,
  0x8F, 0xE7, 0x39, 0x8E, 0x63, 0x98, 0xCE, 0x33, 0x8C, 0x67, 0x1F, 0xC3,
  0xF0, 0x3C, 0x7E, 0x67, 0xC7, 0xFF, 0xFE, 0xC0, 0xC0, 0xC4, 0xFE, 0x78,
  0x1E, 0x78, 0xE1, 0x8F, 0xDF, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18,
  0x30, 0x00, 0x1D, 0x8F, 0xE7, 0x39, 0x8E, 0x63, 0x98, 0xE6, 0x31, 0x8C,
  0x67, 0x1F, 0xC3, 0xF0, 0x1C, 0x4E, 0x3F, 0x87, 0x80, 0x38, 0x1C, 0x0E,
  0x06, 0x03, 0x71, 0xF9, 0xCE, 0xE7, 0x73, 0xB1, 0x98, 0xCC, 0x6E, 0x77,
  0x3B, 0x9C, 0x19, 0xC6, 0x03, 0x18, 0xCE, 0x73, 0x98, 0xC6, 0x73, 0x80,
  0x04, 0x1C, 0x18, 0x00, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87,
  0x0E, 0x18, 0x31, 0xE3, 0x80, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x33, 0x8C,
  0xC7, 0x71, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0xE6, 0x39, 0xCE, 0x70,
  0x19, 0xCE, 0x73, 0x18, 0xCE, 0x73, 0x98, 0xC6, 0x73, 0x80, 0x37, 0x78,
  0xFF, 0xE7, 0x39, 0xDC, 0xE7, 0x73, 0x19, 0x8C, 0x66, 0x31, 0x98, 0xCE,
  0xE7, 0x3B, 0x9C, 0xEE, 0x73, 0x00, 0x37, 0x1F, 0x9C, 0xEE, 0x77, 0x3B,
  0x19, 0x8C, 0xC6, 0xE7, 0x73, 0xB9, 0xC0, 0x1E, 0x1F, 0x9C, 0xEE, 0x76,
  0x3B, 0x1D, 0x8E, 0xC6, 0x67, 0x3F, 0x0F, 0x00, 0x1B, 0x87, 0xF3, 0x9C,
  0xE7, 0x39, 0xCC, 0x73, 0x1C, 0xC6, 0x73, 0x9F, 0xE7, 0xF1, 0x80, 0x60,
  0x18, 0x0E, 0x00, 0x1D, 0x9F, 0xDC, 0xEC, 0x76, 0x3B, 0x1B, 0x8D, 0xC6,
  0x67, 0x3F, 0x8F, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x3E, 0x7D, 0xF3, 0x87,
  0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x80, 0x1E, 0x3F, 0x73, 0x70, 0x78, 0x3E,
  0x0E, 0x07, 0xE6, 0x7E, 0x3C, 0x31, 0xBF, 0xF6, 0x31, 0x9C, 0xE7, 0x39,
  0xE7, 0x00, 0x63, 0x63, 0xE7, 0xE7, 0xE7, 0xC6, 0xC6, 0xC6, 0xCE, 0xFE,
  0x7E, 0xE7, 0xE6, 0xE6, 0xEE, 0x6C, 0x6C, 0x78, 0x78, 0x78, 0x70, 0x70,
  0xE6, 0x7E, 0xE6, 0xEE, 0x6E, 0xEE, 0xFE, 0xCF, 0xEC, 0xF7, 0x8F, 0x38,
  0x73, 0x86, 0x30, 0x63, 0x00, 0x39, 0xC6, 0x61, 0xB8, 0x7C, 0x0E, 0x03,
  0x81, 0xE0, 0xF8, 0x37, 0x1C, 0xC6, 0x30, 0x39, 0xCE, 0x63, 0xB8, 0xEE,
  0x1B, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C,
  0x0E, 0x00, 0x3F, 0xBF, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60,
  0x7F, 0x3F, 0x80, 0x04, 0x1C, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0xC1,
  0x83, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC0, 0xC0, 0x80, 0x18, 0x84, 0x63,
  0x18, 0xC4, 0x23, 0x18, 0xC6, 0x21, 0x08, 0xC0, 0x10, 0x61, 0xC3, 0x1C,
  0x71, 0x86, 0x18, 0x30, 0xC6, 0x38, 0xC3, 0x0C, 0x31, 0x8E, 0x30, 0x71,
  0xBC, 0xF3, 0xD8, 0xE0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 6, 1, -15 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 9, 18, 10, 1, -16 },
  { 53, 9, 14, 12, 2, -14 },
  { 69, 10, 14, 11, 0, -14 },
  { 87, 3, 5, 3, 1, -15 },
  { 89, 6, 20, 6, 1, -16 },
  { 104, 6, 21, 6, -1, -16 },
  { 120, 8, 9, 9, 1, -14 },
  { 129, 8, 10, 9, 1, -12 },
  { 139, 4, 6, 5, -1, -2 },
  { 142, 5, 2, 7, 1, -7 },
  { 144, 3, 3, 6, 0, -3 },
  { 146, 9, 15, 7, -1, -14 },
  { 163, 8, 14, 10, 1, -14 },
  { 177, 6, 14, 10, 2, -14 },
  { 188, 9, 14, 10, 0, -14 },
  { 204, 9, 14, 10, 0, -14 },
  { 220, 9, 14, 10, 0, -14 },
  { 236, 9, 14, 10, 1, -14 },
  { 252, 8, 14, 10, 1, -14 },
  { 266, 9, 14, 10, 1, -14 },
  { 282, 8, 14, 10, 1, -14 },
  { 296, 8, 14, 10, 1, -14 },
  { 310, 5, 11, 5, 0, -11 },
  { 317, 6, 15, 5, -1, -11 },
  { 329, 8, 9, 9, 0, -11 },
  { 338, 8, 6, 10, 1, -9 },
  { 344, 8, 10, 9, 0, -11 },
  { 354, 8, 14, 9, 1, -14 },
  { 368, 14, 18, 15, 0, -14 },
  { 400, 11, 14, 12, -1, -14 },
  { 420, 11, 14, 11, 0, -14 },
  { 440, 10, 14, 11, 1, -14 },
  { 458, 11, 14, 11, 0, -14 },
  { 478, 10, 14, 10, 0, -14 },
  { 496, 10, 14, 9, 0, -14 },
  { 514, 10, 14, 11, 1, -14 },
  { 532, 12, 14, 12, 0, -14 },
  { 553, 5, 14, 5, 0, -14 },
  { 562, 10, 14, 9, 0, -14 },
  { 580, 12, 14, 11, 0, -14 },
  { 601, 8, 14, 9, 0, -14 },
  { 615, 15, 14, 15, 0, -14 },
  { 642, 12, 14, 12, 0, -14 },
  { 663, 10, 14, 12, 1, -14 },
  { 681, 11, 14, 11, 0, -14 },
  { 701, 10, 17, 12, 1, -14 },
  { 723, 11, 14, 11, 0, -14 },
  { 743, 10, 14, 10, 0, -14 },
  { 761, 9, 14, 10, 2, -14 },
  { 777, 10, 14, 11, 1, -14 },
  { 795, 10, 14, 11, 2, -14 },
  { 813, 14, 14, 15, 2, -14 },
  { 838, 13, 14, 11, -1, -14 },
  { 861, 10, 14, 10, 2, -14 },
  { 879, 11, 14, 10, 0, -14 },
  { 899, 6, 19, 5, 0, -16 },
  { 914, 4, 15, 7, 2, -14 },
  { 922, 7, 19, 5, -1, -16 },
  { 939, 6, 7, 7, 1, -14 },
  { 945, 8, 2, 8, -1, 0 },
  { 947, 4, 3, 6, 2, -15 },
  { 949, 8, 11, 9, 0, -11 },
  { 960, 9, 15, 10, 0, -15 },
  { 977, 9, 11, 9, 0, -11 },
  { 990, 10, 15, 10, 0, -15 },
  { 1009, 8, 11, 9, 1, -11 },
  { 1020, 7, 15, 6, 1, -15 },
  { 1034, 10, 15, 10, 0, -11 },
  { 1053, 9, 15, 10, 0, -15 },
  { 1070, 5, 15, 5, 0, -15 },
  { 1080, 7, 19, 5, -2, -15 },
  { 1097, 10, 15, 9, 0, -15 },
  { 1116, 5, 15, 5, 0, -15 },
  { 1126, 14, 11, 14, 0, -11 },
  { 1146, 9, 11, 10, 0, -11 },
  { 1159, 9, 11, 10, 0, -11 },
  { 1172, 10, 15, 10, -1, -11 },
  { 1191, 9, 15, 10, 0, -11 },
  { 1208, 7, 11, 6, 0, -11 },
  { 1218, 8, 11, 9, 0, -11 },
  { 1229, 5, 13, 6, 1, -13 },
  { 1238, 8, 11, 10, 1, -11 },
  { 1249, 8, 11, 9, 1, -11 },
  { 1260, 12, 11, 12, 1, -11 },
  { 1277, 10, 11, 9, -1, -11 },
  { 1291, 10, 15, 9, -1, -11 },
  { 1310, 9, 11, 9, 0, -11 },
  { 1323, 7, 20, 6, 0, -16 },
  { 1341, 5, 17, 5, 0, -14 },
  { 1352, 6, 20, 6, -1, -16 },
  { 1367, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC20PT7B_H_
