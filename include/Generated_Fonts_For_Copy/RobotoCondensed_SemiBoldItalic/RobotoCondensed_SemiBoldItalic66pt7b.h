#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC66PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x08, 0x1F, 0x87, 0xE0, 0x18,
  0x3E, 0x07, 0xC0, 0x7C, 0xFC, 0x0F, 0x81, 0xF9, 0xF8, 0x1F, 0x03, 0xE3,
  0xF0, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F,
  0x03, 0xF1, 0xF8, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x1F, 0x8F, 0x80, 0xFC,
  0x3F, 0x3F, 0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF9, 0xF0, 0x01, 0xFF,
  0xE7, 0xE0, 0x01, 0xFF, 0x9F, 0x80, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xE3,
  0xFF, 0x00, 0x0F, 0xCF, 0xFF, 0x00, 0x3F, 0x3F, 0xFE, 0x00, 0x7C, 0xFF,
  0xFE, 0x01, 0xF9, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0xF8, 0x0F, 0x8F, 0xC1,
  0xF8, 0x3F, 0x1F, 0x03, 0xF0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x7C, 0x0F,
  0x87, 0xE0, 0xF8, 0x1F, 0x1F, 0x83, 0xF0, 0x3E, 0x3E, 0x07, 0xE0, 0x7C,
  0xFC, 0x07, 0xC1, 0xF8, 0xF0, 0x0F, 0x83, 0xF0, 0xC0, 0x1F, 0x8F, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0x1F,
  0xFF, 0xF8, 0x7F, 0x1F, 0xE7, 0xFC, 0x7F, 0x3F, 0xC7, 0xFC, 0xFE, 0x7F,
  0xC3, 0xFE, 0xFE, 0x7F, 0x83, 0xFE, 0xFE, 0x7F, 0x81, 0xFF, 0xFE, 0x7F,
  0x80, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0x80, 0x7F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xC3, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x8F, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0x00, 0x7C, 0x02, 0x3C, 0x0F, 0x80, 0xE3, 0xF0,
  0xF8, 0x7E, 0x7F, 0xCF, 0xBF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x01,
  0xE0, 0x02, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x06, 0x0F, 0xC7, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFD, 0xFE, 0x3F, 0x87, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x1F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0x1F, 0xE7, 0x07, 0xF9, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xC3, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x8F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFD,
  0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xF3, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xC0, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xF0, 0x07, 0xF3, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF,
  0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0x9F, 0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xFC,
  0x7F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF7, 0xF8, 0x07, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x03,
  0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x81, 0xFE, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0x7F,
  0xC1, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x03, 0xF0,
  0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x81, 0xE0, 0x7E, 0x03,
  0xFF, 0xFE, 0x07, 0x83, 0xF0, 0x1F, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7F,
  0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xF8, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xE3, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0x8F, 0x81, 0xFC, 0x07, 0xE0, 0x3E, 0x3E, 0x07, 0xF0, 0x1F, 0x80,
  0xF9, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x03, 0xF0, 0x0F,
  0x9F, 0x83, 0xF8, 0x0F, 0xC0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3F, 0x01, 0xF1,
  0xF0, 0x3F, 0x80, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE3, 0xF0,
  0x3F, 0x03, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x3F, 0x03,
  0xF8, 0x7F, 0x01, 0xF0, 0xFC, 0x0F, 0xE3, 0xFE, 0x0F, 0x83, 0xF0, 0x3F,
  0xFF, 0xF8, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xFF,
  0xCF, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x3F, 0xFC, 0x01, 0xF0, 0x07, 0xF0,
  0x7F, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8,
  0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xC7, 0xF8,
  0x0F, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFE, 0x3F,
  0xE0, 0x3F, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8,
  0x07, 0xFB, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xF8,
  0x0F, 0xF3, 0xF0, 0x07, 0xF7, 0xF8, 0x0F, 0xF3, 0xF0, 0x0F, 0xE7, 0xF8,
  0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xF3, 0xF8, 0x1F, 0xCF, 0xF0,
  0x0F, 0xF3, 0xF8, 0x1F, 0xCF, 0xF0, 0x1F, 0xF3, 0xF8, 0x3F, 0x8F, 0xF0,
  0x1F, 0xE1, 0xF8, 0x3F, 0x8F, 0xF0, 0x1F, 0xE1, 0xF8, 0x3F, 0x0F, 0xF0,
  0x1F, 0xE1, 0xF8, 0x7F, 0x1F, 0xF0, 0x1F, 0xE1, 0xF8, 0x7F, 0x1F, 0xE0,
  0x1F, 0xE1, 0xF8, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xF8, 0xFE, 0x1F, 0xE0,
  0x3F, 0xE1, 0xFD, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFD, 0xFC, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0x01, 0xFF,
  0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFE, 0x03, 0xFD, 0xF8, 0x07, 0xF8, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF7, 0xF0, 0x1F, 0xE0, 0x1F, 0xE7, 0xE0, 0x3F, 0xC0, 0x7F, 0xCF, 0xC0,
  0xFF, 0x80, 0xFF, 0x9F, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0x83, 0xFC, 0x03,
  0xFC, 0x3F, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x1F, 0xF0, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFC, 0x7F, 0xC0, 0x7F, 0xC1, 0xF8, 0xFF, 0x80,
  0xFF, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x03, 0xF3, 0xFC, 0x03, 0xFC, 0x07,
  0xE7, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F,
  0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x9F,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFD,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xEF, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xF0,
  0x1F, 0xF1, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xFC, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFB, 0xF8, 0x7F, 0x81, 0xFE,
  0x1F, 0xDF, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xE7, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xF9,
  0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x8F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x7F,
  0x3F, 0xC0, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x1F, 0xDF,
  0xE0, 0x07, 0xF7, 0xF0, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x83, 0xF7, 0xF0,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x07, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBF, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x03, 0xF8, 0x7C,
  0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x87, 0xF8, 0xFF,
  0xC0, 0xFF, 0x1F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xF0, 0x00,
  0x7F, 0x9F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00,
  0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFD, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xE0, 0xFF,
  0x1F, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFE,
  0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x1F, 0xF1, 0xFF, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x03, 0xFC, 0x00,
  0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xF7, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x7F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x7F, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F,
  0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0,
  0x07, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0C, 0x07, 0xF8, 0x03,
  0xC0, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0xE1, 0xFC, 0x01, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xEF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFB, 0xFC, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x08, 0x00, 0x7F, 0x80, 0x38, 0x01, 0xFF, 0x00, 0x78, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xF0, 0x00,
  0x7F, 0x9F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x03,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x07,
  0xF9, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFB, 0xFC, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xE3, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x87,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xC7, 0xFC, 0x00, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03,
  0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x7F, 0xC0, 0x03, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF,
  0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xDF, 0xFF, 0x80, 0xFF, 0x3F, 0xFE, 0x01, 0xFE, 0x1F,
  0xF0, 0x03, 0xFC, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xC0,
  0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0x7F, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xE0, 0x3F,
  0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x9F, 0xE0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFB, 0xFC, 0x00, 0x1E, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x7F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9,
  0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x01,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xBF, 0xC0, 0x7F, 0x01, 0xFE, 0xFF,
  0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x0F, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0xC0,
  0xFF, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xFC, 0x1F, 0xE3, 0xFC,
  0x3F, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F, 0xC7, 0xFF, 0x8F,
  0xF0, 0xFF, 0x1F, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0xF8, 0xFE, 0x07, 0xF3,
  0xF7, 0xE7, 0xF8, 0x1F, 0xCF, 0xDF, 0x9F, 0xC0, 0x7F, 0x7F, 0x7E, 0x7F,
  0x01, 0xFD, 0xF9, 0xFB, 0xFC, 0x07, 0xFF, 0xE7, 0xEF, 0xE0, 0x1F, 0xFF,
  0x1F, 0xBF, 0x80, 0x7F, 0xFC, 0x7F, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF0,
  0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x3F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x1F,
  0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x03,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x3F,
  0xF8, 0x03, 0xF0, 0xFF, 0xF8, 0x07, 0xE3, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF,
  0xF8, 0x3F, 0x9F, 0xFF, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xFC, 0xFE, 0x0F,
  0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xE3, 0xF0, 0x0F, 0xFF, 0x87, 0xE0, 0x0F,
  0xFE, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 48, 16, 1, -47 },
  { 103, 18, 17, 21, 5, -50 },
  { 142, 33, 47, 34, 2, -47 },
  { 336, 29, 62, 32, 2, -55 },
  { 561, 31, 49, 41, 6, -48 },
  { 751, 32, 49, 37, 1, -48 },
  { 947, 9, 17, 11, 4, -50 },
  { 967, 20, 67, 21, 3, -52 },
  { 1135, 21, 67, 21, -3, -52 },
  { 1311, 28, 28, 29, 3, -47 },
  { 1409, 28, 35, 31, 2, -39 },
  { 1532, 13, 19, 15, -4, -8 },
  { 1563, 16, 7, 21, 3, -24 },
  { 1577, 10, 10, 18, 1, -9 },
  { 1590, 29, 51, 22, -4, -47 },
  { 1775, 28, 49, 32, 3, -48 },
  { 1947, 19, 47, 32, 7, -47 },
  { 2059, 31, 48, 32, 0, -48 },
  { 2245, 30, 49, 32, 1, -48 },
  { 2429, 30, 47, 32, 1, -47 },
  { 2606, 30, 48, 32, 2, -47 },
  { 2786, 26, 48, 32, 3, -47 },
  { 2942, 31, 47, 32, 3, -47 },
  { 3125, 29, 49, 32, 2, -48 },
  { 3303, 25, 48, 32, 5, -48 },
  { 3453, 15, 37, 17, 1, -36 },
  { 3523, 18, 47, 16, -3, -36 },
  { 3629, 25, 31, 29, 2, -36 },
  { 3726, 27, 21, 32, 3, -32 },
  { 3797, 27, 30, 29, 1, -35 },
  { 3899, 24, 49, 28, 5, -48 },
  { 4046, 46, 61, 49, 1, -46 },
  { 4397, 37, 47, 38, -3, -47 },
  { 4615, 34, 47, 36, 1, -47 },
  { 4815, 34, 49, 36, 3, -48 },
  { 5024, 34, 47, 36, 1, -47 },
  { 5224, 33, 47, 32, 1, -47 },
  { 5418, 33, 47, 31, 1, -47 },
  { 5612, 34, 49, 38, 3, -48 },
  { 5821, 39, 47, 39, 1, -47 },
  { 6051, 17, 47, 17, 1, -47 },
  { 6151, 32, 48, 31, 0, -47 },
  { 6343, 39, 47, 35, 1, -47 },
  { 6573, 26, 47, 31, 1, -47 },
  { 6726, 48, 47, 49, 1, -47 },
  { 7008, 39, 47, 39, 1, -47 },
  { 7238, 34, 49, 39, 3, -48 },
  { 7447, 35, 47, 36, 1, -47 },
  { 7653, 34, 56, 39, 3, -48 },
  { 7891, 34, 47, 35, 1, -47 },
  { 8091, 34, 49, 34, 1, -48 },
  { 8300, 33, 47, 34, 5, -47 },
  { 8494, 36, 48, 36, 2, -47 },
  { 8710, 35, 47, 37, 5, -47 },
  { 8916, 45, 47, 48, 6, -47 },
  { 9181, 41, 47, 36, -2, -47 },
  { 9422, 33, 47, 34, 6, -47 },
  { 9616, 37, 47, 34, -1, -47 },
  { 9834, 22, 65, 17, -1, -54 },
  { 10013, 15, 51, 24, 6, -47 },
  { 10109, 22, 65, 17, -4, -54 },
  { 10288, 22, 23, 25, 2, -47 },
  { 10352, 26, 7, 26, -4, 0 },
  { 10375, 13, 10, 21, 7, -50 },
  { 10392, 27, 37, 30, 1, -36 },
  { 10517, 29, 51, 32, 0, -50 },
  { 10702, 26, 37, 29, 2, -36 },
  { 10823, 32, 51, 32, 1, -50 },
  { 11027, 27, 37, 31, 2, -36 },
  { 11152, 23, 51, 21, 2, -51 },
  { 11299, 31, 49, 32, 0, -36 },
  { 11489, 29, 50, 31, 0, -50 },
  { 11671, 17, 49, 16, 0, -49 },
  { 11776, 23, 62, 15, -7, -49 },
  { 11955, 32, 50, 30, 0, -50 },
  { 12155, 17, 50, 16, 0, -50 },
  { 12262, 45, 36, 48, 0, -36 },
  { 12465, 29, 36, 31, 0, -36 },
  { 12596, 28, 37, 32, 2, -36 },
  { 12726, 31, 49, 32, -2, -36 },
  { 12916, 29, 49, 32, 2, -36 },
  { 13094, 22, 36, 21, 0, -36 },
  { 13193, 28, 37, 29, 0, -36 },
  { 13323, 18, 44, 19, 2, -43 },
  { 13422, 29, 36, 31, 2, -35 },
  { 13553, 27, 35, 28, 3, -35 },
  { 13672, 38, 35, 41, 4, -35 },
  { 13839, 32, 35, 29, -2, -35 },
  { 13979, 32, 48, 28, -2, -35 },
  { 14171, 30, 35, 29, -1, -35 },
  { 14303, 20, 64, 19, 2, -52 },
  { 14463, 14, 56, 16, 1, -47 },
  { 14561, 21, 63, 19, -3, -51 },
  { 14727, 31, 14, 36, 3, -26 },
};

const GFXfont RobotoCondensed_SemiBoldItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC66PT7B_H_
