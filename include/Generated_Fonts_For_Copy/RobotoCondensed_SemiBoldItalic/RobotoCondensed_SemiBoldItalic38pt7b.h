#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC38PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xF0, 0xF8, 0x7C, 0x1C, 0x00, 0x79, 0xDC, 0x77, 0x3D,
  0xCF, 0xF3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0x39, 0xC0, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00,
  0x79, 0xC0, 0x0E, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x01,
  0xCF, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F,
  0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0x9F, 0x0F, 0x87, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01,
  0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x3C, 0x1F, 0x1F, 0x1F, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xE7, 0x04, 0x71, 0xC3, 0x9C, 0x71, 0xEF, 0x1C, 0x73, 0xC7, 0x38, 0xF1,
  0xDC, 0x1C, 0xFF, 0x07, 0xFB, 0x80, 0xFD, 0xC0, 0x1E, 0xF0, 0x00, 0x38,
  0x00, 0x1D, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xDC, 0x70, 0xE7, 0x1C,
  0x7B, 0xC7, 0x1C, 0xE1, 0xCE, 0x38, 0x77, 0x8E, 0x3D, 0xC3, 0xCE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0x9F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFE, 0x3C, 0xFF, 0xCF, 0x7D, 0xF3, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFB, 0xE1, 0xFE, 0xF8, 0x7F, 0x3E, 0x0F, 0xCF, 0x87, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFB, 0xE0, 0xF8, 0xF8, 0x3C, 0xE3, 0x9E, 0x79, 0xE7,
  0x1C, 0x71, 0xC0, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x02, 0x00, 0x02, 0x00, 0x30,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC2, 0x79, 0xCE, 0xFF, 0xFE, 0x7F, 0xFF,
  0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1E, 0xE0, 0x3C, 0xF0, 0x78, 0x70,
  0x30, 0x70, 0x00, 0x40, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F,
  0x3C, 0xF9, 0xE1, 0x80, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xF7,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8,
  0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x60, 0x3C,
  0x3F, 0x9F, 0xF7, 0xFE, 0xFF, 0xBC, 0xF6, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x8F, 0x87, 0xC1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF1, 0xF1, 0xF0,
  0x7C, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0xC1, 0xE3, 0xE1,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x1E,
  0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E,
  0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xBC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x1E, 0x0F,
  0x87, 0xC7, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xFB, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF,
  0xDF, 0x8F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xEF, 0x07, 0xDF, 0x0F, 0xBE, 0x3E, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x8F, 0x87, 0xC7,
  0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xF0, 0x7C, 0x78, 0x7C,
  0x3E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3,
  0xF1, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0xC7, 0xCF, 0x87, 0xBE, 0x0F,
  0x7C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x87, 0xDF,
  0x1F, 0xBF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF8, 0x3D, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xC0, 0x00, 0x1E, 0x1F, 0x3F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0x70, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x3F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xC0, 0x10, 0x00, 0x38,
  0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x3E,
  0x00, 0x70, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE,
  0xFC, 0xFB, 0xE1, 0xEF, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x07, 0x01, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x07, 0x81, 0xC7, 0x07,
  0xF8, 0x73, 0xC3, 0xFF, 0x1C, 0xE1, 0xE3, 0x87, 0x78, 0x70, 0xE1, 0xDC,
  0x3C, 0x38, 0x77, 0x0E, 0x1E, 0x1D, 0xC7, 0x87, 0x07, 0xF1, 0xE1, 0xC1,
  0xB8, 0x70, 0x70, 0xEE, 0x1C, 0x3C, 0x3B, 0x8F, 0x0E, 0x0E, 0xE3, 0xC3,
  0x87, 0x38, 0xF1, 0xE1, 0xCE, 0x1E, 0xF8, 0xE3, 0x87, 0xFF, 0xF8, 0xE1,
  0xF9, 0xFC, 0x38, 0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x3E,
  0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0xFC, 0x7C, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF8, 0x7C, 0x7E, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x3E,
  0x78, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3F, 0x0F, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0xF8, 0x7C, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F,
  0x7C, 0x03, 0xEF, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0xFF, 0xBE, 0x1F, 0xF7, 0xC3, 0xFE, 0xF8, 0x7F, 0xDF, 0x00, 0xFB,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x0F, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x80, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1F, 0x1F, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1E, 0x07,
  0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0,
  0x07, 0xCF, 0xC0, 0x0F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xBE, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x7B, 0xE1, 0xF7, 0x07, 0xBC, 0x1E, 0x70, 0xFB, 0xC1, 0xE7,
  0x8F, 0x7C, 0x1E, 0x78, 0xF7, 0xC3, 0xE7, 0x9E, 0x7C, 0x3E, 0x79, 0xE7,
  0xC3, 0xE7, 0xBC, 0x78, 0x3E, 0x7B, 0xCF, 0x83, 0xC3, 0xF8, 0xF8, 0x7C,
  0x3F, 0x8F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7F, 0x01, 0xE0,
  0xFE, 0x07, 0xC1, 0xFC, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x0F,
  0xF0, 0x7C, 0x3E, 0xE0, 0xF0, 0x7D, 0xE3, 0xE0, 0xFB, 0xC7, 0xC1, 0xF3,
  0x8F, 0x83, 0xE7, 0x9F, 0x07, 0x8F, 0x3E, 0x1F, 0x1E, 0x78, 0x3E, 0x1D,
  0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0x7F, 0x87, 0xC0, 0xFF,
  0x0F, 0x81, 0xFC, 0x1F, 0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x1F, 0x0F,
  0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x7E, 0x07,
  0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9,
  0xF0, 0x3F, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80,
  0x00, 0x40, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xE3, 0xE0, 0x3E,
  0x1E, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87,
  0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1,
  0xF0, 0x3E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F,
  0x07, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0x3C, 0x3E, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x83, 0xE0,
  0x7D, 0xE0, 0xFC, 0x3E, 0x78, 0x3F, 0x0F, 0x9E, 0x1F, 0xC3, 0xE7, 0x87,
  0xF0, 0xF1, 0xE1, 0xFC, 0x7C, 0x78, 0xFF, 0x1F, 0x1E, 0x3F, 0xC7, 0x87,
  0x8F, 0xF3, 0xE1, 0xE7, 0xBC, 0xF8, 0x79, 0xEF, 0x3C, 0x1E, 0x7B, 0xDF,
  0x07, 0xBC, 0xF7, 0xC1, 0xEF, 0x3D, 0xE0, 0x7B, 0xCF, 0xF8, 0x1F, 0xE3,
  0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E,
  0x00, 0x78, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3,
  0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F,
  0x80, 0xF8, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0x78, 0x3E, 0x0F, 0x0F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7C, 0x03, 0xCF,
  0x80, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x00, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3B, 0xC3, 0xDE, 0x1C, 0x71, 0xE3, 0x8E, 0x1C, 0xF0, 0xE7,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x7C,
  0x3C, 0x1E, 0x1E, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F,
  0x1F, 0x1E, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x7C, 0x7C, 0x7F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0xBE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8,
  0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x3E,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0x7F, 0x0F, 0x9F, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xBE,
  0x1F, 0x7C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0xF3, 0xE1, 0xFE, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8,
  0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0x78, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x38, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x03,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xC1,
  0xFD, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF8, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3E, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC1, 0x83, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F,
  0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E,
  0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0x07, 0x81,
  0xE0, 0xFC, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0x8F,
  0x81, 0xF3, 0xE0, 0x3C, 0xFC, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFD, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0x1F, 0x7C, 0x1E, 0x07, 0xFF, 0x9F,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0x1F, 0xC7, 0xC7, 0x83,
  0xE1, 0xF3, 0xE0, 0xF0, 0x7C, 0xF8, 0x3C, 0x1F, 0x3E, 0x1F, 0x07, 0x8F,
  0x87, 0xC1, 0xE3, 0xC1, 0xF0, 0xF8, 0xF0, 0x7C, 0x3E, 0x7C, 0x1E, 0x0F,
  0x9F, 0x07, 0x83, 0xE7, 0xC3, 0xE0, 0xF1, 0xF0, 0xF8, 0x3C, 0x78, 0x3E,
  0x1F, 0x1E, 0x0F, 0x87, 0xCF, 0x83, 0xC1, 0xF3, 0xE0, 0xF0, 0x7C, 0x1F,
  0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E,
  0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3C, 0xF8, 0x3C, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E,
  0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x7C, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0xBE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x07,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0x87,
  0xDF, 0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x07, 0xCF,
  0x8F, 0xF7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF0, 0x3E, 0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xE3, 0xE0, 0xF1, 0xF0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x03, 0xEF, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x78,
  0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0xF8, 0x3C, 0xF8,
  0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0xFF, 0xDF, 0xF7, 0xFE, 0xFF, 0xC3,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0x9F, 0x07, 0x8F, 0x83, 0xC7, 0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x03, 0xCF, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3,
  0xE7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xF0, 0xF3, 0xC1,
  0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x78, 0x3F, 0xE1, 0xE1,
  0xFF, 0x8F, 0x87, 0xBE, 0x3E, 0x1E, 0xF8, 0xF8, 0xFB, 0xE7, 0xE3, 0xC7,
  0x9F, 0x8F, 0x1E, 0xFE, 0x7C, 0x7B, 0xF9, 0xE1, 0xEE, 0xF7, 0x87, 0xFB,
  0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xE3, 0xF8,
  0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1E,
  0x07, 0x80, 0x1F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x07,
  0x9E, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0x80,
  0x7D, 0xF0, 0x3E, 0x7C, 0x1F, 0x0F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x1F,
  0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x03, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xF7, 0xC0,
  0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x20, 0x0E, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xC0,
  0x04, 0x00, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x04, 0x00,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0x83, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x70, 0x08,
  0x00, 0x0F, 0x00, 0x07, 0xF0, 0x73, 0xFE, 0x3D, 0xFF, 0x8F, 0x79, 0xFF,
  0x9C, 0x3F, 0xE7, 0x07, 0xF0, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 27, 9, 1, -27 },
  { 32, 10, 10, 12, 3, -29 },
  { 45, 19, 27, 20, 1, -27 },
  { 110, 17, 35, 19, 1, -31 },
  { 185, 18, 27, 23, 3, -27 },
  { 246, 18, 27, 21, 1, -27 },
  { 307, 6, 10, 6, 2, -29 },
  { 315, 11, 39, 12, 2, -30 },
  { 369, 12, 39, 12, -2, -30 },
  { 428, 16, 16, 17, 2, -27 },
  { 460, 16, 19, 18, 1, -22 },
  { 498, 7, 11, 9, -2, -4 },
  { 508, 9, 4, 12, 2, -14 },
  { 513, 5, 5, 11, 1, -5 },
  { 517, 17, 29, 13, -2, -27 },
  { 579, 16, 27, 19, 2, -27 },
  { 633, 11, 27, 19, 4, -27 },
  { 671, 18, 27, 19, 0, -27 },
  { 732, 17, 27, 19, 1, -27 },
  { 790, 18, 27, 19, 0, -27 },
  { 851, 18, 27, 19, 1, -27 },
  { 912, 15, 27, 19, 2, -27 },
  { 963, 17, 27, 19, 2, -27 },
  { 1021, 17, 27, 19, 1, -27 },
  { 1079, 15, 27, 19, 3, -27 },
  { 1130, 8, 20, 10, 1, -20 },
  { 1150, 11, 27, 9, -2, -20 },
  { 1188, 15, 18, 16, 1, -21 },
  { 1222, 15, 12, 18, 2, -18 },
  { 1245, 15, 17, 17, 1, -20 },
  { 1277, 14, 27, 16, 3, -27 },
  { 1325, 26, 34, 28, 1, -26 },
  { 1436, 21, 27, 22, -2, -27 },
  { 1507, 20, 27, 21, 0, -27 },
  { 1575, 19, 27, 21, 2, -27 },
  { 1640, 20, 27, 21, 0, -27 },
  { 1708, 20, 27, 18, 0, -27 },
  { 1776, 19, 27, 18, 0, -27 },
  { 1841, 19, 27, 22, 2, -27 },
  { 1906, 23, 27, 23, 0, -27 },
  { 1984, 9, 27, 10, 1, -27 },
  { 2015, 19, 27, 18, 0, -27 },
  { 2080, 23, 27, 20, 0, -27 },
  { 2158, 15, 27, 18, 0, -27 },
  { 2209, 28, 27, 28, 0, -27 },
  { 2304, 23, 27, 23, 0, -27 },
  { 2382, 19, 27, 22, 2, -27 },
  { 2447, 21, 27, 21, 0, -27 },
  { 2518, 19, 32, 22, 2, -27 },
  { 2594, 20, 27, 20, 0, -27 },
  { 2662, 19, 27, 20, 1, -27 },
  { 2727, 19, 27, 20, 3, -27 },
  { 2792, 21, 27, 21, 1, -27 },
  { 2863, 20, 27, 21, 3, -27 },
  { 2931, 26, 27, 28, 3, -27 },
  { 3019, 23, 27, 21, -1, -27 },
  { 3097, 19, 27, 20, 3, -27 },
  { 3162, 21, 27, 19, 0, -27 },
  { 3233, 13, 37, 10, -1, -31 },
  { 3294, 9, 29, 14, 3, -27 },
  { 3327, 13, 37, 10, -2, -31 },
  { 3388, 13, 13, 14, 1, -27 },
  { 3410, 14, 4, 15, -2, 0 },
  { 3417, 8, 6, 12, 4, -29 },
  { 3423, 16, 20, 17, 0, -20 },
  { 3463, 17, 29, 18, 0, -29 },
  { 3525, 15, 20, 17, 1, -20 },
  { 3563, 18, 29, 18, 1, -29 },
  { 3629, 16, 20, 18, 1, -20 },
  { 3669, 13, 29, 12, 1, -29 },
  { 3717, 18, 28, 18, 0, -20 },
  { 3780, 16, 29, 18, 0, -29 },
  { 3838, 10, 28, 9, 0, -28 },
  { 3873, 13, 36, 9, -4, -28 },
  { 3932, 19, 29, 17, 0, -29 },
  { 4001, 10, 29, 9, 0, -29 },
  { 4038, 26, 20, 27, 0, -20 },
  { 4103, 16, 20, 18, 0, -20 },
  { 4143, 16, 20, 18, 1, -20 },
  { 4183, 18, 28, 18, -1, -20 },
  { 4246, 17, 28, 18, 1, -20 },
  { 4306, 13, 20, 12, 0, -20 },
  { 4339, 16, 20, 17, 0, -20 },
  { 4379, 11, 25, 11, 1, -25 },
  { 4414, 17, 20, 18, 1, -20 },
  { 4457, 15, 20, 16, 2, -20 },
  { 4495, 22, 20, 23, 2, -20 },
  { 4550, 18, 20, 17, -1, -20 },
  { 4595, 18, 28, 16, -1, -20 },
  { 4658, 16, 20, 17, 0, -20 },
  { 4698, 12, 37, 11, 1, -30 },
  { 4754, 8, 32, 9, 1, -27 },
  { 4786, 11, 37, 11, -1, -30 },
  { 4837, 18, 8, 21, 1, -15 },
};

const GFXfont RobotoCondensed_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC38PT7B_H_
