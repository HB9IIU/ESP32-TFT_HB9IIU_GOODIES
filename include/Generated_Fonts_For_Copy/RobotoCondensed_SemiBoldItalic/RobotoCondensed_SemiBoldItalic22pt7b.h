#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC22PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0xC7, 0x00, 0x01, 0x8E,
  0x18, 0x66, 0xD9, 0xB3, 0x64, 0xC9, 0x00, 0x06, 0xC0, 0x98, 0x32, 0x06,
  0xC7, 0xFC, 0xFF, 0x86, 0xC0, 0xD8, 0x32, 0x06, 0xC3, 0xFE, 0x7F, 0xC6,
  0xC0, 0xD8, 0x13, 0x06, 0x40, 0x02, 0x03, 0x03, 0xC7, 0xF3, 0xBB, 0x8D,
  0xC6, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x36, 0x1B, 0x9D, 0xCE, 0x7E,
  0x1E, 0x04, 0x06, 0x00, 0x78, 0x1E, 0x0C, 0xCF, 0x36, 0xCD, 0x3E, 0xC7,
  0x60, 0x10, 0x0C, 0x06, 0xE3, 0x7C, 0xDB, 0x64, 0xF3, 0x34, 0x7C, 0x1E,
  0x07, 0x01, 0xF0, 0x77, 0x0C, 0xE1, 0x98, 0x37, 0x07, 0xC0, 0xF0, 0x3E,
  0x6E, 0xCD, 0xDF, 0xF1, 0xEE, 0x3C, 0xE7, 0x1F, 0xF1, 0xE7, 0x6D, 0xB7,
  0x80, 0x04, 0x1C, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x03, 0x04, 0x00, 0x10, 0x30, 0x30,
  0x60, 0xC0, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18,
  0x70, 0xC3, 0x0E, 0x10, 0x00, 0x0C, 0x06, 0x03, 0x3F, 0xF3, 0xF0, 0xE0,
  0xD8, 0xCC, 0x02, 0x00, 0x0C, 0x06, 0x03, 0x03, 0x8F, 0xFF, 0xFF, 0xFE,
  0x30, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0x37, 0x76, 0xEC, 0xFF, 0xC0, 0x6F,
  0x60, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x00, 0x0F, 0x1F, 0xCE,
  0xEE, 0x37, 0x1B, 0x0D, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x6E, 0x77,
  0x31, 0xF8, 0x78, 0x06, 0x3D, 0xF3, 0xE9, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x0F, 0x87, 0xF3, 0x9C, 0xE7, 0x31, 0xC0,
  0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFB,
  0xFE, 0x0F, 0x07, 0xE3, 0x9C, 0xE7, 0x01, 0xC0, 0x70, 0x38, 0x3C, 0x0F,
  0x00, 0xE0, 0x18, 0x06, 0xE3, 0x9D, 0xE7, 0xF0, 0xF8, 0x01, 0xC0, 0xF0,
  0x3C, 0x1F, 0x0F, 0x83, 0x61, 0xB8, 0xEE, 0x33, 0x98, 0xEF, 0xFF, 0xFF,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x70, 0x1F,
  0x87, 0xF1, 0x9C, 0x03, 0x80, 0xE0, 0x3B, 0x0C, 0xE7, 0x39, 0xC7, 0xE0,
  0xF0, 0x07, 0x07, 0x87, 0x87, 0x07, 0x03, 0xF1, 0xFD, 0xEE, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x77, 0x39, 0xF8, 0x78, 0x7F, 0xDF, 0xF0, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0x0F, 0x1F, 0xCE, 0xEE, 0x37, 0x1B, 0x9C, 0xCE, 0x7E,
  0x7E, 0x73, 0xB8, 0xD8, 0x6C, 0x77, 0x3B, 0xF8, 0xF8, 0x1E, 0x1F, 0x8E,
  0xEE, 0x76, 0x3B, 0x1D, 0x8E, 0xC7, 0x77, 0xBF, 0x8E, 0xC0, 0xE0, 0xE1,
  0xF1, 0xF0, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x3C, 0xC0, 0x1C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x1C, 0x73, 0x84, 0x00, 0x01,
  0x07, 0x1F, 0x7C, 0xF0, 0xE0, 0xF8, 0x3E, 0x0E, 0x04, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x20, 0x1C, 0x0F, 0x81, 0xF0, 0x38, 0x3C, 0xFC,
  0xF8, 0x70, 0x20, 0x00, 0x3C, 0x7E, 0xEE, 0xC7, 0x06, 0x0E, 0x1C, 0x3C,
  0x38, 0x70, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x01, 0xF0, 0x07, 0xFC,
  0x0E, 0x0E, 0x1C, 0x06, 0x18, 0x02, 0x31, 0xE2, 0x33, 0xF3, 0x63, 0x33,
  0x66, 0x22, 0x66, 0x62, 0x6E, 0x66, 0x4C, 0x66, 0xCC, 0xC4, 0xCF, 0xFC,
  0x47, 0x78, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x06, 0x60, 0xE6,
  0x0C, 0x61, 0xC6, 0x1F, 0xF3, 0xFF, 0x38, 0x77, 0x07, 0x70, 0x7E, 0x07,
  0x1F, 0xC1, 0xFE, 0x38, 0xE3, 0x86, 0x38, 0x63, 0x8E, 0x38, 0xE3, 0xFC,
  0x7F, 0xC7, 0x0C, 0x70, 0xE7, 0x0C, 0x71, 0xC6, 0x3C, 0xFF, 0x8F, 0xF0,
  0x0F, 0x83, 0xF8, 0xF7, 0xB8, 0x77, 0x0E, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0xEE, 0x1D, 0xE7, 0x1F, 0xC1, 0xF0, 0x1F, 0x81,
  0xFC, 0x39, 0xE3, 0x8E, 0x38, 0x63, 0x87, 0x38, 0x63, 0x06, 0x70, 0xE7,
  0x0E, 0x70, 0xE7, 0x0C, 0x71, 0xC6, 0x78, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3,
  0xFC, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFC, 0x7F, 0x8E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x3F, 0xE7, 0xFC, 0x1F, 0xE3, 0xFC, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x0F, 0x83, 0xF8, 0xF7, 0xB8, 0x77,
  0x0E, 0xE0, 0x18, 0x07, 0x00, 0xE7, 0xFC, 0xFB, 0x87, 0x70, 0xEE, 0x1C,
  0xE7, 0x9F, 0xE1, 0xF8, 0x1C, 0x18, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x18, 0xE0, 0xC7, 0xFE, 0x7F, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xC7,
  0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E,
  0x31, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x71, 0xCE, 0x39,
  0xEE, 0x1F, 0x81, 0xE0, 0x1C, 0x78, 0xC3, 0x8E, 0x38, 0x73, 0xC3, 0xBC,
  0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1E, 0xE0, 0xE7, 0x07,
  0x38, 0x30, 0xE3, 0x87, 0x1C, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0xFF, 0xFF,
  0x1E, 0x07, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F,
  0x36, 0x36, 0x36, 0x36, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0xCE, 0x73, 0xCC,
  0x73, 0xCC, 0x63, 0x9C, 0xE3, 0x9C, 0xE3, 0x1C, 0x1C, 0x38, 0xE1, 0xCF,
  0x0E, 0x7C, 0x73, 0xE3, 0x9F, 0x18, 0xF9, 0xC6, 0x6E, 0x73, 0x73, 0x9B,
  0x9C, 0xFC, 0xE3, 0xC7, 0x1E, 0x30, 0xF3, 0x83, 0x9C, 0x1C, 0x0F, 0x83,
  0xF8, 0xF7, 0xB8, 0x77, 0x06, 0xE0, 0xD8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x6E, 0x1C, 0xE7, 0x1F, 0xC1, 0xF0, 0x1F, 0xC1, 0xFE, 0x38,
  0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0x73, 0x1E, 0x7F, 0xC7, 0xF8, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x83, 0xF8, 0xF7,
  0xB8, 0x77, 0x0E, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xEE, 0x1C, 0xE7, 0x1F, 0xC1, 0xF8, 0x03, 0x80, 0x70, 0x04, 0x00, 0x1F,
  0xC1, 0xFE, 0x38, 0xE3, 0x87, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x1E, 0x7F,
  0xC7, 0xF8, 0x73, 0x87, 0x38, 0x73, 0x86, 0x1C, 0xE1, 0xCE, 0x1C, 0x07,
  0x81, 0xFC, 0x1C, 0xE3, 0x86, 0x38, 0x63, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xCE, 0x1C, 0x61, 0xC7, 0x3C, 0x3F, 0x81, 0xF0, 0xFF,
  0xDF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x30, 0x73, 0x06,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE3, 0x8F, 0x78, 0x7F, 0x03, 0xE0, 0xE0, 0xFC, 0x1F,
  0x87, 0x70, 0xEE, 0x1D, 0xC7, 0x18, 0xE3, 0x38, 0x67, 0x0E, 0xC1, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0xE3, 0x8F, 0xC7, 0x1F, 0x9E,
  0x77, 0x3C, 0xEE, 0x79, 0xDD, 0xF3, 0x3B, 0x6E, 0x76, 0xDC, 0xFD, 0xB1,
  0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0x70,
  0xE0, 0x1C, 0x3C, 0x70, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x1B, 0x80,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0x70, 0x1D, 0xC0,
  0xE3, 0x87, 0x8E, 0x1C, 0x38, 0xE0, 0xFC, 0x3B, 0x8F, 0x31, 0xC7, 0x70,
  0xEE, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xFF, 0xCF, 0xFC, 0x1E, 0x3C, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61,
  0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0F, 0x1E, 0x00, 0xE7,
  0x39, 0xCE, 0x31, 0x8E, 0x73, 0x9C, 0xE3, 0x18, 0xC7, 0x38, 0x1E, 0x3C,
  0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x60, 0xC3, 0x8F, 0x1E, 0x00, 0x1C, 0x38, 0xF1, 0xE7, 0xCC, 0xF9,
  0xE3, 0xFF, 0xFF, 0x63, 0x8C, 0x0F, 0x1F, 0xCE, 0xEE, 0x70, 0x38, 0xFD,
  0xFE, 0xE7, 0xE3, 0x73, 0x9F, 0xC7, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xE3, 0xF8, 0xE7, 0x71, 0xDC, 0x77, 0x1D, 0xC7, 0x61, 0x98,
  0xEF, 0x3B, 0xFC, 0xEE, 0x00, 0x1E, 0x7F, 0x77, 0xE3, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC7, 0xEE, 0xFE, 0x78, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x3D, 0x8F, 0xF1, 0xDE, 0x71, 0xCE, 0x39, 0x86, 0x30, 0xC6, 0x38, 0xC7,
  0x1D, 0xE3, 0xFC, 0x3B, 0x00, 0x1E, 0x3F, 0x9D, 0xDC, 0x6E, 0x3F, 0xFB,
  0xFD, 0x80, 0xC0, 0x73, 0x3F, 0x87, 0x80, 0x0E, 0x3C, 0xF1, 0xC3, 0x9F,
  0xBF, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x1E, 0xCF,
  0xF3, 0x9D, 0xC7, 0x71, 0xD8, 0x76, 0x19, 0x8E, 0x63, 0x9C, 0xE7, 0xF8,
  0xEC, 0x07, 0x11, 0xCF, 0xE1, 0xF0, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xC3, 0xF8, 0xEE, 0x71, 0xDC, 0x67, 0x19, 0xCE, 0x63, 0x98, 0xEE,
  0x3B, 0x8C, 0xE3, 0x00, 0x18, 0x71, 0x80, 0x00, 0xE3, 0x8C, 0x31, 0xC7,
  0x1C, 0x71, 0x86, 0x38, 0xE0, 0x06, 0x0C, 0x18, 0x00, 0x01, 0xC3, 0x86,
  0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x71, 0xC7, 0x8E, 0x00,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x73, 0x8C, 0xE1, 0xBC, 0x77,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xCE, 0x39, 0xC7, 0x38, 0xE3, 0x80,
  0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8C, 0x31, 0xC7, 0x1C, 0x71, 0x86, 0x38,
  0xE0, 0x3F, 0xBC, 0x7F, 0xFC, 0xEF, 0x3B, 0x8E, 0x77, 0x18, 0xEE, 0x31,
  0xDC, 0xE3, 0xB1, 0xC6, 0x63, 0x9D, 0xC7, 0x3B, 0x8C, 0x77, 0x18, 0xE0,
  0x37, 0x8F, 0xE3, 0xB9, 0xC7, 0x71, 0x9C, 0x67, 0x39, 0x8E, 0x63, 0xB8,
  0xEE, 0x33, 0x8C, 0x1E, 0x3F, 0x9D, 0xDC, 0x7E, 0x3E, 0x1F, 0x0F, 0x86,
  0xC7, 0x73, 0xBF, 0x8F, 0x80, 0x1B, 0xC3, 0xF8, 0x73, 0x9C, 0x73, 0x8E,
  0x71, 0xCE, 0x39, 0x86, 0x31, 0xCF, 0x39, 0xFE, 0x3B, 0x87, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0x1E, 0xCF, 0xF3, 0xBD, 0xC7, 0x71, 0xD8, 0x66, 0x39,
  0x8E, 0x63, 0x9D, 0xE7, 0xF0, 0xEC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3E,
  0x7C, 0xFB, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x00, 0x1F, 0x1F,
  0xCC, 0xEE, 0x77, 0x81, 0xF0, 0x7C, 0x0E, 0xE3, 0x73, 0x9F, 0xC7, 0x80,
  0x38, 0xCF, 0xFF, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0xF1, 0xC0, 0x73,
  0xB1, 0xD8, 0xFC, 0x7E, 0x3F, 0x1B, 0x9D, 0x8E, 0xC7, 0x77, 0xBF, 0x8E,
  0xC0, 0xE3, 0xF1, 0xB9, 0xCC, 0xE6, 0x63, 0x71, 0xB0, 0xF8, 0x78, 0x3C,
  0x1E, 0x0E, 0x00, 0xE7, 0x3F, 0x39, 0xF9, 0xCD, 0xDE, 0xEE, 0xF6, 0x3F,
  0xB1, 0xEF, 0x8F, 0x78, 0x73, 0xC3, 0x9E, 0x1C, 0xE0, 0xC7, 0x00, 0x18,
  0xE3, 0x38, 0x77, 0x0F, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x3B, 0x07,
  0x61, 0xCE, 0x39, 0xC0, 0x38, 0xE7, 0x18, 0xE7, 0x0C, 0xC1, 0xB8, 0x37,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x3C,
  0x07, 0x00, 0x3F, 0x8F, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x18, 0x0F, 0xF3, 0xFC, 0x04, 0x31, 0x8E, 0x38, 0xC3, 0x0C, 0x71,
  0xCE, 0x30, 0xE1, 0x86, 0x38, 0xE3, 0x86, 0x18, 0x20, 0x18, 0xC6, 0x21,
  0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x8C, 0x62, 0x30, 0x18, 0x38, 0x30,
  0x60, 0xC1, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0xE3, 0x87, 0x0E, 0x18, 0x30,
  0x61, 0xC7, 0x0C, 0x00, 0x38, 0xDF, 0x3E, 0xDF, 0x1E, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 7, 6, 7, 1, -17 },
  { 19, 11, 16, 11, 1, -16 },
  { 41, 9, 20, 11, 1, -18 },
  { 64, 10, 16, 14, 2, -16 },
  { 84, 11, 16, 12, 0, -16 },
  { 106, 3, 6, 4, 1, -17 },
  { 109, 7, 22, 7, 1, -17 },
  { 129, 7, 22, 7, -1, -17 },
  { 149, 9, 9, 10, 1, -16 },
  { 160, 9, 12, 10, 1, -13 },
  { 174, 4, 6, 5, -1, -3 },
  { 177, 5, 2, 7, 1, -8 },
  { 179, 4, 3, 6, 0, -3 },
  { 181, 9, 17, 7, -1, -16 },
  { 201, 9, 16, 11, 1, -16 },
  { 219, 7, 16, 11, 2, -16 },
  { 233, 10, 16, 11, 0, -16 },
  { 253, 10, 16, 11, 0, -16 },
  { 273, 10, 16, 11, 0, -16 },
  { 293, 10, 16, 11, 1, -16 },
  { 313, 9, 16, 11, 1, -16 },
  { 331, 10, 16, 11, 1, -16 },
  { 351, 9, 16, 11, 1, -16 },
  { 369, 9, 16, 11, 1, -16 },
  { 387, 5, 12, 6, 0, -12 },
  { 395, 6, 15, 5, -1, -12 },
  { 407, 8, 10, 10, 1, -12 },
  { 417, 9, 6, 11, 1, -10 },
  { 424, 9, 10, 10, 0, -12 },
  { 436, 8, 16, 9, 2, -16 },
  { 452, 16, 20, 16, 0, -15 },
  { 492, 12, 16, 13, -1, -16 },
  { 516, 12, 16, 12, 0, -16 },
  { 540, 11, 16, 12, 1, -16 },
  { 562, 12, 16, 12, 0, -16 },
  { 586, 11, 16, 11, 0, -16 },
  { 608, 11, 16, 10, 0, -16 },
  { 630, 11, 16, 13, 1, -16 },
  { 652, 13, 16, 13, 0, -16 },
  { 678, 6, 16, 6, 0, -16 },
  { 690, 11, 16, 10, 0, -16 },
  { 712, 13, 16, 12, 0, -16 },
  { 738, 9, 16, 10, 0, -16 },
  { 756, 16, 16, 16, 0, -16 },
  { 788, 13, 16, 13, 0, -16 },
  { 814, 11, 16, 13, 1, -16 },
  { 836, 12, 16, 12, 0, -16 },
  { 860, 11, 19, 13, 1, -16 },
  { 887, 12, 16, 12, 0, -16 },
  { 911, 12, 16, 11, 0, -16 },
  { 935, 11, 16, 11, 2, -16 },
  { 957, 12, 16, 12, 1, -16 },
  { 981, 11, 16, 12, 2, -16 },
  { 1003, 15, 16, 16, 2, -16 },
  { 1033, 14, 16, 12, -1, -16 },
  { 1061, 11, 16, 12, 2, -16 },
  { 1083, 12, 16, 11, 0, -16 },
  { 1107, 7, 22, 6, 0, -18 },
  { 1127, 5, 17, 8, 2, -16 },
  { 1138, 7, 22, 6, -1, -18 },
  { 1158, 7, 8, 8, 1, -16 },
  { 1165, 8, 2, 9, -1, 0 },
  { 1167, 5, 3, 7, 2, -16 },
  { 1169, 9, 12, 10, 0, -12 },
  { 1183, 10, 17, 11, 0, -17 },
  { 1205, 8, 12, 10, 1, -12 },
  { 1217, 11, 17, 11, 0, -17 },
  { 1241, 9, 12, 10, 1, -12 },
  { 1255, 7, 17, 7, 1, -17 },
  { 1270, 10, 16, 11, 0, -12 },
  { 1290, 10, 17, 10, 0, -17 },
  { 1312, 6, 17, 5, 0, -17 },
  { 1325, 7, 21, 5, -2, -17 },
  { 1344, 11, 17, 10, 0, -17 },
  { 1368, 6, 17, 5, 0, -17 },
  { 1381, 15, 12, 16, 0, -12 },
  { 1404, 10, 12, 10, 0, -12 },
  { 1419, 9, 12, 11, 1, -12 },
  { 1433, 11, 16, 11, -1, -12 },
  { 1455, 10, 16, 11, 0, -12 },
  { 1475, 7, 12, 7, 0, -12 },
  { 1486, 9, 12, 10, 0, -12 },
  { 1500, 6, 14, 6, 1, -14 },
  { 1511, 9, 12, 10, 1, -12 },
  { 1525, 9, 12, 9, 1, -12 },
  { 1539, 13, 12, 14, 1, -12 },
  { 1559, 11, 12, 10, -1, -12 },
  { 1576, 11, 16, 9, -1, -12 },
  { 1598, 10, 12, 10, 0, -12 },
  { 1613, 6, 21, 6, 1, -17 },
  { 1629, 5, 19, 5, 0, -16 },
  { 1641, 7, 21, 6, -1, -17 },
  { 1660, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC22PT7B_H_
