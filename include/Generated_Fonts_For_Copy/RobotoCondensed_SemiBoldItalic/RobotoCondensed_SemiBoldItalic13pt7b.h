#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC13PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB4, 0x86, 0xC0, 0xEA, 0xA0, 0x14, 0x28, 0x53, 0xF2, 0x9F,
  0x9C, 0x28, 0x50, 0x08, 0xE2, 0xD9, 0x60, 0xE0, 0xB3, 0x59, 0xC2, 0x00,
  0x62, 0xDA, 0x9C, 0x10, 0xF5, 0x75, 0x1C, 0x38, 0x58, 0xB1, 0xC3, 0x6A,
  0xB7, 0x6E, 0x7C, 0xE8, 0x12, 0x44, 0xC8, 0x88, 0x88, 0x88, 0x40, 0x21,
  0x11, 0x11, 0x11, 0x33, 0x24, 0x80, 0x21, 0x3E, 0xCF, 0x48, 0x10, 0x41,
  0x1F, 0xFC, 0xC3, 0x08, 0x6D, 0x60, 0xE0, 0xF0, 0x04, 0x20, 0x84, 0x10,
  0xC2, 0x18, 0x43, 0x00, 0x72, 0xF3, 0xB9, 0xCE, 0x56, 0xE0, 0x17, 0xB3,
  0x22, 0x26, 0x60, 0x39, 0xB6, 0xC3, 0x18, 0xC6, 0x30, 0xF8, 0x39, 0xB6,
  0xC3, 0x38, 0x2C, 0xB6, 0x70, 0x0C, 0x71, 0xCA, 0x69, 0x6F, 0xC6, 0x18,
  0x3C, 0x86, 0x1E, 0x6C, 0x3C, 0xD6, 0x70, 0x33, 0x31, 0xED, 0xCE, 0x7E,
  0xE0, 0xFC, 0x21, 0x84, 0x30, 0x86, 0x30, 0xC0, 0x38, 0xB6, 0xDB, 0x39,
  0x2C, 0x96, 0x70, 0x76, 0xF7, 0xBD, 0xBC, 0x4E, 0xC0, 0x6C, 0x01, 0xB0,
  0x33, 0x00, 0x02, 0x64, 0xC0, 0x09, 0xD9, 0xC3, 0x88, 0xF8, 0x3C, 0x43,
  0x86, 0x76, 0x40, 0x76, 0xF6, 0x66, 0x20, 0x18, 0xC0, 0x0F, 0x08, 0xC8,
  0x29, 0xD5, 0xAA, 0x96, 0x53, 0x2A, 0x9F, 0x60, 0x10, 0x07, 0x80, 0x04,
  0x0E, 0x0E, 0x1E, 0x12, 0x32, 0x3E, 0x62, 0x43, 0x3C, 0xCD, 0x9B, 0x27,
  0x88, 0x91, 0x66, 0xF8, 0x39, 0xBC, 0x70, 0x82, 0x08, 0xB6, 0x70, 0x3C,
  0xD9, 0x9B, 0x36, 0x68, 0x91, 0x6E, 0xF8, 0x3E, 0xC1, 0x83, 0x07, 0x88,
  0x10, 0x60, 0xF8, 0x3E, 0xC1, 0x83, 0x07, 0x88, 0x10, 0x60, 0xC0, 0x39,
  0xBC, 0x70, 0x82, 0x78, 0xF6, 0x78, 0x23, 0x63, 0x62, 0x62, 0x7E, 0x46,
  0x46, 0xC6, 0xC4, 0x25, 0xB6, 0x96, 0xC0, 0x04, 0x30, 0xC3, 0x0C, 0x2C,
  0xB6, 0x70, 0x26, 0x66, 0x6C, 0x78, 0x78, 0x78, 0x48, 0xCC, 0xCC, 0x23,
  0x18, 0xC6, 0x21, 0x18, 0xF8, 0x31, 0xDC, 0x67, 0x39, 0xCA, 0x57, 0x95,
  0x65, 0x5B, 0x64, 0xC9, 0x00, 0x23, 0x73, 0x72, 0x72, 0x7E, 0x4E, 0x4E,
  0xCE, 0xC4, 0x39, 0xBC, 0x71, 0x8E, 0x38, 0xF6, 0x70, 0x3C, 0xCD, 0x9B,
  0x36, 0xEF, 0x90, 0x60, 0xC0, 0x39, 0xBC, 0x71, 0x8E, 0x38, 0xF6, 0x70,
  0x60, 0x80, 0x3C, 0xCD, 0x9B, 0x36, 0xCF, 0x12, 0x66, 0xCC, 0x3C, 0x6D,
  0x9B, 0x03, 0x81, 0xB3, 0x36, 0x78, 0xFC, 0xC3, 0x0C, 0x20, 0x86, 0x18,
  0x60, 0x22, 0xC5, 0x9B, 0x34, 0x68, 0x91, 0x36, 0x78, 0xC7, 0x9B, 0x36,
  0x45, 0x8A, 0x1C, 0x38, 0x60, 0xC9, 0xEC, 0xF6, 0x5B, 0x6F, 0xB7, 0x53,
  0xB9, 0xDC, 0xCC, 0x00, 0x66, 0x26, 0x3C, 0x38, 0x18, 0x38, 0x68, 0x4C,
  0xCC, 0xCD, 0x99, 0x62, 0xC7, 0x0C, 0x18, 0x30, 0x60, 0x7E, 0x0C, 0x30,
  0xC1, 0x06, 0x18, 0x60, 0xFC, 0x32, 0x66, 0x66, 0x44, 0xCC, 0xCC, 0xC0,
  0xDB, 0x24, 0x9B, 0x6C, 0x38, 0x84, 0x63, 0x18, 0xC4, 0x21, 0x18, 0xCE,
  0x00, 0x11, 0x8C, 0xA5, 0x80, 0xF8, 0x4C, 0x3B, 0x42, 0xFD, 0xED, 0xE0,
  0x21, 0x86, 0x1E, 0x6D, 0x34, 0xF3, 0xDB, 0xE0, 0x39, 0xA4, 0xF0, 0xC3,
  0x67, 0x00, 0x06, 0x08, 0x11, 0xE6, 0xC9, 0xB2, 0x64, 0xD8, 0xD0, 0x39,
  0xB4, 0xFF, 0xC1, 0x27, 0x80, 0x19, 0x88, 0xE6, 0x31, 0x88, 0x42, 0x00,
  0x35, 0xB4, 0xF3, 0xCB, 0x66, 0x86, 0x9B, 0xC0, 0x21, 0x86, 0x1E, 0x6D,
  0x34, 0xB2, 0xCB, 0x60, 0x24, 0x36, 0x92, 0xD8, 0x11, 0x03, 0x32, 0x22,
  0x66, 0x64, 0xC0, 0x21, 0x86, 0x1B, 0x79, 0xC7, 0x34, 0xDB, 0x60, 0x25,
  0xB6, 0x92, 0xD8, 0x7B, 0x36, 0xD3, 0x69, 0x3C, 0x96, 0xCB, 0x64, 0x79,
  0xB4, 0xD2, 0xCB, 0x2D, 0x80, 0x39, 0xB4, 0xF3, 0xCD, 0x67, 0x00, 0x79,
  0xB4, 0xD3, 0xCF, 0x6F, 0xB0, 0x82, 0x00, 0x35, 0xB4, 0xF3, 0xCB, 0x67,
  0x86, 0x18, 0x60, 0x77, 0x44, 0xCC, 0xC0, 0x3B, 0x58, 0xE1, 0xED, 0xC0,
  0x22, 0x76, 0x64, 0x44, 0x60, 0x6D, 0xB4, 0xD2, 0xCB, 0x67, 0x80, 0x9C,
  0xAD, 0x4E, 0x73, 0x00, 0x93, 0x6E, 0xD5, 0xAD, 0xDB, 0x36, 0x00, 0x6D,
  0xE3, 0x0C, 0x71, 0x4D, 0x80, 0x4D, 0x25, 0x94, 0x71, 0xC6, 0x18, 0xC3,
  0x00, 0x7C, 0x61, 0x0C, 0x63, 0x0F, 0x80, 0x13, 0x22, 0x26, 0xC4, 0x44,
  0x46, 0x24, 0xA4, 0x92, 0x52, 0x00, 0x20, 0x84, 0x23, 0x08, 0x44, 0x21,
  0x18, 0x80, 0xEE, 0xA9, 0x80,
};

const GFXglyph RobotoCondensed_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 4, 1, -10 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 6, 0, -10 },
  { 24, 6, 9, 8, 1, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 2, 3, 2, 1, -10 },
  { 40, 4, 13, 4, 1, -10 },
  { 47, 4, 13, 4, -1, -10 },
  { 54, 5, 6, 6, 1, -9 },
  { 58, 6, 8, 6, 0, -9 },
  { 64, 3, 4, 3, -1, -2 },
  { 66, 3, 1, 4, 1, -4 },
  { 67, 2, 2, 4, 0, -2 },
  { 68, 6, 10, 4, -1, -9 },
  { 76, 5, 9, 6, 1, -9 },
  { 82, 4, 9, 6, 1, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 6, 9, 6, 0, -9 },
  { 115, 5, 9, 6, 1, -9 },
  { 121, 6, 9, 6, 1, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 5, 9, 6, 1, -9 },
  { 141, 3, 7, 3, 0, -7 },
  { 144, 4, 9, 3, -1, -7 },
  { 149, 5, 6, 6, 0, -7 },
  { 153, 5, 3, 6, 1, -6 },
  { 155, 5, 6, 6, 0, -7 },
  { 159, 5, 9, 6, 1, -9 },
  { 165, 9, 12, 10, 0, -9 },
  { 179, 8, 9, 7, -1, -9 },
  { 188, 7, 9, 7, 0, -9 },
  { 196, 6, 9, 7, 1, -9 },
  { 203, 7, 9, 7, 0, -9 },
  { 211, 7, 9, 6, 0, -9 },
  { 219, 7, 9, 6, 0, -9 },
  { 227, 6, 9, 7, 1, -9 },
  { 234, 8, 9, 8, 0, -9 },
  { 243, 3, 9, 3, 0, -9 },
  { 247, 6, 9, 6, 0, -9 },
  { 254, 8, 9, 7, 0, -9 },
  { 263, 5, 9, 6, 0, -9 },
  { 269, 10, 9, 10, 0, -9 },
  { 281, 8, 9, 8, 0, -9 },
  { 290, 6, 9, 8, 1, -9 },
  { 297, 7, 9, 7, 0, -9 },
  { 305, 6, 11, 8, 1, -9 },
  { 314, 7, 9, 7, 0, -9 },
  { 322, 7, 9, 7, 0, -9 },
  { 330, 6, 9, 7, 1, -9 },
  { 337, 7, 9, 7, 0, -9 },
  { 345, 7, 9, 7, 1, -9 },
  { 353, 9, 9, 9, 1, -9 },
  { 364, 8, 9, 7, 0, -9 },
  { 373, 7, 9, 7, 1, -9 },
  { 381, 7, 9, 7, 0, -9 },
  { 389, 4, 13, 3, 0, -11 },
  { 396, 3, 10, 5, 1, -9 },
  { 400, 5, 13, 3, -1, -11 },
  { 409, 5, 5, 5, 0, -9 },
  { 413, 5, 1, 5, -1, 0 },
  { 414, 3, 2, 4, 1, -10 },
  { 415, 5, 7, 6, 0, -7 },
  { 420, 6, 10, 6, 0, -10 },
  { 428, 6, 7, 6, 0, -7 },
  { 434, 7, 10, 6, 0, -10 },
  { 443, 6, 7, 6, 0, -7 },
  { 449, 5, 10, 4, 0, -10 },
  { 456, 6, 10, 6, 0, -7 },
  { 464, 6, 10, 6, 0, -10 },
  { 472, 3, 10, 3, 0, -10 },
  { 476, 4, 13, 3, -1, -10 },
  { 483, 6, 10, 6, 0, -10 },
  { 491, 3, 10, 3, 0, -10 },
  { 495, 9, 7, 9, 0, -7 },
  { 503, 6, 7, 6, 0, -7 },
  { 509, 6, 7, 6, 0, -7 },
  { 515, 6, 10, 6, 0, -7 },
  { 523, 6, 10, 6, 0, -7 },
  { 531, 4, 7, 4, 0, -7 },
  { 535, 5, 7, 6, 0, -7 },
  { 540, 4, 9, 4, 0, -9 },
  { 545, 6, 7, 6, 0, -7 },
  { 551, 5, 7, 6, 1, -7 },
  { 556, 7, 7, 8, 1, -7 },
  { 563, 6, 7, 6, 0, -7 },
  { 569, 6, 10, 6, 0, -7 },
  { 577, 6, 7, 6, 0, -7 },
  { 583, 4, 12, 4, 0, -10 },
  { 589, 3, 11, 3, 0, -9 },
  { 594, 5, 12, 4, -1, -10 },
  { 602, 6, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC13PT7B_H_
