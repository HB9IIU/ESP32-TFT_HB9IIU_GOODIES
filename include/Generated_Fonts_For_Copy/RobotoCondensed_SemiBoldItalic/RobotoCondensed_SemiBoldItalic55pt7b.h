#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC55PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x04, 0x00, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3C, 0x3E, 0x78, 0x79, 0xF0, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x1E,
  0x1E, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0x1F, 0x01, 0x07, 0x83, 0xC0, 0xF3, 0xE0, 0xF0, 0x7C, 0xF8, 0x3C, 0x1E,
  0x3E, 0x0F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xE0, 0xF8, 0x7C,
  0xF8, 0x3E, 0x3E, 0x7C, 0x07, 0xFF, 0x9E, 0x01, 0xFF, 0xCF, 0x80, 0x3F,
  0xE7, 0xC0, 0x07, 0xF3, 0xE0, 0x00, 0x20, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE7,
  0xF8, 0x00, 0xF3, 0xFF, 0x00, 0x7D, 0xFF, 0xC0, 0x3E, 0x7F, 0xF8, 0x0F,
  0x3E, 0x1E, 0x07, 0xCF, 0x87, 0x83, 0xE3, 0xC1, 0xE0, 0xF1, 0xF0, 0x78,
  0x7C, 0x7C, 0x1E, 0x3E, 0x1F, 0x07, 0x9F, 0x07, 0xC3, 0xE7, 0xC1, 0xF0,
  0xF8, 0xE0, 0x7C, 0x3E, 0x10, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xC3,
  0xFF, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0x3F, 0x9F, 0xCF, 0xCF, 0xF3, 0xF9,
  0xF9, 0xFC, 0x3F, 0xBF, 0x3F, 0x87, 0xFF, 0xCF, 0xE0, 0x7F, 0xF9, 0xFC,
  0x0F, 0xFF, 0x3F, 0x80, 0xFF, 0xC7, 0xF0, 0x1F, 0xF8, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xE0, 0x3F, 0xF1, 0xFE,
  0x00, 0x60, 0x00, 0x00, 0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0x3C, 0x1E, 0x0E, 0x7E, 0x3C, 0xFD, 0xFF, 0x7F,
  0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xDE, 0x00, 0x1F, 0x3E, 0x00,
  0x7C, 0x7C, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0x80, 0xF8, 0x06,
  0x01, 0xC0, 0x04, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x1E, 0x00, 0x80,
  0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xFF, 0xE0, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF9, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF,
  0x0F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0xFC,
  0xE0, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x10, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x3E, 0x01, 0xFB, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0x7F, 0x81, 0xFD, 0xFC, 0x07,
  0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x07, 0xF0, 0xFE, 0x3F, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x18, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF9,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0x87, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x1F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0x1F, 0xC7, 0xF0, 0x7E, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xBF, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x1F,
  0x80, 0x78, 0x1F, 0x01, 0xFF, 0x80, 0xF0, 0xF8, 0x0F, 0xFF, 0x03, 0xC3,
  0xE0, 0x7F, 0xFE, 0x0F, 0x1F, 0x03, 0xF9, 0xF8, 0x3C, 0x7C, 0x0F, 0x83,
  0xE0, 0xF1, 0xE0, 0x7C, 0x1F, 0x03, 0xCF, 0x83, 0xF0, 0x7C, 0x0F, 0x3E,
  0x0F, 0x81, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x3E,
  0x07, 0xDF, 0x07, 0xC0, 0xF8, 0x1E, 0x7C, 0x1F, 0x03, 0xE0, 0x79, 0xE0,
  0xFC, 0x0F, 0x81, 0xE7, 0x83, 0xE0, 0x7C, 0x07, 0xBE, 0x0F, 0x81, 0xF0,
  0x3E, 0xF8, 0x3E, 0x07, 0xC0, 0xF3, 0xE0, 0xF8, 0x1F, 0x03, 0xCF, 0x83,
  0xE0, 0xF8, 0x1E, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0xF8, 0x3E, 0x1F, 0x83,
  0xE3, 0xE0, 0xFC, 0xFE, 0x1F, 0x0F, 0x83, 0xFF, 0xFF, 0xF8, 0x3E, 0x07,
  0xFD, 0xFF, 0xE0, 0xF8, 0x1F, 0xF3, 0xFE, 0x01, 0xE0, 0x3F, 0x07, 0xF0,
  0x07, 0x80, 0x10, 0x02, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xF1,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x03,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x03, 0xFF, 0xC7, 0xF0, 0x3F, 0xFE, 0x3F, 0x81, 0xFF, 0xF1,
  0xFC, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0xFC, 0x7F, 0x03, 0xFF, 0xE3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xFB, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x3F,
  0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0xFF,
  0x80, 0x0F, 0xE1, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xF0, 0x00, 0x3F, 0xE7, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xDF, 0x80,
  0x7F, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF8,
  0x1F, 0xDF, 0x80, 0xF9, 0xF8, 0x1F, 0xDF, 0x81, 0xFB, 0xF8, 0x1F, 0xCF,
  0x81, 0xFB, 0xF8, 0x1F, 0xCF, 0x83, 0xF3, 0xF8, 0x1F, 0x8F, 0x83, 0xF3,
  0xF8, 0x1F, 0x8F, 0x87, 0xE3, 0xF0, 0x3F, 0x8F, 0x87, 0xE7, 0xF0, 0x3F,
  0x8F, 0xCF, 0xC7, 0xF0, 0x3F, 0x8F, 0xCF, 0xC7, 0xF0, 0x3F, 0x8F, 0xCF,
  0x87, 0xF0, 0x3F, 0x87, 0xDF, 0x87, 0xE0, 0x3F, 0x87, 0xDF, 0x0F, 0xE0,
  0x7F, 0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07,
  0xFC, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x07,
  0xFE, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x0F,
  0xFF, 0x00, 0xFE, 0x0F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x81, 0xFC, 0x0F,
  0xEF, 0x81, 0xFC, 0x0F, 0xEF, 0x81, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC, 0x1F,
  0xCF, 0xC1, 0xFC, 0x1F, 0xC7, 0xC3, 0xF8, 0x1F, 0xC7, 0xC3, 0xF8, 0x1F,
  0xC7, 0xE3, 0xF8, 0x1F, 0xC3, 0xE3, 0xF8, 0x1F, 0xC3, 0xE3, 0xF8, 0x3F,
  0x83, 0xE3, 0xF8, 0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0x81, 0xF7, 0xF0, 0x3F,
  0x81, 0xF7, 0xF0, 0x3F, 0x81, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xF0, 0x7F,
  0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F,
  0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1B, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xF0,
  0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE1, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x9F,
  0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0x0F,
  0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xC0, 0x7E,
  0x3F, 0x81, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F,
  0xF0, 0x3F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0x07, 0xF0,
  0xFE, 0x1F, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0xF0, 0xFE, 0x0F, 0xE1, 0xF7,
  0xC3, 0xF8, 0x3F, 0x8F, 0xDF, 0x0F, 0xC0, 0xFE, 0x3F, 0x7C, 0x7F, 0x03,
  0xF8, 0xF9, 0xF1, 0xFC, 0x0F, 0xE7, 0xE7, 0xC7, 0xE0, 0x3F, 0x9F, 0x9F,
  0x1F, 0x80, 0xFE, 0x7C, 0x7C, 0xFE, 0x03, 0xFB, 0xF1, 0xF3, 0xF0, 0x0F,
  0xEF, 0xC7, 0xCF, 0xC0, 0x1F, 0xBE, 0x1F, 0x7F, 0x00, 0x7F, 0xF8, 0x7D,
  0xF8, 0x01, 0xFF, 0xE1, 0xF7, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0x7C, 0xF0, 0x3E,
  0x3C, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F,
  0x9F, 0x83, 0xE7, 0xC0, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xE3, 0xF9, 0xFE, 0x0F,
  0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xF7, 0xF0, 0x7F, 0x9F, 0xC0, 0x10, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x0F, 0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFB, 0xFF, 0xC1, 0xFC, 0xFF, 0xC0, 0xFC, 0x3F, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE,
  0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x8F,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xE3, 0xF8, 0x07, 0xFE, 0x7F, 0x01, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0x80, 0x0F, 0xF3,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFC,
  0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x10, 0x3F,
  0x80, 0x70, 0x7F, 0xC7, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x1F, 0xFC,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0x8F, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0,
  0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xE7, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x04, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x08, 0x01, 0xFC, 0x03, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x40, 0x07, 0xF7, 0xF8, 0x07, 0xEF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0xE0, 0x7F, 0x07, 0xF8,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x07, 0xF7,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xF3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0xC1, 0xFE, 0x01, 0xFB,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE7, 0xFF, 0x9F, 0xE1, 0xFC, 0x1F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xE0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x0F, 0xE3, 0xF0,
  0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xF0, 0x3F,
  0x8F, 0xE0, 0x3F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F,
  0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xF0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0,
  0x7F, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0x1F, 0x8F, 0xE0,
  0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE7, 0xF8, 0x07, 0xEF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFE, 0x1F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x07, 0xEF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xDF, 0xFE, 0x03, 0xF9, 0xFF,
  0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE0, 0x40, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F,
  0xC0, 0xFF, 0xCF, 0xE0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x8F, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xBF, 0x80, 0x06, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x7E, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xF3, 0x0F, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0x7F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x9F,
  0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x7F, 0x07, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFE,
  0x00, 0x30, 0x00, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xE0, 0x02, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF1, 0xF8,
  0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x03,
  0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0,
  0x7F, 0xFE, 0x07, 0xE0, 0x7E, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0,
  0xFE, 0x7E, 0x1F, 0xE0, 0xFC, 0x7E, 0x1F, 0xE1, 0xFC, 0x7E, 0x1F, 0xE1,
  0xF8, 0x7E, 0x3F, 0xE1, 0xF8, 0x7E, 0x3F, 0xE3, 0xF8, 0x7E, 0x7F, 0xE3,
  0xF0, 0x7E, 0x7F, 0xE3, 0xF0, 0x7E, 0x7F, 0xE7, 0xE0, 0x7E, 0xFB, 0xE7,
  0xE0, 0x7E, 0xF9, 0xF7, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF,
  0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFC, 0x01, 0xF1, 0xFF, 0xC0, 0x7C, 0x7F, 0xF0, 0x3F, 0x3F, 0xFE, 0x0F,
  0x9F, 0xFF, 0xC7, 0xE7, 0xE3, 0xFF, 0xF9, 0xF0, 0x7F, 0xFC, 0xFC, 0x0F,
  0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 15, 14, 17, 4, -41 },
  { 98, 28, 39, 28, 1, -39 },
  { 235, 24, 52, 27, 2, -46 },
  { 391, 26, 41, 34, 5, -40 },
  { 525, 27, 41, 30, 1, -40 },
  { 664, 7, 14, 9, 4, -41 },
  { 677, 16, 56, 17, 3, -44 },
  { 789, 17, 56, 17, -2, -44 },
  { 908, 23, 24, 24, 3, -39 },
  { 977, 23, 28, 26, 2, -32 },
  { 1058, 11, 16, 12, -3, -6 },
  { 1080, 14, 6, 18, 2, -20 },
  { 1091, 8, 8, 15, 1, -7 },
  { 1099, 24, 42, 18, -3, -39 },
  { 1225, 24, 41, 27, 2, -40 },
  { 1348, 16, 39, 27, 6, -39 },
  { 1426, 26, 40, 27, 0, -40 },
  { 1556, 25, 41, 27, 1, -40 },
  { 1685, 25, 39, 27, 1, -39 },
  { 1807, 25, 40, 27, 2, -39 },
  { 1932, 22, 40, 27, 2, -39 },
  { 2042, 25, 39, 27, 3, -39 },
  { 2164, 24, 41, 27, 2, -40 },
  { 2287, 21, 40, 27, 4, -40 },
  { 2392, 12, 30, 14, 1, -29 },
  { 2437, 16, 39, 13, -3, -29 },
  { 2515, 22, 26, 24, 1, -30 },
  { 2587, 23, 17, 27, 2, -26 },
  { 2636, 22, 25, 24, 1, -29 },
  { 2705, 20, 41, 24, 4, -40 },
  { 2808, 38, 50, 41, 1, -38 },
  { 3046, 30, 39, 32, -2, -39 },
  { 3193, 28, 39, 30, 1, -39 },
  { 3330, 28, 41, 30, 2, -40 },
  { 3474, 28, 39, 30, 1, -39 },
  { 3611, 28, 39, 26, 1, -39 },
  { 3748, 27, 39, 25, 1, -39 },
  { 3880, 29, 41, 31, 2, -40 },
  { 4029, 32, 39, 33, 1, -39 },
  { 4185, 14, 39, 14, 1, -39 },
  { 4254, 27, 40, 26, 0, -39 },
  { 4389, 32, 39, 29, 1, -39 },
  { 4545, 21, 39, 25, 1, -39 },
  { 4648, 40, 39, 40, 1, -39 },
  { 4843, 32, 39, 33, 1, -39 },
  { 4999, 29, 41, 32, 2, -40 },
  { 5148, 29, 39, 30, 1, -39 },
  { 5290, 29, 47, 32, 2, -40 },
  { 5461, 28, 39, 29, 1, -39 },
  { 5598, 28, 41, 29, 1, -40 },
  { 5742, 27, 39, 29, 4, -39 },
  { 5874, 30, 40, 30, 2, -39 },
  { 6024, 30, 39, 31, 4, -39 },
  { 6171, 38, 39, 40, 5, -39 },
  { 6357, 34, 39, 30, -2, -39 },
  { 6523, 27, 39, 29, 5, -39 },
  { 6655, 31, 39, 28, -1, -39 },
  { 6807, 18, 54, 14, -1, -45 },
  { 6929, 12, 42, 20, 5, -39 },
  { 6992, 18, 54, 14, -3, -45 },
  { 7114, 18, 20, 21, 2, -39 },
  { 7159, 21, 6, 21, -3, 0 },
  { 7175, 12, 8, 17, 5, -41 },
  { 7187, 22, 31, 25, 1, -30 },
  { 7273, 25, 42, 26, 0, -41 },
  { 7405, 23, 31, 25, 1, -30 },
  { 7495, 27, 42, 26, 1, -41 },
  { 7637, 23, 31, 25, 1, -30 },
  { 7727, 19, 42, 17, 2, -42 },
  { 7827, 26, 41, 27, 0, -30 },
  { 7961, 24, 41, 26, 0, -41 },
  { 8084, 14, 41, 13, 0, -41 },
  { 8156, 20, 52, 13, -6, -41 },
  { 8286, 27, 41, 25, 0, -41 },
  { 8425, 14, 41, 13, 0, -41 },
  { 8497, 37, 30, 40, 0, -30 },
  { 8636, 24, 30, 26, 0, -30 },
  { 8726, 24, 31, 27, 1, -30 },
  { 8819, 27, 41, 26, -2, -30 },
  { 8958, 25, 41, 27, 1, -30 },
  { 9087, 18, 30, 17, 0, -30 },
  { 9155, 23, 31, 24, 0, -30 },
  { 9245, 15, 37, 16, 2, -36 },
  { 9315, 24, 30, 26, 2, -29 },
  { 9405, 22, 29, 24, 3, -29 },
  { 9485, 32, 29, 34, 3, -29 },
  { 9601, 27, 29, 24, -2, -29 },
  { 9699, 27, 40, 23, -2, -29 },
  { 9834, 25, 29, 24, -1, -29 },
  { 9925, 17, 53, 16, 1, -43 },
  { 10038, 12, 46, 13, 1, -39 },
  { 10107, 17, 53, 16, -2, -43 },
  { 10220, 26, 12, 30, 2, -22 },
};

const GFXfont RobotoCondensed_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC55PT7B_H_
