#ifndef _ROBOTOCONDENSED_SEMIBOLDITALIC44PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF0, 0x1C, 0x00, 0x3C, 0xF3, 0xCF, 0x78,
  0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xF1,
  0xCE, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x78,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01,
  0xE3, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x79,
  0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0xC0,
  0x07, 0x8E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x3F, 0x0F, 0x83,
  0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0x9E, 0x00, 0x70, 0xE0, 0xEF, 0x0E, 0x1E, 0xF0,
  0xE1, 0xEF, 0x0E, 0x3C, 0xF0, 0xE7, 0x8F, 0x1E, 0x70, 0xF1, 0xEF, 0x0F,
  0xBD, 0xE0, 0x7F, 0xFC, 0x03, 0xFB, 0xC0, 0x1F, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE7, 0xC0, 0x1F, 0xFE, 0x03, 0xDF, 0xF0, 0x7B, 0xCF, 0x07, 0xB8,
  0x70, 0xF7, 0x87, 0x1E, 0x78, 0x71, 0xC7, 0x87, 0x3C, 0x78, 0x77, 0x87,
  0x8F, 0xF0, 0x78, 0xF3, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0x1F, 0xF8, 0xF9, 0xFF,
  0xC7, 0xCF, 0xBF, 0x3E, 0xFC, 0xF9, 0xEF, 0xC7, 0xFF, 0x7E, 0x1F, 0xFB,
  0xF0, 0xFF, 0x9F, 0x83, 0xFC, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFD, 0xF8, 0x1F, 0x8F, 0xC0,
  0x3D, 0xF7, 0x9E, 0x79, 0xE7, 0xBC, 0xF3, 0xCF, 0x00, 0x00, 0x08, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0x80, 0x02, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x08, 0x3C,
  0x17, 0x8E, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xE3, 0x80, 0xF8, 0xF0, 0x7C,
  0x3E, 0x0E, 0x07, 0x00, 0x01, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x01, 0x00, 0x7F, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0xFD, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x87, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x18, 0x07, 0x80, 0xFC,
  0x3F, 0xE7, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0x7C, 0xC3, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xF7, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3C,
  0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x3E,
  0x0F, 0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFB, 0xF8, 0x0E, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7C,
  0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE7, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF9, 0xF8, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E,
  0xFC, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xF1, 0xF8, 0x7E,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F,
  0xC0, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0xFD, 0xF8, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0x7E, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE0, 0xFB, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01,
  0xE0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF0, 0xF0, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0x80,
  0x00, 0x40, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0x00,
  0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x07, 0xC0, 0xF0, 0xF0,
  0x7F, 0xC1, 0xC7, 0x83, 0xFF, 0x87, 0x1E, 0x1F, 0xFE, 0x1C, 0xF0, 0x78,
  0x78, 0x73, 0xC3, 0xC1, 0xC1, 0xCF, 0x0F, 0x0F, 0x07, 0x78, 0x78, 0x3C,
  0x1D, 0xE1, 0xE0, 0xF0, 0x77, 0x87, 0x83, 0x83, 0xDC, 0x3C, 0x1E, 0x0F,
  0xF0, 0xF0, 0x78, 0x3B, 0xC3, 0xC1, 0xE0, 0xEF, 0x0F, 0x07, 0x83, 0xBC,
  0x3C, 0x3C, 0x1E, 0xF0, 0xF0, 0xF0, 0x73, 0xC3, 0xC3, 0xC3, 0xCF, 0x0F,
  0x1F, 0x0E, 0x3C, 0x3F, 0xFE, 0x78, 0xF0, 0xFF, 0x7F, 0xC3, 0xC1, 0xF9,
  0xFE, 0x0F, 0x03, 0xC3, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x3E, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F,
  0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0,
  0x7C, 0x07, 0xE0, 0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00,
  0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8,
  0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xFE, 0xFC, 0x1F,
  0xFB, 0xF0, 0x7F, 0xEF, 0xC1, 0xFF, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF8,
  0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x0F, 0x83, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF,
  0x01, 0xFF, 0x81, 0xF7, 0x81, 0xF7, 0xC0, 0xFB, 0xC0, 0xFF, 0xE0, 0xFD,
  0xE0, 0xFB, 0xF0, 0x7E, 0xF0, 0x7D, 0xF0, 0x3E, 0x7C, 0x3C, 0xF8, 0x1F,
  0x3E, 0x3E, 0x7C, 0x0F, 0x9F, 0x1E, 0x7E, 0x07, 0xC7, 0x9F, 0x3F, 0x07,
  0xE3, 0xCF, 0x1F, 0x03, 0xF1, 0xEF, 0x8F, 0x81, 0xF8, 0xF7, 0x87, 0xC0,
  0xF8, 0x7F, 0xC7, 0xE0, 0x7C, 0x3F, 0xE3, 0xF0, 0x3E, 0x1F, 0xE1, 0xF8,
  0x3F, 0x0F, 0xF0, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x7E,
  0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x0F,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0xC0, 0x1F, 0x03,
  0xF8, 0x03, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x03,
  0xF0, 0x3F, 0xC0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x83, 0xF0, 0x3F,
  0xF0, 0x7E, 0x07, 0xDF, 0x0F, 0xC0, 0xF9, 0xE1, 0xF8, 0x3F, 0x3C, 0x3E,
  0x07, 0xE7, 0x87, 0xC0, 0xFC, 0xF9, 0xF8, 0x1F, 0x8F, 0x3F, 0x03, 0xE1,
  0xE7, 0xE0, 0x7C, 0x3E, 0xFC, 0x1F, 0x83, 0xDF, 0x03, 0xF0, 0x7B, 0xE0,
  0x7E, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x3E, 0x03,
  0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07,
  0xC0, 0x1F, 0xC0, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7E,
  0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x1F,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0,
  0x0F, 0x9F, 0x00, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xF0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8,
  0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8,
  0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF,
  0x80, 0xF8, 0x0F, 0xBE, 0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0x81, 0xFB, 0xE0,
  0x7E, 0x07, 0xCF, 0x83, 0xFC, 0x3F, 0x3E, 0x0F, 0xF0, 0xFC, 0xF8, 0x3F,
  0xC3, 0xE3, 0xE1, 0xFF, 0x1F, 0x8F, 0x87, 0xFC, 0x7E, 0x3E, 0x1F, 0xF1,
  0xF0, 0xF8, 0xFF, 0xC7, 0xC3, 0xE3, 0xDF, 0x3F, 0x0F, 0x8F, 0x7C, 0xF8,
  0x3E, 0x7C, 0xF3, 0xE0, 0xF9, 0xE3, 0xDF, 0x83, 0xEF, 0x8F, 0x7C, 0x0F,
  0xBE, 0x3D, 0xF0, 0x3E, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x1F, 0x00, 0x0F, 0xC3,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8,
  0x7C, 0x03, 0xE3, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEE, 0x03, 0xDC,
  0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0x9F,
  0x0F, 0xBC, 0x0F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x01, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xBF, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F,
  0x9F, 0x3F, 0x87, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xEF, 0x81, 0xF3, 0xF0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x9F, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0x9F, 0xE0, 0xF8, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC3,
  0xE3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0xFC,
  0x1F, 0x3F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0xF8, 0x1F, 0xF7, 0xC1, 0xFF,
  0xBE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE1, 0xFC, 0x7E, 0x07, 0xC3,
  0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F,
  0x7C, 0x07, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0x87, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07,
  0xC3, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x18, 0x0F, 0xC0, 0xF9, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x7C, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC,
  0x0F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x7E, 0x07, 0xCF, 0xC1, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0x80, 0x03,
  0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0xFE, 0x1F, 0x0F,
  0xE0, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xF0, 0x1F,
  0x7F, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x0F, 0x83,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x9F, 0x03, 0xE0, 0x3F, 0xFF,
  0x3F, 0xC0, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xF0, 0x7E, 0x0F, 0xC7, 0xC1, 0xF8, 0x3F,
  0x1F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0x7C, 0x0F, 0x8F,
  0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x07, 0xE3, 0xE0,
  0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x0F, 0x81, 0xF1, 0xF0, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0xFC, 0x7C, 0x1F, 0x83,
  0xF3, 0xF0, 0x7E, 0x0F, 0x8F, 0xC1, 0xF0, 0x3E, 0x00, 0x0F, 0x9F, 0x01,
  0xF7, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x0F, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x3F, 0x7C,
  0x07, 0xEF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xEF, 0xC0, 0x7D, 0xF8,
  0x0F, 0xBF, 0x01, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0x8F, 0x83, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0x7F, 0x81, 0xF9, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF1, 0xF0, 0xFF, 0xBE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xF0, 0xFE, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F,
  0x8F, 0x81, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xBF, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x9E, 0x1F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0xCF, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0x9F, 0x07, 0xC7, 0xE3, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07,
  0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E,
  0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFD, 0xF0, 0x1F, 0xBF,
  0x00, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x03,
  0xCF, 0x80, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x3C, 0x0F, 0xFC, 0x1E, 0x0F, 0xFE,
  0x1F, 0x07, 0xDF, 0x0F, 0xC3, 0xEF, 0x8F, 0xE3, 0xF7, 0xC7, 0xF1, 0xF3,
  0xE3, 0xF8, 0xF9, 0xF3, 0xFC, 0xF8, 0xF9, 0xFE, 0x7C, 0x7D, 0xFF, 0x3E,
  0x3E, 0xF7, 0xBE, 0x1F, 0x7B, 0xDF, 0x0F, 0xF9, 0xEF, 0x07, 0xFC, 0xFF,
  0x83, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0,
  0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0x81, 0xF0,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xBE, 0x00, 0xFD, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x83,
  0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F,
  0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x0F,
  0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0E, 0x00, 0x08, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C,
  0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0x01,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFE, 0x0F,
  0x7F, 0xF1, 0xFF, 0x8F, 0xFE, 0xF0, 0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x3F,
  0x80, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 31, 11, 1, -31 },
  { 44, 12, 12, 14, 3, -33 },
  { 62, 22, 31, 23, 1, -31 },
  { 148, 20, 40, 21, 1, -36 },
  { 248, 20, 31, 27, 4, -31 },
  { 326, 21, 31, 24, 1, -31 },
  { 408, 6, 11, 7, 3, -33 },
  { 417, 14, 45, 14, 2, -35 },
  { 496, 14, 45, 14, -2, -35 },
  { 575, 18, 19, 19, 2, -31 },
  { 618, 19, 23, 21, 1, -26 },
  { 673, 9, 13, 10, -3, -5 },
  { 688, 11, 5, 14, 2, -16 },
  { 695, 6, 6, 12, 1, -6 },
  { 700, 20, 34, 15, -3, -31 },
  { 785, 19, 31, 21, 2, -31 },
  { 859, 13, 31, 21, 5, -31 },
  { 910, 21, 31, 21, 0, -31 },
  { 992, 20, 31, 21, 1, -31 },
  { 1070, 20, 31, 21, 0, -31 },
  { 1148, 21, 31, 21, 1, -31 },
  { 1230, 18, 31, 21, 2, -31 },
  { 1300, 21, 31, 21, 2, -31 },
  { 1382, 20, 31, 21, 1, -31 },
  { 1460, 17, 31, 21, 3, -31 },
  { 1526, 9, 24, 12, 1, -24 },
  { 1553, 12, 32, 11, -2, -24 },
  { 1601, 17, 21, 19, 1, -24 },
  { 1646, 18, 14, 21, 2, -21 },
  { 1678, 17, 21, 19, 1, -24 },
  { 1723, 16, 31, 19, 3, -31 },
  { 1785, 30, 41, 33, 1, -31 },
  { 1939, 24, 31, 25, -2, -31 },
  { 2032, 23, 31, 24, 0, -31 },
  { 2122, 22, 31, 24, 2, -31 },
  { 2208, 23, 31, 24, 0, -31 },
  { 2298, 23, 31, 21, 0, -31 },
  { 2388, 22, 31, 20, 0, -31 },
  { 2474, 22, 31, 25, 2, -31 },
  { 2560, 27, 31, 26, 0, -31 },
  { 2665, 11, 31, 11, 1, -31 },
  { 2708, 22, 31, 21, 0, -31 },
  { 2794, 27, 31, 24, 0, -31 },
  { 2899, 18, 31, 20, 0, -31 },
  { 2969, 33, 31, 32, 0, -31 },
  { 3097, 27, 31, 26, 0, -31 },
  { 3202, 23, 31, 26, 2, -31 },
  { 3292, 24, 31, 24, 0, -31 },
  { 3385, 23, 37, 26, 2, -31 },
  { 3492, 23, 31, 23, 0, -31 },
  { 3582, 22, 31, 23, 1, -31 },
  { 3668, 22, 31, 23, 3, -31 },
  { 3754, 24, 31, 24, 1, -31 },
  { 3847, 24, 31, 25, 3, -31 },
  { 3940, 30, 31, 32, 4, -31 },
  { 4057, 27, 31, 24, -1, -31 },
  { 4162, 22, 31, 23, 4, -31 },
  { 4248, 25, 31, 23, -1, -31 },
  { 4345, 15, 43, 11, -1, -36 },
  { 4426, 10, 34, 16, 4, -31 },
  { 4469, 14, 43, 11, -2, -36 },
  { 4545, 15, 16, 16, 1, -31 },
  { 4575, 17, 4, 17, -3, 0 },
  { 4584, 9, 7, 14, 4, -33 },
  { 4592, 18, 23, 20, 1, -23 },
  { 4644, 20, 33, 21, 0, -33 },
  { 4727, 18, 23, 20, 1, -23 },
  { 4779, 21, 33, 21, 1, -33 },
  { 4866, 18, 23, 20, 1, -23 },
  { 4918, 16, 33, 14, 1, -33 },
  { 4984, 21, 32, 21, 0, -23 },
  { 5068, 19, 33, 21, 0, -33 },
  { 5147, 11, 32, 11, 0, -32 },
  { 5191, 16, 41, 10, -5, -32 },
  { 5273, 21, 33, 20, 0, -33 },
  { 5360, 11, 33, 11, 0, -33 },
  { 5406, 30, 23, 32, 0, -23 },
  { 5493, 19, 23, 21, 0, -23 },
  { 5548, 19, 23, 21, 1, -23 },
  { 5603, 21, 32, 21, -1, -23 },
  { 5687, 20, 32, 21, 1, -23 },
  { 5767, 15, 23, 14, 0, -23 },
  { 5811, 18, 23, 19, 0, -23 },
  { 5863, 12, 29, 13, 2, -29 },
  { 5907, 20, 23, 21, 1, -23 },
  { 5965, 18, 23, 19, 2, -23 },
  { 6017, 25, 23, 27, 3, -23 },
  { 6089, 21, 23, 19, -1, -23 },
  { 6150, 21, 32, 19, -1, -23 },
  { 6234, 20, 23, 19, -1, -23 },
  { 6292, 14, 42, 13, 1, -34 },
  { 6366, 9, 37, 11, 1, -31 },
  { 6408, 14, 42, 13, -2, -34 },
  { 6482, 20, 10, 24, 2, -18 },
};

const GFXfont RobotoCondensed_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_SEMIBOLDITALIC44PT7B_H_
