#ifndef _NOTOSANS_CONDENSED_BLACKITALIC65PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x1F, 0xFC, 0xFF, 0xE3,
  0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xC7, 0xE0,
  0x1F, 0xF9, 0xE0, 0xE0, 0x0F, 0xFC, 0xF0, 0x10, 0x07, 0xFE, 0x78, 0x00,
  0x03, 0xFF, 0x78, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0x7F, 0xE0, 0x00, 0x07, 0x9F, 0xF0, 0x20, 0x03, 0xCF, 0xF8, 0x18, 0x01,
  0xE7, 0xFC, 0x0F, 0x00, 0xF3, 0xFE, 0x07, 0xE0, 0xF3, 0xFF, 0x03, 0xFE,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x07, 0xFC, 0x00,
  0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0x87, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x7F, 0xC0,
  0x20, 0x1F, 0xE3, 0xFE, 0x3F, 0xC1, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3,
  0xFF, 0xC7, 0xF9, 0xFF, 0x3F, 0xE3, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xE3,
  0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0x8F, 0xF9,
  0xFF, 0x3F, 0xE3, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xF8,
  0x07, 0xFF, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x08, 0x07, 0xFC, 0x00, 0x70,
  0x3F, 0xC0, 0x03, 0xC1, 0xFE, 0x00, 0x1F, 0x8F, 0xF0, 0x01, 0xFF, 0x7F,
  0x81, 0x8F, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xFC, 0x01,
  0xF8, 0x7F, 0xE0, 0x07, 0x81, 0xFE, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x40,
  0x78, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x07,
  0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0x03, 0xFF,
  0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC,
  0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF,
  0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0xBF, 0xF8, 0x3F,
  0xCF, 0xFE, 0x03, 0xF1, 0xFF, 0xC0, 0x3C, 0x3F, 0xF8, 0x07, 0x07, 0xFF,
  0x00, 0x41, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x3F, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x1E, 0x01, 0xFF,
  0xC0, 0x07, 0x00, 0xFF, 0xF0, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xFF, 0xC0, 0x1E, 0x01, 0xFF, 0xE0, 0x04,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x10, 0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x0F, 0xFF, 0x87, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xDF, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xEF,
  0xFE, 0x00, 0x1F, 0xE7, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xE0, 0x0F, 0xF8,
  0x7F, 0xF0, 0x07, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x3F, 0xF8, 0x07, 0xFC,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x01, 0xFF,
  0xF0, 0xE0, 0x03, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xF4, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x0F,
  0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x8F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x7F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x9F, 0xFE, 0x0F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xF1, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0x1F, 0xF8, 0x00,
  0x70, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x10, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0xF0, 0xF8, 0x1F, 0xFC, 0x30, 0x07, 0xFF,
  0x08, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x07, 0xFF, 0xFC,
  0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x87, 0xFE, 0x7F, 0x83,
  0xF9, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE7, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xDF, 0xE1, 0xFE, 0x07, 0xF0, 0x7F,
  0xBF, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC,
  0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFB, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF7,
  0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xEF, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0x9F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x3F, 0x87, 0xF8, 0x3F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x80,
  0x7C, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xC0, 0x3F, 0xFF, 0x00, 0x30, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x02, 0x00, 0xFF, 0xF8, 0x03, 0x80, 0x3F, 0xFF, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xBC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x0F, 0xFF,
  0xC0, 0x03, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x41, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x00, 0x7F, 0xF3, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x0F, 0xFB,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC7,
  0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x3F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF,
  0xF3, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x9F, 0xF7, 0xFF, 0x00, 0x7F,
  0xF7, 0xFC, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xBF, 0xEF, 0xF9, 0xFF, 0xC0,
  0x1F, 0xF9, 0xFF, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC7, 0xFF, 0x00, 0x7F,
  0xF7, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF9,
  0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F,
  0xF7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x8F, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x07,
  0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF,
  0xCF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE,
  0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF9,
  0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xF3,
  0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07,
  0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xC7,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0x9F,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF,
  0x8F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x7F, 0xF8, 0x07, 0x00, 0x3F, 0xF8,
  0x00, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x18, 0x00, 0x3F, 0xF8, 0x0E, 0x00, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F,
  0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x87,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF8, 0xFF, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xFF,
  0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF,
  0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xCF, 0xFB, 0xFE, 0xFF, 0xE0, 0x07, 0xFE,
  0xFF, 0xDF, 0xF7, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0xBF, 0xE7, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0x3F, 0xF0,
  0x1F, 0xFF, 0xDF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFF, 0xBF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x08, 0x00, 0x0F, 0xFE, 0x7F, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0x1F,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0x07, 0x03, 0xFF, 0xC0, 0x10, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x40, 0xFF, 0xE0, 0x08, 0x0F, 0xFF, 0x03,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x02, 0x01, 0xFF, 0xC0, 0x01,
  0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF7, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xC7, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xC1, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x08, 0x3F, 0xF8, 0x00, 0xC0, 0xFF, 0xF0, 0x1F, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x18, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xF0, 0x07,
  0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x00,
  0x40, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x10, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0x87, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x0C, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x03,
  0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x7F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xC7, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F,
  0xF7, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x3F, 0xE7,
  0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF,
  0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F,
  0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xBF, 0xF8, 0x1F, 0xFC,
  0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x3F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xE7, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0,
  0x1F, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xF0, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x0E, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F,
  0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0xF8, 0x0F,
  0xFE, 0x03, 0x00, 0xFF, 0xE0, 0x10, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x07, 0xFF, 0x0F, 0x00,
  0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC1, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0xC0,
  0x3F, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFB, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF,
  0x9F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xF9, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x00, 0xFF,
  0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFB, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xCF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFE,
  0x3F, 0xF0, 0x7F, 0xFE, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0x8F, 0xFE, 0x0F,
  0xFC, 0xFF, 0xFF, 0x1F, 0xF8, 0x1F, 0xF9, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F,
  0xF3, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xF7, 0xF9, 0xFF, 0x80, 0xFF,
  0xDF, 0xEF, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xDF, 0xEF, 0xFC, 0x03, 0xFF,
  0xFF, 0x3F, 0xDF, 0xF8, 0x07, 0xFD, 0xFE, 0x7F, 0xFF, 0xE0, 0x0F, 0xFB,
  0xF8, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF,
  0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFD, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFD, 0x00, 0x00,
  0xFF, 0x80,
};

const GFXglyph NotoSans_Condensed_BlackItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 21, 47, 18, 0, -46 },
  { 125, 27, 16, 29, 6, -46 },
  { 179, 38, 46, 37, 0, -46 },
  { 398, 33, 53, 33, 1, -49 },
  { 617, 49, 48, 54, 4, -47 },
  { 911, 42, 48, 41, 0, -47 },
  { 1163, 13, 16, 16, 6, -46 },
  { 1189, 24, 58, 20, 1, -48 },
  { 1363, 24, 58, 20, -5, -48 },
  { 1537, 29, 31, 31, 4, -50 },
  { 1650, 29, 32, 34, 3, -39 },
  { 1766, 17, 18, 18, -4, -9 },
  { 1805, 19, 10, 20, 1, -22 },
  { 1829, 12, 12, 18, 0, -11 },
  { 1847, 36, 48, 27, -3, -47 },
  { 2063, 31, 48, 33, 2, -47 },
  { 2249, 27, 46, 33, 5, -46 },
  { 2405, 34, 47, 33, -2, -47 },
  { 2605, 33, 48, 33, 0, -47 },
  { 2803, 33, 46, 33, 0, -46 },
  { 2993, 32, 47, 33, 1, -46 },
  { 3181, 33, 48, 33, 2, -47 },
  { 3379, 34, 46, 33, 2, -46 },
  { 3575, 32, 48, 33, 1, -47 },
  { 3767, 31, 48, 33, 2, -47 },
  { 3953, 18, 37, 18, 0, -36 },
  { 4037, 22, 45, 18, -4, -36 },
  { 4161, 29, 33, 34, 3, -40 },
  { 4281, 29, 23, 34, 3, -34 },
  { 4365, 29, 33, 34, 3, -40 },
  { 4485, 26, 48, 27, 3, -47 },
  { 4641, 47, 52, 50, 2, -47 },
  { 4947, 37, 47, 37, -4, -47 },
  { 5165, 36, 46, 36, 0, -46 },
  { 5372, 34, 48, 34, 3, -47 },
  { 5576, 38, 46, 38, 0, -46 },
  { 5795, 33, 46, 30, 0, -46 },
  { 5985, 33, 46, 30, 0, -46 },
  { 6175, 37, 48, 39, 3, -47 },
  { 6397, 41, 46, 40, 0, -46 },
  { 6633, 32, 46, 25, -2, -46 },
  { 6817, 32, 61, 20, -10, -46 },
  { 7061, 42, 46, 36, 0, -46 },
  { 7303, 26, 46, 28, 0, -46 },
  { 7453, 53, 46, 51, 0, -46 },
  { 7758, 45, 46, 43, 0, -46 },
  { 8017, 37, 48, 41, 3, -47 },
  { 8239, 35, 46, 34, 0, -46 },
  { 8441, 37, 58, 41, 3, -47 },
  { 8710, 35, 46, 36, 0, -46 },
  { 8912, 33, 48, 30, 0, -47 },
  { 9110, 30, 46, 30, 5, -46 },
  { 9283, 38, 47, 38, 3, -46 },
  { 9507, 35, 46, 36, 6, -46 },
  { 9709, 53, 46, 52, 5, -46 },
  { 10014, 45, 46, 36, -4, -46 },
  { 10273, 34, 46, 34, 6, -46 },
  { 10469, 38, 46, 30, -3, -46 },
  { 10688, 28, 59, 20, -3, -48 },
  { 10895, 16, 48, 27, 7, -47 },
  { 10991, 28, 59, 20, -5, -48 },
  { 11198, 33, 30, 32, -1, -46 },
  { 11322, 28, 8, 26, -6, 4 },
  { 11350, 15, 11, 22, 9, -50 },
  { 11371, 33, 38, 34, 1, -37 },
  { 11528, 33, 50, 34, 0, -49 },
  { 11735, 28, 38, 28, 2, -37 },
  { 11868, 36, 50, 34, 1, -49 },
  { 12093, 30, 38, 32, 2, -37 },
  { 12236, 36, 66, 22, -7, -50 },
  { 12533, 35, 53, 34, -1, -37 },
  { 12765, 33, 49, 34, 0, -49 },
  { 12968, 21, 50, 18, 0, -50 },
  { 13100, 29, 66, 18, -8, -50 },
  { 13340, 38, 49, 34, 0, -49 },
  { 13573, 21, 49, 18, 0, -49 },
  { 13702, 49, 37, 51, 0, -37 },
  { 13929, 33, 37, 34, 0, -37 },
  { 14082, 30, 38, 34, 2, -37 },
  { 14225, 37, 53, 34, -4, -37 },
  { 14471, 33, 53, 34, 1, -37 },
  { 14690, 28, 37, 25, 0, -37 },
  { 14820, 28, 38, 27, 0, -37 },
  { 14953, 23, 44, 24, 3, -43 },
  { 15080, 33, 37, 34, 2, -36 },
  { 15233, 31, 36, 31, 4, -36 },
  { 15373, 47, 36, 47, 4, -36 },
  { 15585, 39, 36, 32, -4, -36 },
  { 15761, 39, 52, 31, -4, -36 },
  { 16015, 31, 36, 27, -2, -36 },
  { 16155, 28, 56, 23, 0, -46 },
  { 16351, 9, 65, 29, 10, -50 },
  { 16425, 27, 56, 23, -4, -46 },
  { 16614, 29, 12, 34, 3, -29 },
};

const GFXfont NotoSans_Condensed_BlackItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC65PT7B_H_
