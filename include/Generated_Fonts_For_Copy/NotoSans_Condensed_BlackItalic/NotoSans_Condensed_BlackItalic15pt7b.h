#ifndef _NOTOSANS_CONDENSED_BLACKITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0xE7, 0x31, 0x80, 0x47, 0x38, 0x6E, 0xD9, 0xB7, 0x60,
  0x0D, 0x0D, 0x86, 0xCF, 0xF7, 0xF9, 0xB3, 0xFD, 0xFE, 0x6C, 0x36, 0x36,
  0x00, 0x04, 0x3F, 0x3E, 0x78, 0x78, 0x3C, 0x1E, 0x96, 0xFE, 0xFC, 0x10,
  0x20, 0x30, 0xCF, 0x33, 0x6C, 0x6D, 0x8D, 0xE5, 0xEF, 0xDB, 0x78, 0xDB,
  0x1B, 0x66, 0x7D, 0x87, 0x00, 0x0E, 0x07, 0xC3, 0x70, 0xDC, 0x3E, 0x0F,
  0x77, 0xFB, 0xBC, 0xEF, 0x3F, 0xC7, 0xF8, 0x6D, 0xF0, 0x1C, 0x63, 0x0C,
  0x61, 0x86, 0x38, 0xE3, 0x8E, 0x38, 0x60, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x39, 0x8C, 0xCE, 0x00, 0x20, 0x33, 0x47, 0xF3, 0xFF, 0x1F, 0x08, 0x30,
  0xC3, 0x3F, 0xFC, 0xC3, 0x00, 0x76, 0x6C, 0xFF, 0x80, 0x5F, 0x80, 0x03,
  0x83, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x38, 0x00,
  0x0C, 0x3E, 0x36, 0x77, 0x76, 0x66, 0x66, 0xEE, 0x6C, 0x7C, 0x78, 0x0C,
  0x77, 0xFF, 0x58, 0x63, 0x8E, 0x38, 0xC3, 0x00, 0x1C, 0xFC, 0xD9, 0x30,
  0xE3, 0x86, 0x18, 0x61, 0xFB, 0xF0, 0x1C, 0x3E, 0x27, 0x06, 0x3E, 0x38,
  0x3E, 0x0E, 0x8E, 0xFC, 0xF8, 0x07, 0x0E, 0x0E, 0x1E, 0x3E, 0x6E, 0x6C,
  0xFE, 0xFE, 0x1C, 0x18, 0x1F, 0x3E, 0x3E, 0x30, 0x7C, 0x7E, 0x0E, 0x0E,
  0x8E, 0xFC, 0xF8, 0x1E, 0x7D, 0xC7, 0x0F, 0xDF, 0xB3, 0x6E, 0xDD, 0xF3,
  0xC0, 0x3F, 0x3F, 0x7F, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0xE0,
  0x1E, 0x3E, 0x37, 0x36, 0x3E, 0x3C, 0x7E, 0xEE, 0xEE, 0xFC, 0x78, 0x1C,
  0x3E, 0x76, 0x77, 0x76, 0x7E, 0x7E, 0x0E, 0x1C, 0xF8, 0xF0, 0x77, 0x00,
  0x04, 0xEE, 0x39, 0xC0, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x04, 0x77, 0xB8,
  0xF8, 0xF0, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x7F, 0xCC,
  0x00, 0x7B, 0xF5, 0xC7, 0x39, 0xC6, 0x20, 0x43, 0x8C, 0x00, 0x07, 0x83,
  0xF8, 0xC1, 0x93, 0xD6, 0xDA, 0xB2, 0x56, 0xDE, 0xDB, 0xDD, 0xCC, 0x01,
  0xCC, 0x1F, 0x80, 0x07, 0x07, 0x83, 0xC1, 0xE1, 0xB0, 0xDC, 0xEE, 0x7F,
  0x7F, 0xB9, 0xF8, 0xE0, 0x3E, 0x3F, 0x37, 0x33, 0x7F, 0x7C, 0x7E, 0x67,
  0x6E, 0xFE, 0xFC, 0x1E, 0x3F, 0x76, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xE4,
  0xFC, 0x7C, 0x3C, 0x1F, 0x8F, 0xC6, 0x77, 0x3B, 0x9D, 0xCC, 0xCE, 0x6E,
  0x7F, 0x3E, 0x00, 0x3F, 0x3E, 0x3E, 0x30, 0x7E, 0x7C, 0x7C, 0x60, 0x60,
  0xFC, 0xF8, 0x3F, 0x3E, 0x3E, 0x30, 0x70, 0x7C, 0x7C, 0x60, 0x60, 0xE0,
  0xE0, 0x1E, 0x3F, 0x7A, 0xE0, 0xE1, 0xEE, 0xDE, 0xCE, 0xEE, 0xFE, 0x7C,
  0x39, 0xCE, 0x63, 0x38, 0xCE, 0x7F, 0x9F, 0xC7, 0xF1, 0x9C, 0x67, 0x39,
  0xCE, 0x60, 0x1F, 0x3F, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x7C,
  0xFC, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xCF,
  0x1C, 0x00, 0x39, 0xCE, 0xE3, 0x70, 0xDC, 0x7E, 0x1F, 0x07, 0xC1, 0xB8,
  0x6E, 0x3B, 0x8E, 0x70, 0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x18, 0x63, 0xFF,
  0xC0, 0x3C, 0x73, 0xCF, 0x3C, 0xF3, 0xDF, 0x7D, 0xE7, 0xFE, 0x6F, 0x66,
  0xFE, 0x6E, 0xEE, 0xEC, 0xEC, 0xC0, 0x38, 0xCE, 0x33, 0xDC, 0xF7, 0x7D,
  0x9F, 0x66, 0xF9, 0xBE, 0x67, 0xB9, 0xCE, 0x70, 0x1E, 0x3F, 0x77, 0xE3,
  0xE7, 0xE7, 0xC7, 0xC7, 0xEE, 0xFC, 0x78, 0x3C, 0x3F, 0x3F, 0x37, 0x77,
  0x7F, 0x7E, 0x60, 0x60, 0xE0, 0xE0, 0x1E, 0x3F, 0x77, 0xE3, 0xE7, 0xE7,
  0xC7, 0xC7, 0xEE, 0xFC, 0x78, 0x1C, 0x1C, 0x1C, 0x3C, 0x3F, 0x37, 0x37,
  0x77, 0x7E, 0x7C, 0x6C, 0x6E, 0xEE, 0xE7, 0x1E, 0x3F, 0x7E, 0x70, 0x78,
  0x3C, 0x1C, 0x0C, 0x9C, 0xFC, 0xF8, 0x7F, 0xFF, 0xF9, 0x83, 0x0E, 0x1C,
  0x38, 0x60, 0xC3, 0x80, 0x73, 0x77, 0x67, 0x67, 0xE6, 0xE6, 0xEE, 0xCE,
  0xCE, 0xFC, 0x78, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE7, 0x61, 0xF0, 0xF0,
  0x78, 0x38, 0x1C, 0x00, 0xE6, 0x3E, 0x67, 0xEE, 0x7E, 0xE6, 0xEE, 0xEF,
  0xEC, 0xFF, 0xCF, 0x7C, 0xF7, 0x8F, 0x78, 0xE7, 0x00, 0x19, 0xC7, 0x71,
  0xF8, 0x7C, 0x0F, 0x03, 0x81, 0xE0, 0xF8, 0x3F, 0x1D, 0xCE, 0x70, 0xE7,
  0x66, 0x6E, 0x6C, 0x7C, 0x78, 0x70, 0x70, 0x70, 0x70, 0x60, 0x1F, 0x9F,
  0xCF, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x3F, 0x3F, 0x80, 0x1E,
  0x38, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x07, 0x1E, 0x00,
  0xDB, 0x6D, 0xBB, 0x6D, 0x80, 0x1C, 0xF0, 0xC7, 0x18, 0x61, 0x86, 0x38,
  0xC3, 0x0C, 0xF3, 0x80, 0x0C, 0x18, 0x71, 0xE3, 0x6C, 0xF9, 0x80, 0xFF,
  0xF0, 0xE7, 0x3F, 0x7F, 0x76, 0x66, 0xEE, 0xEE, 0xFE, 0x7C, 0x38, 0x30,
  0x30, 0x3E, 0x7E, 0x77, 0x66, 0x66, 0xEE, 0xFC, 0xDC, 0x3E, 0xF9, 0xC3,
  0x0E, 0x1C, 0x9E, 0x3C, 0x03, 0x81, 0x81, 0xC7, 0xE7, 0xF3, 0xB1, 0x99,
  0xDC, 0xEE, 0x7F, 0x1F, 0x00, 0x3E, 0xED, 0x9B, 0xFF, 0x9C, 0x1F, 0x3E,
  0x07, 0x87, 0x83, 0x83, 0xE1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x0F, 0x07, 0x81, 0x00, 0x3B, 0x7F, 0x66, 0x66, 0xEE, 0xEE, 0xFE,
  0x7C, 0x0C, 0x9C, 0xF8, 0x60, 0x38, 0x30, 0x30, 0x3E, 0x7F, 0x76, 0x66,
  0x66, 0xEE, 0xEE, 0xEC, 0x11, 0xCC, 0x03, 0x39, 0xCC, 0x67, 0x39, 0xC0,
  0x04, 0x1C, 0x30, 0x00, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x1E,
  0x3C, 0x60, 0x38, 0x18, 0x0C, 0x2E, 0xE7, 0xE3, 0xE1, 0xF0, 0xF8, 0xEC,
  0x77, 0x3B, 0x80, 0x39, 0x8C, 0x67, 0x39, 0x8C, 0xE7, 0x38, 0x3E, 0xEF,
  0xFD, 0xDD, 0xB3, 0x36, 0x6F, 0xDD, 0xFB, 0xB7, 0x66, 0x3E, 0x7F, 0x76,
  0x66, 0x66, 0xEE, 0xEE, 0xEC, 0x3E, 0xFD, 0x9B, 0x3E, 0x7D, 0xDF, 0x3C,
  0x1F, 0x1F, 0x8E, 0xE6, 0x63, 0x33, 0xB9, 0xF8, 0xDC, 0x60, 0x30, 0x38,
  0x1C, 0x00, 0x3B, 0x7F, 0x76, 0x66, 0xEE, 0xEE, 0xFC, 0x7C, 0x0C, 0x1C,
  0x1C, 0x18, 0x3D, 0xF7, 0x18, 0x63, 0x8E, 0x38, 0x7D, 0xF7, 0x1E, 0x3A,
  0x7F, 0xBE, 0x33, 0x3F, 0xFE, 0x73, 0x18, 0xF7, 0x80, 0x77, 0x77, 0x76,
  0x66, 0x6E, 0xEE, 0xFE, 0x7C, 0xCF, 0x9B, 0x76, 0xCF, 0x9E, 0x3C, 0x70,
  0xCE, 0xFB, 0xFB, 0x76, 0x7A, 0xCF, 0xF9, 0xFE, 0x3B, 0xC7, 0x70, 0x3B,
  0x8F, 0x87, 0x83, 0xC1, 0xE1, 0xF1, 0xF9, 0xCE, 0x33, 0x99, 0x8D, 0xC6,
  0xC3, 0xE1, 0xE0, 0xF0, 0x30, 0x38, 0x78, 0x3C, 0x18, 0x00, 0x3F, 0x3E,
  0x0C, 0x1C, 0x38, 0x32, 0x7C, 0xFC, 0x0C, 0x73, 0x8E, 0x31, 0xCE, 0x38,
  0x71, 0x86, 0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xE1, 0x86, 0x18,
  0x61, 0xCF, 0x30, 0xC7, 0x3C, 0xE0, 0xE7, 0xFB, 0xC0,
};

const GFXglyph NotoSans_Condensed_BlackItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 9, 11, 8, 0, -11 },
  { 25, 8, 12, 8, 0, -11 },
  { 37, 11, 11, 13, 1, -11 },
  { 53, 10, 11, 10, 0, -11 },
  { 67, 3, 4, 4, 1, -11 },
  { 69, 6, 13, 5, 0, -11 },
  { 79, 5, 13, 5, -1, -11 },
  { 88, 7, 8, 7, 1, -12 },
  { 95, 6, 7, 8, 1, -9 },
  { 101, 4, 4, 4, -1, -2 },
  { 103, 5, 2, 5, 0, -5 },
  { 105, 3, 3, 4, 0, -3 },
  { 107, 9, 11, 6, -1, -11 },
  { 120, 8, 11, 8, 0, -11 },
  { 131, 6, 11, 8, 1, -11 },
  { 140, 7, 11, 8, 0, -11 },
  { 150, 8, 11, 8, 0, -11 },
  { 161, 8, 11, 8, 0, -11 },
  { 172, 8, 11, 8, 0, -11 },
  { 183, 7, 11, 8, 1, -11 },
  { 193, 8, 11, 8, 0, -11 },
  { 204, 8, 11, 8, 0, -11 },
  { 215, 8, 11, 8, 0, -11 },
  { 226, 4, 8, 4, 0, -8 },
  { 230, 5, 10, 4, -1, -8 },
  { 237, 6, 7, 8, 1, -9 },
  { 243, 6, 5, 8, 1, -8 },
  { 247, 6, 7, 8, 1, -9 },
  { 253, 6, 11, 6, 1, -11 },
  { 262, 11, 12, 11, 0, -11 },
  { 279, 9, 11, 9, -1, -11 },
  { 292, 8, 11, 8, 0, -11 },
  { 303, 8, 11, 8, 1, -11 },
  { 314, 9, 11, 9, 0, -11 },
  { 327, 8, 11, 7, 0, -11 },
  { 338, 8, 11, 7, 0, -11 },
  { 349, 8, 11, 9, 1, -11 },
  { 360, 10, 11, 9, 0, -11 },
  { 374, 8, 11, 6, -1, -11 },
  { 385, 7, 14, 5, -2, -11 },
  { 398, 10, 11, 8, 0, -11 },
  { 412, 6, 11, 7, 0, -11 },
  { 421, 12, 11, 12, 0, -11 },
  { 438, 10, 11, 10, 0, -11 },
  { 452, 8, 11, 9, 1, -11 },
  { 463, 8, 11, 8, 0, -11 },
  { 474, 8, 14, 9, 1, -11 },
  { 488, 8, 11, 8, 0, -11 },
  { 499, 8, 11, 7, 0, -11 },
  { 510, 7, 11, 7, 1, -11 },
  { 520, 8, 11, 9, 1, -11 },
  { 531, 9, 11, 8, 1, -11 },
  { 544, 12, 11, 12, 1, -11 },
  { 561, 10, 11, 8, -1, -11 },
  { 575, 8, 11, 8, 1, -11 },
  { 586, 9, 11, 7, -1, -11 },
  { 599, 7, 14, 5, -1, -11 },
  { 612, 3, 11, 6, 2, -11 },
  { 617, 6, 14, 5, -1, -11 },
  { 628, 7, 7, 7, 0, -11 },
  { 635, 6, 2, 6, -1, 1 },
  { 637, 4, 2, 5, 2, -11 },
  { 638, 8, 8, 8, 0, -8 },
  { 646, 8, 11, 8, 0, -11 },
  { 657, 7, 8, 6, 0, -8 },
  { 664, 9, 11, 8, 0, -11 },
  { 677, 7, 8, 7, 0, -8 },
  { 684, 9, 15, 5, -2, -11 },
  { 701, 8, 12, 8, 0, -8 },
  { 713, 8, 11, 8, 0, -11 },
  { 724, 5, 12, 4, 0, -12 },
  { 732, 7, 16, 4, -2, -12 },
  { 746, 9, 11, 8, 0, -11 },
  { 759, 5, 11, 4, 0, -11 },
  { 766, 11, 8, 12, 0, -8 },
  { 777, 8, 8, 8, 0, -8 },
  { 785, 7, 8, 8, 0, -8 },
  { 792, 9, 12, 8, -1, -8 },
  { 806, 8, 12, 8, 0, -8 },
  { 818, 6, 8, 6, 0, -8 },
  { 824, 6, 8, 6, 0, -8 },
  { 830, 5, 10, 6, 1, -10 },
  { 837, 8, 8, 8, 0, -8 },
  { 845, 7, 8, 7, 1, -8 },
  { 852, 11, 8, 11, 1, -8 },
  { 863, 9, 8, 7, -1, -8 },
  { 872, 9, 12, 7, -1, -8 },
  { 886, 8, 8, 6, -1, -8 },
  { 894, 6, 13, 5, 0, -11 },
  { 904, 2, 15, 7, 2, -12 },
  { 908, 6, 13, 5, -1, -11 },
  { 918, 6, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_BlackItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC15PT7B_H_
