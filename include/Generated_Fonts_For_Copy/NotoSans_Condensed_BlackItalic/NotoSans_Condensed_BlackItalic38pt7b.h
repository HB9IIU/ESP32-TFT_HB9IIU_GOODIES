#ifndef _NOTOSANS_CONDENSED_BLACKITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0xFC, 0xFC, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07,
  0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x78, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x3C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x81,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E,
  0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xB3, 0x83, 0xEE, 0x10, 0x7D, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x8C, 0x19, 0xF1, 0xC3, 0x7E,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x7C, 0x07, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E,
  0x03, 0xFF, 0x83, 0xE0, 0x3E, 0x7C, 0x3E, 0x01, 0xF3, 0xE1, 0xF0, 0x0F,
  0x9F, 0x1F, 0x00, 0xF8, 0xF8, 0xF8, 0x07, 0xC7, 0xCF, 0x80, 0x3E, 0x7C,
  0xF8, 0x01, 0xF3, 0xE7, 0xC7, 0x0F, 0x9F, 0x7C, 0xFE, 0x7F, 0xF3, 0xCF,
  0xFB, 0xFF, 0x3E, 0xFF, 0xCF, 0xFB, 0xE7, 0xFF, 0x3F, 0x1F, 0x7C, 0xF8,
  0x61, 0xF3, 0xE7, 0xC0, 0x1F, 0x1F, 0x3E, 0x00, 0xF9, 0xF1, 0xF0, 0x0F,
  0x8F, 0x8F, 0x00, 0x7C, 0x7C, 0xF8, 0x07, 0xC3, 0xE7, 0xC0, 0x7C, 0x1F,
  0x7E, 0x03, 0xE0, 0xFF, 0xE0, 0x3E, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xF0,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0x0F, 0xFC,
  0x7F, 0x1F, 0xFE, 0x7E, 0x3F, 0xFF, 0xFE, 0x7F, 0x7F, 0xFC, 0x7E, 0x7F,
  0xFC, 0xFE, 0x3F, 0xF8, 0xFE, 0x3F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0x3F,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xF3, 0xFC, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x63, 0xE0, 0x73, 0xE0,
  0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x07, 0xFF, 0x0F, 0xE3,
  0x3F, 0xF0, 0x7F, 0xF0, 0xFE, 0xF8, 0x3C, 0xFC, 0x1C, 0xFC, 0x08, 0x70,
  0x00, 0x40, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC,
  0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x00, 0x7F, 0xEF, 0xFD, 0xFF,
  0xBF, 0xF7, 0xFD, 0xFF, 0x80, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xFD, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xCF, 0xE3,
  0xF3, 0xF0, 0xFD, 0xFC, 0x3F, 0x7F, 0x1F, 0xDF, 0x87, 0xF7, 0xE1, 0xFD,
  0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xE3, 0xFB, 0xF8, 0xFC, 0xFC,
  0x7F, 0x3F, 0x9F, 0x8F, 0xEF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x7D,
  0xFC, 0x39, 0xF8, 0x11, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0x04, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xEF, 0xF0, 0x38, 0x7F, 0x01, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xC3, 0xF8, 0x20, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF9, 0x00,
  0x7F, 0x3C, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xFB, 0xF8, 0x3E,
  0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x88, 0x0F, 0xF1, 0xC3,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFD, 0xFC, 0xFF, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F,
  0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0xFE, 0x1F, 0x9F, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xF7, 0xF1,
  0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x8F, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xDF, 0xC7, 0xF7, 0xF1,
  0xFD, 0xFC, 0x7F, 0x7F, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xF3, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x08, 0x3F, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x83, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xE7, 0xFF, 0xCE, 0x3F, 0x90, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xE3, 0xFC,
  0x07, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x0F, 0x81, 0x81, 0xE1, 0xF0,
  0xFF, 0xDE, 0x1E, 0x1F, 0xF9, 0xF3, 0xE3, 0xFF, 0x9F, 0x3C, 0x7C, 0xF9,
  0xF7, 0xCF, 0x8F, 0x9F, 0x78, 0xF8, 0xF1, 0xF7, 0x8F, 0x0F, 0x1E, 0xF9,
  0xF1, 0xF1, 0xEF, 0x9F, 0x1F, 0x1E, 0xF9, 0xE1, 0xE3, 0xCF, 0x1E, 0x3E,
  0x3C, 0xF1, 0xF3, 0xE7, 0x8F, 0x1F, 0xFF, 0xF8, 0xF1, 0xFF, 0xFF, 0x0F,
  0x8F, 0xCF, 0xE0, 0xF8, 0x78, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x10, 0x03, 0xF0, 0x0E, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F,
  0x81, 0xFC, 0x7E, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0x9F, 0xC0,
  0x7E, 0x7F, 0x01, 0xFB, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xF3, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x3F,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7E, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0x9F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xC7, 0x83, 0xFC, 0x08, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x81, 0xFE, 0x78, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF0, 0x7F, 0x0F, 0xC3, 0xFC, 0x7F, 0x1F, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xC3, 0x87, 0xF8, 0x04, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0x7F, 0x1F,
  0xF3, 0xF8, 0xFF, 0x9F, 0xCF, 0xFC, 0xFE, 0x7F, 0xE7, 0xE3, 0xFF, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xFE, 0x7F,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0x0F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0xC0, 0x3F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF,
  0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF,
  0xE0, 0xFD, 0xF3, 0xEF, 0xC1, 0xFB, 0xE7, 0xFF, 0x83, 0xF7, 0xDF, 0x7E,
  0x07, 0xEF, 0xBE, 0xFC, 0x1F, 0xDF, 0xFD, 0xF8, 0x3F, 0x3F, 0xF7, 0xF0,
  0x7E, 0x7F, 0xEF, 0xC0, 0xFC, 0xFF, 0x9F, 0x81, 0xF9, 0xFF, 0x3F, 0x07,
  0xF3, 0xFC, 0x7E, 0x0F, 0xC7, 0xF9, 0xFC, 0x1F, 0x8F, 0xE3, 0xF0, 0x3F,
  0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x83, 0xF0,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xC1, 0xFF, 0x03, 0xF0, 0x7F, 0xC0,
  0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0x81, 0xFF, 0x07, 0xE0, 0xFF,
  0xE1, 0xF8, 0x3F, 0xF8, 0xFE, 0x0F, 0xFE, 0x3F, 0x03, 0xFF, 0x8F, 0xC0,
  0xFB, 0xF3, 0xF0, 0x7E, 0xFC, 0xFC, 0x1F, 0xBF, 0x7F, 0x07, 0xEF, 0xDF,
  0x81, 0xFB, 0xF7, 0xE0, 0xFE, 0x7F, 0xF8, 0x3F, 0x1F, 0xFE, 0x0F, 0xC7,
  0xFF, 0x83, 0xF1, 0xFF, 0xC0, 0xFC, 0x7F, 0xF0, 0x7F, 0x0F, 0xFC, 0x1F,
  0x83, 0xFF, 0x07, 0xE0, 0xFF, 0x81, 0xF8, 0x3F, 0xE0, 0x7E, 0x07, 0xF8,
  0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x08, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0x9F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xCF,
  0xC0, 0xFE, 0x7F, 0x0F, 0xF3, 0xFD, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF7,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF1, 0xFC, 0x3F, 0x9F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x7F, 0x9F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F,
  0xCF, 0xC0, 0xFE, 0x7F, 0x0F, 0xF3, 0xFD, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xF3, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7E, 0x3F, 0x83, 0xF1, 0xFC, 0x3F, 0x9F, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFD,
  0xF8, 0x0F, 0xCF, 0xE0, 0x7E, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xC1,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFF, 0x3F, 0x83,
  0xF8, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xF9, 0xE0, 0xFE, 0x04, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x88, 0x07, 0xF0, 0xC0, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x3F,
  0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x83, 0xFB, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFF,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F, 0x07,
  0xF1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0,
  0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0xFF,
  0xFC, 0x1F, 0x81, 0xFB, 0xF8, 0x3F, 0x07, 0xF7, 0xF0, 0xFE, 0x0F, 0xCF,
  0xC1, 0xFC, 0x3F, 0x9F, 0x87, 0xF8, 0x7F, 0x3F, 0x0F, 0xF0, 0xFC, 0x7E,
  0x1F, 0xE3, 0xF8, 0xFC, 0x7F, 0xC7, 0xE1, 0xF8, 0xFF, 0x8F, 0xC3, 0xF3,
  0xFF, 0x3F, 0x87, 0xE7, 0xFE, 0x7E, 0x0F, 0xCF, 0xFD, 0xFC, 0x1F, 0xBF,
  0xFB, 0xF0, 0x3F, 0x7D, 0xF7, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xF0,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF,
  0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x7F,
  0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF7,
  0xE0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF8,
  0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xF8, 0x7C, 0x3F,
  0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xFC, 0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C,
  0x1F, 0x07, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x3F, 0x8F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x07, 0xE7, 0xE1, 0xFE, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7E,
  0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3F, 0x1F, 0xC7, 0xF3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xBF, 0x03, 0xE7, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xDF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xE1,
  0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7,
  0xF3, 0xF9, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7E, 0xFF,
  0x0F, 0x8F, 0x80, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x84, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x08, 0xFE, 0x38, 0xFF,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0xBF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xF7,
  0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF,
  0xF9, 0xF8, 0x7D, 0xFC, 0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0x0F, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x08,
  0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0x90, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x9F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x1F, 0xEF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x00, 0xFB, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x10, 0x0F, 0xE0, 0xE0, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xDF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFC, 0x7F,
  0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC,
  0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC7, 0xF3,
  0xF8, 0xFE, 0x7F, 0x1F, 0x8F, 0xC3, 0xF0, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x9F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0,
  0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xF7, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x9F, 0xC7, 0xE0, 0x7D, 0xFE, 0x7F, 0x83,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xF7,
  0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3,
  0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3,
  0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3,
  0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xFC, 0x00, 0x0F, 0x9F, 0x81,
  0xF7, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xDF, 0xC7,
  0xF3, 0xF8, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0x1F,
  0x87, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0x8F, 0xC3, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE7,
  0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFC, 0x3F, 0xBF, 0x0F, 0xEF, 0xC3, 0xF3, 0xF9, 0xFC, 0xFF,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x03,
  0xE7, 0xE0, 0x1F, 0x7F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7E, 0xFF, 0x03, 0xF3, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE1, 0xFE, 0xFC, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8,
  0xFE, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x1F, 0xCF, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xF3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xBF, 0x03, 0xEF, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0x9F, 0x0F, 0xBF, 0x0F, 0xBF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xF2, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x84,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x81, 0xFC, 0xC1, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0x1F,
  0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xF1, 0xF8,
  0x7E, 0x3F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xF3,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xDF, 0x03, 0xF3,
  0xE0, 0xFE, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0x7E, 0x7F, 0x1F, 0xCF, 0xE3,
  0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xF8, 0x7E, 0xFC, 0x7F,
  0x8F, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC, 0x7F, 0x9F, 0xCF, 0xCF, 0xF9, 0xF8,
  0xFC, 0xFF, 0x9F, 0x8F, 0xDF, 0xFB, 0xF0, 0xFD, 0xFF, 0xBF, 0x0F, 0xDE,
  0xFB, 0xF0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x7F, 0x03,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E,
  0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x9F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFE, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_BlackItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 27, 10, 0, -27 },
  { 42, 16, 10, 17, 3, -27 },
  { 62, 23, 27, 21, 0, -27 },
  { 140, 19, 31, 19, 1, -29 },
  { 214, 29, 28, 32, 2, -28 },
  { 316, 24, 28, 24, 0, -28 },
  { 400, 8, 10, 9, 3, -27 },
  { 410, 14, 34, 12, 1, -28 },
  { 470, 14, 34, 12, -3, -28 },
  { 530, 16, 18, 18, 3, -29 },
  { 566, 17, 19, 20, 2, -23 },
  { 607, 10, 10, 10, -2, -5 },
  { 620, 11, 6, 12, 0, -13 },
  { 629, 7, 7, 10, 0, -7 },
  { 636, 21, 28, 16, -2, -28 },
  { 710, 18, 28, 19, 1, -28 },
  { 773, 16, 27, 19, 3, -27 },
  { 827, 20, 28, 19, -1, -28 },
  { 897, 19, 28, 19, 0, -28 },
  { 964, 19, 27, 19, 0, -27 },
  { 1029, 19, 27, 19, 1, -27 },
  { 1094, 19, 28, 19, 1, -28 },
  { 1161, 20, 27, 19, 1, -27 },
  { 1229, 19, 28, 19, 0, -28 },
  { 1296, 18, 28, 19, 1, -28 },
  { 1359, 11, 21, 11, 0, -21 },
  { 1388, 13, 26, 11, -2, -21 },
  { 1431, 17, 19, 20, 2, -23 },
  { 1472, 17, 13, 20, 2, -20 },
  { 1500, 17, 19, 20, 2, -23 },
  { 1541, 15, 28, 16, 2, -28 },
  { 1594, 28, 30, 29, 1, -27 },
  { 1699, 22, 27, 22, -2, -27 },
  { 1774, 21, 27, 21, 0, -27 },
  { 1845, 21, 28, 20, 1, -28 },
  { 1919, 22, 27, 22, 0, -27 },
  { 1994, 19, 27, 18, 0, -27 },
  { 2059, 19, 27, 17, 0, -27 },
  { 2124, 21, 28, 23, 2, -28 },
  { 2198, 24, 27, 23, 0, -27 },
  { 2279, 18, 27, 15, -1, -27 },
  { 2340, 19, 36, 12, -6, -27 },
  { 2426, 25, 27, 21, 0, -27 },
  { 2511, 15, 27, 17, 0, -27 },
  { 2562, 31, 27, 30, 0, -27 },
  { 2667, 26, 27, 25, 0, -27 },
  { 2755, 21, 28, 24, 2, -28 },
  { 2829, 21, 27, 20, 0, -27 },
  { 2900, 21, 34, 24, 2, -28 },
  { 2990, 21, 27, 21, 0, -27 },
  { 3061, 19, 28, 18, 0, -28 },
  { 3128, 17, 27, 18, 3, -27 },
  { 3186, 22, 27, 22, 2, -27 },
  { 3261, 21, 27, 21, 3, -27 },
  { 3332, 31, 27, 30, 3, -27 },
  { 3437, 26, 27, 21, -2, -27 },
  { 3525, 20, 27, 20, 3, -27 },
  { 3593, 22, 27, 18, -2, -27 },
  { 3668, 17, 34, 12, -2, -28 },
  { 3741, 9, 28, 16, 4, -28 },
  { 3773, 16, 34, 12, -3, -28 },
  { 3841, 20, 18, 18, -1, -27 },
  { 3886, 17, 5, 15, -4, 2 },
  { 3897, 9, 6, 13, 5, -29 },
  { 3904, 19, 21, 20, 1, -21 },
  { 3954, 19, 29, 20, 0, -29 },
  { 4023, 16, 21, 16, 1, -21 },
  { 4065, 21, 29, 20, 1, -29 },
  { 4142, 17, 21, 19, 1, -21 },
  { 4187, 21, 38, 13, -4, -29 },
  { 4287, 21, 30, 20, -1, -21 },
  { 4366, 19, 29, 20, 0, -29 },
  { 4435, 12, 29, 10, 0, -29 },
  { 4479, 17, 38, 10, -5, -29 },
  { 4560, 22, 29, 20, 0, -29 },
  { 4640, 12, 29, 10, 0, -29 },
  { 4684, 29, 21, 30, 0, -21 },
  { 4761, 19, 21, 20, 0, -21 },
  { 4811, 18, 21, 20, 1, -21 },
  { 4859, 21, 30, 20, -2, -21 },
  { 4938, 19, 30, 20, 1, -21 },
  { 5010, 16, 21, 14, 0, -21 },
  { 5052, 16, 21, 16, 0, -21 },
  { 5094, 13, 25, 14, 2, -25 },
  { 5135, 19, 21, 20, 1, -21 },
  { 5185, 19, 21, 18, 2, -21 },
  { 5235, 28, 21, 27, 2, -21 },
  { 5309, 23, 21, 19, -2, -21 },
  { 5370, 22, 30, 18, -2, -21 },
  { 5453, 18, 21, 16, -1, -21 },
  { 5501, 16, 33, 13, 0, -27 },
  { 5567, 5, 38, 17, 6, -29 },
  { 5591, 15, 33, 13, -2, -27 },
  { 5653, 17, 7, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_BlackItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC38PT7B_H_
