#ifndef _NOTOSANS_CONDENSED_BLACKITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x7D, 0xFB, 0xEF, 0x9E, 0x7D, 0xF3, 0xEF,
  0x9E, 0x7C, 0xF3, 0xC7, 0x9E, 0x7C, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC1, 0xE7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x1F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1C, 0x70, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x1F, 0x64, 0x3D,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF9, 0x85, 0xF3, 0xDF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F, 0x80, 0xF0,
  0x7F, 0x83, 0xC1, 0xFF, 0x07, 0x83, 0xDE, 0x1E, 0x0F, 0x3C, 0x78, 0x1E,
  0x78, 0xF0, 0x3C, 0xF3, 0xC0, 0x79, 0xE7, 0x80, 0xF7, 0x9E, 0x31, 0xEF,
  0x79, 0xFB, 0xFE, 0xF7, 0xFF, 0xFB, 0xDF, 0xF7, 0xEF, 0x3D, 0xE0, 0x1E,
  0xF3, 0xC0, 0x79, 0xE7, 0x80, 0xF3, 0xCF, 0x03, 0xC7, 0x9E, 0x0F, 0x0F,
  0x78, 0x1E, 0x1E, 0xF0, 0x78, 0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xC0, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7D, 0xF0, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF3, 0xF1, 0xFF, 0x3E, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFC, 0xFF, 0xCF, 0xCF, 0xF8, 0xFC, 0x7F, 0x0F, 0xCF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFD, 0xFC, 0x7D, 0xF7, 0xBE, 0xFB,
  0xEF, 0x3C, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3C, 0x18, 0xF0, 0x7B, 0x85, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC,
  0x7F, 0x03, 0xFE, 0x1F, 0x78, 0x39, 0xF0, 0x67, 0x80, 0x08, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F,
  0xBF, 0xDF, 0xEF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xF7, 0xC7, 0xCF, 0xCF, 0x9F,
  0xBF, 0x3F, 0x7C, 0x7E, 0xF8, 0xF9, 0xF1, 0xF7, 0xE3, 0xEF, 0x8F, 0xDF,
  0x1F, 0xBE, 0x3E, 0x7C, 0x7C, 0xF9, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x0F, 0xF1, 0xFE, 0x3F,
  0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0x77, 0xC4, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xBF,
  0x06, 0x1F, 0x04, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x3F, 0x08, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x80, 0xFC, 0xE1, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7C,
  0x0F, 0x7C, 0x1E, 0xFC, 0x3C, 0xF8, 0x7C, 0xF8, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x40, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x80, 0xFC,
  0xF1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x01, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x70, 0x7D, 0xF8, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF, 0xEF, 0xCF, 0xDF, 0x9F,
  0xBE, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xFB, 0xF3, 0xFF, 0xC3, 0xFF, 0x83,
  0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F,
  0x1F, 0x3E, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xCF, 0xCF, 0x9F, 0x9F, 0xBE, 0x3E, 0x7C,
  0x7C, 0xF9, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0x3E,
  0x00, 0xF8, 0x03, 0xF1, 0x0F, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC,
  0x7F, 0xC7, 0xF8, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x01, 0xFC, 0x01, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xF3, 0xFF, 0x3F, 0xF0,
  0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0xE1, 0xFF, 0x8F, 0xFE,
  0x7F, 0xF3, 0x8F, 0x90, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x83, 0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x78, 0xF3,
  0xC7, 0xF9, 0xCE, 0x3F, 0xE7, 0x79, 0xF7, 0x9D, 0xC7, 0x9E, 0x77, 0x3C,
  0x71, 0xFC, 0xF3, 0xC7, 0xF3, 0x8F, 0x3F, 0x9E, 0x3C, 0xEE, 0x79, 0xE7,
  0xB9, 0xFF, 0xFC, 0xE3, 0xFF, 0xF3, 0xCF, 0xDF, 0x0F, 0x08, 0x18, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x03, 0xE7, 0x80, 0xF9, 0xF0,
  0x7E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F,
  0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0xF9, 0xF8, 0x7C, 0x7C, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF0, 0xF8, 0xFC, 0xFC,
  0x7E, 0x7E, 0x7E, 0x3E, 0x7F, 0x1F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC,
  0x61, 0xFC, 0x10, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x08, 0x7F, 0x38, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF9, 0xF8,
  0xFC, 0x7E, 0x7F, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xC3, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x9F, 0xE7, 0xC7, 0xF3, 0xF3, 0xFC, 0xFC, 0xFF,
  0x3F, 0x3F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0xDF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xC3, 0xF0,
  0xFC, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7E,
  0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1,
  0xF0, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0xC3, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xC0,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF,
  0xC0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xFB, 0xF0, 0x1F, 0xBF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7C, 0x07,
  0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7E, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF3,
  0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xBD, 0xFF, 0x87, 0xDE, 0xF7, 0xC3, 0xEF,
  0x7B, 0xE1, 0xF7, 0xFB, 0xF0, 0xFB, 0xFD, 0xF0, 0xF9, 0xFC, 0xF8, 0x7C,
  0xFE, 0x7C, 0x3E, 0x7F, 0x3E, 0x1F, 0x3F, 0x3E, 0x0F, 0x9F, 0x9F, 0x0F,
  0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xC0, 0x07, 0xE0, 0xF8, 0x7F, 0x07, 0xC3,
  0xF8, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x1F, 0x07, 0xF8, 0xF8, 0x7F, 0xC7,
  0xC3, 0xFE, 0x3E, 0x1F, 0xF9, 0xF0, 0xF7, 0xDF, 0x0F, 0xBE, 0xF8, 0x7D,
  0xF7, 0xC3, 0xE7, 0xFE, 0x1F, 0x3F, 0xF0, 0xF9, 0xFF, 0x0F, 0x8F, 0xF8,
  0x7C, 0x7F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xE0, 0xF8, 0x7F, 0x0F, 0x83,
  0xF8, 0x7C, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x1F, 0xCF, 0xCF, 0xC3, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F,
  0xDF, 0x83, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x07, 0xEF,
  0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFB, 0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F,
  0x1F, 0x0F, 0x9F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xCF, 0xCF, 0xC3, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0xDF, 0x83, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x07,
  0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0xBF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFB, 0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F,
  0x1F, 0x0F, 0xBF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0,
  0xFB, 0xE0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x3E, 0x1F, 0x1F, 0x8F, 0x8F,
  0xCF, 0xC7, 0xE7, 0xE1, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0x9C, 0x1F, 0x04, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0xC1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xC1, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC7, 0xE1, 0xF1,
  0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8,
  0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xBF, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x1F, 0xFC,
  0x1F, 0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF1,
  0xF1, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x1E, 0x0F, 0xDF,
  0x0F, 0x83, 0xE7, 0xC3, 0xE1, 0xF9, 0xF1, 0xF8, 0x7C, 0x7C, 0x7E, 0x3F,
  0x1F, 0x1F, 0x8F, 0x87, 0xCF, 0xE3, 0xE1, 0xF3, 0xF9, 0xF8, 0x7D, 0xFE,
  0x7C, 0x1F, 0x7F, 0x9F, 0x07, 0xBF, 0xEF, 0x83, 0xEF, 0x7B, 0xE0, 0xFB,
  0xDE, 0xF8, 0x3F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0x80,
  0xFF, 0x9F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x1F,
  0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F,
  0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0xFC, 0x7E, 0xFC, 0x7C,
  0xFC, 0xFC, 0x7C, 0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x00, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x1F, 0x7C, 0x3C, 0x78, 0xF8, 0xF3, 0xE1, 0xE7, 0x83, 0xFF, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0xF8, 0xF9, 0xF1,
  0xE0, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xE7, 0xCF, 0x8F,
  0xBF, 0x1F, 0x7E, 0x3E, 0xF8, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x9F, 0x9F, 0xFF, 0x3F, 0xFC, 0x3F, 0xF8, 0x7C, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7E,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xF3, 0xE0, 0x07, 0xF0, 0xFF,
  0xCF, 0xFC, 0x7F, 0xE7, 0xE2, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x4F, 0xCC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x8F, 0xCF, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3F, 0x0F, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0xC0, 0xF9, 0xE0, 0x07, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0x7E,
  0x7D, 0xF1, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x23, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE7, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x18, 0x1F, 0x0F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x7C, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x07, 0x81, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83,
  0xE0, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x3F, 0x1F, 0x1F, 0x87, 0xCF, 0xC1, 0xF7, 0xE0, 0xFD, 0xF0, 0x3E,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x81, 0xF3, 0xE0, 0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0xC3,
  0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0x1F, 0x7E, 0x7C, 0x1F,
  0xFE, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x1F,
  0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x07, 0xF0, 0x7F,
  0xE1, 0xFF, 0xCF, 0xFF, 0x7E, 0x7D, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x3E, 0xF9, 0xFB, 0xFF, 0xCF, 0xFE, 0x1F,
  0xF0, 0x3F, 0x80, 0x07, 0xDF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x87,
  0xE3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0xBF, 0x07, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x9E, 0x3F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7E, 0x3E,
  0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x9F, 0xFF, 0x3F,
  0xFC, 0x7F, 0xF8, 0x7D, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x78, 0xFF, 0xC7, 0xFC, 0x3F,
  0xE3, 0xFF, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xE1, 0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xEC, 0x3E, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8,
  0x7F, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF1, 0x1F, 0xE7, 0xFE, 0x7F,
  0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xFD, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFE, 0xF0, 0x7C, 0xF0, 0xF8, 0x7F, 0xF1, 0xFB,
  0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0xFC, 0x7D, 0xF0, 0xFB,
  0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0xFC, 0x7F, 0xE7, 0xF3, 0xEF, 0x9F, 0xCF,
  0xBE, 0x7F, 0x7E, 0xFB, 0xFD, 0xF3, 0xEF, 0xE7, 0xCF, 0xFB, 0xBE, 0x3F,
  0xFE, 0xF8, 0xFF, 0xFB, 0xC3, 0xDD, 0xFF, 0x0F, 0xF7, 0xFC, 0x3F, 0xDF,
  0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xEF,
  0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8,
  0x0F, 0xDF, 0x83, 0xF3, 0xF0, 0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xE1, 0xF1,
  0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x78,
  0x1F, 0xC1, 0xFE, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0x3C, 0x05, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_BlackItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 22, 8, 0, -22 },
  { 29, 13, 8, 14, 3, -22 },
  { 42, 18, 22, 17, 0, -22 },
  { 92, 15, 26, 16, 1, -24 },
  { 141, 23, 22, 26, 2, -22 },
  { 205, 20, 22, 20, 0, -22 },
  { 260, 6, 8, 7, 3, -22 },
  { 266, 11, 28, 10, 1, -23 },
  { 305, 11, 28, 10, -2, -23 },
  { 344, 14, 15, 15, 2, -24 },
  { 371, 14, 16, 16, 1, -19 },
  { 399, 8, 8, 9, -2, -4 },
  { 407, 9, 5, 10, 0, -11 },
  { 413, 6, 5, 9, 0, -5 },
  { 417, 18, 22, 13, -2, -22 },
  { 467, 15, 22, 16, 1, -22 },
  { 509, 12, 22, 16, 3, -22 },
  { 542, 16, 22, 16, -1, -22 },
  { 586, 16, 22, 16, 0, -22 },
  { 630, 16, 22, 16, 0, -22 },
  { 674, 16, 22, 16, 0, -22 },
  { 718, 15, 22, 16, 1, -22 },
  { 760, 16, 22, 16, 1, -22 },
  { 804, 16, 22, 16, 0, -22 },
  { 848, 15, 22, 16, 1, -22 },
  { 890, 9, 17, 9, 0, -17 },
  { 910, 11, 21, 9, -2, -17 },
  { 939, 14, 16, 16, 1, -19 },
  { 967, 14, 11, 16, 1, -16 },
  { 987, 14, 16, 16, 1, -19 },
  { 1015, 13, 22, 13, 1, -22 },
  { 1051, 22, 24, 24, 1, -22 },
  { 1117, 18, 22, 18, -2, -22 },
  { 1167, 17, 22, 17, 0, -22 },
  { 1214, 17, 22, 16, 1, -22 },
  { 1261, 18, 22, 18, 0, -22 },
  { 1311, 16, 22, 14, 0, -22 },
  { 1355, 16, 22, 14, 0, -22 },
  { 1399, 18, 22, 18, 1, -22 },
  { 1449, 20, 22, 19, 0, -22 },
  { 1504, 15, 22, 12, -1, -22 },
  { 1546, 15, 29, 9, -5, -22 },
  { 1601, 20, 22, 17, 0, -22 },
  { 1656, 12, 22, 14, 0, -22 },
  { 1689, 25, 22, 25, 0, -22 },
  { 1758, 21, 22, 20, 0, -22 },
  { 1816, 18, 22, 19, 1, -22 },
  { 1866, 17, 22, 16, 0, -22 },
  { 1913, 18, 27, 19, 1, -22 },
  { 1974, 17, 22, 17, 0, -22 },
  { 2021, 16, 22, 15, 0, -22 },
  { 2065, 15, 22, 14, 2, -22 },
  { 2107, 18, 22, 18, 1, -22 },
  { 2157, 17, 22, 17, 3, -22 },
  { 2204, 26, 22, 25, 2, -22 },
  { 2276, 21, 22, 17, -2, -22 },
  { 2334, 16, 22, 16, 3, -22 },
  { 2378, 18, 22, 15, -1, -22 },
  { 2428, 13, 28, 10, -1, -23 },
  { 2474, 8, 22, 13, 3, -22 },
  { 2496, 13, 28, 10, -2, -23 },
  { 2542, 15, 14, 15, 0, -22 },
  { 2569, 13, 4, 13, -3, 2 },
  { 2576, 7, 5, 10, 4, -24 },
  { 2581, 15, 17, 16, 1, -17 },
  { 2613, 16, 24, 16, 0, -24 },
  { 2661, 13, 17, 13, 1, -17 },
  { 2689, 17, 24, 16, 1, -24 },
  { 2740, 14, 17, 15, 1, -17 },
  { 2770, 17, 31, 11, -3, -24 },
  { 2836, 17, 24, 16, -1, -17 },
  { 2887, 16, 24, 16, 0, -24 },
  { 2935, 10, 24, 9, 0, -24 },
  { 2965, 14, 31, 9, -4, -24 },
  { 3020, 18, 24, 16, 0, -24 },
  { 3074, 10, 24, 8, 0, -24 },
  { 3104, 24, 17, 24, 0, -17 },
  { 3155, 16, 17, 16, 0, -17 },
  { 3189, 14, 17, 16, 1, -17 },
  { 3219, 18, 24, 16, -2, -17 },
  { 3273, 15, 24, 16, 1, -17 },
  { 3318, 13, 17, 12, 0, -17 },
  { 3346, 13, 17, 13, 0, -17 },
  { 3374, 12, 21, 12, 1, -21 },
  { 3406, 16, 17, 16, 1, -17 },
  { 3440, 15, 17, 15, 2, -17 },
  { 3472, 22, 17, 22, 2, -17 },
  { 3519, 19, 17, 15, -2, -17 },
  { 3560, 19, 24, 15, -2, -17 },
  { 3617, 15, 17, 13, -1, -17 },
  { 3649, 13, 27, 11, 0, -22 },
  { 3693, 4, 31, 14, 5, -24 },
  { 3709, 13, 27, 11, -2, -22 },
  { 3753, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_BlackItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC31PT7B_H_
