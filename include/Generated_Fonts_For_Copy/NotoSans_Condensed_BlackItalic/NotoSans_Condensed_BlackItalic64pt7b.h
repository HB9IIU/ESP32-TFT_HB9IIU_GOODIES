#ifndef _NOTOSANS_CONDENSED_BLACKITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x78, 0x78, 0x07, 0xFE, 0x78, 0x10, 0x07, 0xFC,
  0x70, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0x07, 0xBF, 0xF0, 0x60, 0x07,
  0x9F, 0xF0, 0x78, 0x0F, 0x3F, 0xF0, 0x7E, 0x0F, 0x3F, 0xE0, 0x7F, 0x8F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE3, 0xFC,
  0x3F, 0xF8, 0xFF, 0x3F, 0xE7, 0xF8, 0x7F, 0xFC, 0xFF, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xE7, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xC7,
  0xFD, 0xFF, 0x3F, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0xFF,
  0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0xFF, 0xFF,
  0x83, 0xFF, 0xCF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x01, 0x00, 0xFF, 0x00, 0x1C, 0x0F, 0xF0, 0x01, 0xF0, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x03, 0xFE, 0xFE, 0x0F, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFB, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7E,
  0x1F, 0xF8, 0x03, 0xC1, 0xFF, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x80, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F,
  0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0x7F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF1,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8,
  0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0xBF, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE7,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xEF, 0xFE, 0x07,
  0xE3, 0xFF, 0x81, 0xF0, 0xFF, 0xE0, 0x38, 0x7F, 0xF0, 0x04, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0xF0,
  0x01, 0xC0, 0x3F, 0xF8, 0x00, 0x40, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7E, 0x0F, 0xFF,
  0x00, 0x70, 0x07, 0xFF, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x80, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0xFF, 0xF0, 0xF8, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x1F,
  0xE7, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0x80, 0x0F,
  0xF1, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xF0, 0x07,
  0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x3F, 0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xC3, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x01, 0xFF, 0xE0, 0xC0, 0x03,
  0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x04, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFB,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF1,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x03, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0x9F, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC7,
  0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF,
  0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0,
  0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x3F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF7, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x1F,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xF0, 0xFF, 0xF0, 0xE0, 0x1F, 0xFC, 0x30,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x0C, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0xC7, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x87,
  0xFF, 0xFF, 0x87, 0xF3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xCF, 0xF0, 0xFF,
  0x07, 0xF0, 0x7F, 0x3F, 0x87, 0xFC, 0x1F, 0xC1, 0xFD, 0xFE, 0x1F, 0xE0,
  0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xDF, 0xC3, 0xFC, 0x0F,
  0xE0, 0xFF, 0x7F, 0x0F, 0xF0, 0x3F, 0x83, 0xFB, 0xFC, 0x3F, 0xC1, 0xFE,
  0x0F, 0xEF, 0xF1, 0xFE, 0x07, 0xF8, 0x3F, 0xBF, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xCF, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0xC7, 0xF8,
  0xFE, 0x1F, 0xF7, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xEF, 0xFF, 0xC0, 0xFE,
  0x07, 0xFF, 0x3F, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0,
  0x0F, 0x80, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF9,
  0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFF,
  0x80, 0x78, 0x03, 0xFF, 0xE0, 0x02, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0x00, 0x3F,
  0xFC, 0x00, 0xE0, 0x07, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0xFF,
  0xFC, 0x00, 0x10, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xE1, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0x87, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00,
  0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0xFF,
  0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xC7, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFE,
  0x3F, 0xDF, 0xFC, 0x00, 0xFF, 0xDF, 0xF3, 0xFE, 0xFF, 0xE0, 0x07, 0xFE,
  0xFF, 0x9F, 0xF7, 0xFE, 0x00, 0x7F, 0xF7, 0xFD, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xFF, 0x9F, 0xFC,
  0x00, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0x87, 0xFE, 0x00, 0x7F,
  0xF1, 0xFF, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xEF, 0xFC,
  0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x7F,
  0xF0, 0x07, 0xFE, 0x7F, 0xE7, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x7F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF1,
  0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xCF,
  0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F,
  0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F,
  0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x3E, 0x00, 0x7F, 0xF0, 0x07, 0x00,
  0x7F, 0xF8, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x20, 0x00, 0xFF, 0xF0, 0x1C, 0x00, 0x7F, 0xF8, 0x0F, 0x80,
  0x7F, 0xFC, 0x07, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xD0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x80,
  0x0F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xCF,
  0xFB, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xBF, 0xCF, 0xFE, 0x00, 0xFF,
  0xCF, 0xFB, 0xFC, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x7F, 0xDF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF7, 0xFD, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x7F, 0xDF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xDF,
  0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF8,
  0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xC0, 0x1F, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF,
  0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xE1, 0xE0, 0xFF, 0xF0, 0x08, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0x03, 0xFF, 0x80,
  0xE0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC,
  0x3F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F,
  0xFB, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF7,
  0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xF9, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xC1, 0xFF, 0xE0,
  0x3E, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF,
  0x00, 0x1F, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF8,
  0x00, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x80, 0x01, 0xFF, 0xC0, 0x1E, 0x00,
  0x7F, 0xF8, 0x03, 0xFE, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xBF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF,
  0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0x8F, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xCF, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xCF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE7, 0xFF, 0xF7,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE,
  0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x01,
  0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF,
  0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB,
  0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF3,
  0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF8,
  0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x18, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F,
  0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0x1F, 0x81, 0xFF, 0xC0, 0xE0, 0x3F, 0xF8, 0x04,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x10,
  0x01, 0xFF, 0xE3, 0x80, 0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1D, 0x00, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0x80, 0x3F,
  0xFC, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0x00, 0xFF, 0xE7, 0xFE,
  0x03, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xE7, 0xFF,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0,
  0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xBF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0x7F, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0xFC, 0xFF, 0xE0,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xBF, 0xCF, 0xFC, 0x0F,
  0xFD, 0xFE, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFB, 0xFD, 0xFF, 0x80, 0xFF,
  0xBF, 0xCF, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x7F, 0xBF, 0xF0, 0x0F, 0xFB,
  0xFD, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xE7, 0xFB, 0xFE, 0x00, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x41, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x09, 0xFF,
  0xC0, 0x00, 0x5F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFD, 0x00,
  0x01, 0xFF, 0x88, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 21, 47, 17, 0, -46 },
  { 125, 27, 17, 29, 6, -46 },
  { 183, 38, 46, 36, 0, -46 },
  { 402, 32, 53, 32, 1, -49 },
  { 614, 48, 47, 53, 4, -46 },
  { 896, 41, 47, 41, 0, -46 },
  { 1137, 13, 17, 15, 6, -46 },
  { 1165, 24, 57, 20, 1, -47 },
  { 1336, 24, 57, 20, -5, -47 },
  { 1507, 28, 30, 30, 4, -49 },
  { 1612, 29, 31, 34, 3, -38 },
  { 1725, 17, 18, 18, -4, -9 },
  { 1764, 18, 10, 20, 1, -22 },
  { 1787, 12, 12, 18, 0, -11 },
  { 1805, 35, 47, 27, -3, -46 },
  { 2011, 30, 47, 32, 2, -46 },
  { 2188, 26, 46, 32, 5, -46 },
  { 2338, 33, 46, 32, -2, -46 },
  { 2528, 32, 47, 32, 0, -46 },
  { 2716, 33, 46, 32, 0, -46 },
  { 2906, 32, 47, 32, 1, -46 },
  { 3094, 32, 47, 32, 2, -46 },
  { 3282, 34, 46, 32, 2, -46 },
  { 3478, 32, 47, 32, 1, -46 },
  { 3666, 30, 47, 32, 2, -46 },
  { 3843, 18, 37, 18, 0, -36 },
  { 3927, 22, 45, 18, -4, -36 },
  { 4051, 29, 32, 34, 3, -39 },
  { 4167, 29, 23, 34, 3, -34 },
  { 4251, 29, 32, 34, 3, -39 },
  { 4367, 26, 47, 26, 3, -46 },
  { 4520, 46, 51, 49, 2, -46 },
  { 4814, 37, 46, 37, -4, -46 },
  { 5027, 36, 46, 35, 0, -46 },
  { 5234, 35, 47, 33, 2, -46 },
  { 5440, 37, 46, 37, 0, -46 },
  { 5653, 32, 46, 30, 0, -46 },
  { 5837, 32, 46, 29, 0, -46 },
  { 6021, 36, 47, 38, 3, -46 },
  { 6233, 41, 46, 39, 0, -46 },
  { 6469, 31, 46, 25, -2, -46 },
  { 6648, 31, 60, 19, -10, -46 },
  { 6881, 42, 46, 36, 0, -46 },
  { 7123, 25, 46, 28, 0, -46 },
  { 7267, 53, 46, 51, 0, -46 },
  { 7572, 44, 46, 42, 0, -46 },
  { 7825, 36, 47, 40, 3, -46 },
  { 8037, 35, 46, 34, 0, -46 },
  { 8239, 36, 57, 40, 3, -46 },
  { 8496, 35, 46, 35, 0, -46 },
  { 8698, 33, 47, 30, 0, -46 },
  { 8892, 29, 46, 30, 5, -46 },
  { 9059, 37, 47, 38, 3, -46 },
  { 9277, 35, 46, 35, 6, -46 },
  { 9479, 52, 46, 51, 5, -46 },
  { 9778, 44, 46, 35, -4, -46 },
  { 10031, 33, 46, 33, 6, -46 },
  { 10221, 37, 46, 30, -3, -46 },
  { 10434, 28, 58, 20, -3, -47 },
  { 10637, 16, 47, 27, 6, -46 },
  { 10731, 28, 58, 20, -5, -47 },
  { 10934, 32, 30, 31, -1, -46 },
  { 11054, 28, 8, 26, -6, 4 },
  { 11082, 15, 10, 22, 9, -49 },
  { 11101, 33, 37, 33, 1, -36 },
  { 11254, 32, 50, 33, 0, -49 },
  { 11454, 27, 37, 28, 2, -36 },
  { 11579, 36, 50, 33, 1, -49 },
  { 11804, 29, 37, 32, 2, -36 },
  { 11939, 36, 64, 22, -7, -49 },
  { 12227, 35, 51, 33, -1, -36 },
  { 12451, 32, 49, 34, 0, -49 },
  { 12647, 20, 50, 18, 0, -50 },
  { 12772, 28, 65, 18, -8, -50 },
  { 13000, 37, 49, 34, 0, -49 },
  { 13227, 21, 49, 17, 0, -49 },
  { 13356, 49, 36, 50, 0, -36 },
  { 13577, 32, 36, 34, 0, -36 },
  { 13721, 30, 37, 33, 2, -36 },
  { 13860, 36, 51, 33, -4, -36 },
  { 14090, 33, 51, 33, 1, -36 },
  { 14301, 27, 36, 24, 0, -36 },
  { 14423, 27, 37, 27, 0, -36 },
  { 14548, 23, 44, 24, 3, -43 },
  { 14675, 32, 36, 34, 2, -35 },
  { 14819, 31, 35, 31, 4, -35 },
  { 14955, 46, 35, 46, 4, -35 },
  { 15157, 38, 35, 31, -3, -35 },
  { 15324, 39, 50, 31, -4, -35 },
  { 15568, 31, 35, 27, -2, -35 },
  { 15704, 27, 56, 22, 0, -46 },
  { 15893, 9, 64, 28, 10, -49 },
  { 15965, 26, 56, 22, -4, -46 },
  { 16147, 29, 13, 34, 3, -29 },
};

const GFXfont NotoSans_Condensed_BlackItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC64PT7B_H_
