#ifndef _NOTOSANS_CONDENSED_BLACKITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x9C, 0x70, 0x00, 0x3C, 0xF3, 0x80,
  0xFF, 0xEE, 0xEE, 0xEE, 0xCC, 0x06, 0xE1, 0xD8, 0x33, 0x06, 0xE3, 0xFE,
  0xFF, 0xC6, 0x60, 0xDC, 0xFF, 0xDF, 0xF8, 0xDC, 0x3B, 0x06, 0x60, 0xDC,
  0x00, 0x02, 0x03, 0xF3, 0xF8, 0xFE, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0xA2, 0xE6, 0xF3, 0xFC, 0xFE, 0x04, 0x01, 0x00, 0x18, 0x39, 0xF0, 0xC6,
  0xC6, 0x3B, 0x38, 0xEC, 0xC3, 0x37, 0x0F, 0xFB, 0xFE, 0xDF, 0x77, 0x6C,
  0x1B, 0xB0, 0xCE, 0xC7, 0x37, 0x18, 0xF8, 0xE1, 0xC0, 0x07, 0x00, 0xFC,
  0x1F, 0xC1, 0xDC, 0x1F, 0xC1, 0xF8, 0x1F, 0x73, 0xEF, 0x7F, 0xEF, 0x7E,
  0xE7, 0xCF, 0xFC, 0xFF, 0xC7, 0xDE, 0xFE, 0xEE, 0xC0, 0x0E, 0x18, 0x71,
  0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x30, 0x70,
  0x1C, 0x38, 0x30, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x71, 0xC3, 0x87,
  0x1C, 0x30, 0xE0, 0x0A, 0x06, 0x13, 0x0F, 0xEF, 0xF8, 0xFD, 0xF8, 0xFC,
  0x27, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x3B,
  0x9C, 0xEE, 0x70, 0x7D, 0xEF, 0x80, 0xFF, 0xE0, 0x01, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x1F, 0x8F, 0xCE, 0xF7, 0x7F, 0xBF, 0x9D,
  0xCE, 0xE7, 0x77, 0xBB, 0x9F, 0xCF, 0xC3, 0xC0, 0x0E, 0x3C, 0xFB, 0xFF,
  0xDB, 0x97, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x00, 0x07, 0x83, 0xF1,
  0xFC, 0x67, 0x09, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFE,
  0x7F, 0xBF, 0xE0, 0x0F, 0x0F, 0xE3, 0xF8, 0x4F, 0x03, 0x81, 0xE1, 0xE0,
  0x7C, 0x2F, 0x01, 0xE8, 0x73, 0xFC, 0xFE, 0x3F, 0x00, 0x01, 0xC0, 0xE0,
  0x78, 0x3E, 0x0F, 0x87, 0xE3, 0xF1, 0xDC, 0x67, 0x3F, 0xEF, 0xF8, 0x38,
  0x0E, 0x03, 0x80, 0x1F, 0xC7, 0xF1, 0xF8, 0xE0, 0x38, 0x0F, 0x83, 0xF1,
  0xFE, 0x07, 0x81, 0xE8, 0x73, 0xFC, 0xFE, 0x3F, 0x00, 0x07, 0x8F, 0xCF,
  0xEF, 0x07, 0x07, 0xF3, 0xFD, 0xFE, 0xE7, 0x73, 0xBB, 0xDF, 0xCF, 0xE3,
  0xE0, 0x3F, 0xE7, 0xF8, 0xFF, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x07, 0xE3,
  0xFC, 0xE7, 0x3B, 0x8F, 0xE1, 0xF0, 0xFC, 0x7F, 0x1D, 0xEE, 0x7B, 0xDC,
  0x7F, 0x1F, 0x80, 0x0E, 0x07, 0xE3, 0xF8, 0xEE, 0x7B, 0xDC, 0xE7, 0xB9,
  0xFE, 0x3F, 0x85, 0xC0, 0x73, 0xF8, 0xFC, 0x3E, 0x00, 0x19, 0xCE, 0x60,
  0x00, 0x00, 0xF7, 0xB8, 0x0C, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x39, 0xC7,
  0x1C, 0xE3, 0x00, 0x01, 0x03, 0x0F, 0x3E, 0xF8, 0xF0, 0x7E, 0x1F, 0x07,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7E,
  0x1F, 0x0F, 0x3E, 0xF8, 0xE0, 0x80, 0x1C, 0x7E, 0x7F, 0x4F, 0x0E, 0x1E,
  0x3C, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x03, 0xC0, 0x7F, 0x8F,
  0x0E, 0x60, 0x36, 0x7D, 0xF7, 0xEF, 0x37, 0x7B, 0xB3, 0xD9, 0x9E, 0xCD,
  0xB7, 0xFD, 0x99, 0xCC, 0x00, 0x79, 0xC1, 0xFE, 0x00, 0x80, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0x60, 0xEC, 0x1D, 0x87, 0x78, 0xEF, 0x3D, 0xE7, 0xFD,
  0xFF, 0xB8, 0xF7, 0x1F, 0xE3, 0xC0, 0x1F, 0x03, 0xF8, 0xFF, 0x1E, 0xF3,
  0x9C, 0x77, 0x8F, 0xE3, 0xFC, 0x73, 0x8E, 0x79, 0xCE, 0x3F, 0xCF, 0xF1,
  0xFC, 0x00, 0x07, 0x07, 0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xF8, 0xFE, 0x1F, 0x80, 0x1E, 0x03, 0xF8, 0xFF,
  0x1E, 0xF3, 0x9E, 0x71, 0xCE, 0x7B, 0xCF, 0x71, 0xCE, 0x39, 0xCF, 0x3F,
  0xCF, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xE3, 0xF8, 0xF0, 0x38, 0x0E, 0x03,
  0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xF8, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xE3, 0xF8, 0xF0, 0x38, 0x0E, 0x03, 0xF1, 0xFC, 0x7F, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0x3C, 0x27, 0x81, 0xE0,
  0x3D, 0xF7, 0x3E, 0xEF, 0x9C, 0x73, 0x8E, 0x7F, 0xC7, 0xF0, 0x7E, 0x00,
  0x1C, 0x71, 0xC7, 0x3C, 0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x3F, 0xE7, 0xFE,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xF3, 0xCE, 0x38, 0x1F, 0xC7, 0xE1,
  0xF8, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x7E, 0x3F, 0x80, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x71, 0xF8, 0xF8, 0x78, 0x00,
  0x1C, 0x71, 0xCF, 0x3D, 0xE3, 0xDC, 0x3B, 0xC3, 0xF8, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0x78, 0x77, 0x87, 0x78, 0xF3, 0x8E, 0x3C, 0x1C, 0x38, 0xF1,
  0xE3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0xFF, 0xFF, 0xC0, 0x1E, 0x1F,
  0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0xFC,
  0x76, 0xFC, 0x76, 0xDC, 0x77, 0xDC, 0x77, 0xB8, 0x77, 0xB8, 0xE7, 0x38,
  0xE7, 0x38, 0x1E, 0x38, 0xF1, 0xCF, 0x8E, 0x7C, 0xE3, 0xE7, 0x1F, 0xB8,
  0xFD, 0xCE, 0xEE, 0x77, 0xE3, 0x9F, 0x1C, 0xF8, 0xE7, 0xCE, 0x3E, 0x71,
  0xE0, 0x07, 0x03, 0xF8, 0xFF, 0x3C, 0xF7, 0x1F, 0xE3, 0xFC, 0x7F, 0x0E,
  0xE1, 0xDC, 0x7B, 0x8E, 0x7F, 0xCF, 0xF0, 0xFC, 0x00, 0x1E, 0x07, 0xE3,
  0xFC, 0xF7, 0x39, 0xCE, 0x73, 0xBD, 0xFE, 0x7F, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x38, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0x3C, 0xF7, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0E, 0xE1, 0xDC, 0x7B, 0x8E, 0x7F, 0xCF, 0xF0, 0xFC, 0x03, 0x80,
  0x78, 0x0F, 0x00, 0x1E, 0x07, 0xF3, 0xFC, 0xF7, 0x39, 0xCE, 0x73, 0xFD,
  0xFE, 0x7F, 0x1D, 0xC7, 0x71, 0xDE, 0xF3, 0xB8, 0xF0, 0x0F, 0x07, 0xF3,
  0xF8, 0xE6, 0x38, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xC8, 0x73, 0xFC,
  0xFE, 0x3F, 0x00, 0x7F, 0xBF, 0xDF, 0xF3, 0x81, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x80, 0x38, 0xE7, 0x3D, 0xE7, 0x3C,
  0xE7, 0x1C, 0xE7, 0x9C, 0xF7, 0x9C, 0xE3, 0x9C, 0x73, 0x9E, 0x7F, 0x8F,
  0xF0, 0xFC, 0x00, 0xE1, 0xF8, 0xFE, 0x3B, 0x9E, 0xE7, 0x3B, 0xCE, 0xE3,
  0xB8, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x71, 0xC7, 0x73,
  0xCF, 0x73, 0xCE, 0x73, 0xDE, 0x77, 0xDC, 0x77, 0xDC, 0x7F, 0xFC, 0x7F,
  0xB8, 0x6D, 0xB8, 0x7D, 0xF0, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF1,
  0xE0, 0x1C, 0x78, 0xF3, 0x87, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x77, 0x87, 0x3C, 0x78, 0xE0,
  0xE3, 0xF9, 0xEE, 0x73, 0xBC, 0xFE, 0x1F, 0x87, 0xC1, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x81, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x3F, 0xC7, 0xF9,
  0xFF, 0x00, 0x0F, 0x0F, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x70, 0x78, 0xF8, 0xE7, 0x39, 0xC6, 0x31, 0xCE,
  0x73, 0x9C, 0xE3, 0x1C, 0x1F, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0x06, 0x03, 0x03,
  0xC1, 0xE1, 0xF1, 0xD8, 0xCE, 0xE7, 0xE3, 0x80, 0x7F, 0xFF, 0xFF, 0xEE,
  0x70, 0x0D, 0xCF, 0xF3, 0xFD, 0xEE, 0x73, 0x9C, 0xE7, 0x3B, 0xDE, 0xFF,
  0x1F, 0xC7, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xEC, 0x3F, 0x8F, 0xE7, 0xBD,
  0xCE, 0x73, 0x9C, 0xE7, 0x7B, 0xDC, 0xFF, 0x3B, 0x80, 0x0E, 0x0F, 0xCF,
  0xCF, 0x27, 0x03, 0x81, 0xC1, 0xE0, 0x7E, 0x3F, 0x0F, 0x00, 0x01, 0xE0,
  0x38, 0x07, 0x06, 0xE3, 0xFC, 0x7F, 0x9E, 0xE3, 0x9C, 0x73, 0x8E, 0x73,
  0xDE, 0x7F, 0x87, 0xF0, 0xFE, 0x00, 0x06, 0x0F, 0xCF, 0xEF, 0x77, 0x7B,
  0xF9, 0xF9, 0xE0, 0x73, 0x3F, 0x8F, 0x80, 0x00, 0x80, 0x7C, 0x1F, 0x03,
  0x80, 0xF8, 0x3F, 0x07, 0xE0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x1F, 0x03, 0xC0, 0x20, 0x00, 0x0D,
  0xCF, 0xF3, 0xFD, 0xEE, 0x73, 0x9C, 0xE7, 0x3B, 0xDE, 0xFF, 0x1F, 0xC7,
  0x70, 0x1C, 0x8E, 0x3F, 0x8F, 0xC0, 0xC0, 0x1C, 0x07, 0x03, 0xC0, 0xEC,
  0x3F, 0x8F, 0xF7, 0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x3B, 0xDE, 0xE7, 0x39,
  0xC0, 0x1C, 0x71, 0xC0, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0xF3, 0x8E,
  0x00, 0x03, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xF0, 0xC0, 0x1C, 0x03, 0x80,
  0xF0, 0x1C, 0xF3, 0x9C, 0x77, 0x1F, 0xE3, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC,
  0x7B, 0x8E, 0x79, 0xCF, 0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE7, 0x9C, 0x71,
  0xC7, 0x3C, 0xE3, 0x80, 0x3B, 0x18, 0xFE, 0xF3, 0xFF, 0xDE, 0xF7, 0x7B,
  0x9D, 0xCE, 0x77, 0x39, 0xDC, 0xEF, 0xF7, 0xBB, 0x9C, 0xEE, 0x73, 0x80,
  0x3B, 0x0F, 0xE3, 0xFD, 0xEF, 0x7B, 0x9C, 0xE7, 0x39, 0xCE, 0xF7, 0xB9,
  0xCE, 0x70, 0x0E, 0x0F, 0xCF, 0xEF, 0x77, 0x3B, 0x9D, 0xCF, 0xEF, 0x77,
  0x3F, 0x8F, 0x00, 0x1D, 0x83, 0xF8, 0x7F, 0x1E, 0xF3, 0x9C, 0x73, 0x8E,
  0x71, 0xCE, 0x7F, 0x8F, 0xF1, 0xDC, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0x0D, 0xCF, 0xF3, 0xFD, 0xEE, 0x73, 0x9C, 0xE7, 0x3B, 0xDE, 0xFF,
  0x1F, 0xC7, 0xF0, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x3B, 0x3F, 0x3F,
  0x7E, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x1C, 0x3F, 0x7E, 0x72,
  0x78, 0x3C, 0x1E, 0x0E, 0xDE, 0xFC, 0xFC, 0x18, 0x70, 0xFF, 0xEF, 0xCE,
  0x1C, 0x78, 0xE1, 0xC3, 0xE7, 0xCF, 0x80, 0x73, 0xB9, 0xDC, 0xFE, 0xFE,
  0x77, 0x3B, 0x9D, 0xDE, 0xFF, 0x7F, 0x3F, 0x80, 0xE3, 0xF3, 0xF9, 0xDC,
  0xEE, 0xE7, 0x73, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x00, 0xE7, 0x9F, 0x9E,
  0xEE, 0xFB, 0xBB, 0xDC, 0xEF, 0x73, 0xFD, 0xCF, 0xBE, 0x3E, 0xF8, 0xFB,
  0xC3, 0xCF, 0x0F, 0x3C, 0x00, 0x3C, 0xE3, 0xBC, 0x77, 0x0F, 0xC1, 0xF8,
  0x1E, 0x07, 0xC1, 0xF8, 0x3F, 0x8E, 0xF3, 0xCE, 0x00, 0x38, 0xE7, 0x3C,
  0xE7, 0x1C, 0xE3, 0xB8, 0x77, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0x81, 0xF0, 0x3C, 0x06, 0x00, 0x1F, 0xC7, 0xE3, 0xF8, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x7F, 0x1F, 0xCF, 0xF0, 0x03, 0x0F, 0x1F,
  0x1C, 0x1C, 0x1C, 0x3C, 0x78, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x1C,
  0x3E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1F, 0x0E, 0x1E, 0x3C, 0x38, 0x38, 0x78,
  0xF0, 0xF0, 0xE0, 0x21, 0xFD, 0xFF, 0x8F,
};

const GFXglyph NotoSans_Condensed_BlackItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 8, 5, 9, 2, -14 },
  { 17, 11, 14, 11, 0, -14 },
  { 37, 10, 15, 10, 0, -14 },
  { 56, 14, 14, 16, 1, -14 },
  { 81, 12, 14, 12, 0, -14 },
  { 102, 4, 5, 5, 2, -14 },
  { 105, 7, 17, 6, 0, -14 },
  { 120, 7, 17, 6, -1, -14 },
  { 135, 9, 9, 9, 1, -15 },
  { 146, 8, 9, 10, 1, -11 },
  { 155, 5, 6, 5, -1, -3 },
  { 159, 6, 3, 6, 0, -7 },
  { 162, 4, 3, 5, 0, -3 },
  { 164, 11, 14, 8, -1, -14 },
  { 184, 9, 14, 10, 1, -14 },
  { 200, 7, 14, 10, 2, -14 },
  { 213, 10, 14, 10, -1, -14 },
  { 231, 10, 14, 10, 0, -14 },
  { 249, 10, 14, 10, 0, -14 },
  { 267, 10, 14, 10, 0, -14 },
  { 285, 9, 14, 10, 1, -14 },
  { 301, 11, 14, 10, 0, -14 },
  { 321, 10, 14, 10, 0, -14 },
  { 339, 10, 14, 10, 0, -14 },
  { 357, 5, 11, 5, 0, -11 },
  { 364, 6, 14, 5, -1, -11 },
  { 375, 8, 10, 10, 1, -12 },
  { 385, 8, 7, 10, 1, -10 },
  { 392, 8, 10, 10, 1, -12 },
  { 402, 8, 14, 8, 1, -14 },
  { 416, 13, 16, 15, 1, -14 },
  { 442, 11, 14, 11, -1, -14 },
  { 462, 11, 14, 10, 0, -14 },
  { 482, 10, 14, 10, 1, -14 },
  { 500, 11, 14, 11, 0, -14 },
  { 520, 10, 14, 9, 0, -14 },
  { 538, 10, 14, 9, 0, -14 },
  { 556, 11, 14, 11, 1, -14 },
  { 576, 12, 14, 12, 0, -14 },
  { 597, 10, 14, 7, -1, -14 },
  { 615, 9, 18, 6, -3, -14 },
  { 636, 12, 14, 11, 0, -14 },
  { 657, 7, 14, 8, 0, -14 },
  { 670, 16, 14, 15, 0, -14 },
  { 698, 13, 14, 13, 0, -14 },
  { 721, 11, 14, 12, 1, -14 },
  { 741, 10, 14, 10, 0, -14 },
  { 759, 11, 17, 12, 1, -14 },
  { 783, 10, 14, 10, 0, -14 },
  { 801, 10, 14, 9, 0, -14 },
  { 819, 9, 14, 9, 1, -14 },
  { 835, 11, 14, 11, 1, -14 },
  { 855, 10, 14, 10, 2, -14 },
  { 873, 16, 14, 15, 1, -14 },
  { 901, 13, 14, 10, -1, -14 },
  { 924, 10, 14, 10, 2, -14 },
  { 942, 11, 14, 9, -1, -14 },
  { 962, 8, 17, 6, -1, -14 },
  { 979, 5, 14, 8, 2, -14 },
  { 988, 8, 17, 6, -1, -14 },
  { 1005, 9, 9, 9, 0, -14 },
  { 1016, 8, 3, 8, -2, 1 },
  { 1019, 4, 3, 6, 3, -15 },
  { 1021, 10, 11, 10, 0, -11 },
  { 1035, 10, 14, 10, 0, -14 },
  { 1053, 9, 11, 8, 0, -11 },
  { 1066, 11, 14, 10, 0, -14 },
  { 1086, 9, 11, 9, 0, -11 },
  { 1099, 11, 20, 6, -2, -15 },
  { 1127, 10, 16, 10, 0, -11 },
  { 1147, 10, 14, 10, 0, -14 },
  { 1165, 6, 15, 5, 0, -15 },
  { 1177, 8, 20, 5, -2, -15 },
  { 1197, 11, 14, 10, 0, -14 },
  { 1217, 6, 14, 5, 0, -14 },
  { 1228, 14, 11, 15, 0, -11 },
  { 1248, 10, 11, 10, 0, -11 },
  { 1262, 9, 11, 10, 0, -11 },
  { 1275, 11, 16, 10, -1, -11 },
  { 1297, 10, 16, 10, 0, -11 },
  { 1317, 8, 11, 7, 0, -11 },
  { 1328, 8, 11, 8, 0, -11 },
  { 1339, 7, 13, 7, 1, -13 },
  { 1351, 9, 11, 10, 1, -11 },
  { 1364, 9, 11, 9, 1, -11 },
  { 1377, 14, 11, 14, 1, -11 },
  { 1397, 11, 11, 9, -1, -11 },
  { 1413, 11, 16, 9, -1, -11 },
  { 1435, 10, 11, 8, -1, -11 },
  { 1449, 8, 17, 7, 0, -14 },
  { 1466, 3, 19, 8, 3, -15 },
  { 1474, 8, 17, 7, -1, -14 },
  { 1491, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_BlackItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC19PT7B_H_
