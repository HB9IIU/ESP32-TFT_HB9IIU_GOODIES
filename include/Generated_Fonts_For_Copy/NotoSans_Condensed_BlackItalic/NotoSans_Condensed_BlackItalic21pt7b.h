#ifndef _NOTOSANS_CONDENSED_BLACKITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xE0, 0x03, 0x0F,
  0x1E, 0x38, 0x00, 0x77, 0xFB, 0xB9, 0xDC, 0xEE, 0xE0, 0x07, 0x70, 0x66,
  0x0E, 0xE0, 0xEE, 0x3F, 0xF3, 0xFF, 0x5D, 0xC1, 0xDC, 0x19, 0x8F, 0xFE,
  0xFF, 0xE3, 0x30, 0x77, 0x07, 0x70, 0x66, 0x00, 0x01, 0x00, 0x60, 0x3F,
  0x8F, 0xE3, 0xEC, 0x74, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x1E, 0x27,
  0xC7, 0xF9, 0xFF, 0x1F, 0x80, 0x40, 0x18, 0x00, 0x3C, 0x1C, 0x7E, 0x38,
  0x76, 0x38, 0x66, 0x70, 0xEE, 0x60, 0xEE, 0xE0, 0xED, 0xDE, 0xFD, 0xBF,
  0x7B, 0xBF, 0x07, 0x77, 0x07, 0x77, 0x0E, 0x77, 0x0C, 0x76, 0x1C, 0x7E,
  0x38, 0x3C, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x39, 0xC1, 0xDE, 0x0F, 0xE0,
  0x7E, 0x07, 0xEF, 0x7F, 0xFB, 0xBF, 0xBC, 0xFD, 0xE7, 0xCF, 0xFE, 0x3F,
  0xF1, 0xFB, 0xC0, 0x7F, 0xEE, 0xE0, 0x0F, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70,
  0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x0E, 0x03, 0x86, 0xE1, 0xFE, 0xFF,
  0xC7, 0xF3, 0xE1, 0xDC, 0x37, 0x00, 0x80, 0x1C, 0x0E, 0x07, 0x03, 0x8F,
  0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3B, 0xDC, 0xEE, 0x70,
  0x7D, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0xE3, 0xF9, 0xEF, 0x73, 0xFC, 0xFF,
  0x3B, 0xCE, 0xE7, 0xB9, 0xEE, 0x73, 0xBC, 0xFE, 0x3F, 0x87, 0xC0, 0x07,
  0x1F, 0x3F, 0x7F, 0xFE, 0xEE, 0x5E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x07, 0xC1, 0xFC, 0x7F, 0x86, 0x70, 0x8E, 0x03, 0xC0, 0x70,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xFC, 0xFF, 0xBF, 0xE0, 0x1F,
  0x87, 0xF8, 0x7F, 0x88, 0xE0, 0x1C, 0x07, 0x87, 0xC0, 0xF8, 0x1F, 0x80,
  0x70, 0x0E, 0x43, 0xCF, 0xF9, 0xFE, 0x3F, 0x80, 0x01, 0xE0, 0x78, 0x1F,
  0x03, 0xE0, 0xFC, 0x3F, 0x86, 0xE1, 0xDC, 0x77, 0x9F, 0xFB, 0xFF, 0x7F,
  0xE0, 0x70, 0x1E, 0x03, 0xC0, 0x0F, 0xE3, 0xF8, 0x7F, 0x0E, 0x03, 0xC0,
  0x7E, 0x0F, 0xE1, 0xFC, 0x27, 0xC0, 0x78, 0x0E, 0x43, 0xCF, 0xF9, 0xFE,
  0x3F, 0x80, 0x07, 0xC7, 0xF3, 0xFC, 0xE0, 0x78, 0x1D, 0xCF, 0xFB, 0xFE,
  0xF7, 0xB9, 0xEE, 0x7B, 0x9E, 0xFF, 0x3F, 0x87, 0xC0, 0x1F, 0xF3, 0xFE,
  0x3F, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x7F,
  0x9E, 0xF3, 0xDC, 0x7F, 0x87, 0xE0, 0xF8, 0x3F, 0x8F, 0x73, 0xCF, 0x79,
  0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xE7, 0x9E,
  0xF3, 0x9E, 0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x0E, 0x03, 0x8F, 0xF1, 0xFC,
  0x3F, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x63, 0xCF, 0x38, 0x0C,
  0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87, 0x1C, 0x38,
  0x00, 0x00, 0x81, 0xC3, 0xE7, 0xEF, 0xC7, 0x83, 0xF0, 0x7F, 0x0F, 0x80,
  0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3C, 0x7E, 0xFC, 0xF8, 0x70, 0x20, 0x00, 0x3E,
  0x7F, 0x7F, 0x47, 0x07, 0x0F, 0x1E, 0x3C, 0x78, 0x70, 0x00, 0x60, 0xF0,
  0xF0, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x77, 0x3E, 0xEC,
  0xFD, 0xFB, 0xBB, 0xE6, 0x77, 0xDC, 0xCD, 0xB9, 0x9B, 0x77, 0x66, 0x7F,
  0xCC, 0x66, 0x1C, 0x00, 0x1E, 0x70, 0x1F, 0xE0, 0x0F, 0x00, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xF1, 0xEF, 0x1C, 0xF3,
  0xFF, 0x3F, 0xF7, 0xFF, 0x78, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F, 0xC1, 0xFE,
  0x1F, 0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x3F, 0xC3, 0xF8, 0x7F, 0xC7, 0x9E,
  0x79, 0xE7, 0x3C, 0x7F, 0xCF, 0xF8, 0xFF, 0x00, 0x0F, 0xC3, 0xFC, 0xFF,
  0x3E, 0x27, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x38, 0xF3, 0x8F, 0x78, 0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0x7F,
  0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0x01, 0xE0, 0x38, 0x07, 0xF1, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE3, 0xF8, 0x7F, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xE1, 0xFC,
  0x7F, 0x8F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xE1,
  0xFF, 0x3F, 0xE3, 0xC2, 0x78, 0x07, 0x80, 0xF3, 0xEF, 0x7E, 0xF7, 0xEF,
  0x1C, 0xF3, 0xCF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x80, 0x1E, 0x38, 0xF3,
  0xC7, 0x1E, 0x78, 0xF3, 0xC7, 0x1E, 0x38, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3,
  0xC7, 0x1E, 0x38, 0xE3, 0xC7, 0x1E, 0x78, 0xF3, 0xC7, 0x00, 0x1F, 0xE3,
  0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xE0, 0xFE, 0x3F, 0xC0, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0xBC, 0x3F, 0x0F, 0x83, 0x80, 0x1E, 0x7C, 0x79, 0xE1,
  0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81,
  0xEE, 0x07, 0xBC, 0x1C, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3E, 0x00, 0x1E,
  0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x7F,
  0xFF, 0xFF, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xE7, 0xE3, 0xF3, 0xF3,
  0xF1, 0xF9, 0xF8, 0xFD, 0xFC, 0x7E, 0xFE, 0x7F, 0x6E, 0x3F, 0xF7, 0x1D,
  0xFB, 0x8E, 0xFB, 0xC7, 0x7D, 0xE7, 0xBC, 0xE3, 0xDE, 0x70, 0x1E, 0x1E,
  0x3E, 0x38, 0x7C, 0x71, 0xF9, 0xE3, 0xF3, 0xC7, 0xF7, 0x0F, 0xEE, 0x1D,
  0xDC, 0x7B, 0xF8, 0xF7, 0xF1, 0xCF, 0xC3, 0x9F, 0x87, 0x1F, 0x1E, 0x3E,
  0x38, 0x78, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xCF, 0x78, 0xF7, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8,
  0x3E, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0x9E, 0xF3, 0xCE, 0x7B, 0xCE, 0x79,
  0xFE, 0x7F, 0xCF, 0xE1, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0xC1, 0xFE, 0x3F, 0xF7, 0xCF, 0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x1F, 0xC3, 0xFC, 0x7F, 0x9E, 0x73, 0xCE, 0x7B,
  0xCF, 0xF9, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x39, 0xC7, 0x3D, 0xE7, 0xBC,
  0xF8, 0x0F, 0xC3, 0xFC, 0xFF, 0x1E, 0x43, 0xC0, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x1E, 0x63, 0xCF, 0xF1, 0xFE, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xE7, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0xC0, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x79, 0xE7, 0x9E,
  0x71, 0xE7, 0x1E, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x8F, 0xF0,
  0x7E, 0x00, 0xF1, 0xFE, 0x3F, 0xCF, 0x79, 0xEF, 0x39, 0xEF, 0x39, 0xC7,
  0x78, 0xEE, 0x1D, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0xE1,
  0xC7, 0xF1, 0xE3, 0xB8, 0xF3, 0xDC, 0xF9, 0xCE, 0x7D, 0xE7, 0x7E, 0xF3,
  0xBF, 0x71, 0xDF, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x79, 0xE0, 0xE7,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0x70, 0x79, 0xE1, 0xE7, 0x8F, 0x1E, 0x00, 0xF1, 0xFE,
  0x7B, 0xCE, 0x3B, 0xC7, 0x70, 0xFE, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x7F, 0xCF, 0xFC, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7C, 0x7C, 0x3E, 0x00, 0xE7, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0xCE, 0x73,
  0x9C, 0xE0, 0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x7C, 0x3E, 0x3E, 0x00,
  0x03, 0x01, 0xC0, 0xF0, 0x3E, 0x1F, 0x87, 0xE3, 0x99, 0xC7, 0x71, 0xF8,
  0x70, 0xFF, 0xFF, 0xFF, 0xE0, 0xF3, 0x8E, 0x0C, 0xE3, 0xDC, 0xFF, 0xBC,
  0xE7, 0x9C, 0xE3, 0x9C, 0xF3, 0x9E, 0xF3, 0x8F, 0xF1, 0xFE, 0x3D, 0xC0,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xD8, 0x7F, 0x8F, 0xF1, 0xEF, 0x79,
  0xEF, 0x39, 0xC7, 0x39, 0xE7, 0x3D, 0xFF, 0x3F, 0xE7, 0x78, 0x0E, 0x1F,
  0xDF, 0xCF, 0x2F, 0x07, 0x03, 0x81, 0xC0, 0xE2, 0x7F, 0x3F, 0x8F, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x0C, 0xE1, 0xFE, 0x3F, 0xE7, 0x9C,
  0x79, 0xC7, 0x1C, 0x73, 0xC7, 0x3C, 0xF3, 0x87, 0xF8, 0x7F, 0x87, 0xB8,
  0x07, 0x07, 0xF3, 0xFC, 0xE7, 0x79, 0xDF, 0xF7, 0xF1, 0xC0, 0xF0, 0x1F,
  0xC7, 0xF0, 0xFC, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0x7C, 0x3F, 0x87,
  0xF0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x83, 0xE0, 0x7C, 0x0F, 0x00, 0x0E, 0xE3, 0xDC, 0xFF,
  0x9C, 0xE7, 0x9C, 0xE3, 0x9C, 0xF7, 0x9E, 0xF3, 0x9F, 0xF1, 0xFE, 0x3F,
  0xC0, 0x79, 0x0E, 0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xD8, 0x7F, 0x8F, 0xF9, 0xEF, 0x79, 0xCF, 0x39, 0xEF, 0x39,
  0xE7, 0x3D, 0xE7, 0x3C, 0xE7, 0xBC, 0x1E, 0x3C, 0x70, 0x03, 0xC7, 0x8E,
  0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0x03, 0xC0, 0xF0, 0x38,
  0x00, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x0F, 0xC3, 0xE0, 0xF0, 0x00, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0xF3, 0xDE, 0x39, 0xC3, 0xBC, 0x7F,
  0x87, 0xF0, 0x7F, 0x07, 0xF8, 0x77, 0x8F, 0x78, 0xF3, 0x8F, 0x3C, 0x1E,
  0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C,
  0x78, 0x39, 0x8E, 0x3F, 0xDF, 0x3F, 0xFF, 0x3D, 0xEF, 0x79, 0xEF, 0x79,
  0xCF, 0x7B, 0xCE, 0x73, 0xCE, 0x73, 0xDE, 0xF3, 0x9E, 0xF3, 0x9E, 0xF7,
  0x9C, 0x39, 0x87, 0xF8, 0xFF, 0x9E, 0xF7, 0x9C, 0xF3, 0x9E, 0xF3, 0x9E,
  0x73, 0xDE, 0x73, 0xCE, 0x7B, 0xC0, 0x0E, 0x1F, 0xDF, 0xEE, 0x7F, 0x3F,
  0x1F, 0x8F, 0xCF, 0xE7, 0xFF, 0xBF, 0x8F, 0x80, 0x1D, 0xC1, 0xFE, 0x1F,
  0xE1, 0xEF, 0x3C, 0xF3, 0xCE, 0x38, 0xE3, 0x9E, 0x39, 0xE7, 0xFC, 0x7F,
  0xC7, 0x78, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0xE3,
  0xDC, 0xFF, 0x9C, 0xE7, 0x9C, 0xE3, 0x9C, 0xF7, 0x9E, 0xF3, 0x9F, 0xF1,
  0xFE, 0x3F, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x39, 0x9D,
  0xCF, 0xC7, 0xE7, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x00,
  0x1E, 0x1F, 0xDF, 0xCF, 0x27, 0x81, 0xF0, 0xF8, 0x1E, 0x8F, 0x7F, 0xBF,
  0x9F, 0x80, 0x1C, 0x30, 0xFF, 0xFF, 0xEF, 0x1C, 0x38, 0xF1, 0xE3, 0xC7,
  0xEF, 0xCF, 0x80, 0x79, 0xDE, 0xF7, 0x3D, 0xCF, 0xF3, 0xBC, 0xEF, 0x7B,
  0x9E, 0xE7, 0xBF, 0xCF, 0xF3, 0xDC, 0xF1, 0xFC, 0xFF, 0x3B, 0xDE, 0xF7,
  0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF3, 0xCF, 0xEF,
  0xBF, 0xDF, 0x77, 0xBE, 0xEF, 0xFB, 0xDD, 0xB7, 0x3B, 0x6E, 0x7E, 0xF8,
  0xF9, 0xF1, 0xF3, 0xC3, 0xEF, 0x87, 0x9F, 0x00, 0x3C, 0xF1, 0xCF, 0x1F,
  0xE1, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x83, 0xB8, 0x7B,
  0xCF, 0x3C, 0x3C, 0x73, 0xCF, 0x3C, 0xE3, 0xDE, 0x1D, 0xC1, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0xF8,
  0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0x1E, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1F, 0xE7, 0xF3, 0xFC, 0x07, 0x87, 0xC3, 0xC3, 0xC1,
  0xE0, 0xE0, 0x70, 0xF8, 0xF8, 0x78, 0x3E, 0x07, 0x07, 0x83, 0xC1, 0xC0,
  0xF0, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x0F, 0x0F, 0x1F, 0x3C,
  0x38, 0x38, 0x38, 0xF8, 0xF0, 0xF0, 0xFC, 0xFF, 0xE7, 0xF0, 0x60,
};

const GFXglyph NotoSans_Condensed_BlackItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 15, 6, 0, -15 },
  { 15, 9, 5, 9, 2, -15 },
  { 21, 12, 15, 12, 0, -15 },
  { 44, 11, 17, 11, 0, -16 },
  { 68, 16, 15, 18, 1, -15 },
  { 98, 13, 15, 13, 0, -15 },
  { 123, 4, 5, 5, 2, -15 },
  { 126, 8, 18, 7, 0, -15 },
  { 144, 8, 18, 7, -2, -15 },
  { 162, 10, 10, 10, 1, -16 },
  { 175, 9, 11, 11, 1, -13 },
  { 188, 5, 6, 6, -1, -3 },
  { 192, 6, 3, 7, 0, -7 },
  { 195, 4, 4, 6, 0, -4 },
  { 197, 12, 15, 9, -1, -15 },
  { 220, 10, 15, 11, 1, -15 },
  { 239, 8, 15, 11, 2, -15 },
  { 254, 11, 15, 11, -1, -15 },
  { 275, 11, 15, 11, 0, -15 },
  { 296, 11, 15, 11, 0, -15 },
  { 317, 11, 15, 11, 0, -15 },
  { 338, 10, 15, 11, 1, -15 },
  { 357, 12, 15, 11, 0, -15 },
  { 380, 11, 15, 11, 0, -15 },
  { 401, 11, 15, 11, 0, -15 },
  { 422, 6, 12, 6, 0, -12 },
  { 431, 7, 15, 6, -1, -12 },
  { 445, 9, 11, 11, 1, -13 },
  { 458, 9, 7, 11, 1, -11 },
  { 466, 9, 11, 11, 1, -13 },
  { 479, 8, 15, 9, 1, -15 },
  { 494, 15, 17, 16, 1, -15 },
  { 526, 12, 15, 12, -1, -15 },
  { 549, 12, 15, 12, 0, -15 },
  { 572, 11, 15, 11, 1, -15 },
  { 593, 12, 15, 12, 0, -15 },
  { 616, 11, 15, 10, 0, -15 },
  { 637, 11, 15, 10, 0, -15 },
  { 658, 12, 15, 12, 1, -15 },
  { 681, 13, 15, 13, 0, -15 },
  { 706, 11, 15, 8, -1, -15 },
  { 727, 10, 20, 6, -3, -15 },
  { 752, 14, 15, 12, 0, -15 },
  { 779, 8, 15, 9, 0, -15 },
  { 794, 17, 15, 17, 0, -15 },
  { 826, 15, 15, 14, 0, -15 },
  { 855, 12, 15, 13, 1, -15 },
  { 878, 11, 15, 11, 0, -15 },
  { 899, 12, 19, 13, 1, -15 },
  { 928, 11, 15, 12, 0, -15 },
  { 949, 11, 15, 10, 0, -15 },
  { 970, 9, 15, 10, 2, -15 },
  { 987, 12, 15, 12, 1, -15 },
  { 1010, 11, 15, 12, 2, -15 },
  { 1031, 17, 15, 17, 2, -15 },
  { 1063, 14, 15, 12, -1, -15 },
  { 1090, 11, 15, 11, 2, -15 },
  { 1111, 12, 15, 10, -1, -15 },
  { 1134, 9, 19, 6, -1, -15 },
  { 1156, 5, 15, 9, 2, -15 },
  { 1166, 9, 19, 6, -2, -15 },
  { 1188, 10, 10, 10, 0, -15 },
  { 1201, 9, 3, 8, -2, 1 },
  { 1205, 5, 3, 7, 3, -16 },
  { 1207, 11, 12, 11, 0, -12 },
  { 1224, 11, 16, 11, 0, -16 },
  { 1246, 9, 12, 9, 1, -12 },
  { 1260, 12, 16, 11, 0, -16 },
  { 1284, 10, 12, 10, 0, -12 },
  { 1299, 11, 21, 7, -2, -16 },
  { 1328, 11, 17, 11, 0, -12 },
  { 1352, 11, 16, 11, 0, -16 },
  { 1374, 7, 16, 6, 0, -16 },
  { 1388, 10, 21, 6, -3, -16 },
  { 1415, 12, 16, 11, 0, -16 },
  { 1439, 7, 16, 6, 0, -16 },
  { 1453, 16, 12, 16, 0, -12 },
  { 1477, 11, 12, 11, 0, -12 },
  { 1494, 9, 12, 11, 1, -12 },
  { 1508, 12, 17, 11, -1, -12 },
  { 1534, 11, 17, 11, 0, -12 },
  { 1558, 9, 12, 8, 0, -12 },
  { 1572, 9, 12, 9, 0, -12 },
  { 1586, 7, 14, 8, 1, -14 },
  { 1599, 10, 12, 11, 1, -12 },
  { 1614, 10, 12, 10, 1, -12 },
  { 1629, 15, 12, 15, 1, -12 },
  { 1652, 12, 12, 10, -1, -12 },
  { 1670, 12, 17, 10, -1, -12 },
  { 1696, 10, 12, 9, -1, -12 },
  { 1711, 9, 18, 7, 0, -15 },
  { 1732, 3, 21, 9, 3, -16 },
  { 1740, 8, 18, 7, -1, -15 },
  { 1758, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_BlackItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC21PT7B_H_
